#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B,
  0x9C, 0xE7, 0x38, 0x00, 0x01, 0x3F, 0xFF, 0xFF, 0xE4, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xF0, 0x00, 0xF0, 0x70, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0xC0, 0x07,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xE0,
  0xF0, 0x01, 0xC1, 0xE0, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF0, 0x3C, 0x3C, 0x00, 0x70, 0x78, 0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x1E, 0x07, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x81, 0xC1, 0xC0, 0x07, 0x83, 0x80, 0x0F,
  0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x87, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0xF3, 0xFF, 0xF9,
  0xFF, 0xFE, 0x7C, 0xE1, 0xBE, 0x38, 0x0F, 0x0E, 0x03, 0xC3, 0x80, 0xF8,
  0xE0, 0x1E, 0x38, 0x07, 0xEE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xEF, 0xC0, 0x39, 0xF0, 0x0E, 0x3C,
  0x03, 0x8F, 0x00, 0xE3, 0xE0, 0x38, 0xFE, 0x0E, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0x3F, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x1F, 0x80, 0x07, 0x00, 0xFF, 0x00, 0x3C,
  0x07, 0xFE, 0x00, 0xE0, 0x1E, 0x78, 0x07, 0x80, 0xF0, 0xE0, 0x1C, 0x03,
  0xC3, 0xC0, 0xF0, 0x0E, 0x0F, 0x03, 0x80, 0x38, 0x3C, 0x1E, 0x00, 0xE0,
  0xF0, 0x70, 0x03, 0x83, 0xC3, 0xC0, 0x0E, 0x0F, 0x0E, 0x00, 0x38, 0x3C,
  0x78, 0x00, 0xE0, 0xF1, 0xC3, 0xC3, 0xC3, 0xCF, 0x3F, 0xCF, 0x0E, 0x38,
  0xFF, 0x9E, 0x79, 0xE7, 0x9E, 0x7F, 0xE7, 0x1C, 0x3C, 0xFF, 0x3C, 0xF0,
  0xF1, 0xF8, 0xE3, 0xC1, 0xC0, 0x07, 0x8F, 0x07, 0x00, 0x1E, 0x3C, 0x1C,
  0x00, 0xF0, 0xF0, 0x70, 0x03, 0xC3, 0xC1, 0xC0, 0x1E, 0x0F, 0x07, 0x00,
  0x78, 0x3C, 0x1C, 0x03, 0xC0, 0xF0, 0xF0, 0x0F, 0x01, 0xC3, 0xC0, 0x78,
  0x07, 0x8F, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0x00, 0x3F, 0xC0, 0x3C, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x78,
  0x00, 0xF8, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x0F, 0x1F, 0x9F, 0x03,
  0xC7, 0xC7, 0xE1, 0xF3, 0xE0, 0xFC, 0x78, 0xF8, 0x1F, 0x3E, 0x3C, 0x03,
  0xEF, 0x8F, 0x00, 0x7F, 0xC3, 0xC0, 0x0F, 0xF0, 0xF8, 0x01, 0xF8, 0x3E,
  0x00, 0x7E, 0x0F, 0xC0, 0x7F, 0xC1, 0xFE, 0xFF, 0xF8, 0x7F, 0xFF, 0xBF,
  0x0F, 0xFF, 0xC7, 0xE0, 0xFF, 0xC0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C,
  0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xE0,
  0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x81, 0xC0, 0x5E, 0x38, 0x73, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0x7C, 0x03, 0xC7,
  0x80, 0xF8, 0xF8, 0x1E, 0x0F, 0x80, 0xC1, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3D, 0xF7,
  0xDF, 0x79, 0xEF, 0xBC, 0xF3, 0x8E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x27, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xFF, 0x83, 0xE0, 0xF8, 0xF8, 0x1F, 0x1E, 0x01, 0xE3, 0xC0, 0x3E,
  0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xBE, 0x00, 0xF3,
  0xC0, 0x3E, 0x78, 0x07, 0xCF, 0x80, 0xF0, 0xF8, 0x3E, 0x1F, 0xDF, 0x81,
  0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0,
  0x7F, 0x1F, 0xF3, 0xFF, 0x7E, 0xFF, 0x8F, 0x70, 0xF2, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xFC, 0x7F, 0xFF, 0x87, 0x81, 0xF8, 0x40, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x70, 0x0F, 0x88, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x1F, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFB, 0xF1, 0xFE, 0xFF,
  0xFF, 0x3F, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xDE,
  0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0xF1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00,
  0x78, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xFC, 0x00, 0xFB, 0xF1, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x83,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1,
  0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x10, 0x0F, 0x1F, 0xE1, 0xE7, 0xFE, 0x3D,
  0xFF, 0xE7, 0xF8, 0x7E, 0xFC, 0x07, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0x7C,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFB, 0xC0, 0x1F, 0x78,
  0x03, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x1F, 0xDF, 0xC1, 0xFF, 0xF0, 0x1F,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8,
  0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x9F, 0xC7, 0xC0, 0xF8, 0xF0, 0x0F,
  0x9E, 0x01, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF9, 0xF0, 0x1E,
  0x1F, 0x07, 0xC1, 0xFB, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x1F, 0xFE, 0x07, 0xE7, 0xE1, 0xF0, 0x3E, 0x3C, 0x03, 0xEF, 0x80, 0x3D,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7B,
  0xE0, 0x1F, 0x3F, 0x07, 0xE7, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x87, 0xC1, 0xF8,
  0xF0, 0x1F, 0x3E, 0x01, 0xE7, 0x80, 0x3E, 0xF0, 0x03, 0xDE, 0x00, 0x7B,
  0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xF3,
  0xE0, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0x78, 0x7F, 0xCF, 0x03, 0xE1, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x10, 0x7F, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xF8, 0x00, 0x27, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x09, 0xFF, 0xFF, 0xFF, 0x20, 0x08, 0x7C, 0xF9, 0xF3, 0xE7, 0xC2,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF3,
  0xE7, 0xCF, 0x1E, 0x3C, 0xF1, 0xE3, 0xC7, 0x1E, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xE0,
  0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0xFF, 0xFE,
  0x7F, 0xFF, 0x30, 0x1F, 0x40, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0x3C, 0x78, 0x1F, 0xF8,
  0x78, 0xE0, 0x7F, 0xF0, 0x73, 0xC1, 0xF1, 0xE0, 0xE7, 0x87, 0xC1, 0xC1,
  0xEE, 0x0F, 0x03, 0x83, 0xFC, 0x1C, 0x07, 0x07, 0xF8, 0x78, 0x0E, 0x0F,
  0xF0, 0xF0, 0x1C, 0x1F, 0xE1, 0xE0, 0x78, 0x3F, 0xC3, 0xC0, 0xF0, 0x7F,
  0x87, 0x81, 0xE0, 0xEF, 0x0F, 0x03, 0xC1, 0xDE, 0x1E, 0x07, 0x87, 0xBC,
  0x1E, 0x1F, 0x8E, 0x38, 0x3F, 0xF7, 0xFC, 0x78, 0x3F, 0xC7, 0xF0, 0xF0,
  0x3F, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xC0, 0x03, 0xFE,
  0x3F, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xEF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07,
  0xC0, 0x0F, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x78,
  0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x1F,
  0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0xF7, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3E, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0xF0, 0x1F, 0xCF, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0,
  0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0x00, 0xFC,
  0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xFF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x07, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFC, 0x03, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x04, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xF0, 0x1F, 0xE3, 0xC0, 0x1F, 0x8F,
  0x00, 0x3F, 0x3C, 0x00, 0x7C, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xEF, 0x00,
  0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC, 0x00,
  0x7C, 0xF0, 0x03, 0xF3, 0xC0, 0x1F, 0x8F, 0x01, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x1C, 0x1F, 0x80,
  0x04, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0xC0, 0x1F, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFC, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C,
  0x1F, 0xFF, 0xEF, 0xFD, 0xFF, 0x3F, 0x80, 0xF0, 0x01, 0xF7, 0x80, 0x1F,
  0x3C, 0x00, 0xF9, 0xE0, 0x0F, 0x8F, 0x00, 0xF8, 0x78, 0x0F, 0x83, 0xC0,
  0x7C, 0x1E, 0x07, 0xC0, 0xF0, 0x7C, 0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x01,
  0xE3, 0xE0, 0x0F, 0x3E, 0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xEF, 0x80, 0x3E, 0x3E, 0x01, 0xE1, 0xF8, 0x0F,
  0x07, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xE0, 0xF0, 0x0F,
  0x87, 0x80, 0x7C, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0xCF, 0x00, 0x3E, 0x78,
  0x00, 0xFB, 0xC0, 0x07, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3D, 0xFF, 0xE0, 0x01, 0xEF,
  0xF7, 0x80, 0x0F, 0x7F, 0xBC, 0x00, 0xF3, 0xFD, 0xE0, 0x07, 0x9F, 0xE7,
  0x80, 0x3C, 0xFF, 0x3C, 0x03, 0xC7, 0xF9, 0xE0, 0x1E, 0x3F, 0xC7, 0x80,
  0xF1, 0xFE, 0x3C, 0x0F, 0x0F, 0xF1, 0xE0, 0x78, 0x7F, 0x87, 0x83, 0xC3,
  0xFC, 0x3C, 0x3C, 0x1F, 0xE1, 0xE1, 0xE0, 0xFF, 0x07, 0x8F, 0x07, 0xF8,
  0x3C, 0xF0, 0x3F, 0xC1, 0xE7, 0x81, 0xFE, 0x07, 0xBC, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x00,
  0xFF, 0x01, 0xF8, 0x07, 0xF8, 0x07, 0xC0, 0x3F, 0xC0, 0x3C, 0x01, 0xE0,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xF7,
  0xC0, 0x3F, 0xEF, 0x80, 0x7F, 0xCF, 0x80, 0xFF, 0x9F, 0x01, 0xFF, 0x1F,
  0x03, 0xFE, 0x1E, 0x07, 0xFC, 0x3E, 0x0F, 0xF8, 0x3E, 0x1F, 0xF0, 0x7C,
  0x3F, 0xE0, 0x7C, 0x7F, 0xC0, 0xF8, 0xFF, 0x80, 0xF8, 0xFF, 0x01, 0xF1,
  0xFE, 0x01, 0xF3, 0xFC, 0x01, 0xE7, 0xF8, 0x03, 0xEF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0x7E, 0x07, 0xC0,
  0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF0, 0x3F, 0xBC, 0x03,
  0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xEF, 0x01, 0xFB, 0xC7, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0,
  0x7E, 0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xE0, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF0,
  0x3F, 0x8F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF,
  0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0xF8,
  0xF0, 0x3F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x01,
  0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0,
  0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0xE3,
  0xFF, 0xF9, 0xFF, 0xFE, 0x7E, 0x07, 0x1F, 0x00, 0x4F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x03, 0xEC, 0x01, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF7,
  0x80, 0x07, 0xDE, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xE3, 0xE0,
  0x1F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3E, 0x00,
  0x7C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3,
  0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0x00, 0x3C,
  0xF8, 0x01, 0xF0, 0x01, 0xE7, 0xC0, 0x1F, 0xC0, 0x1F, 0x3E, 0x00, 0xFE,
  0x00, 0xF8, 0xF0, 0x07, 0x70, 0x07, 0x87, 0x80, 0x7B, 0x80, 0x3C, 0x3E,
  0x03, 0xDE, 0x03, 0xE1, 0xF0, 0x1E, 0xF0, 0x1F, 0x07, 0x80, 0xF7, 0x80,
  0xF0, 0x3C, 0x0F, 0x1E, 0x07, 0x81, 0xF0, 0x78, 0xF0, 0x3C, 0x0F, 0x83,
  0xC7, 0x83, 0xE0, 0x3C, 0x1E, 0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0xF0, 0xF0,
  0x0F, 0x0F, 0x07, 0x87, 0x80, 0x7C, 0x78, 0x3C, 0x7C, 0x01, 0xE3, 0xC1,
  0xE3, 0xC0, 0x0F, 0x3C, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x3C, 0xF0, 0x03,
  0xEF, 0x01, 0xEF, 0x80, 0x0F, 0x78, 0x0F, 0x7C, 0x00, 0x7B, 0x80, 0x3B,
  0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x3C, 0x78, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0,
  0x07, 0xCF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0xF8,
  0xF8, 0x01, 0xF0, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0x78, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0xCF, 0x80, 0x0F,
  0xBE, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0xC0, 0x07,
  0x8F, 0x00, 0x3E, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x07,
  0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xF1,
  0xE0, 0x03, 0xCF, 0x80, 0x0F, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x8F, 0x00, 0x38, 0x78,
  0x03, 0xC1, 0xE0, 0x1C, 0x0F, 0x01, 0xE0, 0x3C, 0x0E, 0x01, 0xE0, 0xF0,
  0x07, 0x87, 0x80, 0x3C, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0xBC, 0x00, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x7E, 0x1F, 0x07,
  0xC1, 0xF0, 0x78, 0x1E, 0x00, 0xC0, 0x07, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF,
  0xE1, 0xC1, 0xF8, 0x80, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xFB, 0xF0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xFB, 0xFF, 0xFD, 0xFF, 0xCE, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x06, 0x03, 0xE7, 0xF8, 0x7D, 0xFF, 0x8F,
  0x7F, 0xF9, 0xFE, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x1E, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x01, 0xEF, 0xC0, 0x7D, 0xFE, 0x3F, 0xBD, 0xFF, 0xE7, 0x9F, 0xF8, 0xF1,
  0xFE, 0x00, 0x00, 0x60, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0x0E,
  0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x7E, 0x01, 0x3F, 0x9E, 0x1F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x30, 0x3C, 0x3F, 0xE7, 0x8F, 0xFE, 0xF3, 0xFF, 0xFE, 0x7E, 0x1F, 0xDF,
  0x01, 0xFB, 0xE0, 0x1F, 0x78, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x7E, 0x7E,
  0x3F, 0xCF, 0xFF, 0x78, 0xFF, 0xEF, 0x07, 0xF0, 0xE0, 0x00, 0x40, 0x01,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3E, 0x0F, 0x9F, 0x01, 0xE7, 0x80,
  0x7D, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0x3F, 0x87, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFC, 0x01, 0xFA, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x01, 0xFF, 0xC7,
  0xFF, 0x8F, 0xFF, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x01, 0xFF, 0x3C, 0x7F, 0xF7,
  0x9F, 0xFF, 0xF3, 0xF0, 0xFE, 0xF8, 0x0F, 0xDF, 0x00, 0xFB, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x7D,
  0xF0, 0x0F, 0xBE, 0x03, 0xF3, 0xF1, 0xFE, 0x7F, 0xFB, 0xC7, 0xFF, 0x78,
  0x3F, 0x8F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x40, 0x0F, 0x8F, 0xCF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03,
  0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x0E,
  0x0F, 0x9F, 0xE3, 0xCF, 0xFE, 0xF7, 0xFF, 0xBF, 0xC3, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xE9, 0xFB, 0xFE, 0xFF, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x81,
  0xF1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xC0, 0xF8, 0xF8, 0x1F, 0x3E,
  0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x0F, 0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xE7, 0xC0, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70,
  0x01, 0x81, 0xE3, 0xFC, 0x1F, 0xE3, 0xDF, 0xFC, 0xFF, 0xE7, 0xBF, 0xFD,
  0xFF, 0xEF, 0xE1, 0xFF, 0x8F, 0xDF, 0x81, 0xFC, 0x0F, 0xBF, 0x01, 0xF8,
  0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80,
  0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03,
  0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F,
  0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFF,
  0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE,
  0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x30, 0x3C, 0x7F, 0x8F,
  0x3F, 0xFB, 0xDF, 0xFE, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F,
  0x0F, 0xC7, 0xC0, 0x7C, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x03,
  0xE3, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x70, 0x1E, 0x3F, 0xC3, 0xCF, 0xFC, 0x7B, 0xFF, 0xCF, 0xF0,
  0xFD, 0xF8, 0x0F, 0xBF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0x7E, 0x03,
  0xEF, 0xF1, 0xF9, 0xEF, 0xFF, 0x3E, 0xFF, 0xC7, 0xCF, 0xF0, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xC0,
  0x01, 0xFF, 0x3C, 0x7F, 0xF7, 0x9F, 0xFF, 0xF3, 0xF0, 0xFE, 0xF8, 0x0F,
  0xDF, 0x00, 0xFB, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xF3, 0xF1, 0xFE,
  0x7F, 0xFB, 0xC7, 0xFE, 0x78, 0x3F, 0x8F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x77, 0x8F, 0xFC, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFF, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0x80,
  0x3F, 0xF9, 0xFF, 0xFB, 0xFF, 0xEF, 0x81, 0xDE, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xFF,
  0x07, 0xFF, 0xFF, 0xBF, 0xFE, 0x3F, 0xF0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x08,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFD,
  0xF8, 0xFF, 0x7F, 0xFF, 0xCF, 0xFE, 0xF1, 0xFE, 0x1C, 0xF8, 0x00, 0xF7,
  0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E,
  0x3E, 0x03, 0xC1, 0xE0, 0x7C, 0x1E, 0x07, 0xC1, 0xF0, 0x78, 0x0F, 0x07,
  0x80, 0xF0, 0xF8, 0x0F, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x9F, 0x00, 0x79,
  0xE0, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x1E, 0xF0,
  0x0F, 0xC0, 0x3D, 0xF0, 0x1F, 0x80, 0xFB, 0xE0, 0x3F, 0x01, 0xE3, 0xC0,
  0xFF, 0x03, 0xC7, 0x81, 0xFE, 0x07, 0x8F, 0x03, 0xBC, 0x1F, 0x1F, 0x0F,
  0x38, 0x3C, 0x1E, 0x1E, 0x78, 0x78, 0x3C, 0x3C, 0xF0, 0xF0, 0x78, 0x71,
  0xE3, 0xE0, 0xF9, 0xE1, 0xC7, 0x80, 0xF3, 0xC3, 0xCF, 0x01, 0xE7, 0x87,
  0x9E, 0x03, 0xCE, 0x0F, 0x3C, 0x07, 0x9C, 0x0E, 0xF0, 0x07, 0xF8, 0x1D,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x7E,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0xF8, 0x03, 0xEF, 0x80, 0xF8, 0xF0, 0x1E, 0x1F, 0x07, 0xC1, 0xE1,
  0xF0, 0x3E, 0x3E, 0x03, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xEF,
  0x00, 0x7D, 0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xE0, 0xF8, 0x3E, 0x1E, 0x07,
  0xC7, 0xC0, 0x7D, 0xF0, 0x07, 0xBE, 0x00, 0xF8, 0xF8, 0x00, 0xFB, 0xC0,
  0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xC3, 0xC0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3C, 0x03, 0xC1,
  0xE0, 0x1F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00,
  0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x27, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x03,
  0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x83, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0xC0, 0xFF,
  0x01, 0xFC, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x07, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x7E, 0x03, 0xF0, 0x7F,
  0x87, 0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0x70, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xF8, 0x07, 0xFD, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Medium43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 32, 11, 3, -31 },
  { 21, 12, 11, 18, 3, -31 },
  { 38, 23, 31, 25, 1, -31 },
  { 128, 18, 36, 23, 2, -33 },
  { 209, 30, 31, 34, 2, -31 },
  { 326, 26, 31, 28, 2, -31 },
  { 427, 4, 11, 10, 3, -31 },
  { 433, 10, 38, 13, 2, -31 },
  { 481, 10, 38, 13, 1, -31 },
  { 529, 19, 18, 21, 1, -33 },
  { 572, 19, 21, 23, 2, -26 },
  { 622, 6, 11, 11, 2, -5 },
  { 631, 11, 4, 13, 1, -14 },
  { 637, 5, 7, 11, 3, -6 },
  { 642, 15, 31, 16, 1, -31 },
  { 701, 19, 31, 22, 2, -31 },
  { 775, 12, 31, 22, 3, -31 },
  { 822, 19, 31, 22, 2, -31 },
  { 896, 18, 31, 22, 2, -31 },
  { 966, 21, 31, 22, 1, -31 },
  { 1048, 18, 31, 22, 2, -31 },
  { 1118, 19, 31, 22, 2, -31 },
  { 1192, 20, 31, 22, 1, -31 },
  { 1270, 19, 31, 22, 2, -31 },
  { 1344, 19, 31, 22, 2, -31 },
  { 1418, 5, 25, 11, 3, -24 },
  { 1434, 7, 30, 11, 1, -24 },
  { 1461, 19, 21, 23, 2, -26 },
  { 1511, 19, 12, 23, 2, -21 },
  { 1540, 19, 21, 23, 2, -26 },
  { 1590, 16, 32, 17, 0, -31 },
  { 1654, 31, 35, 35, 2, -31 },
  { 1790, 25, 31, 25, 0, -31 },
  { 1887, 20, 31, 26, 4, -31 },
  { 1965, 21, 31, 25, 2, -31 },
  { 2047, 22, 31, 28, 4, -31 },
  { 2133, 15, 31, 22, 4, -31 },
  { 2192, 15, 31, 21, 4, -31 },
  { 2251, 24, 31, 28, 2, -31 },
  { 2344, 21, 31, 29, 4, -31 },
  { 2426, 12, 31, 14, 1, -31 },
  { 2473, 11, 39, 12, -3, -31 },
  { 2527, 21, 31, 25, 4, -31 },
  { 2609, 16, 31, 21, 4, -31 },
  { 2671, 29, 31, 37, 4, -31 },
  { 2784, 23, 31, 30, 4, -31 },
  { 2874, 26, 31, 30, 2, -31 },
  { 2975, 18, 31, 24, 4, -31 },
  { 3045, 26, 38, 30, 2, -31 },
  { 3169, 20, 31, 25, 4, -31 },
  { 3247, 18, 31, 22, 2, -31 },
  { 3317, 20, 31, 22, 1, -31 },
  { 3395, 22, 31, 29, 3, -31 },
  { 3481, 24, 31, 24, 0, -31 },
  { 3574, 37, 31, 37, 0, -31 },
  { 3718, 23, 31, 23, 0, -31 },
  { 3808, 22, 31, 22, 0, -31 },
  { 3894, 19, 31, 22, 1, -31 },
  { 3968, 10, 38, 14, 3, -31 },
  { 4016, 16, 31, 16, 0, -31 },
  { 4078, 10, 38, 14, 1, -31 },
  { 4126, 21, 19, 23, 1, -31 },
  { 4176, 19, 3, 19, 0, 4 },
  { 4184, 9, 7, 13, 2, -33 },
  { 4192, 17, 24, 22, 2, -24 },
  { 4243, 19, 33, 24, 3, -33 },
  { 4322, 16, 24, 19, 2, -24 },
  { 4370, 19, 33, 24, 2, -33 },
  { 4449, 18, 24, 22, 2, -24 },
  { 4503, 15, 33, 14, 1, -33 },
  { 4565, 19, 34, 24, 2, -24 },
  { 4646, 18, 33, 24, 3, -33 },
  { 4721, 5, 32, 11, 3, -32 },
  { 4741, 10, 42, 11, -2, -32 },
  { 4794, 19, 33, 22, 3, -33 },
  { 4873, 5, 33, 11, 3, -33 },
  { 4894, 31, 24, 37, 3, -24 },
  { 4987, 18, 24, 24, 3, -24 },
  { 5041, 20, 24, 24, 2, -24 },
  { 5101, 19, 34, 24, 3, -24 },
  { 5182, 19, 34, 24, 2, -24 },
  { 5263, 13, 24, 17, 3, -24 },
  { 5302, 15, 24, 19, 2, -24 },
  { 5347, 13, 28, 15, 1, -28 },
  { 5393, 18, 23, 24, 3, -23 },
  { 5445, 20, 23, 21, 0, -23 },
  { 5503, 31, 23, 32, 0, -23 },
  { 5593, 19, 23, 21, 1, -23 },
  { 5648, 21, 33, 21, 0, -23 },
  { 5735, 16, 23, 18, 1, -23 },
  { 5781, 14, 38, 16, 1, -31 },
  { 5848, 4, 43, 22, 9, -33 },
  { 5870, 13, 38, 16, 2, -31 },
  { 5932, 19, 6, 23, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_Medium43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM43PT7B_H_
