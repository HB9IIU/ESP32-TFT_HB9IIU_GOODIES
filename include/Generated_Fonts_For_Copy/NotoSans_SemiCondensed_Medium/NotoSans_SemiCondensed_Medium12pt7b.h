#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xB6, 0xD0, 0x14, 0x48, 0x93, 0xF2, 0x85, 0x3F, 0x24,
  0x50, 0x27, 0xE9, 0x4E, 0x1C, 0xBE, 0x21, 0x00, 0x62, 0x29, 0x25, 0x12,
  0x85, 0xBB, 0x54, 0x4A, 0x25, 0x23, 0x80, 0x30, 0x68, 0x48, 0x38, 0x30,
  0x5A, 0xCE, 0x44, 0x7B, 0xF0, 0x5A, 0xAA, 0xB4, 0x89, 0x92, 0x49, 0x2B,
  0x00, 0x32, 0x97, 0x8C, 0x48, 0x10, 0x4F, 0xC4, 0x10, 0x40, 0x58, 0xE0,
  0xC0, 0x11, 0x12, 0x26, 0x44, 0x80, 0x66, 0xA7, 0x38, 0xCE, 0x72, 0x70,
  0x2E, 0x92, 0x49, 0x20, 0x31, 0x20, 0x82, 0x08, 0x42, 0x10, 0xFC, 0x33,
  0x20, 0x82, 0x30, 0x20, 0xC3, 0xF8, 0x08, 0x63, 0x8A, 0x49, 0x2F, 0xC2,
  0x08, 0xF7, 0xA1, 0x0F, 0x0C, 0x62, 0xF0, 0x36, 0x21, 0x0F, 0x4E, 0x33,
  0x70, 0xFF, 0xF0, 0x82, 0x18, 0x43, 0x08, 0x60, 0x31, 0x24, 0xD2, 0x31,
  0x2C, 0x53, 0x78, 0x31, 0x24, 0xF3, 0x4D, 0xF0, 0x82, 0x70, 0xC6, 0x50,
  0x05, 0x80, 0x0C, 0xCC, 0x18, 0x1C, 0x10, 0xF8, 0x3E, 0xC0, 0xC0, 0xC6,
  0x62, 0x00, 0x64, 0x86, 0x23, 0x10, 0x04, 0x60, 0x18, 0x66, 0x81, 0xBD,
  0xA5, 0xA5, 0xAD, 0x92, 0xC0, 0x3C, 0x10, 0x70, 0xA1, 0x46, 0xCF, 0x9F,
  0x63, 0x82, 0xE2, 0x68, 0xA2, 0xF2, 0x28, 0xE2, 0xF8, 0x3B, 0x61, 0x08,
  0x42, 0x18, 0x78, 0xE3, 0xE8, 0xE1, 0x86, 0x18, 0x62, 0xF0, 0xFF, 0x88,
  0xF8, 0x88, 0xF0, 0xFF, 0x88, 0xF8, 0x88, 0x80, 0x39, 0x9C, 0x20, 0x9E,
  0x78, 0x71, 0x7C, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x84, 0xF6, 0x66,
  0x66, 0x66, 0xF0, 0x24, 0x92, 0x49, 0x27, 0x80, 0x8E, 0x29, 0x28, 0xE3,
  0xC9, 0x22, 0x8C, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC3, 0xC3, 0xC3, 0xA5,
  0xA5, 0xA5, 0x99, 0x99, 0x99, 0xC7, 0x1E, 0x69, 0xB6, 0x58, 0xE3, 0x84,
  0x38, 0xDA, 0x14, 0x38, 0x70, 0xE1, 0xE2, 0x78, 0xE7, 0xE3, 0x19, 0xFA,
  0x10, 0x80, 0x38, 0xDA, 0x14, 0x38, 0x70, 0xE1, 0xE2, 0x78, 0x10, 0x30,
  0xE3, 0xE8, 0xA2, 0xFB, 0xC9, 0x22, 0x8C, 0x76, 0xA1, 0x06, 0x18, 0x72,
  0xF0, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x73, 0x78, 0x87, 0x89, 0x12, 0x64, 0x85, 0x0A, 0x18, 0x10, 0x84,
  0x73, 0x14, 0xC5, 0x3B, 0x4A, 0x94, 0xA3, 0x28, 0xCE, 0x31, 0x00, 0xC5,
  0x36, 0x8E, 0x10, 0xC6, 0x93, 0xC4, 0x85, 0x34, 0x9A, 0x30, 0xC3, 0x0C,
  0x30, 0xFF, 0xE0, 0x84, 0x30, 0x86, 0x10, 0xFC, 0xF2, 0x49, 0x24, 0x93,
  0x80, 0x84, 0x44, 0x22, 0x31, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x10,
  0xC3, 0x92, 0x4E, 0x10, 0xF8, 0xC4, 0x32, 0x42, 0xF4, 0xE5, 0xE0, 0x84,
  0x2D, 0xB8, 0xC6, 0x31, 0xF0, 0x2D, 0x88, 0x88, 0x70, 0x08, 0x5B, 0xB8,
  0xC6, 0x33, 0xE8, 0x66, 0xA7, 0xF8, 0x41, 0xC0, 0x34, 0x4F, 0x44, 0x44,
  0x40, 0x66, 0xE3, 0x18, 0xCF, 0xA1, 0x9F, 0x80, 0x84, 0x2D, 0xB8, 0xC6,
  0x31, 0x88, 0xDF, 0x80, 0x51, 0x55, 0x57, 0x84, 0x23, 0x2A, 0x72, 0x92,
  0x98, 0xFF, 0x80, 0x32, 0xDD, 0x89, 0x89, 0x89, 0x89, 0x89, 0x36, 0xE3,
  0x18, 0xC6, 0x20, 0x26, 0xE3, 0x18, 0xCD, 0xC0, 0x36, 0xE3, 0x18, 0xC7,
  0xD0, 0x84, 0x00, 0x66, 0xE3, 0x18, 0xCF, 0xA1, 0x08, 0x40, 0x3E, 0x49,
  0x20, 0x6B, 0x8E, 0x31, 0xE0, 0x44, 0xF4, 0x44, 0x47, 0x8C, 0x63, 0x19,
  0xF4, 0xCD, 0x24, 0x9C, 0x30, 0xC0, 0xC9, 0xAA, 0x95, 0x4A, 0xA5, 0x61,
  0x10, 0xCD, 0xC3, 0x0C, 0x5B, 0x30, 0xCD, 0x24, 0x9C, 0x30, 0xC2, 0x08,
  0xC0, 0x78, 0x88, 0xC4, 0x7C, 0x12, 0x22, 0x2C, 0x62, 0x22, 0x30, 0xFF,
  0xFF, 0xFF, 0x86, 0x22, 0x23, 0x22, 0x26, 0xC0, 0x76, 0x20,
};

const GFXglyph NotoSans_SemiCondensed_Medium12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 4, 5, 1, -9 },
  { 5, 7, 9, 7, 0, -9 },
  { 13, 5, 10, 6, 1, -9 },
  { 20, 9, 9, 10, 0, -9 },
  { 31, 8, 9, 8, 0, -9 },
  { 40, 1, 4, 3, 1, -9 },
  { 41, 2, 11, 4, 1, -9 },
  { 44, 3, 11, 4, 0, -9 },
  { 49, 6, 5, 6, 0, -9 },
  { 53, 6, 6, 6, 0, -7 },
  { 58, 2, 3, 3, 0, -1 },
  { 59, 3, 1, 4, 0, -4 },
  { 60, 1, 2, 3, 1, -2 },
  { 61, 4, 9, 5, 0, -9 },
  { 66, 5, 9, 6, 1, -9 },
  { 72, 3, 9, 6, 1, -9 },
  { 76, 6, 9, 6, 0, -9 },
  { 83, 6, 9, 6, 0, -9 },
  { 90, 6, 9, 6, 0, -9 },
  { 97, 5, 9, 6, 1, -9 },
  { 103, 5, 9, 6, 1, -9 },
  { 109, 6, 9, 6, 0, -9 },
  { 116, 6, 9, 6, 0, -9 },
  { 123, 6, 9, 6, 0, -9 },
  { 130, 1, 7, 3, 1, -7 },
  { 131, 2, 9, 3, 0, -7 },
  { 134, 6, 6, 6, 0, -7 },
  { 139, 5, 3, 6, 1, -6 },
  { 141, 6, 6, 6, 0, -7 },
  { 146, 5, 9, 5, 0, -9 },
  { 152, 8, 10, 10, 1, -9 },
  { 162, 7, 9, 7, 0, -9 },
  { 170, 6, 9, 7, 1, -9 },
  { 177, 5, 9, 7, 1, -9 },
  { 183, 6, 9, 8, 1, -9 },
  { 190, 4, 9, 6, 1, -9 },
  { 195, 4, 9, 6, 1, -9 },
  { 200, 6, 9, 8, 1, -9 },
  { 207, 6, 9, 8, 1, -9 },
  { 214, 4, 9, 4, 0, -9 },
  { 219, 3, 11, 3, -1, -9 },
  { 224, 6, 9, 7, 1, -9 },
  { 231, 4, 9, 6, 1, -9 },
  { 236, 8, 9, 10, 1, -9 },
  { 245, 6, 9, 8, 1, -9 },
  { 252, 7, 9, 8, 1, -9 },
  { 260, 5, 9, 7, 1, -9 },
  { 266, 7, 11, 8, 1, -9 },
  { 276, 6, 9, 7, 1, -9 },
  { 283, 5, 9, 6, 1, -9 },
  { 289, 6, 9, 6, 0, -9 },
  { 296, 6, 9, 8, 1, -9 },
  { 303, 7, 9, 7, 0, -9 },
  { 311, 10, 9, 10, 0, -9 },
  { 323, 6, 9, 6, 0, -9 },
  { 330, 6, 9, 6, 0, -9 },
  { 337, 6, 9, 6, 0, -9 },
  { 344, 3, 11, 4, 1, -9 },
  { 349, 4, 9, 5, 0, -9 },
  { 354, 3, 11, 4, 0, -9 },
  { 359, 6, 6, 6, 0, -9 },
  { 364, 5, 1, 5, 0, 1 },
  { 365, 3, 2, 4, 0, -9 },
  { 366, 5, 7, 6, 0, -7 },
  { 371, 5, 9, 7, 1, -9 },
  { 377, 4, 7, 5, 1, -7 },
  { 381, 5, 9, 7, 1, -9 },
  { 387, 5, 7, 6, 1, -7 },
  { 392, 4, 9, 4, 0, -9 },
  { 397, 5, 10, 7, 1, -7 },
  { 404, 5, 9, 7, 1, -9 },
  { 410, 1, 9, 3, 1, -9 },
  { 412, 2, 12, 3, 0, -9 },
  { 415, 5, 9, 6, 1, -9 },
  { 421, 1, 9, 3, 1, -9 },
  { 423, 8, 7, 10, 1, -7 },
  { 430, 5, 7, 7, 1, -7 },
  { 435, 5, 7, 7, 1, -7 },
  { 440, 5, 10, 7, 1, -7 },
  { 447, 5, 10, 7, 1, -7 },
  { 454, 3, 7, 5, 1, -7 },
  { 457, 4, 7, 5, 1, -7 },
  { 461, 4, 8, 4, 0, -8 },
  { 465, 5, 6, 7, 1, -6 },
  { 469, 6, 6, 6, 0, -6 },
  { 474, 9, 6, 9, 0, -6 },
  { 481, 6, 6, 6, 0, -6 },
  { 486, 6, 9, 6, 0, -6 },
  { 493, 5, 6, 5, 0, -6 },
  { 497, 4, 11, 4, 0, -9 },
  { 503, 2, 12, 6, 2, -9 },
  { 506, 4, 11, 4, 0, -9 },
  { 512, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_SemiCondensed_Medium12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM12PT7B_H_
