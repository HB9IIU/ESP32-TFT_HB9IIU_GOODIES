#ifndef _NOTOSANS_BLACKITALIC14PT7B_H_
#define _NOTOSANS_BLACKITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0xE7, 0x30, 0x00, 0xE7, 0x00, 0x6D, 0xBD, 0xB6, 0x0D,
  0x8D, 0x86, 0xCF, 0xF3, 0x61, 0xB3, 0xFE, 0x48, 0x6C, 0x36, 0x00, 0x04,
  0x1E, 0x3F, 0x79, 0x78, 0x3C, 0x1E, 0x1E, 0xF6, 0xFE, 0x30, 0x30, 0x70,
  0xCF, 0x98, 0xD9, 0x8D, 0xB0, 0xF6, 0xEF, 0xDF, 0x0D, 0xB1, 0xBB, 0x31,
  0xE6, 0x1C, 0x1E, 0x0F, 0xC3, 0x30, 0xFC, 0x3E, 0xDF, 0x7E, 0xFB, 0x9E,
  0xFF, 0x1F, 0xE0, 0x6F, 0x60, 0x1C, 0xE3, 0x1C, 0x61, 0x86, 0x38, 0xE1,
  0x86, 0x1C, 0x18, 0x61, 0xC7, 0x1C, 0x71, 0xC6, 0x18, 0xC7, 0x38, 0x10,
  0x33, 0xE7, 0xF3, 0xFF, 0x13, 0x00, 0x30, 0x63, 0xFF, 0xF3, 0x06, 0x00,
  0x37, 0x6C, 0x7F, 0xFC, 0x03, 0x07, 0x06, 0x0C, 0x0C, 0x18, 0x38, 0x30,
  0x70, 0xE0, 0x1E, 0x3F, 0x77, 0x77, 0x67, 0x67, 0xE6, 0xEE, 0x7C, 0x78,
  0x1C, 0xFF, 0xD7, 0x18, 0x63, 0x8E, 0x38, 0xC0, 0x3E, 0x7E, 0x27, 0x06,
  0x0E, 0x1C, 0x38, 0x70, 0xFE, 0xFE, 0x3E, 0x7F, 0x27, 0x06, 0x3C, 0x3E,
  0x06, 0x8E, 0xFE, 0xFC, 0x07, 0x0F, 0x1E, 0x1E, 0x36, 0x6E, 0xFF, 0xFE,
  0x0C, 0x1C, 0x3F, 0x3F, 0x30, 0x78, 0x7E, 0x3E, 0x06, 0x8E, 0xFE, 0xFC,
  0x3E, 0xFF, 0x87, 0xCF, 0xDD, 0xF3, 0xE6, 0xFC, 0xF0, 0x3F, 0xBF, 0x81,
  0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x78, 0x00, 0x1E, 0x3F, 0x37,
  0x37, 0x3C, 0x7E, 0x66, 0xE6, 0xFE, 0x7C, 0x7D, 0xFB, 0xBE, 0x7F, 0xFF,
  0xDB, 0x0E, 0xF9, 0xE0, 0x37, 0x30, 0x00, 0xEE, 0x19, 0xC6, 0x00, 0x01,
  0xCC, 0x66, 0x00, 0x02, 0x1C, 0xF7, 0x0E, 0x0F, 0x83, 0x81, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x81, 0x83, 0xC0, 0xE1, 0xFF, 0x38, 0x40, 0x7B, 0xF4,
  0xC7, 0x39, 0xC0, 0x00, 0xE3, 0x80, 0x1F, 0x87, 0x39, 0x81, 0xE7, 0xBD,
  0xB7, 0x66, 0xEC, 0xDD, 0xFE, 0xC9, 0x1C, 0x61, 0xFC, 0x00, 0x07, 0x83,
  0xE0, 0xD8, 0x76, 0x19, 0x8E, 0x63, 0xF9, 0xFE, 0x71, 0xB8, 0x70, 0x3F,
  0x1F, 0xCE, 0xE6, 0x67, 0xE3, 0xF9, 0xDC, 0xCE, 0x7F, 0x7E, 0x00, 0x3F,
  0x7F, 0x71, 0xE0, 0xE0, 0xC0, 0xC0, 0xE2, 0xFC, 0x7C, 0x3E, 0x1F, 0xCC,
  0xE6, 0x77, 0x3B, 0x9D, 0xCE, 0xCE, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x30,
  0x30, 0x7E, 0x7E, 0x70, 0x60, 0x7E, 0xFC, 0x3F, 0x3F, 0x30, 0x30, 0x7E,
  0x7E, 0x70, 0x60, 0x60, 0xE0, 0x1F, 0xBF, 0x9C, 0x5C, 0x0E, 0xF6, 0x7B,
  0x1D, 0xCC, 0xFE, 0x3F, 0x00, 0x39, 0xCE, 0x73, 0x1C, 0xC6, 0x7F, 0x9F,
  0xE7, 0x39, 0x8C, 0x63, 0x39, 0xC0, 0x3F, 0x3E, 0x1C, 0x1C, 0x1C, 0x18,
  0x38, 0x38, 0x7C, 0xFC, 0x06, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x18,
  0x30, 0xE7, 0xCF, 0x00, 0x39, 0xCE, 0xE3, 0x70, 0xDC, 0x7E, 0x1F, 0x87,
  0xE1, 0x9C, 0x67, 0x39, 0xC0, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x1C, 0x30,
  0x7F, 0xF8, 0x3C, 0x79, 0xE3, 0x8F, 0x3C, 0x79, 0xE7, 0xDF, 0x3E, 0xF9,
  0xBD, 0x8D, 0xEC, 0x6E, 0x67, 0x77, 0x00, 0x3C, 0x67, 0x9C, 0xF3, 0x9E,
  0x67, 0xEC, 0xED, 0x99, 0xF3, 0x3E, 0x67, 0x9C, 0x70, 0x1E, 0x3F, 0x9C,
  0xFC, 0x7E, 0x3E, 0x1F, 0x0D, 0xCE, 0xFE, 0x3E, 0x00, 0x3E, 0x1F, 0x8C,
  0xE6, 0x77, 0xF3, 0xF9, 0xF0, 0xC0, 0x60, 0x70, 0x00, 0x1F, 0x3F, 0x9C,
  0xFC, 0x7E, 0x3E, 0x1F, 0x0D, 0xCE, 0xFE, 0x3E, 0x03, 0x81, 0xE0, 0x3E,
  0x1F, 0x8C, 0xE6, 0x67, 0xF3, 0xF1, 0xF8, 0xCC, 0x67, 0x73, 0x80, 0x1F,
  0x3E, 0x72, 0x70, 0x3C, 0x1C, 0x0E, 0x8E, 0xFC, 0xF8, 0xFF, 0xFE, 0x38,
  0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x73, 0xB9, 0xD8, 0xCC, 0xEE,
  0x77, 0x3B, 0x9D, 0xDC, 0xFE, 0x3E, 0x00, 0xE3, 0xF3, 0xB9, 0x9D, 0xCE,
  0xC7, 0xE3, 0xE0, 0xF0, 0x70, 0x38, 0x00, 0xE7, 0x3F, 0x39, 0xFB, 0xCD,
  0xDE, 0xEE, 0xF6, 0x6D, 0xF3, 0x6F, 0x1E, 0x78, 0xF3, 0xC7, 0x9C, 0x00,
  0x38, 0xE3, 0xB8, 0x76, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC1, 0xDC, 0x73,
  0x9E, 0x70, 0xE7, 0xB3, 0x9B, 0x8D, 0x87, 0xC1, 0xC0, 0xC0, 0xE0, 0x70,
  0x38, 0x00, 0x3F, 0x9F, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x7F,
  0x7F, 0x80, 0x3C, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0xE3, 0x0D, 0x38, 0xDB,
  0x6D, 0xDB, 0x6C, 0x1C, 0xB0, 0xC7, 0x18, 0x61, 0x86, 0x38, 0xC3, 0x3C,
  0x0C, 0x38, 0x71, 0xA6, 0x6C, 0xF1, 0x80, 0xFF, 0xF0, 0xEC, 0x80, 0x36,
  0xFF, 0xBF, 0x7C, 0xD9, 0xBF, 0x76, 0x38, 0x38, 0x38, 0x36, 0x3F, 0x77,
  0x77, 0x67, 0x66, 0xFE, 0xDC, 0x3D, 0xFE, 0x70, 0xC3, 0x2F, 0x9E, 0x07,
  0x07, 0x07, 0x36, 0x7E, 0xEE, 0xEE, 0xCC, 0xCC, 0xFC, 0xEC, 0x3C, 0xFF,
  0xBF, 0xFF, 0xD8, 0x3F, 0x3C, 0x07, 0x0F, 0x1C, 0x1E, 0x3E, 0x18, 0x18,
  0x38, 0x38, 0x38, 0x30, 0x70, 0xF0, 0xE0, 0x1B, 0x3F, 0x77, 0x77, 0x66,
  0x66, 0x7E, 0x7E, 0x0E, 0xFC, 0xF8, 0x38, 0x38, 0x38, 0x36, 0x3F, 0x77,
  0x77, 0x77, 0x67, 0xE6, 0xEE, 0x19, 0xC4, 0x63, 0x39, 0xCE, 0x67, 0x38,
  0x06, 0x1C, 0x10, 0x70, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0xCF, 0x1E,
  0x00, 0x38, 0x1C, 0x0E, 0x06, 0x73, 0x73, 0xF1, 0xF0, 0xF8, 0x7E, 0x77,
  0x39, 0xC0, 0x39, 0xCE, 0x63, 0x39, 0xCE, 0x67, 0x38, 0x36, 0x73, 0xFF,
  0x77, 0xB7, 0x73, 0x77, 0x76, 0x77, 0xE6, 0x7E, 0xE6, 0x36, 0x3F, 0x77,
  0x77, 0x77, 0x67, 0xE6, 0xEE, 0x3C, 0xFF, 0xBF, 0x7C, 0xF9, 0xBF, 0x3C,
  0x1F, 0x0F, 0xCE, 0xE7, 0x73, 0x39, 0x99, 0xFC, 0xFC, 0x70, 0x30, 0x38,
  0x00, 0x36, 0xFF, 0xBF, 0x7C, 0xD9, 0xBF, 0x7E, 0x1C, 0x30, 0xE0, 0x36,
  0x79, 0xF3, 0x87, 0x0C, 0x38, 0x70, 0x3C, 0xFD, 0xD3, 0xC3, 0xC3, 0xBF,
  0x7C, 0x18, 0x7D, 0xF7, 0x87, 0x0E, 0x18, 0x3C, 0x78, 0x67, 0xE6, 0xEE,
  0xEE, 0xCE, 0xCC, 0xFC, 0xEC, 0xCF, 0x9F, 0x36, 0xED, 0x9F, 0x3C, 0x38,
  0xCE, 0x79, 0xDF, 0x7B, 0x6F, 0xEF, 0x79, 0xEF, 0x3D, 0xC7, 0x38, 0x39,
  0xCE, 0xE1, 0xF0, 0x78, 0x1E, 0x0F, 0x87, 0x73, 0xDC, 0x33, 0x99, 0xCC,
  0xC6, 0xE3, 0xE1, 0xF0, 0xF0, 0x38, 0x38, 0x7C, 0x3C, 0x00, 0x7E, 0xFC,
  0x71, 0xC3, 0x8E, 0x3F, 0x7E, 0x1C, 0x73, 0x0C, 0x33, 0xCE, 0x18, 0x61,
  0x87, 0x1C, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0xE1, 0x86, 0x18, 0x71, 0xCC,
  0x31, 0xCE, 0x38, 0xF7, 0xFC,
};

const GFXglyph NotoSans_BlackItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 10, 4, 0, -10 },
  { 8, 6, 4, 6, 1, -10 },
  { 11, 9, 10, 9, 0, -10 },
  { 23, 8, 12, 8, 0, -11 },
  { 35, 12, 10, 13, 1, -10 },
  { 50, 10, 10, 10, 0, -10 },
  { 63, 3, 4, 3, 1, -10 },
  { 65, 6, 12, 5, 0, -10 },
  { 74, 6, 12, 5, -1, -10 },
  { 83, 7, 7, 8, 1, -11 },
  { 90, 7, 6, 8, 1, -8 },
  { 96, 4, 4, 4, -1, -2 },
  { 98, 4, 2, 5, 0, -5 },
  { 99, 3, 2, 4, 0, -2 },
  { 100, 8, 10, 7, -1, -10 },
  { 110, 8, 10, 8, 0, -10 },
  { 120, 6, 10, 8, 1, -10 },
  { 128, 8, 10, 8, 0, -10 },
  { 138, 8, 10, 8, 0, -10 },
  { 148, 8, 10, 8, 0, -10 },
  { 158, 8, 10, 8, 0, -10 },
  { 168, 7, 10, 8, 1, -10 },
  { 177, 9, 10, 8, 0, -10 },
  { 189, 8, 10, 8, 0, -10 },
  { 199, 7, 10, 8, 1, -10 },
  { 208, 4, 8, 4, 0, -8 },
  { 212, 5, 10, 4, -1, -8 },
  { 219, 7, 8, 8, 1, -9 },
  { 226, 7, 5, 8, 1, -7 },
  { 231, 7, 8, 8, 1, -9 },
  { 238, 6, 10, 7, 1, -10 },
  { 246, 11, 11, 13, 1, -10 },
  { 262, 10, 10, 9, -1, -10 },
  { 275, 9, 10, 9, 0, -10 },
  { 287, 8, 10, 9, 1, -10 },
  { 297, 9, 10, 10, 0, -10 },
  { 309, 8, 10, 8, 0, -10 },
  { 319, 8, 10, 8, 0, -10 },
  { 329, 9, 10, 10, 1, -10 },
  { 341, 10, 10, 10, 0, -10 },
  { 354, 8, 10, 6, -1, -10 },
  { 364, 7, 13, 5, -2, -10 },
  { 376, 10, 10, 9, 0, -10 },
  { 389, 7, 10, 7, 0, -10 },
  { 398, 13, 10, 13, 0, -10 },
  { 415, 11, 10, 11, 0, -10 },
  { 429, 9, 10, 10, 1, -10 },
  { 441, 9, 10, 9, 0, -10 },
  { 453, 9, 12, 10, 1, -10 },
  { 467, 9, 10, 9, 0, -10 },
  { 479, 8, 10, 8, 0, -10 },
  { 489, 8, 10, 8, 1, -10 },
  { 499, 9, 10, 10, 1, -10 },
  { 511, 9, 10, 9, 1, -10 },
  { 523, 13, 10, 13, 1, -10 },
  { 540, 11, 10, 9, -1, -10 },
  { 554, 9, 10, 8, 1, -10 },
  { 566, 9, 10, 8, -1, -10 },
  { 578, 6, 12, 5, 0, -10 },
  { 587, 3, 10, 7, 2, -10 },
  { 591, 6, 12, 5, -1, -10 },
  { 600, 7, 7, 7, 0, -10 },
  { 607, 6, 2, 6, -1, 1 },
  { 609, 3, 3, 5, 2, -11 },
  { 611, 7, 8, 9, 1, -8 },
  { 618, 8, 11, 9, 0, -11 },
  { 629, 6, 8, 7, 1, -8 },
  { 635, 8, 11, 8, 1, -11 },
  { 646, 7, 8, 8, 1, -8 },
  { 653, 8, 14, 6, -1, -11 },
  { 667, 8, 11, 9, 0, -8 },
  { 678, 8, 11, 9, 0, -11 },
  { 689, 5, 11, 5, 0, -11 },
  { 696, 7, 14, 5, -2, -11 },
  { 709, 9, 11, 9, 0, -11 },
  { 722, 5, 11, 5, 0, -11 },
  { 729, 12, 8, 13, 0, -8 },
  { 741, 8, 8, 9, 0, -8 },
  { 749, 7, 8, 9, 1, -8 },
  { 756, 9, 11, 9, -1, -8 },
  { 769, 7, 11, 9, 1, -8 },
  { 779, 7, 8, 6, 0, -8 },
  { 786, 7, 8, 7, 0, -8 },
  { 793, 7, 9, 6, 0, -9 },
  { 801, 8, 8, 9, 1, -8 },
  { 809, 7, 8, 8, 1, -8 },
  { 816, 11, 8, 12, 1, -8 },
  { 827, 10, 8, 8, -1, -8 },
  { 837, 9, 11, 8, -1, -8 },
  { 850, 7, 8, 7, 0, -8 },
  { 857, 6, 12, 5, 0, -10 },
  { 866, 2, 14, 8, 3, -11 },
  { 870, 6, 12, 5, -1, -10 },
  { 879, 7, 2, 8, 1, -6 },
};

const GFXfont NotoSans_BlackItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_BLACKITALIC14PT7B_H_
