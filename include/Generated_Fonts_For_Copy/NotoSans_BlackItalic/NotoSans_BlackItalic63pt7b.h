#ifndef _NOTOSANS_BLACKITALIC63PT7B_H_
#define _NOTOSANS_BLACKITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0xCF,
  0xFC, 0x7F, 0xF7, 0xFF, 0x1F, 0xF9, 0xFF, 0x87, 0xFE, 0x7F, 0xE1, 0xFF,
  0x9F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xFC, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF,
  0x83, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xDF, 0x8F, 0xC0, 0xFF, 0xE7, 0xC0,
  0x60, 0x3F, 0xF9, 0xF0, 0x00, 0x0F, 0xFE, 0x7C, 0x00, 0x03, 0xFF, 0x9F,
  0x00, 0x00, 0xFF, 0xEF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xBF,
  0xF8, 0x00, 0x07, 0xE7, 0xFE, 0x00, 0x01, 0xF1, 0xFF, 0x8C, 0x00, 0x7C,
  0x7F, 0xE3, 0xE0, 0x1F, 0x3F, 0xF8, 0xFF, 0x07, 0xDF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x7F, 0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x00,
  0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x00,
  0x00, 0x3F, 0xC1, 0xFF, 0x1F, 0xF0, 0x0E, 0x01, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFF, 0x0F, 0xF9, 0xFF, 0x8F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFC, 0x7F, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFC, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFE, 0x7F, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x1F, 0xFC, 0x3F, 0xE3, 0xFF, 0x1F, 0xF0, 0x1E, 0x03, 0xFE, 0x1F,
  0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFF,
  0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x01,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xFB, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8, 0x7F, 0xFE, 0xFF, 0xFB, 0xFF,
  0xE1, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x3F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF,
  0x7F, 0xF7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x04, 0x00, 0xFF, 0x80, 0x0E, 0x01, 0xFE, 0x00, 0x1F, 0x03, 0xFC,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFF, 0xCF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xE0,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x00, 0x3F,
  0xFD, 0xFF, 0x00, 0x3F, 0xF1, 0xFE, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x1F,
  0x87, 0xFC, 0x00, 0x1E, 0x0F, 0xFC, 0x00, 0x08, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF0, 0x0F, 0xE1, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x9F, 0xF8, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0xFF,
  0xF8, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC0,
  0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0x3F, 0xFC,
  0x03, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xFD, 0xFF,
  0xF0, 0x1F, 0xFE, 0x7F, 0xF8, 0x07, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0xE7,
  0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xF8, 0x07, 0xFF,
  0xBF, 0xFC, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x3F,
  0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0xCF, 0xFF, 0x01,
  0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xFE, 0x3F, 0xFC,
  0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xBF, 0xF8, 0x7F,
  0xF3, 0xFF, 0x83, 0xFE, 0x7F, 0xF8, 0x3F, 0x87, 0xFF, 0x81, 0xF0, 0x7F,
  0xF8, 0x0C, 0x07, 0xFF, 0x00, 0x80, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x00,
  0xE0, 0x0F, 0xFF, 0x00, 0x0C, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xF8, 0x1F, 0xFF, 0x80, 0x1C, 0x01, 0xFF, 0xF0, 0x02, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF2, 0x00, 0x00, 0x3F, 0xFC,
  0x78, 0x00, 0x0F, 0xFF, 0x8F, 0xE0, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0x7F, 0xF0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xF0, 0x00,
  0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFE,
  0x00, 0x7F, 0xE1, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0x81,
  0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x10, 0x00, 0x07, 0xFF, 0xC3, 0x80, 0x01, 0xFF,
  0xF8, 0x7E, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xB8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x02, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x3F, 0xC0, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0xFF, 0xE7, 0xFF,
  0xE0, 0x1F, 0xFD, 0xFF, 0xFE, 0x03, 0xFF, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F,
  0xFE, 0x3F, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF0,
  0x0F, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF,
  0x8F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x01,
  0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8,
  0x03, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF8, 0xFF,
  0xE0, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x7F, 0xFC, 0x0F, 0xFE, 0x7F, 0xFC,
  0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7F, 0xFC,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xEF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x01, 0xFE,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0xC0, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF,
  0xF1, 0xE0, 0x0F, 0xFF, 0x18, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x0C, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xFF,
  0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFF, 0xFE, 0x3F, 0xE1, 0xFF, 0x01, 0xFF,
  0xFF, 0xE1, 0xFE, 0x3F, 0xE0, 0x3F, 0xFF, 0xFE, 0x1F, 0xE3, 0xFC, 0x07,
  0xFF, 0xFF, 0xC1, 0xFE, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xE7, 0xFC,
  0x1F, 0xFE, 0x7F, 0xC1, 0xFF, 0x7F, 0x81, 0xFF, 0x87, 0xFC, 0x1F, 0xF7,
  0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x1F,
  0xEF, 0xF0, 0x7F, 0xC0, 0x7F, 0x81, 0xFE, 0xFF, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xEF, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xEF, 0xF0, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xCF, 0xF0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0xFF,
  0x0F, 0xFC, 0xFF, 0xF3, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x83, 0xFF, 0xF7, 0xFF, 0xF0, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xC0,
  0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xDF, 0xFC,
  0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xC3, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x3F,
  0xF0, 0x00, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F,
  0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x00,
  0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0x00, 0xFF, 0xFC, 0x00, 0x0E, 0x01, 0xFF, 0xF0, 0x00, 0x04,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x10, 0x03, 0xFF, 0xF0, 0x01, 0xE0, 0x07,
  0xFF, 0xF8, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xFC,
  0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x8F, 0xF8, 0x07, 0xFF, 0xF8, 0x00,
  0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x10, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xFC, 0x7F, 0xF8,
  0x1F, 0xFF, 0xFC, 0x7F, 0xF8, 0x1F, 0xFF, 0xFC, 0x7F, 0xF8, 0x1F, 0xFF,
  0xF8, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x9F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0x00, 0xFF, 0xBF, 0xF0,
  0x03, 0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xC0, 0x7F,
  0xDF, 0xFC, 0x00, 0xFF, 0xDF, 0xE0, 0x3F, 0xEF, 0xFE, 0x00, 0xFF, 0xEF,
  0xF0, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xF7, 0xF8, 0x1F, 0xF7, 0xFF, 0x00,
  0x3F, 0xF3, 0xFC, 0x0F, 0xF3, 0xFF, 0x80, 0x1F, 0xF9, 0xFE, 0x0F, 0xF9,
  0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F,
  0x87, 0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0x3F, 0xC3, 0xFC, 0x7F, 0xF0, 0x03,
  0xFF, 0x9F, 0xE3, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0x8F, 0xF1, 0xFF, 0x1F,
  0xFC, 0x01, 0xFF, 0xC7, 0xF9, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xE3, 0xFC,
  0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF1, 0xFE, 0xFF, 0x87, 0xFF, 0x00, 0x3F,
  0xF8, 0xFF, 0x7F, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF,
  0xC0, 0x1F, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF,
  0x87, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFC,
  0x01, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xFB, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xFE, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xFC, 0x01,
  0xFF, 0x9F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xCF, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xE7, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0x83, 0xFF, 0x80,
  0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0,
  0x07, 0xFF, 0x07, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x9F, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF7, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x9F, 0xFF, 0x00, 0x03, 0xFF, 0xCF,
  0xFF, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0xFF, 0xF7, 0xFF, 0xC0,
  0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00,
  0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0xFF,
  0xFB, 0xFF, 0xC0, 0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x9F, 0xFF, 0x00, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x01,
  0xFF, 0xEF, 0xFF, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0xFF, 0xFB,
  0xFF, 0xC0, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x00, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F,
  0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x7F, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFF, 0x1F, 0xFE, 0x00,
  0x7F, 0xFD, 0xFF, 0xE0, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xE0, 0x1F,
  0xFF, 0x00, 0x78, 0x07, 0xFF, 0x80, 0x04, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x20, 0x00, 0x1F, 0xFE,
  0x0E, 0x00, 0x07, 0xFF, 0x83, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x81, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x07, 0xFF, 0xCF,
  0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF0,
  0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x01, 0xFF,
  0xCF, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x83, 0xFE,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xDF, 0xF0, 0x7F, 0xF0, 0x0F,
  0xFE, 0x1F, 0xFB, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFE, 0x7F, 0xC3,
  0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xCF, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x1F,
  0xF9, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE3, 0xFE, 0x3F, 0xE3, 0xFF, 0x80,
  0x0F, 0xFC, 0xFF, 0xC7, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0xFF,
  0x9F, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x1F, 0xF3, 0xFF, 0x00, 0x07, 0xFE,
  0xFF, 0xC3, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x7F, 0xDF, 0xF8,
  0x00, 0x1F, 0xF7, 0xFE, 0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x07, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF3, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xE7, 0xFF, 0x80, 0x1F, 0xFF, 0x9F, 0xFE, 0x00, 0x7F, 0xFC, 0x7F, 0xF8,
  0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x7F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0xFF, 0xEF,
  0xFF, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0x9F, 0xE0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8,
  0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xF0, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0,
  0x0F, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0xF3, 0xFF, 0x01, 0xFF, 0xFF, 0x7F,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF,
  0xC7, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFE, 0x01,
  0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xE7, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xCF, 0xF0, 0x00, 0x7F,
  0xF7, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF1,
  0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF,
  0xE0, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xF0,
  0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0xFF,
  0xF0, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0x9F, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0xF0, 0x07, 0xFC,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xD0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x03, 0xFF, 0xE0,
  0x04, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x40, 0xFF, 0xF0, 0x03, 0x03, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xFF, 0x3F,
  0xF8, 0x03, 0xFF, 0xFD, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xFC, 0xFF, 0xC0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x3F, 0xFE,
  0x07, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x7F, 0xF8,
  0x0F, 0xFF, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x20, 0xFF, 0xF0, 0x00, 0xE0, 0xFF, 0xFC, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x40, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xBF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0x80, 0x1F, 0xFF, 0xCF, 0xFC,
  0x01, 0xFF, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x00,
  0x7F, 0x8F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x02, 0x00, 0x03, 0xFF, 0xC0, 0x18, 0x00,
  0x3F, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF,
  0x87, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03,
  0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFE, 0x1F,
  0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF,
  0x0F, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F,
  0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC,
  0x07, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F,
  0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3B, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0xF0,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xBF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF7, 0xFF, 0xC0, 0x01, 0xFF,
  0xE3, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xF1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x03, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x0F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC3, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE3,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE3, 0xFF,
  0xE0, 0x07, 0xFC, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xFF, 0xE0, 0x3F, 0xF7,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8,
  0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F,
  0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F,
  0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xE0,
  0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF0, 0xFF,
  0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xF0,
  0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0xC7,
  0xFF, 0x81, 0xFF, 0xF7, 0xFF, 0xC0, 0xFF, 0xFB, 0xFF, 0xC0, 0x7F, 0xFD,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0x7F, 0xF8, 0x07, 0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xDF, 0xFE, 0x01, 0xFF,
  0xEF, 0xFF, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F,
  0xF9, 0xFF, 0xE0, 0x7F, 0xFC, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xF8, 0x3F,
  0xFE, 0x3F, 0xFF, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x05, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x80,
  0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xFF, 0xC0, 0x01, 0xFF,
  0xBF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0xFF,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xFF, 0xC7,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xFE, 0x00,
  0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xF0,
  0x18, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0xF3, 0xFF,
  0x01, 0xFF, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE,
  0x1F, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xF0, 0x0F,
  0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF8,
  0x07, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xDF, 0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x00, 0x70, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x83, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC7,
  0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xF7, 0xFF, 0x01, 0xFF, 0xBF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x40, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xE0, 0xFF, 0xF0, 0x06, 0x07, 0xFF, 0xC0,
  0x10, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x80, 0x03, 0xFF, 0xC7, 0x00, 0x1F, 0xFE, 0x3F, 0x01, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x18, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFD, 0xFF, 0x80, 0x3F, 0xFF,
  0x9F, 0xF8, 0x01, 0xFF, 0xF1, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xCF, 0xFF, 0x00,
  0xFF, 0xF9, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF,
  0x80, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0x8F,
  0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xF8, 0x00, 0xFF,
  0xCF, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xF0, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xEF, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xCF, 0xFE,
  0x03, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0x87,
  0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFE, 0x07, 0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0xE0, 0x7F, 0xE1, 0xFE, 0xFF,
  0x1F, 0xFE, 0x07, 0xFE, 0x1F, 0xEF, 0xF1, 0xFF, 0xC0, 0x7F, 0xE3, 0xFC,
  0xFF, 0x1F, 0xFC, 0x07, 0xFE, 0x3F, 0xCF, 0xF3, 0xFF, 0x80, 0x7F, 0xE3,
  0xFD, 0xFE, 0x3F, 0xF8, 0x07, 0xFE, 0x7F, 0x9F, 0xE7, 0xFF, 0x00, 0x7F,
  0xE7, 0xF9, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0x9F, 0xE7, 0xFE, 0x00,
  0x7F, 0xEF, 0xF1, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0x1F, 0xEF, 0xFC,
  0x00, 0x7F, 0xEF, 0xF1, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x03,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xCF, 0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xEF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x02, 0x7F, 0xFE, 0x00, 0x0D, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFA, 0x00, 0x03, 0xFF, 0xC4, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_BlackItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 22, 46, 19, 0, -45 },
  { 128, 26, 16, 29, 6, -45 },
  { 180, 42, 45, 41, 0, -45 },
  { 417, 34, 52, 37, 2, -48 },
  { 638, 53, 47, 59, 4, -46 },
  { 950, 46, 47, 46, 0, -46 },
  { 1221, 12, 16, 15, 6, -45 },
  { 1245, 26, 56, 24, 2, -46 },
  { 1427, 25, 56, 24, -4, -46 },
  { 1602, 31, 31, 34, 5, -48 },
  { 1723, 31, 31, 37, 3, -38 },
  { 1844, 17, 15, 19, -3, -7 },
  { 1876, 19, 10, 21, 1, -22 },
  { 1900, 13, 12, 19, 0, -11 },
  { 1920, 37, 47, 29, -3, -46 },
  { 2138, 34, 47, 37, 2, -46 },
  { 2338, 28, 45, 37, 5, -45 },
  { 2496, 36, 46, 37, -2, -46 },
  { 2703, 35, 47, 37, 0, -46 },
  { 2909, 36, 45, 37, 0, -45 },
  { 3112, 35, 46, 37, 1, -45 },
  { 3314, 35, 47, 37, 2, -46 },
  { 3520, 38, 45, 37, 1, -45 },
  { 3734, 34, 47, 37, 2, -46 },
  { 3934, 32, 47, 37, 3, -46 },
  { 4122, 19, 36, 19, 0, -35 },
  { 4208, 23, 43, 19, -4, -35 },
  { 4332, 31, 35, 37, 3, -40 },
  { 4468, 31, 22, 37, 3, -33 },
  { 4554, 31, 35, 37, 3, -40 },
  { 4690, 28, 47, 31, 5, -46 },
  { 4855, 52, 52, 57, 3, -46 },
  { 5193, 42, 45, 43, -4, -45 },
  { 5430, 38, 45, 40, 1, -45 },
  { 5644, 39, 47, 40, 3, -46 },
  { 5874, 40, 45, 43, 1, -45 },
  { 6099, 36, 45, 35, 1, -45 },
  { 6302, 36, 45, 36, 1, -45 },
  { 6505, 40, 47, 44, 3, -46 },
  { 6740, 44, 45, 45, 1, -45 },
  { 6988, 32, 45, 27, -2, -45 },
  { 7168, 34, 59, 24, -10, -45 },
  { 7419, 46, 45, 42, 1, -45 },
  { 7678, 29, 45, 33, 1, -45 },
  { 7842, 57, 45, 57, 1, -45 },
  { 8163, 49, 45, 50, 1, -45 },
  { 8439, 41, 47, 46, 3, -46 },
  { 8680, 38, 45, 39, 1, -45 },
  { 8894, 41, 57, 46, 3, -46 },
  { 9187, 37, 45, 41, 1, -45 },
  { 9396, 34, 47, 35, 1, -46 },
  { 9596, 34, 45, 35, 5, -45 },
  { 9788, 41, 46, 44, 4, -45 },
  { 10024, 39, 45, 39, 5, -45 },
  { 10244, 59, 45, 59, 5, -45 },
  { 10576, 51, 45, 42, -4, -45 },
  { 10863, 38, 45, 38, 5, -45 },
  { 11077, 40, 45, 34, -3, -45 },
  { 11302, 29, 57, 23, -2, -46 },
  { 11509, 17, 47, 29, 7, -46 },
  { 11609, 28, 57, 23, -4, -46 },
  { 11809, 33, 30, 34, 0, -45 },
  { 11933, 31, 8, 28, -6, 4 },
  { 11964, 15, 10, 22, 9, -48 },
  { 11983, 35, 36, 38, 3, -35 },
  { 12141, 35, 49, 38, 1, -48 },
  { 12356, 30, 36, 32, 3, -35 },
  { 12491, 37, 49, 38, 3, -48 },
  { 12718, 32, 36, 36, 3, -35 },
  { 12862, 38, 63, 26, -6, -48 },
  { 13162, 37, 50, 38, 1, -35 },
  { 13394, 35, 48, 39, 1, -48 },
  { 13604, 21, 49, 20, 1, -49 },
  { 13733, 31, 64, 20, -8, -49 },
  { 13981, 41, 48, 39, 1, -48 },
  { 14227, 22, 48, 20, 1, -48 },
  { 14359, 54, 35, 58, 1, -35 },
  { 14596, 35, 35, 39, 1, -35 },
  { 14750, 33, 36, 38, 3, -35 },
  { 14899, 39, 50, 38, -3, -35 },
  { 15143, 35, 50, 38, 3, -35 },
  { 15362, 29, 35, 28, 1, -35 },
  { 15489, 29, 36, 32, 1, -35 },
  { 15620, 27, 43, 29, 2, -42 },
  { 15766, 36, 36, 39, 3, -35 },
  { 15928, 35, 35, 34, 3, -35 },
  { 16082, 52, 35, 52, 3, -35 },
  { 16310, 44, 35, 36, -4, -35 },
  { 16503, 42, 50, 34, -4, -35 },
  { 16766, 33, 35, 31, -1, -35 },
  { 16911, 28, 55, 23, -1, -45 },
  { 17104, 8, 62, 36, 14, -48 },
  { 17166, 27, 55, 23, -4, -45 },
  { 17352, 31, 12, 37, 3, -28 },
};

const GFXfont NotoSans_BlackItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_BLACKITALIC63PT7B_H_
