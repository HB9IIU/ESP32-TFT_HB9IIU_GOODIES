#ifndef _NOTOSANS_BLACKITALIC34PT7B_H_
#define _NOTOSANS_BLACKITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07,
  0xC0, 0x7E, 0xFD, 0xF3, 0xF7, 0xCF, 0x9F, 0x3E, 0x78, 0xFB, 0xE3, 0xEF,
  0x8F, 0x3E, 0x7C, 0xF1, 0xF0, 0x00, 0x78, 0xF8, 0x01, 0xF1, 0xE0, 0x03,
  0xE7, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x0F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x0F, 0x1F,
  0x00, 0x1E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF9, 0xF0, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00,
  0xF8, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0x9C, 0x3F, 0x70, 0x07,
  0xEE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3B, 0xF2, 0x07, 0x7E, 0x70,
  0xEF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x40, 0xFF, 0x00, 0x7C, 0x0F, 0xFC, 0x03, 0xC0, 0x7F, 0xE0, 0x3E, 0x07,
  0xFF, 0x03, 0xE0, 0x3E, 0x78, 0x3E, 0x03, 0xE3, 0xE1, 0xE0, 0x1F, 0x1E,
  0x1F, 0x00, 0xF9, 0xF1, 0xF0, 0x07, 0xCF, 0x9F, 0x00, 0x3E, 0x7C, 0xF9,
  0xF1, 0xF7, 0xCF, 0xBF, 0xCF, 0xFE, 0xFB, 0xFF, 0x3F, 0xEF, 0x9F, 0xFC,
  0xFE, 0x7D, 0xFB, 0xE0, 0x87, 0xCF, 0x9F, 0x00, 0x7C, 0x7C, 0xF8, 0x07,
  0xC7, 0xC7, 0xC0, 0x3E, 0x3E, 0x3E, 0x03, 0xE1, 0xF3, 0xE0, 0x3E, 0x0F,
  0x9F, 0x03, 0xE0, 0x7F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x0F, 0xF8,
  0x1F, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xE7, 0xF0, 0xFF, 0xE3, 0xF1, 0xFF, 0xE1, 0xF9,
  0xFF, 0xF9, 0xFC, 0xFE, 0xFF, 0xFC, 0xFE, 0x7F, 0xFE, 0x7F, 0x1F, 0xFE,
  0x3F, 0x87, 0xFE, 0x1F, 0xC1, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xF9, 0xFE, 0x00, 0x7E,
  0xF9, 0xF3, 0xE7, 0x9F, 0x3E, 0x7C, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x41,
  0xE0, 0x71, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFF, 0x1F, 0xEF, 0x3F, 0xE0, 0xFF, 0xF0, 0x7C, 0xF0, 0x18, 0xF8, 0x08,
  0xF8, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1F,
  0x8F, 0xCF, 0xC7, 0xE3, 0xE3, 0xF1, 0xF1, 0xF8, 0x7F, 0xEF, 0xF9, 0xFF,
  0x3F, 0xEF, 0xFC, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xF3, 0xF9, 0xFC, 0xFE, 0x3F, 0x7F, 0x0F, 0xDF, 0xC3, 0xF7, 0xE0,
  0xFD, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7E,
  0xFE, 0x3F, 0xBF, 0x8F, 0xEF, 0xE3, 0xF3, 0xF9, 0xFC, 0xFF, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x7E,
  0xFC, 0x3C, 0xFC, 0x10, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x0C, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0x87, 0xF0, 0x30, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80,
  0x00, 0x78, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC1, 0x83, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFA, 0x00, 0x7F, 0x60, 0x1F, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xEF, 0x80, 0xFF, 0xF0,
  0x3F, 0x7E, 0x07, 0xCF, 0xC1, 0xF3, 0xF8, 0x7C, 0x7E, 0x1F, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x87, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0xC0, 0x3F, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x80,
  0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xEF, 0xC1, 0xFB, 0xFC, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xC7, 0xE7, 0xF0, 0xFC, 0xFE,
  0x1F, 0x9F, 0xC3, 0xF3, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xF3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFD, 0xFC, 0xFE, 0x3F, 0xBF,
  0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0xFE, 0xFE, 0x7F, 0x3F, 0xFF, 0xC7, 0xFF,
  0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x01, 0xE0, 0x07, 0xFC, 0x07, 0xFF,
  0x87, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFB, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFC, 0xFF, 0x7E, 0x1F, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F,
  0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0x00, 0x00,
  0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC0,
  0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x0F,
  0xFC, 0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x03,
  0xFF, 0x0F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x1F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFF, 0x30, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xF0, 0x7F, 0x1F, 0x3E, 0x1F, 0xFC,
  0xF3, 0xC3, 0xFF, 0x8F, 0x7C, 0x7F, 0xF8, 0xF7, 0x8F, 0xCF, 0x8F, 0x78,
  0xF8, 0xF8, 0xF7, 0x9F, 0x0F, 0x0F, 0xF9, 0xF0, 0xF0, 0xFF, 0x9F, 0x1F,
  0x1F, 0xF9, 0xF1, 0xF1, 0xEF, 0x9F, 0x3F, 0x3E, 0xF9, 0xFF, 0xFF, 0xC7,
  0x8F, 0xFF, 0xF8, 0x7C, 0x7E, 0x7F, 0x07, 0xC1, 0x81, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF8, 0x07, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xDF,
  0x00, 0x1F, 0xBE, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xF8, 0x03, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0xDF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0x8F, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0x1F, 0xC7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE1,
  0xFC, 0x7E, 0x3F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x03, 0x87, 0xF0,
  0x04, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x41, 0xFE, 0x0E, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xE3, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0xCF, 0xE0, 0x7E, 0x7F, 0x07, 0xF3, 0xF0, 0x3F, 0x9F, 0x81, 0xFC, 0xFC,
  0x0F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF0, 0x7F, 0x1F, 0x9F, 0xF9,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF,
  0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0x81, 0x87, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x7F, 0xEF, 0xE3, 0xFF, 0x7E, 0x1F, 0xFB, 0xF1, 0xFF, 0x9F, 0x8F,
  0xFC, 0xFC, 0x07, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFE, 0x1F, 0x87,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x07,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE,
  0x1F, 0x81, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7F,
  0x07, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0,
  0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0x07, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xF0,
  0x00, 0x0F, 0xE0, 0xFF, 0x0F, 0xE1, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xC3,
  0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0xCF, 0xF0, 0x1F, 0xDF, 0xE0, 0x1F, 0x9F,
  0xC0, 0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x0F, 0xF8,
  0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03,
  0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF,
  0x87, 0xDE, 0x0F, 0x7C, 0x1F, 0x78, 0x7D, 0xF0, 0x7D, 0xE1, 0xFF, 0xC3,
  0xF7, 0x8F, 0xBF, 0x0F, 0xDE, 0x3E, 0xFC, 0x3F, 0x79, 0xF7, 0xE0, 0xFD,
  0xE7, 0xDF, 0x83, 0xE7, 0x9E, 0x7E, 0x1F, 0x9E, 0xF9, 0xF8, 0x7E, 0x7B,
  0xC7, 0xC1, 0xF9, 0xFF, 0x3F, 0x07, 0xC7, 0xF8, 0xFC, 0x3F, 0x1F, 0xE3,
  0xF0, 0xFC, 0x7F, 0x8F, 0xC3, 0xF1, 0xFC, 0x3E, 0x0F, 0xC7, 0xF1, 0xF8,
  0x3E, 0x1F, 0x87, 0xE0, 0x0F, 0xF0, 0x0F, 0xC3, 0xFE, 0x03, 0xF0, 0xFF,
  0x80, 0xF8, 0x3F, 0xE0, 0x7E, 0x0F, 0xFC, 0x1F, 0x87, 0xFF, 0x07, 0xE1,
  0xFF, 0xC1, 0xF8, 0x7D, 0xF0, 0x7C, 0x1F, 0x7E, 0x3F, 0x07, 0xDF, 0x8F,
  0xC3, 0xF3, 0xE3, 0xF0, 0xFC, 0xFC, 0xFC, 0x3F, 0x3F, 0x3E, 0x0F, 0xCF,
  0xDF, 0x83, 0xE1, 0xFF, 0xE1, 0xF8, 0x7F, 0xF8, 0x7E, 0x1F, 0xFC, 0x1F,
  0x83, 0xFF, 0x07, 0xE0, 0xFF, 0xC3, 0xF0, 0x3F, 0xF0, 0xFC, 0x0F, 0xFC,
  0x3F, 0x01, 0xFE, 0x0F, 0xC0, 0x7F, 0x83, 0xE0, 0x1F, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE3, 0xFC, 0x3F, 0xCF, 0xE0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x1F, 0xCF,
  0xE0, 0x7F, 0x3F, 0xC7, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0xFE, 0x3F, 0xBF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3,
  0xFC, 0x3F, 0xCF, 0xE0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x1F, 0xCF, 0xE0, 0xFF, 0x3F,
  0xC7, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xF7,
  0xF0, 0x7F, 0x3F, 0x07, 0xE3, 0xF8, 0x7E, 0x3F, 0x8F, 0xE1, 0xFC, 0xFE,
  0x1F, 0xCF, 0xE1, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0x00, 0x70, 0x00,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC3, 0xF8,
  0x30, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x88, 0x07, 0xE3, 0x83, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xE1,
  0xF8, 0x1F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE3, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xFE, 0x03, 0xFD, 0xF8, 0x0F, 0xE7,
  0xE0, 0x7F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x87, 0xE0,
  0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF0,
  0x1F, 0x9F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x03, 0xEF, 0xC0, 0x0F,
  0xBF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0xFC, 0x07, 0xC0, 0x7F, 0xFC, 0x0F, 0xC0, 0x7E, 0xFC, 0x0F, 0xC0, 0xFC,
  0xFC, 0x1F, 0xC0, 0xFC, 0xFC, 0x1F, 0xC1, 0xFC, 0xFC, 0x3F, 0xC1, 0xF8,
  0xFC, 0x3F, 0xC1, 0xF8, 0xFC, 0x7F, 0xC3, 0xF0, 0xFC, 0x7F, 0xC3, 0xF0,
  0xFC, 0x7B, 0xC7, 0xE0, 0xFC, 0xFB, 0xC7, 0xE0, 0xFC, 0xFB, 0xC7, 0xE0,
  0xF9, 0xF7, 0xCF, 0xC0, 0xF9, 0xF7, 0xCF, 0xC0, 0xFB, 0xF7, 0xDF, 0x80,
  0xFB, 0xE7, 0xDF, 0x80, 0xFB, 0xE7, 0xDF, 0x00, 0xFF, 0xC7, 0xDF, 0x00,
  0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0xFC,
  0x3F, 0x80, 0x1F, 0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x7F, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0xFE, 0x07, 0xFF,
  0xE0, 0xFE, 0xFE, 0x1F, 0xC7, 0xE1, 0xFC, 0x7E, 0x3F, 0x87, 0xE3, 0xF0,
  0x3F, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x81, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0x7C,
  0x07, 0x9F, 0x03, 0xE3, 0xC1, 0xF0, 0xF0, 0x78, 0x3E, 0x3E, 0x07, 0x9F,
  0x01, 0xE7, 0xC0, 0x7F, 0xE0, 0x1F, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x7E, 0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0xFE, 0x7C,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0x3F, 0x9F, 0xC3, 0xF3,
  0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF3, 0xF8, 0x7E, 0x7F, 0x0F, 0xCF,
  0xE3, 0xF9, 0xFC, 0x7E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x7E, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x7C,
  0x0F, 0xDF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFC, 0xFE,
  0x3F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x3F, 0x0F, 0xE7, 0xE1, 0xFC,
  0xFC, 0x3F, 0x9F, 0x8F, 0xE3, 0xF1, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x7D, 0xFE, 0x1F, 0x9F, 0x80, 0x01, 0xFE, 0x03, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1, 0xFC, 0x31, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0,
  0x61, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0xFC, 0x07, 0xF7, 0xE0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xF9, 0xFC, 0x3F, 0x87,
  0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xF0, 0xFC, 0x3F,
  0x87, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xDF, 0xCF, 0xC3, 0xF7, 0xF0,
  0xFD, 0xFC, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xC0,
  0xFE, 0x00, 0x3F, 0x80, 0x87, 0xF1, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x3F, 0x9F, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFC, 0xFE, 0x3F, 0x87, 0xE3, 0xF8,
  0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0xBF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x0C, 0x07, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xE7, 0xF1, 0xFC, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F,
  0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1,
  0xFC, 0x7E, 0x1F, 0x8F, 0xE1, 0xF8, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0,
  0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0xFF, 0x0F, 0xC3, 0xFC, 0x1F, 0x87, 0xF0, 0x3F, 0x1F,
  0xC0, 0xFE, 0x7F, 0x01, 0xFD, 0xFC, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F,
  0x0F, 0xE0, 0x7E, 0x1F, 0xE1, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x0F,
  0x8F, 0x83, 0xF0, 0x3E, 0x7F, 0x1F, 0xE0, 0xFB, 0xFE, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xE1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xFC, 0xFE, 0x1F, 0x87,
  0xE3, 0xF8, 0xFE, 0x1F, 0x8F, 0xC3, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF8,
  0xFC, 0x3F, 0x0F, 0xE7, 0xF0, 0xFC, 0x3F, 0x1F, 0xC7, 0xF0, 0xFC, 0x7E,
  0x1F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0xCF, 0xE1, 0xF8, 0x7F, 0x00, 0x0F,
  0x8F, 0x80, 0xFB, 0xFC, 0x0F, 0xBF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1,
  0xFE, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0x7E,
  0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F,
  0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x1F, 0x80, 0x01,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xE7,
  0xF7, 0xF0, 0xFD, 0xFC, 0x3F, 0x7E, 0x0F, 0xDF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xBF, 0x8F, 0xE7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F,
  0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xCF, 0x80, 0x7D, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x7F,
  0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE3, 0xE0, 0xFE, 0x7C, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFC, 0x7F, 0x3F, 0x9F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0xCF,
  0xC3, 0xF3, 0xF8, 0x7E, 0x7F, 0x0F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7E, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xF7, 0xE0, 0x7D, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x0F, 0x8F, 0x0F, 0x9F, 0x0F,
  0xBF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF7, 0xF3, 0xCF, 0xE0, 0x9F, 0xE0, 0x1F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xD0, 0x3F, 0xBC,
  0xFF, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x00, 0x01, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFC, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x21, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0x8F, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F,
  0x3F, 0x87, 0xE7, 0xF1, 0xFC, 0xFC, 0x3F, 0x9F, 0x87, 0xE3, 0xF0, 0xFC,
  0xFE, 0x1F, 0x9F, 0xC7, 0xF3, 0xF0, 0xFE, 0x7E, 0x1F, 0x8F, 0xC7, 0xF1,
  0xF8, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xF7, 0xC0,
  0xFC, 0xF8, 0x00, 0xFE, 0x0F, 0xEF, 0xC1, 0xFD, 0xF8, 0x3F, 0x3F, 0x0F,
  0xE7, 0xE1, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F, 0xC3, 0xF3, 0xF8, 0x3E, 0x7E,
  0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x3F, 0x87, 0xFF, 0xC3, 0xF8, 0x7E, 0xFC, 0x7F, 0x87, 0xEF,
  0xC7, 0xF8, 0xFC, 0xFC, 0x7F, 0x8F, 0xCF, 0xCF, 0x79, 0xF8, 0xFC, 0xFF,
  0x9F, 0x8F, 0xCF, 0xFB, 0xF0, 0xFD, 0xFF, 0xBF, 0x0F, 0xDE, 0xFB, 0xE0,
  0xFF, 0xEF, 0xFE, 0x0F, 0xFC, 0xF7, 0xE0, 0xFF, 0xCF, 0x7C, 0x0F, 0xFC,
  0xFF, 0xC0, 0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x8F, 0xF0,
  0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x0F,
  0xE3, 0xF8, 0x1F, 0xCF, 0xF0, 0x1F, 0x9F, 0xC0, 0x3F, 0x7F, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xF7, 0xF0, 0x0F, 0xE7, 0xE0, 0x3F, 0x8F, 0xC0, 0xFF, 0x1F, 0xC3,
  0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x3F, 0x83,
  0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF3,
  0xF8, 0x07, 0xCF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x01,
  0xFC, 0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0xFF, 0x07, 0xFC,
  0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xF8, 0x00, 0x7F, 0x01, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x80, 0xFE,
};

const GFXglyph NotoSans_BlackItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 24, 10, 0, -24 },
  { 37, 14, 9, 15, 3, -24 },
  { 53, 23, 24, 22, 0, -24 },
  { 122, 19, 28, 20, 1, -26 },
  { 189, 29, 25, 32, 2, -25 },
  { 280, 25, 25, 25, 0, -25 },
  { 359, 7, 9, 8, 3, -24 },
  { 367, 14, 30, 13, 1, -25 },
  { 420, 14, 30, 13, -2, -25 },
  { 473, 16, 17, 18, 3, -26 },
  { 507, 16, 16, 20, 2, -20 },
  { 539, 9, 8, 10, -2, -4 },
  { 548, 11, 5, 11, 0, -12 },
  { 555, 7, 6, 10, 0, -6 },
  { 561, 20, 25, 16, -2, -25 },
  { 624, 18, 25, 20, 1, -25 },
  { 681, 16, 24, 20, 2, -24 },
  { 729, 20, 25, 20, -1, -25 },
  { 792, 19, 25, 20, 0, -25 },
  { 852, 19, 24, 20, 0, -24 },
  { 909, 20, 24, 20, 0, -24 },
  { 969, 19, 25, 20, 1, -25 },
  { 1029, 20, 24, 20, 1, -24 },
  { 1089, 18, 25, 20, 1, -25 },
  { 1146, 17, 25, 20, 2, -25 },
  { 1200, 10, 19, 10, 0, -19 },
  { 1224, 12, 23, 10, -2, -19 },
  { 1259, 16, 19, 20, 2, -22 },
  { 1297, 16, 12, 20, 2, -18 },
  { 1321, 16, 19, 20, 2, -22 },
  { 1359, 16, 25, 17, 2, -25 },
  { 1409, 28, 28, 31, 1, -25 },
  { 1507, 23, 24, 23, -2, -24 },
  { 1576, 20, 24, 22, 1, -24 },
  { 1636, 21, 25, 21, 2, -25 },
  { 1702, 21, 24, 23, 1, -24 },
  { 1765, 19, 24, 19, 1, -24 },
  { 1822, 19, 24, 19, 1, -24 },
  { 1879, 21, 25, 24, 2, -25 },
  { 1945, 23, 24, 24, 1, -24 },
  { 2014, 17, 24, 14, -1, -24 },
  { 2065, 18, 32, 13, -5, -24 },
  { 2137, 24, 24, 23, 1, -24 },
  { 2209, 15, 24, 18, 1, -24 },
  { 2254, 30, 24, 31, 1, -24 },
  { 2344, 26, 24, 27, 1, -24 },
  { 2422, 22, 25, 25, 2, -25 },
  { 2491, 20, 24, 21, 1, -24 },
  { 2551, 22, 31, 25, 2, -25 },
  { 2637, 20, 24, 22, 1, -24 },
  { 2697, 18, 25, 19, 1, -25 },
  { 2754, 18, 24, 19, 3, -24 },
  { 2808, 22, 24, 24, 2, -24 },
  { 2874, 22, 24, 21, 2, -24 },
  { 2940, 32, 24, 32, 3, -24 },
  { 3036, 27, 24, 23, -2, -24 },
  { 3117, 20, 24, 21, 3, -24 },
  { 3177, 22, 24, 18, -2, -24 },
  { 3243, 15, 31, 12, -1, -25 },
  { 3302, 9, 25, 16, 4, -25 },
  { 3331, 15, 31, 12, -2, -25 },
  { 3390, 18, 16, 18, 0, -24 },
  { 3426, 16, 4, 15, -3, 2 },
  { 3434, 8, 5, 12, 5, -26 },
  { 3439, 19, 19, 21, 1, -19 },
  { 3485, 19, 26, 21, 0, -26 },
  { 3547, 17, 19, 17, 1, -19 },
  { 3588, 21, 26, 21, 1, -26 },
  { 3657, 18, 19, 20, 1, -19 },
  { 3700, 20, 34, 14, -3, -26 },
  { 3785, 20, 27, 21, 0, -19 },
  { 3853, 20, 26, 21, 0, -26 },
  { 3918, 12, 26, 11, 0, -26 },
  { 3957, 16, 34, 11, -4, -26 },
  { 4025, 23, 26, 21, 0, -26 },
  { 4100, 12, 26, 11, 0, -26 },
  { 4139, 30, 19, 31, 0, -19 },
  { 4211, 20, 19, 21, 0, -19 },
  { 4259, 18, 19, 21, 1, -19 },
  { 4302, 20, 27, 21, -1, -19 },
  { 4370, 19, 27, 21, 1, -19 },
  { 4435, 16, 19, 15, 0, -19 },
  { 4473, 15, 19, 17, 1, -19 },
  { 4509, 15, 23, 16, 1, -23 },
  { 4553, 19, 19, 21, 2, -19 },
  { 4599, 19, 19, 19, 1, -19 },
  { 4645, 28, 19, 28, 2, -19 },
  { 4712, 23, 19, 19, -2, -19 },
  { 4767, 22, 27, 19, -2, -19 },
  { 4842, 18, 19, 16, -1, -19 },
  { 4885, 15, 29, 12, 0, -24 },
  { 4940, 5, 34, 19, 7, -26 },
  { 4962, 14, 29, 12, -2, -24 },
  { 5013, 16, 6, 20, 2, -15 },
};

const GFXfont NotoSans_BlackItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_BLACKITALIC34PT7B_H_
