#ifndef _NOTOSANS_BLACKITALIC12PT7B_H_
#define _NOTOSANS_BLACKITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x37, 0x76, 0x66, 0x0E, 0xC0, 0xDE, 0xF5, 0xA0, 0x1A, 0x16, 0x16,
  0x7F, 0x34, 0xFE, 0xFE, 0x68, 0x58, 0x08, 0x7D, 0xB3, 0x83, 0x83, 0xA7,
  0x7E, 0x30, 0x40, 0x61, 0xBC, 0xCF, 0x22, 0xD8, 0xFF, 0xDE, 0xF1, 0x6C,
  0xDB, 0x63, 0x80, 0x1C, 0x1F, 0x0D, 0x87, 0x87, 0xBF, 0xDB, 0x3D, 0xFC,
  0x7F, 0x00, 0xFF, 0x19, 0x8C, 0xC6, 0x23, 0x18, 0x43, 0x18, 0x30, 0xC6,
  0x31, 0x8C, 0x66, 0x33, 0x30, 0x33, 0xCF, 0xDF, 0xD0, 0x60, 0x21, 0x3F,
  0xF2, 0x10, 0x76, 0xC0, 0xFE, 0xF0, 0x06, 0x0C, 0x30, 0x61, 0x87, 0x0C,
  0x30, 0xE0, 0x18, 0x79, 0xFB, 0x76, 0xFD, 0xFB, 0x3E, 0x78, 0x19, 0xFF,
  0xF3, 0x18, 0xC6, 0x70, 0x18, 0xF8, 0xB8, 0x61, 0xC7, 0x1C, 0x7E, 0xFC,
  0x18, 0xF8, 0xB8, 0x63, 0x83, 0x83, 0x7E, 0xF8, 0x06, 0x1C, 0x71, 0xE6,
  0xC9, 0xFF, 0x0C, 0x18, 0x3E, 0x7C, 0xC3, 0xC7, 0xC1, 0x83, 0x7E, 0xF8,
  0x0E, 0x7D, 0xC3, 0x67, 0xDD, 0xBB, 0x3E, 0x78, 0x7E, 0xFC, 0x38, 0x61,
  0xC7, 0x0C, 0x38, 0xE0, 0x18, 0x7D, 0x9B, 0xE3, 0x8D, 0xB3, 0x7E, 0x78,
  0x33, 0xED, 0xF7, 0xFF, 0xE1, 0xBC, 0xE0, 0x27, 0x20, 0x0C, 0xC0, 0x11,
  0xC4, 0x00, 0x09, 0x8C, 0xC0, 0x08, 0xDF, 0x8F, 0x1C, 0x20, 0xF8, 0x3F,
  0xF0, 0x86, 0x3C, 0x37, 0xF2, 0x00, 0x77, 0xE6, 0x77, 0x70, 0x18, 0xC0,
  0x0F, 0x0F, 0xE2, 0x0D, 0xBD, 0x5B, 0x56, 0x9D, 0xFD, 0x6E, 0x62, 0x0F,
  0x80, 0x07, 0x0F, 0x0F, 0x1B, 0x1B, 0x33, 0x3F, 0x63, 0xE3, 0x3C, 0x7C,
  0xDB, 0xB7, 0xCD, 0xDB, 0xBF, 0xFC, 0x1C, 0xFF, 0x96, 0x0C, 0x18, 0x30,
  0x7C, 0x78, 0x38, 0x3E, 0x37, 0x73, 0x67, 0x67, 0x66, 0x7E, 0xF8, 0x3E,
  0x7C, 0xC3, 0x87, 0xCF, 0x98, 0x3E, 0xF8, 0x3E, 0x7C, 0xC3, 0x87, 0xCF,
  0x98, 0x30, 0xE0, 0x1C, 0xFF, 0x8E, 0x0D, 0xFB, 0xF3, 0x7E, 0x7C, 0x33,
  0x99, 0x8C, 0xCE, 0x67, 0xF3, 0xF9, 0x98, 0xCC, 0xE6, 0x00, 0x7D, 0xF3,
  0x0C, 0x31, 0xC6, 0x3C, 0xF0, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C,
  0x18, 0x73, 0xC7, 0x00, 0x33, 0x9B, 0x8D, 0x8F, 0x87, 0xC3, 0xE1, 0xB0,
  0xDC, 0xE6, 0x00, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x1F, 0xF8, 0x38, 0xE7,
  0x3C, 0xE7, 0xBD, 0xE7, 0xBC, 0xF5, 0x9F, 0xB3, 0xEC, 0xDD, 0x80, 0x39,
  0xCE, 0x63, 0x99, 0xB6, 0x6D, 0x9B, 0xC6, 0xF1, 0x9C, 0xC7, 0x00, 0x1C,
  0xFF, 0x9E, 0x3C, 0x78, 0xF3, 0xFE, 0x78, 0x38, 0x7C, 0xDB, 0xB7, 0xEF,
  0x98, 0x30, 0xE0, 0x1C, 0xFF, 0x9E, 0x3C, 0x78, 0xF3, 0xFE, 0x78, 0x38,
  0x30, 0x38, 0x7C, 0xDB, 0xB7, 0xEF, 0x9B, 0x37, 0xE6, 0x1C, 0x7D, 0x93,
  0x83, 0x83, 0xA7, 0x7E, 0xF8, 0xFF, 0xF3, 0x0C, 0x71, 0x86, 0x18, 0xE0,
  0x67, 0x66, 0x66, 0xE6, 0xCE, 0xCC, 0xCC, 0xFC, 0x78, 0xC7, 0x9F, 0x36,
  0x6D, 0x9B, 0x3C, 0x78, 0xE0, 0xC6, 0x79, 0xCF, 0x3B, 0x6F, 0x6D, 0xF9,
  0xEF, 0x3D, 0xE7, 0x38, 0xE7, 0x00, 0x39, 0xC6, 0x61, 0xB0, 0x7C, 0x0E,
  0x07, 0x83, 0xE1, 0xDC, 0xE3, 0x00, 0xC7, 0xDD, 0xF3, 0xC7, 0x0E, 0x18,
  0x30, 0x60, 0x3F, 0x3F, 0x06, 0x0E, 0x1C, 0x38, 0x30, 0x7E, 0xFE, 0x39,
  0xD8, 0xC6, 0x31, 0x18, 0xC6, 0x38, 0xCC, 0x46, 0x66, 0x66, 0x30, 0x3C,
  0xE1, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xCE, 0x00, 0x08, 0x63, 0x8B, 0x6F,
  0x10, 0xFC, 0xCC, 0x36, 0xFD, 0xBB, 0x6E, 0xCF, 0x9F, 0x00, 0x30, 0x60,
  0xF3, 0xF6, 0xED, 0xDB, 0xFE, 0xF8, 0x1D, 0xF6, 0x18, 0xE1, 0xE7, 0x80,
  0x07, 0x06, 0x36, 0x7E, 0x6E, 0x6C, 0xEC, 0x7C, 0x7C, 0x1C, 0xFD, 0xBB,
  0xEF, 0x0F, 0x9F, 0x00, 0x0E, 0x3C, 0x71, 0xE3, 0x86, 0x0C, 0x18, 0x30,
  0xE3, 0x86, 0x00, 0x36, 0xFD, 0xBB, 0x6E, 0xCF, 0x9F, 0x0E, 0xF9, 0xE0,
  0x30, 0x60, 0xF3, 0xF7, 0x6D, 0xDB, 0xF6, 0xEC, 0x33, 0x37, 0x66, 0x6E,
  0xE0, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x8E, 0x38, 0xCF, 0x38, 0x30, 0x30,
  0x77, 0x76, 0x6C, 0x78, 0x7C, 0xEC, 0xEE, 0x33, 0x37, 0x66, 0x6E, 0xE0,
  0x2C, 0xCF, 0xF9, 0xDB, 0xB3, 0x66, 0xED, 0xD9, 0xBB, 0x70, 0x2C, 0xFD,
  0xDB, 0x76, 0xFD, 0xBB, 0x00, 0x1C, 0xFD, 0xBB, 0x7E, 0xEF, 0x9E, 0x00,
  0x2C, 0xFD, 0xBB, 0x76, 0xFF, 0xB6, 0x60, 0xC1, 0x80, 0x36, 0xFD, 0xBB,
  0x6E, 0xCF, 0x9F, 0x0E, 0x18, 0x30, 0x2D, 0xE7, 0x58, 0x63, 0x8E, 0x00,
  0x39, 0xF6, 0x1E, 0x1B, 0xEF, 0x00, 0x30, 0xFF, 0x98, 0x61, 0x87, 0x1C,
  0xEF, 0x3C, 0xF7, 0xDB, 0xEF, 0x80, 0xCF, 0x7D, 0xBE, 0xF3, 0x8E, 0x00,
  0xDD, 0xF7, 0x6D, 0xFB, 0xFC, 0xEF, 0x3B, 0x8E, 0xE0, 0x33, 0x9F, 0x87,
  0x83, 0x83, 0xC1, 0xF3, 0x98, 0x73, 0x37, 0x36, 0x3E, 0x3C, 0x3C, 0x38,
  0x30, 0xF0, 0xE0, 0x7D, 0xF1, 0x8C, 0x63, 0xEF, 0x80, 0x09, 0xCC, 0x66,
  0x63, 0x8C, 0x63, 0x18, 0xFF, 0xF0, 0x21, 0xC6, 0x63, 0x0C, 0xE6, 0x67,
  0x30, 0xFD, 0xC0,
};

const GFXglyph NotoSans_BlackItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 4, 0, -9 },
  { 6, 5, 4, 5, 1, -9 },
  { 9, 8, 9, 8, 0, -9 },
  { 18, 7, 10, 7, 0, -9 },
  { 27, 10, 9, 11, 1, -9 },
  { 39, 9, 9, 9, 0, -9 },
  { 50, 2, 4, 3, 1, -9 },
  { 51, 5, 11, 4, 0, -9 },
  { 58, 5, 11, 4, -1, -9 },
  { 65, 6, 6, 7, 1, -9 },
  { 70, 5, 6, 7, 1, -7 },
  { 74, 4, 3, 4, -1, -1 },
  { 76, 4, 2, 4, 0, -4 },
  { 77, 2, 2, 4, 0, -2 },
  { 78, 7, 9, 6, -1, -9 },
  { 86, 7, 9, 7, 0, -9 },
  { 94, 5, 9, 7, 1, -9 },
  { 100, 7, 9, 7, 0, -9 },
  { 108, 7, 9, 7, 0, -9 },
  { 116, 7, 9, 7, 0, -9 },
  { 124, 7, 9, 7, 0, -9 },
  { 132, 7, 9, 7, 0, -9 },
  { 140, 7, 9, 7, 0, -9 },
  { 148, 7, 9, 7, 0, -9 },
  { 156, 6, 9, 7, 1, -9 },
  { 163, 4, 7, 4, 0, -7 },
  { 167, 5, 9, 4, -1, -7 },
  { 173, 5, 7, 7, 1, -8 },
  { 178, 5, 4, 7, 1, -6 },
  { 181, 5, 7, 7, 1, -8 },
  { 186, 5, 9, 6, 1, -9 },
  { 192, 10, 10, 11, 0, -9 },
  { 205, 8, 9, 8, -1, -9 },
  { 214, 7, 9, 8, 0, -9 },
  { 222, 7, 9, 8, 1, -9 },
  { 230, 8, 9, 8, 0, -9 },
  { 239, 7, 9, 7, 0, -9 },
  { 247, 7, 9, 7, 0, -9 },
  { 255, 7, 9, 8, 1, -9 },
  { 263, 9, 9, 9, 0, -9 },
  { 274, 6, 9, 5, 0, -9 },
  { 281, 7, 12, 4, -2, -9 },
  { 292, 9, 9, 8, 0, -9 },
  { 303, 6, 9, 6, 0, -9 },
  { 310, 11, 9, 11, 0, -9 },
  { 323, 10, 9, 9, 0, -9 },
  { 335, 7, 9, 9, 1, -9 },
  { 343, 7, 9, 7, 0, -9 },
  { 351, 7, 11, 9, 1, -9 },
  { 361, 7, 9, 8, 0, -9 },
  { 369, 7, 9, 7, 0, -9 },
  { 377, 6, 9, 7, 1, -9 },
  { 384, 8, 9, 8, 1, -9 },
  { 393, 7, 9, 7, 1, -9 },
  { 401, 11, 9, 11, 1, -9 },
  { 414, 10, 9, 8, -1, -9 },
  { 426, 7, 9, 7, 1, -9 },
  { 434, 8, 9, 6, -1, -9 },
  { 443, 5, 11, 4, 0, -9 },
  { 450, 4, 9, 6, 1, -9 },
  { 455, 6, 11, 4, -1, -9 },
  { 464, 6, 6, 6, 0, -9 },
  { 469, 6, 1, 5, -1, 1 },
  { 470, 3, 2, 4, 2, -9 },
  { 471, 7, 7, 7, 0, -7 },
  { 478, 7, 9, 7, 0, -9 },
  { 486, 6, 7, 6, 0, -7 },
  { 492, 8, 9, 7, 0, -9 },
  { 501, 7, 7, 7, 0, -7 },
  { 508, 7, 12, 5, -1, -9 },
  { 519, 7, 10, 7, 0, -7 },
  { 528, 7, 9, 7, 0, -9 },
  { 536, 4, 9, 4, 0, -9 },
  { 541, 6, 12, 4, -2, -9 },
  { 550, 8, 9, 7, 0, -9 },
  { 559, 4, 9, 4, 0, -9 },
  { 564, 11, 7, 11, 0, -7 },
  { 574, 7, 7, 7, 0, -7 },
  { 581, 7, 7, 7, 0, -7 },
  { 588, 7, 10, 7, 0, -7 },
  { 597, 7, 10, 7, 0, -7 },
  { 606, 6, 7, 5, 0, -7 },
  { 612, 6, 7, 6, 0, -7 },
  { 618, 6, 8, 5, 0, -8 },
  { 624, 6, 7, 7, 1, -7 },
  { 630, 6, 7, 7, 1, -7 },
  { 636, 10, 7, 10, 1, -7 },
  { 645, 9, 7, 7, -1, -7 },
  { 653, 8, 10, 7, -1, -7 },
  { 663, 6, 7, 6, 0, -7 },
  { 669, 5, 11, 4, 0, -9 },
  { 676, 1, 12, 7, 3, -9 },
  { 678, 5, 11, 4, -1, -9 },
  { 685, 5, 2, 7, 1, -5 },
};

const GFXfont NotoSans_BlackItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_BLACKITALIC12PT7B_H_
