#ifndef _NOTOSANS_BLACKITALIC64PT7B_H_
#define _NOTOSANS_BLACKITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0xFF, 0xCF, 0xFC, 0x3F, 0xF3, 0xFF, 0x1F, 0xFD, 0xFF, 0xC7, 0xFF,
  0x7F, 0xE1, 0xFF, 0x9F, 0xF8, 0x7F, 0xE7, 0xFE, 0x1F, 0xF9, 0xFF, 0x07,
  0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0xFF, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE,
  0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF0, 0x3F, 0xC3,
  0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFD, 0xFE, 0x03, 0xFF,
  0xCF, 0x83, 0xC0, 0x7F, 0xF3, 0xF0, 0x08, 0x0F, 0xFE, 0x7C, 0x00, 0x01,
  0xFF, 0xCF, 0x80, 0x00, 0x3F, 0xF9, 0xF0, 0x00, 0x07, 0xFF, 0xBE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0x7F, 0xF0, 0x00, 0x03, 0xE7, 0xFF, 0x00, 0x00, 0x7C,
  0xFF, 0xE2, 0x00, 0x1F, 0x9F, 0xFC, 0x60, 0x03, 0xE3, 0xFF, 0x0F, 0x80,
  0x7C, 0x7F, 0xE1, 0xFF, 0x0F, 0xBF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x83,
  0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x00,
  0x00, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0xE3, 0xFF,
  0x1F, 0xF0, 0xFF, 0xF0, 0xFF, 0x9F, 0xF8, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE7, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF8, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFC, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xF1, 0xFF, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF,
  0x8F, 0xFC, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0x00,
  0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xDF, 0xFE, 0x0F, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0x8F,
  0xFC, 0xFF, 0xE7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x04,
  0x01, 0xFF, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0xFF,
  0x8F, 0xF0, 0x01, 0xFF, 0xDF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0x80, 0x61, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x7F, 0xF9, 0xFE,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x1F, 0x0F, 0xFC,
  0x00, 0x1C, 0x0F, 0xF8, 0x00, 0x10, 0x1F, 0xE8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF0, 0x0F, 0xE1, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x9F, 0xF8, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFB, 0xFF, 0xE0, 0x7F, 0xFC, 0x7F,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xC0,
  0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0x3F, 0xFE,
  0x03, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xFD, 0xFF,
  0xF0, 0x0F, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xF7,
  0xFF, 0x80, 0x7F, 0xFD, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xBF, 0xFE, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x3F,
  0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xCF, 0xFF, 0x01,
  0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC,
  0x0F, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF,
  0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFE, 0xFF,
  0xE1, 0xFF, 0xEF, 0xFF, 0x07, 0xFE, 0x7F, 0xF8, 0x3F, 0xC3, 0xFF, 0x80,
  0xFC, 0x3F, 0xFC, 0x07, 0x81, 0xFF, 0xE0, 0x10, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xFE,
  0x00, 0x3F, 0x01, 0xFF, 0xF0, 0x00, 0xF0, 0x07, 0xFF, 0x80, 0x06, 0x00,
  0x3F, 0xFC, 0x00, 0x10, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF9,
  0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0xFF, 0x80, 0x18, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x20, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF3, 0x00,
  0x00, 0x3F, 0xFE, 0x78, 0x00, 0x0F, 0xFF, 0xCF, 0xF0, 0x0F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFB, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF7, 0xFF, 0x80, 0x07, 0xFE,
  0x7F, 0xF0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xF0, 0x01,
  0xFF, 0x8F, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x81,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x80, 0x00, 0x3F, 0xFF,
  0x0E, 0x00, 0x07, 0xFF, 0xE0, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x3C, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x60, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x03,
  0xFF, 0xCF, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xFC, 0x03, 0xFF, 0xBF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xF8,
  0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xE0, 0x7F, 0xFC, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF9, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xE3,
  0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF,
  0x8F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xF0, 0x1F,
  0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x8F,
  0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0xCF, 0xFF, 0x81, 0xFF, 0xE7, 0xFF, 0xC0,
  0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xF0,
  0x1F, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xBF, 0xFE,
  0x07, 0xFF, 0xDF, 0xFF, 0x03, 0xFF, 0xEF, 0xFF, 0xC3, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFB, 0xFF, 0x83,
  0xFF, 0xFD, 0xFF, 0xC0, 0xFF, 0xFD, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0,
  0x07, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x0C, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0x1F, 0xFF, 0x1F, 0x00, 0xFF, 0xF1,
  0xC0, 0x0F, 0xFF, 0x10, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xFF, 0xC1,
  0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF3, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xF7, 0xFC, 0x1F,
  0xFC, 0x3F, 0xC0, 0xFF, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xF7, 0xF8,
  0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xFF, 0xF0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0x81, 0xFE, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xEF, 0xF0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xCF, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F,
  0xFE, 0xFF, 0xFB, 0xFF, 0x8F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x83, 0xFF, 0xF3, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xC0, 0x01,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00, 0x1F, 0xFD, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE7, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xE7, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xBF,
  0xFE, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xE0, 0x00,
  0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x20, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0x00, 0x3E,
  0x00, 0x7F, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFC, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x81,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x7F, 0xF8,
  0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x81, 0xFF, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xFF, 0xE3, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0x83,
  0xFF, 0xFF, 0x87, 0xFF, 0xC0, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xFF,
  0xE1, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xBF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE3,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xDF, 0xFC, 0x00, 0xFF, 0xDF, 0xF0, 0x1F, 0xF7, 0xFF, 0x00,
  0x3F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x03, 0xFE,
  0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xDF,
  0xF0, 0x7F, 0xCF, 0xFE, 0x00, 0x7F, 0xF7, 0xFC, 0x1F, 0xF3, 0xFF, 0x80,
  0x1F, 0xF9, 0xFF, 0x0F, 0xF8, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xC3, 0xFE,
  0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xF1, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE7,
  0xFC, 0x7F, 0xC7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0x1F, 0xE1, 0xFF, 0xC0,
  0x0F, 0xFE, 0x7F, 0xCF, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x1F, 0xF3, 0xFE,
  0x3F, 0xF8, 0x01, 0xFF, 0xC7, 0xFD, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF1,
  0xFF, 0x7F, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xE0,
  0x07, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0xFC,
  0x1F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x7F, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xF0,
  0x03, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF0,
  0x01, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xCF,
  0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC,
  0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF,
  0xC7, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x80, 0x1F,
  0xFC, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x03,
  0xFF, 0x83, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x7F, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xFF,
  0xF1, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0xFF, 0xF3, 0xFF, 0xE0,
  0x00, 0x3F, 0xFD, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xDF, 0xFF, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x7F, 0xFD,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x07, 0xFF,
  0xCF, 0xFF, 0x80, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xFF, 0xF1, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x3F,
  0xFD, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xDF,
  0xFF, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x7F, 0xFD, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xBF, 0xFE, 0x00, 0x01,
  0xFF, 0xEF, 0xFF, 0x80, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xCF, 0xFF,
  0x80, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xF3, 0xFF, 0xE0,
  0x07, 0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x7F, 0xF8,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xE1,
  0xFF, 0xE0, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFF, 0x1F, 0xFE, 0x00,
  0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xF8,
  0x03, 0xFF, 0xE0, 0x03, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x18, 0x00, 0x0F, 0xFF, 0x03, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F,
  0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF7, 0xFF, 0x80,
  0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0x9F, 0xFE, 0x00, 0x1F, 0xFF,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0xFF, 0xF0,
  0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFF,
  0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xE3, 0xFF,
  0xC0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x03,
  0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFD, 0xFF,
  0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x8F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0xFF, 0xBF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFB, 0xFE, 0x0F, 0xFE,
  0x00, 0xFF, 0xE1, 0xFF, 0xBF, 0xE1, 0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xF3,
  0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x3F, 0xE1, 0xFF, 0xC0, 0x07,
  0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x3F, 0xE3,
  0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE3, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xE7,
  0xFC, 0x3F, 0xE7, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC3, 0xFE, 0x7F, 0xF0,
  0x00, 0x7F, 0xEF, 0xF8, 0x3F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x83,
  0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xEF, 0xFC, 0x00, 0x07,
  0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x8F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0xE3, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x01, 0xFF,
  0xC7, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xFC,
  0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F,
  0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xBF, 0xF0, 0x00,
  0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x0F, 0xFC, 0x03, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0x7F, 0xF0, 0x3F,
  0xFF, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE0,
  0x7F, 0xF8, 0xFF, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF,
  0xC0, 0x3F, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0x01, 0xFF, 0xE3,
  0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0xFF,
  0xE1, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xE3, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF7, 0xFE, 0x00, 0x7F, 0xFC,
  0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC7, 0xE0,
  0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80,
  0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF,
  0x80, 0x7F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0xE3,
  0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0x0F, 0xFE, 0x03, 0xFF,
  0xE3, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF, 0xFC,
  0x07, 0xFE, 0x3F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0x0B,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x0E, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x83,
  0xFF, 0xE0, 0x0E, 0x0F, 0xFF, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x7F,
  0xF8, 0x01, 0xFF, 0xFD, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC3, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFB, 0xFF, 0x00, 0x07, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x3F,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF,
  0xCF, 0xFF, 0x81, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0xC0, 0x7F,
  0xF3, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xE0, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x10, 0x3F, 0xFE, 0x00, 0x38, 0x1F, 0xFF,
  0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x18, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xE7, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC7, 0xFE, 0x00, 0xFF, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0xFB, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE,
  0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0xFF,
  0xE0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x10, 0x00, 0x0F, 0xFF, 0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x1F, 0xC0, 0x01,
  0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xF8,
  0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF,
  0xE1, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFC, 0x07, 0xFF,
  0x87, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0xFF,
  0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x67, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x10, 0x1F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xFF, 0xF1,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x01, 0xFF, 0xCF, 0xFF, 0x80, 0x00,
  0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xDF,
  0xFF, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x0F, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC0, 0x7F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x87,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x87,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0x9F,
  0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF7, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xE1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x01,
  0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC,
  0x3F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07,
  0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0x87, 0xFF,
  0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xCF,
  0xFF, 0x83, 0xFF, 0xE7, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xFB,
  0xFF, 0xE0, 0x3F, 0xFD, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x7F,
  0xFB, 0xFF, 0xC0, 0x7F, 0xFD, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xF0, 0x3F,
  0xFE, 0x7F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0xBF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x00, 0x7F, 0xEF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0xC1,
  0xFF, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF,
  0xCF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x38, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0xF1,
  0xFF, 0x80, 0xFF, 0xFF, 0x7F, 0xF0, 0x3F, 0xFF, 0xEF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xF8, 0x0F,
  0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xF8,
  0x07, 0xFF, 0x1F, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F,
  0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFC,
  0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x03, 0xFE, 0x7F,
  0xF8, 0x00, 0x1E, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x07, 0xFE, 0x1F, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x03,
  0xFF, 0x3F, 0xF8, 0x0F, 0xFD, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x8F, 0xE0, 0x7F, 0xFC, 0x07,
  0x81, 0xFF, 0xF0, 0x04, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE2, 0x00, 0x07, 0xFF,
  0x8E, 0x00, 0x3F, 0xFE, 0x3F, 0x83, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x04, 0x07, 0xFF, 0xE3, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xE1,
  0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F,
  0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFC,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x87,
  0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xF1, 0xFF,
  0x80, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xCF,
  0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0x00, 0xFF,
  0xF0, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0x0F, 0xFF,
  0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xF1,
  0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x03,
  0xFF, 0x7F, 0xF8, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFD, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xCF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x1F, 0xEF, 0xF0,
  0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0x7F, 0x8F, 0xFF, 0x01, 0xFF, 0xCF, 0xFB,
  0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0x9F, 0xE3, 0xFF, 0x80, 0x7F, 0xF3,
  0xFC, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xBF, 0xE7, 0xF9, 0xFF, 0xC0, 0x1F,
  0xFD, 0xFE, 0x3F, 0xDF, 0xFC, 0x00, 0xFF, 0xEF, 0xF1, 0xFE, 0xFF, 0xE0,
  0x07, 0xFE, 0xFF, 0x8F, 0xF7, 0xFE, 0x00, 0x3F, 0xF7, 0xF8, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xBF, 0xC3, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE3, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xDF,
  0xFC, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xCF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x1F, 0xFE, 0x00, 0x03,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0xC0, 0x03, 0xFF, 0xFC,
  0x80, 0x00, 0x7F, 0xF0, 0x80, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_BlackItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 22, 47, 19, 0, -46 },
  { 131, 26, 17, 29, 6, -46 },
  { 187, 42, 46, 41, 0, -46 },
  { 429, 35, 53, 37, 2, -49 },
  { 661, 54, 47, 60, 4, -46 },
  { 979, 47, 47, 47, 0, -46 },
  { 1256, 13, 17, 15, 6, -46 },
  { 1284, 26, 57, 24, 2, -47 },
  { 1470, 26, 57, 24, -4, -47 },
  { 1656, 31, 32, 35, 5, -49 },
  { 1780, 32, 31, 38, 3, -38 },
  { 1904, 17, 15, 20, -3, -7 },
  { 1936, 19, 10, 21, 1, -22 },
  { 1960, 13, 12, 20, 0, -11 },
  { 1980, 37, 47, 30, -3, -46 },
  { 2198, 34, 47, 37, 2, -46 },
  { 2398, 29, 46, 37, 5, -46 },
  { 2565, 37, 46, 37, -2, -46 },
  { 2778, 35, 47, 37, 0, -46 },
  { 2984, 36, 46, 37, 0, -46 },
  { 3191, 36, 47, 37, 1, -46 },
  { 3403, 36, 47, 37, 2, -46 },
  { 3615, 39, 46, 37, 1, -46 },
  { 3840, 34, 47, 37, 2, -46 },
  { 4040, 33, 47, 37, 3, -46 },
  { 4234, 19, 37, 20, 0, -36 },
  { 4322, 23, 44, 20, -4, -36 },
  { 4449, 32, 35, 38, 3, -41 },
  { 4589, 32, 23, 38, 3, -34 },
  { 4681, 32, 35, 38, 3, -41 },
  { 4821, 28, 47, 31, 5, -46 },
  { 4986, 52, 52, 57, 3, -46 },
  { 5324, 43, 46, 43, -4, -46 },
  { 5572, 39, 46, 41, 1, -46 },
  { 5797, 40, 47, 40, 3, -46 },
  { 6032, 41, 46, 44, 1, -46 },
  { 6268, 37, 46, 36, 1, -46 },
  { 6481, 37, 46, 36, 1, -46 },
  { 6694, 41, 47, 45, 3, -46 },
  { 6935, 45, 46, 46, 1, -46 },
  { 7194, 33, 46, 27, -2, -46 },
  { 7384, 34, 60, 24, -10, -46 },
  { 7639, 47, 46, 43, 1, -46 },
  { 7910, 29, 46, 34, 1, -46 },
  { 8077, 58, 46, 58, 1, -46 },
  { 8411, 50, 46, 51, 1, -46 },
  { 8699, 42, 47, 47, 3, -46 },
  { 8946, 38, 46, 40, 1, -46 },
  { 9165, 42, 57, 47, 3, -46 },
  { 9465, 38, 46, 42, 1, -46 },
  { 9684, 35, 47, 35, 1, -46 },
  { 9890, 34, 46, 35, 5, -46 },
  { 10086, 41, 47, 45, 4, -46 },
  { 10327, 39, 46, 39, 5, -46 },
  { 10552, 60, 46, 60, 5, -46 },
  { 10897, 51, 46, 42, -4, -46 },
  { 11191, 39, 46, 39, 5, -46 },
  { 11416, 41, 46, 35, -3, -46 },
  { 11652, 29, 58, 23, -2, -47 },
  { 11863, 17, 47, 30, 7, -46 },
  { 11963, 29, 58, 23, -4, -47 },
  { 12174, 34, 30, 34, 0, -46 },
  { 12302, 31, 8, 29, -6, 4 },
  { 12333, 16, 10, 23, 9, -49 },
  { 12353, 35, 37, 39, 3, -36 },
  { 12515, 35, 50, 39, 1, -49 },
  { 12734, 30, 37, 32, 3, -36 },
  { 12873, 38, 50, 39, 3, -49 },
  { 13111, 33, 37, 37, 3, -36 },
  { 13264, 40, 64, 26, -7, -49 },
  { 13584, 37, 51, 39, 1, -36 },
  { 13820, 36, 49, 40, 1, -49 },
  { 14041, 22, 50, 21, 1, -50 },
  { 14179, 31, 65, 21, -8, -50 },
  { 14431, 42, 49, 39, 1, -49 },
  { 14689, 22, 49, 21, 1, -49 },
  { 14824, 55, 36, 59, 1, -36 },
  { 15072, 36, 36, 40, 1, -36 },
  { 15234, 33, 37, 39, 3, -36 },
  { 15387, 39, 51, 39, -3, -36 },
  { 15636, 35, 51, 39, 3, -36 },
  { 15860, 30, 36, 28, 1, -36 },
  { 15995, 30, 37, 32, 1, -36 },
  { 16134, 28, 44, 29, 2, -43 },
  { 16288, 36, 36, 40, 3, -35 },
  { 16450, 36, 35, 35, 3, -35 },
  { 16608, 53, 35, 53, 3, -35 },
  { 16840, 44, 35, 36, -4, -35 },
  { 17033, 42, 50, 35, -4, -35 },
  { 17296, 33, 35, 31, -1, -35 },
  { 17441, 29, 56, 23, -1, -46 },
  { 17644, 8, 63, 36, 14, -48 },
  { 17707, 27, 56, 23, -4, -46 },
  { 17896, 32, 13, 38, 3, -29 },
};

const GFXfont NotoSans_BlackItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_BLACKITALIC64PT7B_H_
