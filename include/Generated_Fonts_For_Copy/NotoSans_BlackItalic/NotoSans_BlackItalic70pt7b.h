#ifndef _NOTOSANS_BLACKITALIC70PT7B_H_
#define _NOTOSANS_BLACKITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFC,
  0x3F, 0xF9, 0xFF, 0xE1, 0xFF, 0xCF, 0xFF, 0x1F, 0xFE, 0x7F, 0xF0, 0xFF,
  0xE3, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xC1, 0xFF, 0xC7,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x87, 0xFF, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x87,
  0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFE, 0xF8, 0xFF, 0x01, 0xFF, 0xE7, 0xE0, 0x38, 0x07, 0xFF, 0x9F, 0x80,
  0x20, 0x3F, 0xFE, 0x7E, 0x00, 0x00, 0xFF, 0xF1, 0xF0, 0x00, 0x03, 0xFF,
  0xE7, 0xC0, 0x00, 0x07, 0xFF, 0xBF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xBF, 0xFE, 0x00, 0x00, 0x7E, 0x7F, 0xF8, 0x00, 0x01, 0xF9, 0xFF, 0xE2,
  0x00, 0x07, 0xC3, 0xFF, 0x8E, 0x00, 0x1F, 0x1F, 0xFE, 0x3F, 0x00, 0xFC,
  0xFF, 0xF0, 0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0x3E, 0x01, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF1, 0xFF, 0xC7, 0xFE, 0x1F, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xE3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0x87, 0xFF, 0x0F, 0xF8,
  0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE3,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xCF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0xF9, 0xFF, 0xF9, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF,
  0xCF, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF,
  0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF,
  0x83, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xC0, 0x0F, 0xF8, 0x00, 0x1E, 0x01, 0xFF, 0x00,
  0x03, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xFC, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xDF, 0xF0, 0x00, 0xFF, 0xFB, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xE0, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x00, 0x7C, 0x1F, 0xFC,
  0x00, 0x07, 0x01, 0xFF, 0x80, 0x00, 0x60, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0,
  0x7F, 0xE3, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x8F, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFC,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x7F, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xFF, 0xCF,
  0xFF, 0xC0, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x03,
  0xFF, 0xE7, 0xFF, 0xE0, 0x0F, 0xFF, 0x9F, 0xFF, 0x80, 0x3F, 0xFE, 0x7F,
  0xFE, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x1F,
  0xFF, 0x9F, 0xFF, 0x00, 0x7F, 0xFE, 0x7F, 0xFC, 0x01, 0xFF, 0xFB, 0xFF,
  0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0xFF, 0xFC, 0x03, 0xFF, 0xF3, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF,
  0x80, 0x7F, 0xFE, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFE, 0xFF, 0xF8, 0x3F, 0xFC, 0xFF, 0xF0, 0x1F, 0xF1, 0xFF, 0xF0,
  0x1F, 0xE1, 0xFF, 0xF0, 0x0F, 0x81, 0xFF, 0xF0, 0x06, 0x01, 0xFF, 0xF0,
  0x04, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xFF, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0x00,
  0x07, 0x00, 0x1F, 0xFF, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x01, 0xC0,
  0x07, 0xFF, 0xE0, 0x02, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x30, 0x00, 0x00, 0xFF, 0xFC, 0x78, 0x00, 0x07,
  0xFF, 0xF8, 0xFF, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0xF0,
  0x00, 0x1F, 0xFD, 0xFF, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x00, 0x3F,
  0xF9, 0xFF, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0xE0, 0x00, 0xFF, 0xE3, 0xFF,
  0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x03,
  0xFF, 0x87, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x07,
  0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x10,
  0x00, 0x01, 0xFF, 0xFC, 0x3C, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0x00, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x04, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE1,
  0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xFE, 0x01,
  0xFF, 0xE7, 0xFF, 0xFC, 0x07, 0xFF, 0xBF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F,
  0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xFE, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0xFF,
  0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFF,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFB, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F,
  0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF,
  0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xC3, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xE0, 0x7F, 0xFC,
  0xFF, 0xFC, 0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0x3F, 0xFC, 0x0F,
  0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xE0, 0x00, 0x40, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x80, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0x81, 0xFF,
  0xF0, 0xF8, 0x03, 0xFF, 0xE1, 0xC0, 0x07, 0xFF, 0xC2, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF,
  0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFE, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xCF, 0xF8, 0x1F, 0xFF,
  0x1F, 0xF0, 0x1F, 0xF7, 0xFE, 0x07, 0xFF, 0x07, 0xFC, 0x07, 0xFD, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0,
  0x7F, 0xDF, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xEF, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFB, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xEF, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF3, 0xFE, 0x0F, 0xF8,
  0x07, 0xFC, 0x07, 0xFC, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x3F,
  0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE0, 0x7F, 0xF0,
  0x7F, 0xE3, 0xFE, 0x0F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F,
  0xFF, 0x1F, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xBF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x83, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xE1, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x8F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x1F, 0xFF, 0xE0,
  0x00, 0x78, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x60, 0x07, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xFF,
  0xE1, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x81, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x3F, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xCF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xC3, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC7, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF9, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xDF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFB,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFD, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xDF, 0xF0, 0x07, 0xFE, 0xFF,
  0xE0, 0x03, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0x7F,
  0xC0, 0x3F, 0xF7, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xFF,
  0x00, 0x3F, 0xFD, 0xFF, 0x00, 0xFF, 0x9F, 0xFE, 0x00, 0x7F, 0xFB, 0xFE,
  0x03, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0xF0,
  0x01, 0xFF, 0xCF, 0xF8, 0x1F, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xF0,
  0x3F, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xE0, 0xFF, 0xC7, 0xFF, 0x80,
  0x1F, 0xFE, 0x7F, 0xC1, 0xFF, 0x9F, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0x87,
  0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF8, 0x01,
  0xFF, 0xE3, 0xFE, 0x3F, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xC7, 0xFC, 0x7F,
  0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xF8, 0xFF, 0x87, 0xFF, 0x80, 0x0F,
  0xFF, 0x1F, 0xF3, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xE7, 0xFC,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xDF, 0xF8, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0xFF, 0xBF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x81,
  0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xFC, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xF0, 0x01,
  0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xF3, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF9, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xCF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xDF,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE7, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF9, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x87, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE3, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF9, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xCF, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF7, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0x00, 0x7F,
  0xFD, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFB, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x03, 0xFF, 0xE3,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x07, 0xFF, 0xF1, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xF8,
  0x03, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x80, 0x00, 0x1F, 0xFF, 0x03, 0x00,
  0x00, 0x7F, 0xFC, 0x0F, 0x80, 0x03, 0xFF, 0xF0, 0x3F, 0x80, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x5F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xEF,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x7F, 0xF8, 0x00,
  0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC7, 0xFF,
  0x80, 0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xC0,
  0x1F, 0xFE, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF,
  0x7F, 0xE0, 0xFF, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xDF, 0xF8, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x7F, 0xE7, 0xFE, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x1F,
  0xF9, 0xFF, 0x87, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x7F, 0xE1, 0xFF,
  0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0xFF, 0xF0, 0x00, 0x7F, 0xF1,
  0xFF, 0xC7, 0xFE, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F,
  0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x7F, 0xE7, 0xFF, 0x80, 0x01, 0xFF,
  0xCF, 0xFE, 0x1F, 0xF9, 0xFF, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0x07, 0xFE,
  0x7F, 0xF0, 0x00, 0x1F, 0xFD, 0xFF, 0xC1, 0xFF, 0xBF, 0xFC, 0x00, 0x07,
  0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFE, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x1F,
  0xFB, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x9F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xEF, 0xFF, 0xC0, 0x03, 0xFF, 0xF1, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x7F,
  0xFC, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC7, 0xFF, 0xE0, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xDF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x03, 0xFF, 0x3F,
  0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x1F,
  0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x03,
  0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0xFC, 0x7F, 0xF0, 0x07, 0xFF,
  0xFC, 0xFF, 0xE0, 0x1F, 0xFF, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xC1, 0xFF,
  0xF0, 0x07, 0xFF, 0x87, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xF9, 0xFF, 0xC0,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xC0, 0x00,
  0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xF7, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF9, 0xFF, 0xFC,
  0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF,
  0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xFF,
  0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF,
  0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xEF, 0xFF,
  0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0x03, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x08, 0x1F, 0xFF, 0x80, 0x1C, 0x0F, 0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x83,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE7, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x1F, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xFF, 0x01,
  0xFF, 0xF3, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xFE, 0x03, 0xFF, 0xE7, 0xFF,
  0xE0, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x40, 0xFF, 0xFC, 0x00,
  0x3C, 0x0F, 0xFF, 0xE0, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0x80,
  0x07, 0xFF, 0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0x80, 0xFF, 0xFE,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x7F, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x10, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x3F,
  0xF0, 0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x01, 0xFF, 0xF7, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xFF,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC3, 0xFF, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xFF,
  0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF,
  0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x3F,
  0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE3,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xDF, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x83, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0x9F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x00, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFE, 0x7F, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF1, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x3F,
  0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x87,
  0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x03, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xFF, 0x9F, 0xFF, 0x80, 0xFF,
  0xFC, 0xFF, 0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0xC0, 0x3F, 0xFF, 0x7F, 0xFE,
  0x01, 0xFF, 0xFB, 0xFF, 0xE0, 0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0x7F, 0xFD,
  0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0xC0, 0x3F, 0xFF, 0x7F, 0xFE, 0x01,
  0xFF, 0xFB, 0xFF, 0xE0, 0x0F, 0xFF, 0xDF, 0xFF, 0x00, 0x7F, 0xFC, 0xFF,
  0xF8, 0x07, 0xFF, 0xE7, 0xFF, 0xC0, 0x3F, 0xFF, 0x3F, 0xFE, 0x03, 0xFF,
  0xF1, 0xFF, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x8F, 0xFF, 0x80,
  0x00, 0x7F, 0xF3, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xDF,
  0xFF, 0xF0, 0x00, 0xFF, 0xF9, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x0F, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xF8,
  0x01, 0xFF, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xFF, 0x87, 0xFF,
  0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0x80, 0x7F,
  0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xFD,
  0xFF, 0xE0, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0xFF, 0x8F, 0xFF, 0x80,
  0x00, 0x38, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0,
  0x3F, 0xF9, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0xE0,
  0x0E, 0x01, 0xFF, 0xF0, 0x01, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x10, 0x00, 0x1F, 0xFF, 0x0E,
  0x00, 0x0F, 0xFF, 0x87, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x04, 0x01, 0xFF, 0xF8, 0x38, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF,
  0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF7, 0xFF, 0x00, 0x1F, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFF, 0xC7,
  0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xF7, 0xFF, 0xC0, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFF,
  0x8F, 0xFF, 0x00, 0x3F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFC,
  0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF,
  0x80, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0xFF, 0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF,
  0xC0, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x03, 0xFF, 0xBF, 0xFE, 0x00, 0x07,
  0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xF9, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x3F, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xF8,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x83, 0xFD, 0xFF, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0xFF, 0xBF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xF7, 0xF8, 0x7F,
  0xFC, 0x03, 0xFF, 0xC3, 0xFC, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0xFF,
  0x9F, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xF7, 0xFC, 0x7F, 0xF8, 0x00,
  0xFF, 0xE7, 0xFC, 0xFF, 0x8F, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0x9F, 0xF3,
  0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xF7,
  0xFC, 0x7F, 0xCF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0x8F, 0xFB, 0xFF, 0xC0,
  0x01, 0xFF, 0xDF, 0xF1, 0xFF, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x3F,
  0xEF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF9, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x04, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x10, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x23, 0xFF, 0xF8, 0x00, 0x0D,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x60, 0x00, 0x1F, 0xFF, 0x88, 0x00, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_BlackItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 24, 51, 21, 0, -50 },
  { 154, 29, 18, 32, 6, -50 },
  { 220, 46, 50, 45, 0, -50 },
  { 508, 38, 57, 41, 2, -53 },
  { 779, 59, 52, 65, 4, -51 },
  { 1163, 51, 52, 51, 0, -51 },
  { 1495, 14, 18, 17, 6, -50 },
  { 1527, 29, 62, 26, 2, -51 },
  { 1752, 29, 62, 26, -5, -51 },
  { 1977, 35, 35, 38, 5, -54 },
  { 2131, 35, 34, 41, 3, -42 },
  { 2280, 19, 17, 21, -4, -8 },
  { 2321, 21, 11, 23, 1, -24 },
  { 2350, 14, 13, 21, 0, -12 },
  { 2373, 40, 52, 33, -3, -51 },
  { 2633, 38, 52, 41, 2, -51 },
  { 2880, 32, 50, 41, 5, -50 },
  { 3080, 40, 51, 41, -2, -51 },
  { 3335, 39, 52, 41, 0, -51 },
  { 3589, 40, 50, 41, 0, -50 },
  { 3839, 39, 51, 41, 1, -50 },
  { 4088, 38, 52, 41, 3, -51 },
  { 4335, 43, 50, 41, 1, -50 },
  { 4604, 38, 52, 41, 2, -51 },
  { 4851, 35, 52, 41, 4, -51 },
  { 5079, 21, 40, 21, 0, -39 },
  { 5184, 25, 48, 21, -4, -39 },
  { 5334, 35, 39, 41, 3, -45 },
  { 5505, 35, 25, 41, 3, -37 },
  { 5615, 35, 39, 41, 3, -45 },
  { 5786, 31, 52, 34, 5, -51 },
  { 5988, 58, 57, 63, 3, -51 },
  { 6402, 47, 50, 47, -4, -50 },
  { 6696, 42, 50, 44, 1, -50 },
  { 6959, 43, 52, 44, 4, -51 },
  { 7239, 45, 50, 48, 1, -50 },
  { 7521, 40, 50, 39, 1, -50 },
  { 7771, 40, 50, 40, 1, -50 },
  { 8021, 44, 52, 49, 4, -51 },
  { 8307, 49, 50, 50, 1, -50 },
  { 8614, 37, 50, 30, -3, -50 },
  { 8846, 37, 66, 26, -11, -50 },
  { 9152, 51, 50, 47, 1, -50 },
  { 9471, 32, 50, 37, 1, -50 },
  { 9671, 63, 50, 64, 1, -50 },
  { 10065, 55, 50, 55, 1, -50 },
  { 10409, 45, 52, 52, 4, -51 },
  { 10702, 42, 50, 44, 1, -50 },
  { 10965, 45, 63, 52, 4, -51 },
  { 11320, 42, 50, 46, 1, -50 },
  { 11583, 38, 52, 38, 1, -51 },
  { 11830, 38, 50, 39, 5, -50 },
  { 12068, 46, 51, 49, 4, -50 },
  { 12362, 43, 50, 43, 5, -50 },
  { 12631, 66, 50, 65, 5, -50 },
  { 13044, 56, 50, 46, -4, -50 },
  { 13394, 42, 50, 42, 6, -50 },
  { 13657, 45, 50, 38, -3, -50 },
  { 13939, 32, 63, 25, -2, -51 },
  { 14191, 19, 52, 33, 8, -51 },
  { 14315, 32, 63, 25, -5, -51 },
  { 14567, 37, 33, 37, 0, -50 },
  { 14720, 33, 8, 32, -6, 5 },
  { 14753, 17, 12, 25, 10, -54 },
  { 14779, 39, 40, 42, 3, -39 },
  { 14974, 39, 54, 42, 1, -53 },
  { 15238, 33, 40, 35, 3, -39 },
  { 15403, 42, 54, 42, 3, -53 },
  { 15687, 36, 40, 41, 3, -39 },
  { 15867, 43, 71, 29, -7, -54 },
  { 16249, 41, 56, 42, 1, -39 },
  { 16536, 39, 53, 44, 1, -53 },
  { 16795, 24, 54, 23, 1, -54 },
  { 16957, 34, 71, 23, -9, -54 },
  { 17259, 46, 53, 43, 1, -53 },
  { 17564, 24, 53, 23, 1, -53 },
  { 17723, 61, 39, 65, 1, -39 },
  { 18021, 39, 39, 44, 1, -39 },
  { 18212, 37, 40, 42, 3, -39 },
  { 18397, 43, 56, 42, -3, -39 },
  { 18698, 39, 56, 42, 3, -39 },
  { 18971, 33, 39, 31, 1, -39 },
  { 19132, 33, 40, 35, 1, -39 },
  { 19297, 31, 47, 32, 2, -46 },
  { 19480, 40, 40, 44, 3, -39 },
  { 19680, 39, 39, 38, 3, -39 },
  { 19871, 59, 39, 58, 3, -39 },
  { 20159, 48, 39, 40, -4, -39 },
  { 20393, 46, 56, 38, -4, -39 },
  { 20715, 36, 39, 34, -1, -39 },
  { 20891, 31, 61, 25, -1, -50 },
  { 21128, 9, 69, 40, 15, -53 },
  { 21206, 30, 61, 25, -4, -50 },
  { 21435, 35, 13, 41, 3, -31 },
};

const GFXfont NotoSans_BlackItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_BLACKITALIC70PT7B_H_
