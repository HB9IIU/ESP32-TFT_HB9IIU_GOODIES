#ifndef _NOTOSANS_BLACKITALIC33PT7B_H_
#define _NOTOSANS_BLACKITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xE0, 0x7E, 0xFD,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3C, 0x0F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0xF1, 0xE0, 0x07,
  0xCF, 0x80, 0x1E, 0x3C, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC0, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF8,
  0xFD, 0xC4, 0x3F, 0x70, 0x0F, 0xD8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xDF, 0x20, 0x77,
  0xCE, 0x19, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0x80,
  0x7F, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x80, 0x0F,
  0x81, 0xFE, 0x01, 0xF0, 0x3F, 0xE0, 0x1E, 0x07, 0xFF, 0x03, 0xE0, 0x7D,
  0xF0, 0x7C, 0x0F, 0x9F, 0x0F, 0x80, 0xF9, 0xF0, 0xF0, 0x0F, 0x9F, 0x1F,
  0x00, 0xF9, 0xF3, 0xE0, 0x0F, 0x9F, 0x3C, 0x00, 0xFB, 0xE7, 0x9F, 0xCF,
  0xFE, 0xFB, 0xFE, 0xFF, 0xDF, 0x7F, 0xF7, 0xF9, 0xE7, 0xDF, 0x1E, 0x3E,
  0xF9, 0xF0, 0x07, 0xCF, 0x9F, 0x00, 0xF8, 0xF9, 0xF0, 0x0F, 0x0F, 0x1F,
  0x01, 0xF0, 0xF1, 0xE0, 0x3E, 0x0F, 0x3E, 0x07, 0xC0, 0xFF, 0xE0, 0x78,
  0x0F, 0xFC, 0x0F, 0x80, 0x7F, 0x81, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xEF, 0xE0,
  0x07, 0xC7, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0x1F, 0xFC, 0x7E,
  0x3F, 0xFC, 0x7E, 0x7F, 0xFE, 0xFE, 0xFE, 0x7F, 0xFC, 0xFE, 0x3F, 0xF8,
  0xFC, 0x3F, 0xF8, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFC, 0x7E, 0xF9, 0xF3,
  0xE7, 0x9F, 0x3E, 0x7C, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x06, 0x3E, 0x07, 0xDE, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0x7F,
  0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x87, 0xFC, 0x07, 0xFE, 0x07, 0xEF, 0x80,
  0xE7, 0xC0, 0x31, 0xF0, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xE3, 0xF1, 0xF1,
  0xF0, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0xFF, 0x80, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE7,
  0xE3, 0xF9, 0xFC, 0xFC, 0x7F, 0x7F, 0x1F, 0xDF, 0x87, 0xF7, 0xE1, 0xFF,
  0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0x87, 0xEF, 0xC3, 0xFB, 0xF0, 0xFE, 0xFC,
  0x3F, 0x3F, 0x1F, 0xCF, 0xC7, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xF8, 0x3F,
  0xF0, 0xFF, 0xE7, 0xFF, 0xBF, 0xFF, 0x3F, 0xFE, 0x3C, 0xFC, 0x73, 0xF8,
  0x87, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xC1, 0xF8, 0x10, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0x00,
  0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xC7,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xEC, 0x03, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF,
  0x8F, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0xFB, 0xF0, 0x1F, 0x7E, 0x07, 0xDF, 0x81, 0xF3, 0xF0,
  0x7C, 0x7E, 0x1F, 0x0F, 0xC3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x1D, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF3, 0x00, 0xFE, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xF8,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x38, 0x1F, 0xBF, 0x87, 0xFF, 0xF1,
  0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0xCF, 0xEF, 0xE3, 0xFB, 0xF8, 0xFE, 0xFE,
  0x3F, 0xBF, 0x0F, 0xE7, 0xE3, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF,
  0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F,
  0x9F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x87, 0xF7, 0xF3, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3,
  0xF9, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x03,
  0xE0, 0x0F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0x7F, 0xBF, 0x3F, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x00, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x3F, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x87, 0xFF, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00,
  0x00, 0x07, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE7, 0x8F,
  0xC8, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x81,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0xF8, 0x00, 0x7C, 0x1F, 0x01, 0x03, 0xE3, 0xE1,
  0xFF, 0x9E, 0x3C, 0x3F, 0xF9, 0xE7, 0xC7, 0xFF, 0x9F, 0x78, 0xFC, 0xF1,
  0xF7, 0x8F, 0x8F, 0x1F, 0x79, 0xF0, 0xF1, 0xEF, 0x9F, 0x1F, 0x1E, 0xF9,
  0xE1, 0xE1, 0xEF, 0x9E, 0x1E, 0x3E, 0xF9, 0xE3, 0xE7, 0xCF, 0x9F, 0xFF,
  0xF8, 0x79, 0xFF, 0xFF, 0x07, 0x8F, 0xEF, 0xE0, 0x7C, 0x38, 0x38, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x60, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x07, 0xE7,
  0xE0, 0x1F, 0x9F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x1F, 0x83, 0xE0,
  0x7E, 0x0F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0x00, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0xFE, 0x3F, 0x9F, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F,
  0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xC7, 0xE3, 0xF8, 0xFE, 0x7E, 0x1F, 0xCF, 0xC3, 0xF9, 0xF8, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE3, 0xFE, 0x7C, 0x3F, 0x80, 0xC7, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x06, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF8,
  0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7E, 0x0F, 0xE3, 0xF0, 0xFF, 0x1F,
  0x9F, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xFF, 0xE1, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xF9, 0xF0, 0xFF, 0x00,
  0x8F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x8F, 0xFD, 0xFC,
  0xFF, 0xCF, 0xC7, 0xFE, 0x7E, 0x3F, 0xF3, 0xF1, 0xFF, 0x9F, 0x81, 0xFC,
  0xFC, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x83, 0xF1, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC3,
  0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xF8,
  0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xFC,
  0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x0F, 0xE1, 0xFE, 0x0F, 0xC1, 0xFC,
  0x0F, 0xC3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0xCF, 0xE0, 0x1F, 0xCF, 0xE0,
  0x1F, 0x9F, 0xC0, 0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80,
  0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE,
  0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F,
  0xF0, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xDF,
  0x0F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF1, 0xEF, 0xC3, 0xEF, 0x9F, 0x7E, 0x1F,
  0x7C, 0xF3, 0xE0, 0xFB, 0xEF, 0xBF, 0x0F, 0xDF, 0x79, 0xF8, 0x7E, 0xFF,
  0xCF, 0xC3, 0xF7, 0xFC, 0x7E, 0x1F, 0x3F, 0xE3, 0xE1, 0xF9, 0xFF, 0x3F,
  0x0F, 0xCF, 0xF1, 0xF8, 0x7E, 0x7F, 0x8F, 0xC3, 0xE3, 0xF8, 0x7C, 0x1F,
  0x1F, 0xC7, 0xE0, 0x0F, 0xF0, 0x0F, 0x87, 0xF8, 0x0F, 0xC3, 0xFC, 0x07,
  0xE1, 0xFF, 0x03, 0xF0, 0xFF, 0x81, 0xF0, 0xFF, 0xC0, 0xF8, 0x7F, 0xF0,
  0xFC, 0x3F, 0xF8, 0x7E, 0x1F, 0x7C, 0x3F, 0x0F, 0xBE, 0x1F, 0x0F, 0xDF,
  0x9F, 0x87, 0xEF, 0xCF, 0xC3, 0xF3, 0xE7, 0xE1, 0xF1, 0xFB, 0xE0, 0xF8,
  0xFD, 0xF0, 0xFC, 0x3E, 0xF8, 0x7E, 0x1F, 0xFC, 0x3F, 0x0F, 0xFE, 0x1F,
  0x07, 0xFE, 0x1F, 0x81, 0xFF, 0x0F, 0xC0, 0xFF, 0x87, 0xE0, 0x7F, 0xC3,
  0xE0, 0x3F, 0xE1, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xF3, 0xFC, 0xFE, 0x0F,
  0xEF, 0xE0, 0x3F, 0x7F, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7E,
  0xFC, 0x07, 0xF7, 0xF0, 0x7F, 0x3F, 0x87, 0xF9, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7,
  0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xFC, 0xFE, 0x7F, 0x9F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xC0, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xF3, 0xFC, 0xFE, 0x0F,
  0xEF, 0xE0, 0x3F, 0x7F, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7E,
  0xFC, 0x07, 0xF7, 0xE0, 0x7F, 0x3F, 0x87, 0xF9, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x3F, 0x9F, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF1,
  0xFC, 0xFE, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFB, 0xF0, 0x7E, 0x7F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7F, 0x1F,
  0xCF, 0xE1, 0xF9, 0xF8, 0x3F, 0xBF, 0x07, 0xF7, 0xE0, 0x7F, 0x00, 0xFC,
  0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF1, 0xFC, 0x78, 0xFC,
  0x04, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x40, 0x7F,
  0x38, 0x3F, 0x9F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E,
  0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x9F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x07, 0xF3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0xFE, 0x3F, 0x07, 0xF3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x1F,
  0xC7, 0xE0, 0xFE, 0x3F, 0x8F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0x9F, 0x81, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xE1, 0xF8,
  0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0,
  0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x07,
  0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x7E, 0x7C, 0x0F, 0xE0, 0x7E, 0x7C, 0x0F,
  0xE0, 0xFC, 0x7C, 0x0F, 0xE0, 0xFC, 0x7C, 0x1F, 0xE1, 0xF8, 0x7C, 0x1F,
  0xE1, 0xF8, 0x7C, 0x3F, 0xE1, 0xF8, 0x7C, 0x3F, 0xE3, 0xF0, 0x7C, 0x7F,
  0xE3, 0xF0, 0x7C, 0x7F, 0xE7, 0xE0, 0x7C, 0x7B, 0xE7, 0xE0, 0x7C, 0xFB,
  0xE7, 0xC0, 0x7C, 0xFB, 0xEF, 0xC0, 0x7D, 0xF3, 0xEF, 0xC0, 0x7D, 0xF3,
  0xEF, 0x80, 0x7D, 0xE3, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0xFC, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x01,
  0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0x7F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0xFC, 0x1F, 0xCF,
  0xE1, 0xFC, 0x7E, 0x3F, 0x87, 0xE3, 0xF0, 0x7E, 0x7F, 0x03, 0xE7, 0xE0,
  0x3E, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xBC, 0x07, 0x9E, 0x07,
  0xCF, 0x87, 0xC3, 0xC3, 0xE1, 0xE3, 0xE0, 0xF3, 0xE0, 0x7D, 0xF0, 0x1F,
  0xF0, 0x0F, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x7E,
  0x7E, 0x3E, 0x1F, 0x00, 0xC0, 0x00, 0xFE, 0xFC, 0x3F, 0xDF, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F,
  0x8F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7F, 0x0F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7E,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xF7, 0xC0, 0x7C, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF1, 0x00, 0x7E, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xC3,
  0xF9, 0xF8, 0x7F, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xEF, 0xF0, 0xFC, 0xFC,
  0x00, 0x00, 0x60, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xDC, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x08, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x87, 0xE0, 0x7E, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x1F, 0x87,
  0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xE1, 0xF0,
  0xFE, 0x3F, 0x0F, 0xE3, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE,
  0x03, 0xFB, 0xE0, 0x1F, 0x3E, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xF1, 0xFF, 0xF9, 0xF8, 0xFD, 0xFC, 0x7E, 0xFC, 0x3F, 0x7F,
  0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0x11,
  0xFC, 0x78, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x40,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x3F, 0xBF, 0x07, 0xFB, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F,
  0x0F, 0xC7, 0xF0, 0xF8, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xBF, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x0C, 0x0F, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x80, 0x7E,
  0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xF7, 0xF1, 0xFC,
  0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x0F, 0xC7, 0xE1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xE7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87,
  0xE3, 0xF0, 0xFC, 0xFE, 0x3F, 0x80, 0x00, 0xC0, 0x3E, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x3C, 0x00, 0x00, 0x02, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x00, 0x0C, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x02, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0xFF, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0xC1, 0xFC, 0xFE, 0x07,
  0xE7, 0xF0, 0x1F, 0xBF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xCF, 0xC0,
  0x7F, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0xFE,
  0x1F, 0xE0, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0x02, 0x01, 0x80, 0x7C, 0xFC, 0x3F, 0x83,
  0xEF, 0xF3, 0xFC, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xF7,
  0xFD, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1,
  0xF9, 0xFC, 0x7F, 0x1F, 0xCF, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE3,
  0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF9, 0xFC, 0x7F, 0x1F, 0xCF, 0xC3,
  0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x3F, 0x3F, 0x8F, 0xE3,
  0xF8, 0x00, 0x02, 0x01, 0xF3, 0xF0, 0x3E, 0xFF, 0x07, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0xDF, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xE7, 0xF1,
  0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x9F, 0xC7,
  0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF8, 0xFE, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE7,
  0xE7, 0xF1, 0xFD, 0xFC, 0x7F, 0x7E, 0x1F, 0xDF, 0x87, 0xFF, 0xE1, 0xFB,
  0xF8, 0x7E, 0xFE, 0x3F, 0xBF, 0x8F, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x7D, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xC7, 0xF0,
  0xFC, 0x7F, 0x0F, 0x87, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x8F, 0xE1, 0xF8, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7E, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x80, 0x00, 0xFE, 0xFC, 0x3F, 0xDF, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC3, 0xF3, 0xF8, 0x7E, 0x7F, 0x0F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7D, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x0F, 0x9F, 0x0F,
  0xBE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xF2, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x40, 0x07,
  0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x84, 0x3F, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x80,
  0xFC, 0xF1, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0x80, 0x3F, 0x0F, 0xCF, 0xC3, 0xF7, 0xF1, 0xFD, 0xF8, 0x7E, 0x7E,
  0x1F, 0x9F, 0x87, 0xE7, 0xE3, 0xFB, 0xF8, 0xFE, 0xFC, 0x3F, 0x3F, 0x0F,
  0xCF, 0xC3, 0xF3, 0xF1, 0xFC, 0xFC, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFE, 0xF8, 0xFF, 0xFE, 0x1F, 0xDF, 0x00, 0xFE, 0x0F, 0xEF, 0xC3, 0xF9,
  0xF8, 0x7E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x9F, 0x83,
  0xF3, 0xF0, 0x3E, 0xFC, 0x07, 0xDF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x3F, 0x0F, 0xFF, 0x8F, 0xE1, 0xFB, 0xF1, 0xFC, 0x3F,
  0x7E, 0x7F, 0x8F, 0xCF, 0xCF, 0xF1, 0xF9, 0xF9, 0xFE, 0x7E, 0x3F, 0x7F,
  0xCF, 0xC7, 0xEF, 0x79, 0xF0, 0xFD, 0xEF, 0x7E, 0x1F, 0xFD, 0xEF, 0x83,
  0xEF, 0x3F, 0xF0, 0x7D, 0xE7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F,
  0xE0, 0x3F, 0xE3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0,
  0x1F, 0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xF0, 0x1F, 0xCF,
  0xE0, 0x7F, 0x0F, 0xC1, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x3F, 0x0F,
  0xE0, 0xFC, 0x3F, 0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xDF, 0x80, 0x1F, 0x7E, 0x00, 0x7D,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0x00,
  0x00, 0x1C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x7F, 0x83, 0xFC,
  0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x1F, 0x00, 0x7E,
  0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0, 0xFE, 0x07,
  0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0xBF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFA, 0x00,
  0x00,
};

const GFXglyph NotoSans_BlackItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 24, 10, 0, -24 },
  { 34, 14, 9, 15, 3, -24 },
  { 50, 22, 24, 21, 0, -24 },
  { 116, 18, 27, 19, 1, -25 },
  { 177, 28, 24, 31, 2, -24 },
  { 261, 24, 24, 24, 0, -24 },
  { 333, 7, 9, 8, 3, -24 },
  { 341, 14, 29, 12, 1, -24 },
  { 392, 13, 29, 12, -2, -24 },
  { 440, 17, 16, 18, 2, -25 },
  { 474, 17, 16, 19, 1, -20 },
  { 508, 9, 8, 10, -2, -4 },
  { 517, 10, 5, 11, 0, -11 },
  { 524, 7, 6, 10, 0, -6 },
  { 530, 19, 24, 15, -1, -24 },
  { 587, 18, 24, 19, 1, -24 },
  { 641, 15, 24, 19, 2, -24 },
  { 686, 19, 24, 19, -1, -24 },
  { 743, 18, 24, 19, 0, -24 },
  { 797, 19, 24, 19, 0, -24 },
  { 854, 19, 24, 19, 0, -24 },
  { 911, 18, 24, 19, 1, -24 },
  { 965, 20, 24, 19, 1, -24 },
  { 1025, 18, 24, 19, 1, -24 },
  { 1079, 16, 24, 19, 2, -24 },
  { 1127, 10, 18, 10, 0, -18 },
  { 1150, 12, 22, 10, -2, -18 },
  { 1183, 17, 18, 19, 1, -21 },
  { 1222, 17, 11, 19, 1, -17 },
  { 1246, 17, 18, 19, 1, -21 },
  { 1285, 15, 24, 16, 2, -24 },
  { 1330, 28, 27, 30, 1, -24 },
  { 1425, 22, 24, 22, -2, -24 },
  { 1491, 19, 24, 21, 1, -24 },
  { 1548, 20, 24, 21, 2, -24 },
  { 1608, 21, 24, 23, 1, -24 },
  { 1671, 19, 24, 19, 1, -24 },
  { 1728, 18, 24, 19, 1, -24 },
  { 1782, 21, 24, 23, 2, -24 },
  { 1845, 23, 24, 24, 1, -24 },
  { 1914, 17, 24, 14, -1, -24 },
  { 1965, 17, 31, 12, -5, -24 },
  { 2031, 24, 24, 22, 1, -24 },
  { 2103, 15, 24, 17, 1, -24 },
  { 2148, 29, 24, 30, 1, -24 },
  { 2235, 25, 24, 26, 1, -24 },
  { 2310, 21, 24, 24, 2, -24 },
  { 2373, 19, 24, 21, 1, -24 },
  { 2430, 21, 30, 24, 2, -24 },
  { 2509, 19, 24, 21, 1, -24 },
  { 2566, 17, 24, 18, 1, -24 },
  { 2617, 17, 24, 18, 3, -24 },
  { 2668, 21, 24, 23, 2, -24 },
  { 2731, 21, 24, 20, 2, -24 },
  { 2794, 32, 24, 31, 2, -24 },
  { 2890, 26, 24, 22, -2, -24 },
  { 2968, 20, 24, 20, 3, -24 },
  { 3028, 21, 24, 18, -1, -24 },
  { 3091, 15, 30, 12, -1, -24 },
  { 3148, 9, 24, 15, 4, -24 },
  { 3175, 15, 30, 12, -2, -24 },
  { 3232, 17, 16, 18, 0, -24 },
  { 3266, 16, 4, 15, -3, 2 },
  { 3274, 8, 5, 12, 5, -25 },
  { 3279, 19, 19, 20, 1, -19 },
  { 3325, 19, 25, 20, 0, -25 },
  { 3385, 16, 19, 17, 1, -19 },
  { 3423, 20, 25, 20, 1, -25 },
  { 3486, 17, 19, 19, 1, -19 },
  { 3527, 20, 33, 14, -3, -25 },
  { 3610, 20, 27, 20, 0, -19 },
  { 3678, 19, 25, 21, 0, -25 },
  { 3738, 12, 26, 11, 0, -26 },
  { 3777, 16, 34, 11, -4, -26 },
  { 3845, 22, 25, 20, 0, -25 },
  { 3914, 12, 25, 11, 0, -25 },
  { 3952, 29, 19, 31, 0, -19 },
  { 4021, 19, 19, 21, 0, -19 },
  { 4067, 18, 19, 20, 1, -19 },
  { 4110, 20, 27, 20, -1, -19 },
  { 4178, 19, 27, 20, 1, -19 },
  { 4243, 16, 19, 14, 0, -19 },
  { 4281, 16, 19, 17, 0, -19 },
  { 4319, 14, 22, 15, 1, -22 },
  { 4358, 18, 18, 21, 2, -18 },
  { 4399, 19, 18, 18, 1, -18 },
  { 4442, 27, 18, 27, 2, -18 },
  { 4503, 23, 18, 19, -2, -18 },
  { 4555, 22, 26, 18, -2, -18 },
  { 4627, 18, 18, 16, -1, -18 },
  { 4668, 14, 29, 12, 0, -24 },
  { 4719, 4, 32, 19, 7, -25 },
  { 4735, 14, 29, 12, -2, -24 },
  { 4786, 17, 7, 19, 1, -15 },
};

const GFXfont NotoSans_BlackItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_BLACKITALIC33PT7B_H_
