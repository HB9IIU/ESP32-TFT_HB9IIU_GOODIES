#ifndef _NOTOSANS_BLACKITALIC66PT7B_H_
#define _NOTOSANS_BLACKITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF8, 0xFF, 0xE7, 0xFF,
  0x1F, 0xFC, 0xFF, 0xC3, 0xFF, 0x9F, 0xF8, 0x7F, 0xE3, 0xFF, 0x0F, 0xFC,
  0xFF, 0xE1, 0xFF, 0x9F, 0xF8, 0x3F, 0xF3, 0xFF, 0x0F, 0xFC, 0x7F, 0xE1,
  0xFF, 0x8F, 0xF8, 0x3F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F,
  0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x81, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFD, 0xF7, 0xFC, 0x0F, 0xFF, 0x3F, 0x07, 0x80, 0xFF, 0xF3, 0xE0, 0x08,
  0x0F, 0xFE, 0x3E, 0x00, 0x00, 0xFF, 0xE3, 0xE0, 0x00, 0x0F, 0xFF, 0x7E,
  0x00, 0x00, 0xFF, 0xF7, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xF7, 0xFF, 0x80, 0x00, 0x3F, 0x3F, 0xF8, 0x00, 0x03, 0xE3,
  0xFF, 0x88, 0x00, 0x3E, 0x3F, 0xF8, 0xF0, 0x03, 0xE3, 0xFF, 0x0F, 0xE0,
  0x7E, 0x7F, 0xF0, 0xFF, 0xF7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC1,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFE,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFF,
  0x87, 0xFE, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFE, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC7, 0xFC, 0x7F, 0xF3, 0xFF, 0x0F, 0xFF, 0x0F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x01, 0xF8, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x83,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x9F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xF8, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE7, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF,
  0x3F, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x10, 0x03, 0xFE,
  0x00, 0x18, 0x03, 0xFE, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x03, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFD, 0xFF,
  0x00, 0x7F, 0xF9, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0xFF,
  0x80, 0x03, 0xE0, 0xFF, 0xC0, 0x01, 0xE0, 0xFF, 0xC0, 0x00, 0xC0, 0x7F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x03,
  0x80, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0x9F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x1F, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF8, 0x0F,
  0xFF, 0x1F, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xF8,
  0x07, 0xFF, 0x9F, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF,
  0xF8, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF,
  0x7F, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0x7F, 0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xFD, 0xFF, 0xF0,
  0x0F, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF,
  0xF8, 0x0F, 0xFF, 0x9F, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x7F, 0xFC,
  0x7F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xDF, 0xFE, 0x0F, 0xFC,
  0x7F, 0xF8, 0x3F, 0xE3, 0xFF, 0xC0, 0x7E, 0x0F, 0xFF, 0x00, 0xF0, 0x3F,
  0xFC, 0x03, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xFF, 0x00, 0x1F, 0xC0, 0x7F,
  0xFC, 0x00, 0x3C, 0x01, 0xFF, 0xF0, 0x00, 0x60, 0x07, 0xFF, 0xC0, 0x01,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x83, 0xFF,
  0xF0, 0x03, 0xC0, 0x1F, 0xFF, 0x00, 0x10, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC8, 0x00, 0x00, 0x7F, 0xFC, 0xE0, 0x00, 0x0F, 0xFF, 0xCF, 0x80, 0x01,
  0xFF, 0xFC, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xDF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x07, 0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0xC0, 0x07, 0xFF,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE1,
  0x80, 0x00, 0x3F, 0xFF, 0x0F, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xE3, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xD0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x01, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF9, 0xFF,
  0xF8, 0x07, 0xFF, 0xBF, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF,
  0x80, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xF8,
  0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F,
  0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x7F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0xC3, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x7F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF,
  0x1F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x03,
  0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xFE,
  0x07, 0xFF, 0xC7, 0xFF, 0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xA0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8,
  0x3F, 0xFE, 0x7F, 0xFE, 0x07, 0xFF, 0x9F, 0xFF, 0x01, 0xFF, 0xE7, 0xFF,
  0xC0, 0x7F, 0xF9, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xDF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0x7F, 0xF8, 0x0F, 0xFF, 0xDF, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xDF, 0xFE, 0x1F, 0xFF,
  0xF7, 0xFF, 0x03, 0xFF, 0xFB, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xF0, 0x0F,
  0xFC, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x0E, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC7, 0xFC, 0x3F, 0xFE, 0x3F, 0x00,
  0xFF, 0xF0, 0xC0, 0x07, 0xFF, 0x84, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0xFF, 0x87, 0xFE, 0x01,
  0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x87, 0xFC, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x1F, 0xF3, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xCF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x7F, 0xC0, 0xFF, 0xE1, 0xFF,
  0x03, 0xFD, 0xFF, 0x07, 0xFF, 0x07, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFF,
  0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFB, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xEF, 0xF0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x3F, 0xC1, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE3, 0xFC,
  0x1F, 0xF0, 0xFF, 0xE1, 0xFF, 0x8F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xFF,
  0x9F, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x9F, 0xF8, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xF0,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0x80, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x20, 0x07, 0xFF, 0xE0, 0x00, 0x70, 0x03, 0xFF, 0xFC, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC1, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x1F,
  0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01,
  0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x0C, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xFF,
  0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xFF, 0xF1, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFE, 0x07,
  0xFF, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xFF, 0xE3, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0x82, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE3, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE7, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xF8, 0x03,
  0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFF, 0x00, 0x7F, 0xF7, 0xFC, 0x07, 0xFC,
  0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xDF,
  0xF0, 0x3F, 0xF7, 0xFF, 0x00, 0x3F, 0xFB, 0xFE, 0x07, 0xFC, 0xFF, 0xE0,
  0x0F, 0xFE, 0x7F, 0xC1, 0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0xCF, 0xF8, 0x3F,
  0xE7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0x0F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF,
  0x3F, 0xE1, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE7, 0xFC, 0x3F, 0xE3, 0xFF,
  0x80, 0x3F, 0xFC, 0xFF, 0x8F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE3, 0xFE, 0x7F, 0xC3, 0xFF, 0x80, 0x1F,
  0xFC, 0x7F, 0xCF, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x8F, 0xFB, 0xFE, 0x1F,
  0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0x7F, 0xC3, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F,
  0xFF, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFF, 0xF0,
  0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xF8,
  0x01, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFF,
  0x81, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xEF, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xFD, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0xBF, 0xFC, 0x07, 0xFF,
  0x00, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xF0, 0x3F,
  0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xE0,
  0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF,
  0x87, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x07,
  0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xFC,
  0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xF9, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE1, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF1, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x87, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xF8,
  0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x3F,
  0xFE, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xEF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xCF,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xCF, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xC7, 0xFF, 0xC0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x1F, 0xFF, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0xE1, 0xFF, 0xF0,
  0x07, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0xFF,
  0xDF, 0xFF, 0x00, 0x1F, 0xFF, 0xBF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xF9, 0xFF,
  0x80, 0x3F, 0xFE, 0x01, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x80, 0x00, 0x3F, 0xFC,
  0x0E, 0x00, 0x03, 0xFF, 0xC0, 0xF8, 0x00, 0x7F, 0xFC, 0x0F, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xBF, 0xFC,
  0x00, 0x0F, 0xFF, 0x9F, 0xFE, 0x00, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x07,
  0xFF, 0xC7, 0xFF, 0x80, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x03, 0xFF, 0xE1,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xF8,
  0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8,
  0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x9F, 0xFC, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xBF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xCF,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE3, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x7F, 0xDF, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x7F,
  0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFD, 0xFF, 0x87, 0xFF, 0x80, 0x1F,
  0xFC, 0x3F, 0xE7, 0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x9F, 0xF8,
  0xFF, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x7F, 0xE3, 0xFF, 0x80, 0x07, 0xFE,
  0x3F, 0xF1, 0xFF, 0x9F, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x7F,
  0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x1F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0x9F,
  0xF8, 0x7F, 0xEF, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xC1, 0xFF, 0xBF, 0xF8,
  0x00, 0x1F, 0xFB, 0xFF, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFC,
  0x1F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC3, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFB,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF1,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x7F,
  0xFC, 0x00, 0x7F, 0xFE, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x7F, 0xFC, 0x00,
  0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xF0,
  0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x10, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x1F,
  0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0xFF, 0x7F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xC7,
  0xFF, 0xE0, 0x7F, 0xFC, 0x7F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x7F,
  0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xF8,
  0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0xEF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFD, 0xFF, 0x80, 0x1F, 0xFF,
  0xDF, 0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0xE7, 0xFF, 0x00,
  0x1F, 0xFE, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xF0,
  0xFF, 0xE0, 0x1F, 0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F,
  0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFE,
  0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0xBF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xEF, 0xFF, 0xF8, 0x0F,
  0xFE, 0x7F, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x03,
  0xC1, 0xFF, 0xF8, 0x01, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0x03, 0xFF,
  0xE0, 0x0E, 0x07, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFC, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00,
  0x7F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xFD,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF7, 0xFE, 0x00, 0x0F,
  0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC0,
  0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0x3F, 0xFC,
  0x07, 0xFF, 0xDF, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0xFF, 0xF9, 0xFF,
  0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0x03, 0xFF, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x82, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x3F, 0xF0, 0x03, 0xFF, 0xF8, 0xFF, 0xC0, 0x1F, 0xFF, 0xE7, 0xFF, 0x00,
  0xFF, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFF, 0xEF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xFD,
  0xFF, 0xE0, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0x00, 0x03, 0xFF, 0xE0, 0x0F,
  0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0x07, 0xFF, 0x9F,
  0xFE, 0x00, 0x3F, 0xFD, 0xFF, 0xF8, 0x01, 0xFF, 0xDF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFC,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFC, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF,
  0xC3, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x83, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0x87, 0xFF, 0xE0, 0x01, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0xFF, 0xF3, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xBF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xCF, 0xFF, 0x80, 0x01,
  0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x83, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xF3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF,
  0xF0, 0x03, 0xFF, 0x3F, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F,
  0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF,
  0xC0, 0x7F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFF,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xFC,
  0x3F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0,
  0x7F, 0xFC, 0xFF, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE, 0x03, 0xFF, 0xDF, 0xFF,
  0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x3F, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xEF, 0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF, 0xF0, 0x1F,
  0xFF, 0x3F, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0x83, 0xFF, 0xF3, 0xFF, 0xE1,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x3F, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0xF8,
  0x00, 0x1F, 0xFB, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xF8,
  0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x03, 0xFF, 0xFB, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x0F,
  0xF8, 0x00, 0x0F, 0xFF, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xFE, 0x3F, 0xF0,
  0x1F, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0xFF, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x7F,
  0xFC, 0x7F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8,
  0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0x8F,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0xEF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFB, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xF8, 0x00, 0x0F, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x81,
  0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF,
  0xE0, 0x1F, 0xFB, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xCF, 0xF0, 0x1F, 0xFE, 0x03, 0xE0,
  0x7F, 0xFC, 0x01, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE3, 0x00, 0x07, 0xFF, 0xC7, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x20, 0x0F, 0xFF, 0xDF, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x3F,
  0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFC,
  0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF9, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF,
  0xF3, 0xFF, 0x00, 0x3F, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xCF,
  0xFF, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F,
  0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0xE1,
  0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x01,
  0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF,
  0x80, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF,
  0xE7, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F,
  0xDF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xBF, 0xC7, 0xFF, 0x80, 0x7F,
  0xF1, 0xFE, 0x7F, 0x8F, 0xFE, 0x00, 0xFF, 0xE7, 0xFC, 0xFF, 0x1F, 0xFC,
  0x01, 0xFF, 0xCF, 0xF9, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xE3, 0xFC,
  0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xC7, 0xFB, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0x8F, 0xF7, 0xFF, 0x00, 0x0F, 0xFD, 0xFE, 0x1F, 0xEF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x00,
  0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x83, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x87, 0xFF, 0x00, 0x00,
  0xCF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x98, 0x00, 0x0F, 0xFF, 0x88, 0x00, 0x00, 0xFF, 0x00,
};

const GFXglyph NotoSans_BlackItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 23, 48, 20, 0, -47 },
  { 139, 27, 17, 30, 6, -47 },
  { 197, 44, 47, 43, 0, -47 },
  { 456, 36, 54, 38, 2, -50 },
  { 699, 56, 49, 61, 4, -48 },
  { 1042, 48, 49, 48, 0, -48 },
  { 1336, 13, 17, 16, 6, -47 },
  { 1364, 27, 58, 25, 2, -48 },
  { 1560, 26, 58, 25, -4, -48 },
  { 1749, 32, 33, 36, 5, -51 },
  { 1881, 33, 32, 39, 3, -39 },
  { 2013, 17, 17, 20, -3, -8 },
  { 2050, 20, 10, 22, 1, -23 },
  { 2075, 14, 13, 20, 0, -12 },
  { 2098, 38, 49, 31, -3, -48 },
  { 2331, 35, 49, 38, 2, -48 },
  { 2546, 30, 47, 38, 5, -47 },
  { 2723, 38, 48, 38, -2, -48 },
  { 2951, 36, 49, 38, 0, -48 },
  { 3172, 37, 47, 38, 0, -47 },
  { 3390, 37, 48, 38, 1, -47 },
  { 3612, 36, 49, 38, 3, -48 },
  { 3833, 40, 47, 38, 1, -47 },
  { 4068, 35, 49, 38, 2, -48 },
  { 4283, 34, 49, 38, 3, -48 },
  { 4492, 20, 38, 20, 0, -37 },
  { 4587, 24, 46, 20, -4, -37 },
  { 4725, 33, 36, 39, 3, -42 },
  { 4874, 33, 23, 39, 3, -35 },
  { 4969, 33, 36, 39, 3, -42 },
  { 5118, 29, 49, 32, 5, -48 },
  { 5296, 54, 54, 59, 3, -48 },
  { 5661, 44, 47, 45, -4, -47 },
  { 5920, 40, 47, 42, 1, -47 },
  { 6155, 41, 49, 42, 3, -48 },
  { 6407, 42, 47, 45, 1, -47 },
  { 6654, 38, 47, 37, 1, -47 },
  { 6878, 38, 47, 38, 1, -47 },
  { 7102, 42, 49, 46, 3, -48 },
  { 7360, 46, 47, 47, 1, -47 },
  { 7631, 34, 47, 28, -2, -47 },
  { 7831, 36, 62, 25, -11, -47 },
  { 8110, 48, 47, 44, 1, -47 },
  { 8392, 30, 47, 35, 1, -47 },
  { 8569, 59, 47, 60, 1, -47 },
  { 8916, 51, 47, 52, 1, -47 },
  { 9216, 44, 49, 49, 3, -48 },
  { 9486, 39, 47, 41, 1, -47 },
  { 9716, 44, 59, 49, 3, -48 },
  { 10041, 39, 47, 43, 1, -47 },
  { 10271, 36, 49, 36, 1, -48 },
  { 10492, 35, 47, 36, 5, -47 },
  { 10698, 43, 48, 46, 4, -47 },
  { 10956, 41, 47, 41, 5, -47 },
  { 11197, 62, 47, 62, 5, -47 },
  { 11562, 53, 47, 44, -4, -47 },
  { 11874, 40, 47, 40, 5, -47 },
  { 12109, 42, 47, 36, -3, -47 },
  { 12356, 30, 59, 24, -2, -48 },
  { 12578, 18, 49, 31, 7, -48 },
  { 12689, 29, 59, 24, -4, -48 },
  { 12903, 35, 31, 35, 0, -47 },
  { 13039, 32, 8, 30, -6, 4 },
  { 13071, 16, 11, 23, 9, -51 },
  { 13093, 36, 38, 40, 3, -37 },
  { 13264, 36, 51, 40, 1, -50 },
  { 13494, 31, 38, 33, 3, -37 },
  { 13642, 39, 51, 40, 3, -50 },
  { 13891, 34, 38, 38, 3, -37 },
  { 14053, 41, 66, 27, -7, -50 },
  { 14392, 38, 53, 40, 1, -37 },
  { 14644, 37, 50, 41, 1, -50 },
  { 14876, 22, 51, 21, 1, -51 },
  { 15017, 33, 67, 21, -9, -51 },
  { 15294, 43, 50, 41, 1, -50 },
  { 15563, 23, 50, 21, 1, -50 },
  { 15707, 57, 37, 61, 1, -37 },
  { 15971, 37, 37, 41, 1, -37 },
  { 16143, 34, 38, 40, 3, -37 },
  { 16305, 40, 53, 40, -3, -37 },
  { 16570, 36, 53, 40, 3, -37 },
  { 16809, 31, 37, 29, 1, -37 },
  { 16953, 31, 38, 33, 1, -37 },
  { 17101, 29, 45, 30, 2, -44 },
  { 17265, 37, 38, 41, 3, -37 },
  { 17441, 37, 37, 36, 3, -37 },
  { 17613, 55, 37, 54, 3, -37 },
  { 17868, 46, 37, 37, -4, -37 },
  { 18081, 44, 53, 36, -4, -37 },
  { 18373, 34, 37, 32, -1, -37 },
  { 18531, 29, 57, 24, -1, -47 },
  { 18738, 9, 65, 37, 14, -50 },
  { 18812, 28, 57, 24, -4, -47 },
  { 19012, 33, 13, 39, 3, -30 },
};

const GFXfont NotoSans_BlackItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_BLACKITALIC66PT7B_H_
