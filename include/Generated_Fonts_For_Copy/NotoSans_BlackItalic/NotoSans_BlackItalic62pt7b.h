#ifndef _NOTOSANS_BLACKITALIC62PT7B_H_
#define _NOTOSANS_BLACKITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0xF1, 0xFF, 0xBF, 0xF8, 0xFF, 0xDF, 0xF8, 0x7F, 0xEF, 0xFC, 0x3F,
  0xE7, 0xFE, 0x3F, 0xF3, 0xFE, 0x1F, 0xF9, 0xFF, 0x0F, 0xF8, 0xFF, 0x87,
  0xFC, 0xFF, 0x83, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0xFF, 0x1F, 0xF0,
  0xFF, 0x8F, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFC,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x9F, 0x07, 0x80,
  0xFF, 0xE7, 0xC0, 0x20, 0x3F, 0xF1, 0xF0, 0x00, 0x0F, 0xFC, 0xF8, 0x00,
  0x03, 0xFF, 0xBE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0xFF, 0xC0,
  0x00, 0x1F, 0x3F, 0xF8, 0x00, 0x07, 0xC7, 0xFE, 0x20, 0x01, 0xF1, 0xFF,
  0x0F, 0x00, 0x7C, 0xFF, 0xC3, 0xF8, 0x3E, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xF1, 0xFE, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0x80, 0x3F,
  0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x0F,
  0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF,
  0x83, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0x00, 0x00,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x1F, 0xF8, 0xFF, 0x8F,
  0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF,
  0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x7F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFE, 0x7F, 0xC7, 0xFE, 0x7F, 0xC1, 0xFF, 0xC3, 0xFE, 0x3F, 0xE3, 0xFE,
  0x03, 0xF0, 0x3F, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xF8, 0xFF, 0xFD, 0xFF, 0xF7, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xBF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF7, 0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFC, 0x7F, 0xC7,
  0xFC, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x03, 0x00, 0x7F, 0x80, 0x0E, 0x01, 0xFE, 0x00, 0x3E, 0x07, 0xF0,
  0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xF8, 0x04, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xBF, 0xC0, 0x1F, 0xFE, 0xFF, 0x00, 0x3F, 0xF3, 0xFE,
  0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0xF0, 0x7F, 0xC0,
  0x01, 0x81, 0xFF, 0x80, 0x02, 0x07, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0xFF, 0x9F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0x9F, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F,
  0xF8, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F,
  0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x9F, 0xFE, 0x03, 0xFF, 0xDF, 0xFE, 0x01,
  0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x7F, 0xFB, 0xFF, 0xC0,
  0x3F, 0xFD, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xF0,
  0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xDF, 0xFE,
  0x01, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xF3, 0xFF,
  0xC0, 0x7F, 0xF9, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F,
  0xF8, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xBF, 0xF8, 0x7F, 0xE7, 0xFF, 0x83, 0xFC, 0x7F,
  0xF0, 0x1F, 0x07, 0xFF, 0x01, 0xC0, 0xFF, 0xF0, 0x08, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xE1, 0xFF, 0xF0, 0x03, 0xF8, 0x0F, 0xFF, 0x00, 0x1E, 0x00,
  0xFF, 0xF0, 0x00, 0xC0, 0x0F, 0xFF, 0x00, 0x08, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x3F,
  0xFC, 0x00, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x20, 0x00,
  0x07, 0xFF, 0xCE, 0x00, 0x03, 0xFF, 0xF3, 0xF0, 0x01, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xBF, 0xF8, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x07, 0xFC, 0xFF,
  0xC0, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x1F, 0xF8,
  0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x80, 0x00, 0x3F, 0xFE, 0x18, 0x00, 0x0F, 0xFF, 0x83,
  0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x18, 0x00, 0x1F, 0xFC, 0x7F, 0xC0,
  0x0F, 0xFE, 0x7F, 0xFC, 0x03, 0xFF, 0xBF, 0xFF, 0x80, 0xFF, 0xDF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF,
  0xF8, 0x0F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xE3,
  0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF,
  0x87, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x0F, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE,
  0x1F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0x00,
  0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFE, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xFB, 0xFF, 0xE0, 0xFF, 0xF7,
  0xFF, 0x80, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x7F, 0xF0, 0xFF, 0xFE,
  0xFF, 0xE0, 0xFF, 0xF1, 0xFF, 0xC0, 0x7F, 0xC7, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x84, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0xFF, 0xF0, 0xE0,
  0x07, 0xFF, 0x08, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF,
  0xFE, 0x1F, 0xE1, 0xFF, 0x01, 0xFF, 0xFF, 0xE1, 0xFE, 0x1F, 0xF0, 0x3F,
  0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xF3, 0xFC, 0x0F, 0xFC, 0x3F, 0xC0, 0xFF, 0x3F,
  0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xF7, 0xF8, 0x3F, 0xC0, 0x7F, 0x80,
  0xFE, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x1F, 0xE7, 0xF8, 0x7F, 0xC0, 0x7F,
  0x81, 0xFE, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x1F, 0xE7, 0xF0, 0x7F, 0x80,
  0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xCF, 0xF0, 0x7F,
  0x81, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0x87, 0xF8,
  0x7F, 0xC7, 0xFF, 0x1F, 0xF0, 0x7F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xF8, 0x3F, 0xFF, 0x7F, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xE3, 0xFF,
  0xE0, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x1E, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xDF, 0xF8,
  0x00, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x87, 0xFF, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x7F, 0xF8,
  0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xFC,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0xF8, 0x0F, 0xFF, 0xC0,
  0x00, 0xC0, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x10, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0x1F, 0xFF,
  0xE0, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xC7, 0xFF, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF,
  0xC3, 0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x70, 0x0F, 0xFF, 0xC0,
  0x00, 0x10, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0xFC, 0x7F, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F,
  0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xE3, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFB,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x1F, 0xFD, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xE1, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xDF, 0xF8, 0x03, 0xFF,
  0x7F, 0x80, 0x7F, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0x80, 0xFF,
  0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F,
  0x81, 0xFF, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xE0, 0x07,
  0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0x83, 0xFC, 0xFF,
  0xE0, 0x07, 0xFE, 0x7F, 0x87, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0x87,
  0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0x8F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC,
  0x7F, 0x8F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0x9F, 0xF1, 0xFF, 0xC0,
  0x1F, 0xFC, 0x7F, 0x9F, 0xF1, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xBF, 0xE1,
  0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xBF, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F,
  0xBF, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0x80, 0x3F,
  0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xFE, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x7F, 0xF0, 0x3F, 0xF8, 0x03,
  0xFF, 0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x3F, 0xF8, 0x07,
  0xFF, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF8, 0x3F, 0xF0, 0x07,
  0xFE, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xF0, 0x07,
  0xFE, 0x1F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xE0, 0x0F,
  0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x1F,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x7F,
  0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x01, 0xFF,
  0xEF, 0xFF, 0x80, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x7F, 0xFB, 0xFF,
  0xC0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x3F, 0xFD, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xBF, 0xFC, 0x00, 0x07, 0xFF, 0xDF, 0xFE, 0x00, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x00,
  0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x1F, 0xFE,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x9F, 0xFE,
  0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x7F, 0xFD,
  0xFF, 0xE0, 0x00, 0x3F, 0xFD, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x07,
  0xFF, 0xDF, 0xFE, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x03, 0xFF, 0xE7,
  0xFF, 0x80, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0xF1, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0xFF,
  0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFC, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x7F,
  0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFF, 0x3F, 0xFC, 0x00, 0x7F,
  0xFD, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFC, 0x07, 0xC0, 0x1F, 0xFE, 0x00, 0x30, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x80, 0x00,
  0x7F, 0xF8, 0x38, 0x00, 0x3F, 0xFC, 0x0F, 0x80, 0x0F, 0xFF, 0x03, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x40, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFF, 0x3F,
  0xF8, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xF3, 0xFF, 0x80, 0x07,
  0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0xFF,
  0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF,
  0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xF0,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x1F, 0xFC,
  0x7F, 0xF0, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xF7,
  0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFB,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xCF, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xF8,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFD, 0xFF,
  0x07, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x7F, 0xC3, 0xFF, 0x80, 0x3F, 0xF8,
  0xFF, 0xDF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xF0,
  0x03, 0xFF, 0x0F, 0xF9, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xC7, 0xFC, 0x7F,
  0xC7, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x1F, 0xF3, 0xFF, 0x80, 0x0F, 0xFC,
  0xFF, 0xC7, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F, 0xF0,
  0x00, 0x7F, 0xCF, 0xF8, 0x7F, 0xDF, 0xFC, 0x00, 0x1F, 0xF7, 0xFC, 0x1F,
  0xF7, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x07, 0xFD, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFF, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xC0,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x3F, 0xF3,
  0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x7F,
  0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xEF, 0xF8,
  0x00, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xE1,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFF, 0x8F, 0xFC,
  0x07, 0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x7F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x87, 0xFF,
  0x80, 0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F,
  0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0x9F, 0xF8, 0x00,
  0x7F, 0xC7, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC3, 0xE0, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xE0,
  0x0F, 0xFE, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xF0, 0xFF,
  0xE0, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0xC7,
  0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFE,
  0x1F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF,
  0xF8, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0x7F, 0xFF, 0xC0, 0xFF, 0xCF, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0xE0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x7E, 0x0F, 0xFF, 0x80, 0x70,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x03, 0x07, 0xFF, 0xC0, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0xE0,
  0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xF8, 0x7F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xF3, 0xFE, 0x00, 0x0F,
  0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x3F, 0xFC, 0x0F, 0xFE, 0x3F, 0xFC, 0x0F,
  0xFE, 0x7F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x7F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x40, 0xFF, 0xF0, 0x01, 0xC0, 0xFF, 0xF8, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xFE, 0x3F, 0xF0, 0x07, 0xFF,
  0xF3, 0xFE, 0x00, 0xFF, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF,
  0x83, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xBF, 0xF8,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x80,
  0x00, 0xFF, 0xF0, 0x0C, 0x00, 0x1F, 0xFE, 0x00, 0xFC, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x3F, 0x80, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0xC0, 0x1F,
  0xFD, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xEF, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC,
  0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F,
  0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0,
  0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8,
  0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xE0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x08, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xEF,
  0xFF, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x01, 0xFF, 0xC3, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x7F,
  0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x07,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFC,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF0, 0x0F, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x07, 0xFC, 0x7F,
  0xFC, 0x01, 0xFF, 0x9F, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0xFF, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0x0F,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF,
  0x0F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC,
  0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F,
  0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE,
  0x1F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFE, 0x0F, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x7F, 0xFC,
  0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0,
  0x1F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xF0,
  0x7F, 0xFC, 0xFF, 0xF0, 0x7F, 0xF8, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0xF0,
  0x00, 0xFF, 0xDF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x3F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xBF,
  0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x07,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x1E, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xFD, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x03,
  0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xF0,
  0x0F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xC3, 0xFF,
  0xC0, 0x7F, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x0F,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xBF, 0xF8, 0x00, 0x7F, 0x9F, 0xFE, 0x00, 0x03, 0x87, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0xC7, 0xFC, 0x07, 0xFE,
  0x7F, 0xE0, 0x3F, 0xF7, 0xFF, 0x01, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x80, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0x0F, 0xC0, 0xFF, 0xF0, 0x0E, 0x07, 0xFF, 0x80, 0x20, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x80, 0x03, 0xFF,
  0xC6, 0x00, 0x1F, 0xFE, 0x3F, 0x01, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFC,
  0x3F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F,
  0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF0, 0xFF,
  0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F,
  0xF8, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xBF, 0xF0, 0x1F, 0xFF, 0xF7, 0xFC, 0x01, 0xFF, 0xFD, 0xFF, 0x80, 0x1F,
  0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xEF, 0xFE, 0x00,
  0x7F, 0xFB, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0x3F, 0xFC,
  0x07, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x81,
  0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF8,
  0x03, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x0F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xDF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x1F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xCF, 0xFE, 0x03,
  0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0x8F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0x07,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFE, 0x0F, 0xFE,
  0x07, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFC, 0x07, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xE1, 0xFD, 0xFE,
  0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xDF, 0xE3, 0xFF, 0x80, 0x7F, 0xE3, 0xFD,
  0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0x9F, 0xE7, 0xFF, 0x00, 0x7F, 0xE7,
  0xF9, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0x9F, 0xE7, 0xFE, 0x00, 0x7F,
  0xEF, 0xF1, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0x1F, 0xEF, 0xFC, 0x00,
  0x7F, 0xEF, 0xF1, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE1, 0xFD, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x9F, 0xFF, 0x00, 0x00, 0xFF, 0xF3,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x01, 0xFF, 0xE3, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F,
  0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x8F, 0xFE, 0x00, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x9F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x04, 0x7F, 0xF0, 0x00, 0x17, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x20, 0x00, 0x0F, 0xF0,
};

const GFXglyph NotoSans_BlackItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 21, 45, 19, 0, -44 },
  { 120, 25, 16, 28, 6, -44 },
  { 170, 41, 44, 40, 0, -44 },
  { 396, 34, 51, 36, 2, -47 },
  { 613, 53, 46, 58, 3, -45 },
  { 918, 45, 46, 45, 0, -45 },
  { 1177, 12, 16, 15, 6, -44 },
  { 1201, 25, 56, 23, 2, -46 },
  { 1376, 25, 56, 23, -4, -46 },
  { 1551, 30, 31, 34, 5, -48 },
  { 1668, 30, 30, 36, 3, -37 },
  { 1781, 16, 15, 19, -3, -7 },
  { 1811, 18, 9, 20, 1, -21 },
  { 1832, 13, 12, 19, 0, -11 },
  { 1852, 36, 46, 29, -3, -45 },
  { 2059, 33, 46, 36, 2, -45 },
  { 2249, 28, 44, 36, 5, -44 },
  { 2403, 36, 45, 36, -2, -45 },
  { 2606, 34, 46, 36, 0, -45 },
  { 2802, 35, 44, 36, 0, -44 },
  { 2995, 35, 45, 36, 1, -44 },
  { 3192, 34, 46, 36, 2, -45 },
  { 3388, 38, 44, 36, 1, -44 },
  { 3597, 34, 46, 36, 1, -45 },
  { 3793, 31, 46, 36, 3, -45 },
  { 3972, 19, 36, 19, 0, -35 },
  { 4058, 23, 43, 19, -4, -35 },
  { 4182, 30, 35, 36, 3, -40 },
  { 4314, 31, 22, 36, 3, -33 },
  { 4400, 30, 35, 36, 3, -40 },
  { 4532, 28, 46, 30, 4, -45 },
  { 4693, 52, 51, 56, 2, -45 },
  { 5025, 42, 44, 42, -4, -44 },
  { 5256, 37, 44, 39, 1, -44 },
  { 5460, 38, 46, 39, 3, -45 },
  { 5679, 39, 44, 42, 1, -44 },
  { 5894, 36, 44, 35, 1, -44 },
  { 6092, 35, 44, 35, 1, -44 },
  { 6285, 40, 46, 43, 3, -45 },
  { 6515, 44, 44, 44, 1, -44 },
  { 6757, 32, 44, 26, -2, -44 },
  { 6933, 33, 58, 23, -10, -44 },
  { 7173, 45, 44, 41, 1, -44 },
  { 7421, 28, 44, 33, 1, -44 },
  { 7575, 56, 44, 56, 1, -44 },
  { 7883, 48, 44, 49, 1, -44 },
  { 8147, 41, 46, 46, 3, -45 },
  { 8383, 37, 44, 39, 1, -44 },
  { 8587, 41, 56, 46, 3, -45 },
  { 8874, 37, 44, 40, 1, -44 },
  { 9078, 34, 46, 34, 1, -45 },
  { 9274, 33, 44, 34, 5, -44 },
  { 9456, 40, 45, 43, 4, -44 },
  { 9681, 38, 44, 38, 5, -44 },
  { 9890, 58, 44, 58, 5, -44 },
  { 10209, 50, 44, 41, -4, -44 },
  { 10484, 38, 44, 37, 5, -44 },
  { 10693, 40, 44, 33, -3, -44 },
  { 10913, 28, 56, 22, -2, -46 },
  { 11109, 17, 46, 29, 7, -45 },
  { 11207, 28, 56, 22, -4, -46 },
  { 11403, 33, 29, 33, 0, -44 },
  { 11523, 30, 7, 28, -6, 4 },
  { 11550, 15, 9, 22, 9, -47 },
  { 11567, 34, 36, 38, 3, -35 },
  { 11720, 34, 48, 38, 1, -47 },
  { 11924, 29, 36, 31, 3, -35 },
  { 12055, 37, 48, 37, 3, -47 },
  { 12277, 32, 36, 36, 3, -35 },
  { 12421, 38, 62, 25, -6, -47 },
  { 12716, 36, 50, 38, 1, -35 },
  { 12941, 35, 47, 39, 1, -47 },
  { 13147, 21, 48, 20, 1, -48 },
  { 13273, 30, 63, 20, -8, -48 },
  { 13510, 41, 47, 38, 1, -47 },
  { 13751, 21, 47, 20, 1, -47 },
  { 13875, 54, 35, 57, 1, -35 },
  { 14112, 35, 35, 39, 1, -35 },
  { 14266, 32, 36, 38, 3, -35 },
  { 14410, 37, 50, 38, -2, -35 },
  { 14642, 34, 50, 38, 3, -35 },
  { 14855, 29, 35, 27, 1, -35 },
  { 14982, 29, 36, 31, 1, -35 },
  { 15113, 27, 42, 28, 2, -41 },
  { 15255, 35, 35, 39, 3, -34 },
  { 15409, 34, 34, 34, 3, -34 },
  { 15554, 52, 34, 51, 3, -34 },
  { 15775, 43, 34, 35, -4, -34 },
  { 15958, 41, 49, 34, -4, -34 },
  { 16210, 32, 34, 30, -1, -34 },
  { 16346, 28, 54, 22, -1, -44 },
  { 16535, 9, 61, 35, 13, -47 },
  { 16604, 27, 54, 22, -4, -44 },
  { 16787, 30, 12, 36, 3, -28 },
};

const GFXfont NotoSans_BlackItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_BLACKITALIC62PT7B_H_
