#ifndef _NOTOSANS_BLACKITALIC20PT7B_H_
#define _NOTOSANS_BLACKITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x78, 0xF1, 0xE3, 0xC7, 0x0E, 0x3C, 0x78, 0x00, 0x87, 0x8F,
  0x1E, 0x00, 0xF7, 0xE7, 0xEE, 0xEE, 0xCE, 0x07, 0x70, 0x33, 0x83, 0x98,
  0x1D, 0xC7, 0xFF, 0xBF, 0xFC, 0x73, 0x03, 0xB8, 0xFF, 0xF7, 0xFF, 0x8E,
  0xE0, 0x77, 0x03, 0x38, 0x3B, 0x80, 0x03, 0x03, 0xE3, 0xFD, 0xFF, 0x76,
  0x5D, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xE8, 0xBF, 0xBE, 0xFF, 0xBF, 0xC1,
  0x80, 0x40, 0x3E, 0x0E, 0x3F, 0x0E, 0x1D, 0xCE, 0x1C, 0xE7, 0x0E, 0x67,
  0x07, 0x77, 0x33, 0xFF, 0x7E, 0xFB, 0xFF, 0x03, 0xBB, 0x83, 0x9D, 0xC3,
  0x8E, 0xE1, 0xC7, 0x71, 0xC3, 0xF1, 0xC0, 0xF0, 0x01, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0xE7, 0x81, 0xCE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xCF, 0x7F,
  0xBD, 0xFF, 0x7B, 0xCF, 0xE7, 0x8F, 0x8F, 0xFE, 0x0F, 0xFE, 0x0F, 0xDE,
  0x00, 0xFE, 0xEE, 0xC0, 0x0F, 0x0E, 0x1C, 0x38, 0x78, 0x70, 0x70, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x1C, 0x0E,
  0x0E, 0x0E, 0x0F, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C,
  0x3C, 0x38, 0x70, 0xE0, 0x07, 0x11, 0x86, 0x61, 0xFF, 0xBF, 0xC7, 0xF3,
  0xE1, 0xDC, 0x17, 0x81, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF,
  0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x3B, 0xDD, 0xCE, 0x00, 0x7D, 0xFF,
  0xC0, 0x2F, 0xFF, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00,
  0x02, 0x07, 0xE3, 0xFD, 0xFF, 0x7B, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8,
  0xFE, 0x3B, 0xDE, 0xFF, 0xBF, 0xC7, 0xE0, 0x07, 0xC3, 0xE3, 0xFB, 0xFE,
  0x77, 0x89, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07,
  0x80, 0x0F, 0xE1, 0xFF, 0x1F, 0xF0, 0x8F, 0x00, 0xF0, 0x1E, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0xFE, 0x7F, 0xEF, 0xFC, 0x1F, 0xC7,
  0xFC, 0x7F, 0x80, 0xF0, 0x1E, 0x3F, 0x87, 0xC0, 0xFC, 0x03, 0xC0, 0x7A,
  0x0F, 0x7F, 0xEF, 0xF9, 0xFE, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x83, 0xF0,
  0xFC, 0x3B, 0x8E, 0xF3, 0xDE, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xC0, 0x78,
  0x0E, 0x00, 0x1F, 0xF1, 0xFE, 0x1F, 0xE3, 0xC0, 0x3C, 0x03, 0xF8, 0x7F,
  0xC3, 0xFC, 0x03, 0xC0, 0x3C, 0x83, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0x0F,
  0xE7, 0xF8, 0xFF, 0x3C, 0x07, 0x21, 0xFF, 0x3F, 0xF7, 0xFE, 0xF3, 0xDE,
  0x7B, 0xCE, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0,
  0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x7C, 0x0F, 0x80, 0x01, 0x01, 0xF8, 0x7F, 0x9E, 0x73, 0xCE, 0x7B,
  0xC7, 0xF0, 0x7C, 0x3F, 0xCF, 0x79, 0xC7, 0x78, 0xE7, 0xFC, 0xFF, 0x8F,
  0xC0, 0x3F, 0x9F, 0xE7, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0xFF, 0xFF, 0x7B,
  0xC0, 0xE0, 0x7B, 0xFC, 0xFE, 0x3F, 0x00, 0x3C, 0xF3, 0xC4, 0x00, 0x00,
  0x08, 0xF3, 0xCF, 0x00, 0x1E, 0x3C, 0x78, 0x40, 0x00, 0x00, 0x00, 0x00,
  0xF1, 0xC3, 0x8E, 0x1C, 0x00, 0x00, 0x40, 0x70, 0x7C, 0x7E, 0x7E, 0x3E,
  0x0F, 0x81, 0xFC, 0x0F, 0xC0, 0xF0, 0x0C, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x7C, 0xFC, 0xFC, 0x3C, 0x0C, 0x00, 0x7F, 0x3F, 0xDF, 0xE8, 0x70,
  0x78, 0xF8, 0xF8, 0x78, 0x78, 0x00, 0x08, 0x0F, 0x0F, 0x83, 0x80, 0x07,
  0xF8, 0x1F, 0xFE, 0x3C, 0x0E, 0x70, 0xE7, 0x73, 0xF3, 0xE7, 0xF3, 0xEE,
  0x73, 0xCE, 0x73, 0xCC, 0x67, 0xCE, 0xEE, 0xEF, 0xFE, 0xE7, 0x38, 0x70,
  0x00, 0x7C, 0xE0, 0x3F, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0xFC,
  0x0F, 0xE0, 0x77, 0x07, 0xB8, 0x39, 0xE3, 0xCF, 0x1F, 0xF9, 0xFF, 0xCF,
  0xFE, 0xF0, 0xF7, 0x07, 0xF8, 0x3C, 0x1F, 0xE1, 0xFF, 0x1F, 0xF1, 0xCF,
  0x3C, 0xF3, 0xFE, 0x3F, 0xC3, 0xFE, 0x79, 0xE7, 0x8E, 0x79, 0xE7, 0xFE,
  0x7F, 0xCF, 0xF8, 0x01, 0x00, 0xFF, 0x1F, 0xF3, 0xFE, 0x7C, 0x27, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x84, 0x7F, 0xC7, 0xFC,
  0x3F, 0x80, 0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x38, 0xF3, 0xC7, 0x9E, 0x3C,
  0xF1, 0xE7, 0x8F, 0x78, 0x7B, 0xC7, 0x9E, 0x7C, 0xFF, 0xC7, 0xFC, 0x7F,
  0x80, 0x1F, 0xF1, 0xFE, 0x1F, 0xE1, 0xC0, 0x3C, 0x03, 0xFC, 0x3F, 0xC3,
  0xFC, 0x78, 0x07, 0x80, 0x78, 0x07, 0xF8, 0x7F, 0x8F, 0xF8, 0x1F, 0xF1,
  0xFE, 0x1F, 0xE1, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xC3, 0xFC, 0x7F, 0xC7,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x00, 0x80, 0x7F, 0xC7, 0xFC,
  0x7F, 0xE7, 0xC1, 0x3C, 0x03, 0xC0, 0x1E, 0x7E, 0xF3, 0xF7, 0xBF, 0x3C,
  0x39, 0xE3, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x0F, 0x3C, 0x38, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x78, 0x79,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x70, 0xF3, 0xC3, 0x80, 0x1F, 0xE3, 0xF8,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x07, 0xF1, 0xFE, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0x87, 0xF0, 0xFC, 0x1F, 0x81, 0x00, 0x00, 0x1E, 0x3E, 0x3C, 0xF0,
  0x7B, 0xE0, 0xE7, 0x83, 0xDE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC0, 0xF7, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x1F, 0x1E, 0x1E, 0x00, 0x1E,
  0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F,
  0xF7, 0xFF, 0xFC, 0x1F, 0x07, 0xC7, 0xC3, 0xF1, 0xF0, 0xFC, 0x7C, 0x7E,
  0x3F, 0x1F, 0x8E, 0xCE, 0xE3, 0xB3, 0xF8, 0xEC, 0xDE, 0x7B, 0x77, 0x1E,
  0xD9, 0xC7, 0x3E, 0x71, 0xCF, 0xBC, 0x73, 0xCF, 0x3C, 0xF3, 0x80, 0x1F,
  0x0F, 0x1F, 0x0F, 0x1F, 0x8E, 0x1F, 0x8E, 0x3B, 0x9E, 0x3B, 0x9E, 0x3B,
  0xDC, 0x39, 0xDC, 0x79, 0xDC, 0x79, 0xFC, 0x71, 0xFC, 0x70, 0xF8, 0x70,
  0xF8, 0xF0, 0xF8, 0x01, 0x00, 0x7F, 0x07, 0xFC, 0x7F, 0xF7, 0xC7, 0xBC,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3D, 0xE3, 0xE7, 0xFE,
  0x3F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xF1, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3F, 0xF3, 0xFE, 0x7F, 0xC7, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0x01, 0x00, 0x7F, 0x07, 0xFC, 0x7F, 0xF7, 0xC7, 0xBC, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3D, 0xE3, 0xE7, 0xFE, 0x3F, 0xE0,
  0xFE, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xE1, 0xFF, 0x1F, 0xF1,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xE3, 0xFC, 0x7F, 0xC7, 0xBC, 0x79, 0xE7,
  0x9E, 0x71, 0xEF, 0x0F, 0x0F, 0xE3, 0xFC, 0xFF, 0x1E, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0x7B, 0x0E, 0x7F, 0xCF, 0xF8, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x00, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0xF0,
  0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCE, 0x1C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79,
  0xFF, 0x87, 0xFC, 0x1F, 0x80, 0xF0, 0xFB, 0x87, 0x9C, 0x38, 0xE3, 0xC7,
  0x1C, 0x39, 0xE1, 0xCE, 0x0E, 0xF0, 0x77, 0x03, 0xB8, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x00, 0xF0, 0xF1, 0xEE, 0x1E, 0x3D, 0xC7, 0xC7, 0x38,
  0xF9, 0xE7, 0x3F, 0x38, 0xE7, 0xEF, 0x1D, 0xDD, 0xC3, 0xBB, 0xB8, 0x77,
  0x7F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0,
  0xF0, 0x00, 0x1E, 0x1F, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x78, 0xF8, 0xF0, 0x78, 0xF1, 0xFF, 0x3C, 0xF3, 0xC7, 0x78,
  0x77, 0x07, 0xF0, 0x7E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xFF, 0xCF, 0xFE,
  0x7F, 0xE0, 0x0F, 0xC3, 0xE0, 0xF8, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x7C, 0x3F,
  0x00, 0xE3, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x38, 0xE3, 0x8E, 0x38, 0xF0,
  0x1F, 0x8F, 0x87, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0xF8, 0x7C, 0x00, 0x03, 0x00, 0xE0,
  0x3E, 0x07, 0xC1, 0xD8, 0x73, 0x0C, 0x73, 0x8E, 0xE0, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0xF3, 0x8E, 0x1E, 0xE7, 0xFD, 0xFF, 0x7D, 0xEF, 0x3D, 0xE7,
  0xBC, 0xF7, 0x9C, 0xFF, 0x9F, 0xF1, 0xEE, 0x00, 0x1E, 0x03, 0xC0, 0x78,
  0x0E, 0x03, 0xFC, 0x7F, 0xCF, 0xF9, 0xEF, 0x39, 0xEF, 0x3D, 0xE7, 0xBC,
  0xF7, 0xFC, 0xFF, 0xBB, 0xE0, 0x1F, 0x9F, 0xDF, 0xDF, 0x0F, 0x07, 0x83,
  0xC1, 0xE2, 0xFF, 0x3F, 0x9F, 0x80, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E,
  0x1D, 0xE3, 0xFE, 0x7F, 0xCF, 0xBC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x38,
  0xFF, 0x8F, 0xF8, 0x7B, 0x80, 0x1F, 0x8F, 0xF7, 0xBF, 0xCF, 0xFF, 0xFF,
  0xEF, 0xE3, 0xC0, 0xFF, 0x1F, 0xC3, 0xF0, 0x01, 0xF0, 0x3F, 0x03, 0xE0,
  0x78, 0x0F, 0xE1, 0xFE, 0x1F, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x0F, 0xC0, 0xF8, 0x0F,
  0x00, 0x0F, 0x71, 0xFF, 0x3F, 0xE7, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9C, 0x7F, 0xC7, 0xFC, 0x3F, 0xC0, 0x38, 0x87, 0x8F, 0xF8, 0xFF, 0x07,
  0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3F, 0xE3, 0xFE, 0x3F, 0xF3,
  0xCE, 0x38, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0xF3, 0xC0,
  0x04, 0x3C, 0x78, 0xE0, 0x07, 0x8F, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x8F,
  0x1C, 0x78, 0x00, 0x80, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07,
  0x8F, 0xC3, 0xF0, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03,
  0xC7, 0x9E, 0x78, 0xF7, 0x87, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xF7,
  0x87, 0xBC, 0x39, 0xF3, 0xC7, 0x80, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F,
  0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x8E, 0x3C, 0x00, 0x3F, 0xE7, 0x8E, 0xFB,
  0xE3, 0xFF, 0xFC, 0xF3, 0xCF, 0x38, 0xE3, 0x9E, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xE7, 0x9C, 0x71, 0xCF, 0x3C, 0xF0, 0x3F, 0xE3, 0xFE,
  0x3F, 0xF3, 0xCE, 0x38, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1C,
  0xF3, 0xC0, 0x1F, 0x8F, 0xF7, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xFF, 0xBF, 0xC7, 0xE0, 0x1F, 0xE1, 0xFF, 0x1F, 0xF1, 0xEF, 0x1C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xE3, 0xFE, 0x7B, 0xC7, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0x1E, 0xE7, 0xFD, 0xFF, 0x7D, 0xEF, 0x3D, 0xE7,
  0xBC, 0xF7, 0x9C, 0xFF, 0x9F, 0xF1, 0xFE, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0xC0, 0x78, 0x3F, 0xCE, 0xE3, 0xF8, 0xFA, 0x3C, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x0F, 0x00, 0x1F, 0xCF, 0xE7, 0x99, 0xF0, 0x3E, 0x0F, 0xC0,
  0xF8, 0x1E, 0xFF, 0xBF, 0xCF, 0xE0, 0x1C, 0x3C, 0x7F, 0xFF, 0xFF, 0x78,
  0x78, 0x70, 0xF0, 0xF0, 0xFC, 0xFC, 0x7C, 0x79, 0xEF, 0x3D, 0xE7, 0xB8,
  0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0xBE, 0xFF, 0x9F, 0xF1, 0xEE, 0x00, 0xF1,
  0xFE, 0x7B, 0xCF, 0x7B, 0xCF, 0x78, 0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x0F,
  0x81, 0xE0, 0x00, 0xF3, 0xC7, 0xF9, 0xE7, 0xBD, 0xF3, 0x9E, 0xDB, 0xCF,
  0xFD, 0xC7, 0xFE, 0xE3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x3C, 0xF8,
  0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x7B, 0xC1, 0xEF, 0x03, 0xF8, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC1, 0xE7, 0x8F, 0x9E, 0x00, 0x3C,
  0x79, 0xE7, 0x8F, 0x3C, 0x7B, 0xC3, 0xDE, 0x0E, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x7E, 0x03, 0xE0, 0x1C,
  0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF,
  0x3F, 0xCF, 0xF0, 0x07, 0x87, 0x87, 0xC3, 0x81, 0xC0, 0xE0, 0xF1, 0xF0,
  0xE0, 0x78, 0x1E, 0x07, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x1E, 0x3E, 0x0E, 0x0E,
  0x1C, 0x1E, 0x0F, 0x07, 0x1F, 0x3C, 0x38, 0x38, 0x38, 0xF8, 0xF0, 0xE0,
  0x78, 0x7F, 0xFF, 0xFE, 0x1E,
};

const GFXglyph NotoSans_BlackItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 14, 6, 0, -14 },
  { 14, 8, 5, 9, 2, -14 },
  { 19, 13, 14, 13, 0, -14 },
  { 42, 10, 16, 12, 1, -15 },
  { 62, 17, 14, 19, 1, -14 },
  { 92, 15, 15, 15, 0, -15 },
  { 121, 4, 5, 5, 2, -14 },
  { 124, 8, 18, 7, 1, -15 },
  { 142, 8, 18, 7, -1, -15 },
  { 160, 10, 10, 11, 1, -15 },
  { 173, 10, 10, 12, 1, -12 },
  { 186, 5, 5, 6, -1, -2 },
  { 190, 6, 3, 7, 0, -7 },
  { 193, 4, 4, 6, 0, -4 },
  { 195, 12, 14, 9, -1, -14 },
  { 216, 10, 15, 12, 1, -15 },
  { 235, 10, 14, 12, 1, -14 },
  { 253, 12, 14, 12, -1, -14 },
  { 274, 11, 14, 12, 0, -14 },
  { 294, 11, 14, 12, 0, -14 },
  { 314, 12, 14, 12, 0, -14 },
  { 335, 11, 14, 12, 1, -14 },
  { 355, 12, 14, 12, 0, -14 },
  { 376, 11, 15, 12, 0, -15 },
  { 397, 10, 14, 12, 1, -14 },
  { 415, 6, 11, 6, 0, -11 },
  { 424, 7, 14, 6, -1, -11 },
  { 437, 10, 11, 12, 1, -13 },
  { 451, 10, 8, 12, 1, -11 },
  { 461, 10, 11, 12, 1, -13 },
  { 475, 9, 14, 10, 1, -14 },
  { 491, 16, 16, 18, 1, -14 },
  { 523, 13, 14, 14, -1, -14 },
  { 546, 12, 14, 13, 0, -14 },
  { 567, 12, 15, 13, 1, -15 },
  { 590, 13, 14, 14, 0, -14 },
  { 613, 12, 14, 11, 0, -14 },
  { 634, 12, 14, 11, 0, -14 },
  { 655, 13, 15, 14, 1, -15 },
  { 680, 14, 14, 14, 0, -14 },
  { 705, 11, 14, 9, -1, -14 },
  { 725, 11, 19, 7, -3, -14 },
  { 752, 15, 14, 13, 0, -14 },
  { 779, 9, 14, 11, 0, -14 },
  { 795, 18, 14, 18, 0, -14 },
  { 827, 16, 14, 16, 0, -14 },
  { 855, 13, 15, 15, 1, -15 },
  { 880, 12, 14, 12, 0, -14 },
  { 901, 13, 18, 15, 1, -15 },
  { 931, 12, 14, 13, 0, -14 },
  { 952, 11, 14, 11, 0, -14 },
  { 972, 10, 14, 11, 2, -14 },
  { 990, 13, 14, 14, 1, -14 },
  { 1013, 13, 14, 12, 1, -14 },
  { 1036, 19, 14, 19, 1, -14 },
  { 1070, 16, 14, 13, -1, -14 },
  { 1098, 12, 14, 12, 2, -14 },
  { 1119, 13, 14, 11, -1, -14 },
  { 1142, 10, 18, 7, -1, -15 },
  { 1165, 6, 14, 9, 2, -14 },
  { 1176, 9, 18, 7, -1, -15 },
  { 1197, 11, 9, 11, 0, -14 },
  { 1210, 10, 3, 9, -2, 1 },
  { 1214, 5, 3, 7, 3, -15 },
  { 1216, 11, 11, 12, 1, -11 },
  { 1232, 11, 15, 12, 0, -15 },
  { 1253, 9, 11, 10, 1, -11 },
  { 1266, 12, 15, 12, 1, -15 },
  { 1289, 10, 11, 12, 1, -11 },
  { 1303, 12, 20, 8, -2, -15 },
  { 1333, 12, 16, 12, 0, -11 },
  { 1357, 12, 15, 12, 0, -15 },
  { 1380, 7, 16, 7, 0, -16 },
  { 1394, 10, 21, 7, -3, -16 },
  { 1421, 13, 15, 12, 0, -15 },
  { 1446, 7, 15, 7, 0, -15 },
  { 1460, 18, 11, 19, 0, -11 },
  { 1485, 12, 11, 12, 0, -11 },
  { 1502, 10, 11, 12, 1, -11 },
  { 1516, 12, 16, 12, -1, -11 },
  { 1540, 11, 16, 12, 1, -11 },
  { 1562, 10, 11, 9, 0, -11 },
  { 1576, 10, 11, 10, 0, -11 },
  { 1590, 8, 13, 9, 1, -13 },
  { 1603, 11, 11, 12, 1, -11 },
  { 1619, 11, 11, 11, 1, -11 },
  { 1635, 17, 11, 16, 1, -11 },
  { 1659, 14, 11, 11, -1, -11 },
  { 1679, 13, 16, 11, -1, -11 },
  { 1705, 10, 11, 10, 0, -11 },
  { 1719, 9, 17, 7, 0, -14 },
  { 1739, 3, 20, 11, 4, -15 },
  { 1747, 8, 17, 7, -1, -14 },
  { 1764, 10, 4, 12, 1, -9 },
};

const GFXfont NotoSans_BlackItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_BLACKITALIC20PT7B_H_
