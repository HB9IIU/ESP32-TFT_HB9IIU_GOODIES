#ifndef _NOTOSANS_BLACKITALIC11PT7B_H_
#define _NOTOSANS_BLACKITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x76, 0x66, 0x60, 0xCC, 0xDE, 0xBC, 0x16, 0x29, 0xFB, 0xF2, 0x9F,
  0xDE, 0x2C, 0x19, 0xF7, 0x1C, 0x1E, 0x7F, 0x9C, 0x20, 0x63, 0x7B, 0x2D,
  0x15, 0x6F, 0xF9, 0xBC, 0x96, 0xCE, 0x3C, 0x3C, 0x2C, 0x38, 0x7B, 0xDE,
  0xFC, 0x7E, 0xFC, 0x19, 0x98, 0xC4, 0x63, 0x18, 0x43, 0x00, 0x30, 0xC6,
  0x31, 0x88, 0xC6, 0x66, 0x00, 0x37, 0x1F, 0xE5, 0x00, 0x30, 0xCF, 0xFF,
  0x30, 0xC0, 0x7C, 0xFC, 0xF0, 0x0C, 0x61, 0x0C, 0x21, 0x8C, 0x30, 0x39,
  0xF6, 0xDB, 0xEF, 0x3F, 0x9C, 0x1B, 0xFD, 0x63, 0x19, 0x8C, 0x39, 0xF4,
  0xC7, 0x39, 0xCF, 0xBE, 0x39, 0xF0, 0xCE, 0x38, 0x3F, 0xFE, 0x0C, 0x73,
  0xCB, 0x5B, 0xF1, 0x86, 0x3C, 0xF6, 0x1E, 0x5C, 0x3F, 0xBE, 0x1C, 0xF6,
  0x1F, 0xEF, 0xB7, 0xDE, 0x7E, 0xFC, 0x30, 0xC3, 0x86, 0x1C, 0x70, 0x3D,
  0xF6, 0xCE, 0x7B, 0x3F, 0xDE, 0x77, 0xF7, 0xBF, 0x8F, 0xDC, 0x6C, 0x0D,
  0x80, 0x33, 0x00, 0x06, 0xC0, 0x04, 0x77, 0x3C, 0x3C, 0x10, 0xFF, 0xF0,
  0x3F, 0xC3, 0xC3, 0xC7, 0xF3, 0x00, 0xF7, 0xCE, 0xEE, 0x03, 0x18, 0x1F,
  0x0C, 0x66, 0xE9, 0x6B, 0xD6, 0xB5, 0xE5, 0xB1, 0x88, 0x3E, 0x00, 0x0E,
  0x0E, 0x1E, 0x1E, 0x32, 0x3E, 0x7F, 0xE3, 0x3C, 0x7D, 0x9B, 0xE7, 0xCD,
  0xBF, 0x7C, 0x3D, 0xFC, 0x30, 0xC3, 0x0F, 0x9E, 0x3C, 0x7D, 0x9B, 0x36,
  0x6D, 0xFF, 0x7C, 0x3E, 0x79, 0x83, 0xE7, 0x8C, 0x3E, 0x7C, 0x3C, 0xF6,
  0x1F, 0x79, 0x8E, 0x30, 0x3E, 0xFB, 0x86, 0xED, 0xD9, 0xBF, 0x3C, 0x33,
  0x33, 0x66, 0x7E, 0x7E, 0x66, 0xEE, 0xCC, 0x7B, 0xCC, 0x66, 0x31, 0x9E,
  0x0C, 0x30, 0xC6, 0x18, 0x61, 0x8E, 0x33, 0xC0, 0x37, 0x36, 0x6C, 0x78,
  0x78, 0x6C, 0xEC, 0xCE, 0x31, 0x98, 0xC6, 0x33, 0xFF, 0x39, 0xCE, 0x77,
  0xBD, 0xEE, 0x7F, 0x9F, 0x6D, 0xDB, 0x6C, 0x31, 0x9C, 0x9E, 0xCF, 0x66,
  0xF3, 0x7B, 0x39, 0x8C, 0x3C, 0xFB, 0x1E, 0x3C, 0xF9, 0xBF, 0x3C, 0x3C,
  0x7D, 0x9B, 0x77, 0xCC, 0x38, 0x60, 0x3C, 0xFB, 0x1E, 0x3C, 0xF9, 0xBF,
  0x3C, 0x18, 0x38, 0x3C, 0x7D, 0x9B, 0x67, 0xCF, 0xBB, 0x67, 0x3D, 0xF6,
  0x1C, 0x38, 0x6F, 0xBC, 0xFF, 0xE7, 0x18, 0x61, 0x86, 0x30, 0x66, 0xDB,
  0x36, 0x6C, 0xD9, 0xBE, 0x78, 0xCF, 0x9B, 0x66, 0xCF, 0x1E, 0x38, 0x70,
  0xCC, 0xF3, 0x3D, 0xDB, 0x76, 0xFF, 0x3B, 0xCE, 0xE3, 0xB8, 0x33, 0x8D,
  0x87, 0x83, 0xC1, 0xC1, 0xB1, 0xD9, 0xCE, 0xCF, 0xB9, 0x63, 0x87, 0x0C,
  0x18, 0x70, 0x3F, 0x3E, 0x0C, 0x1C, 0x38, 0x30, 0x7C, 0xFC, 0x3B, 0x18,
  0xC6, 0x23, 0x18, 0xE7, 0x00, 0xD9, 0x26, 0xDB, 0x38, 0xC6, 0x21, 0x18,
  0xC6, 0x67, 0x00, 0x10, 0xE2, 0x9A, 0xCC, 0xF8, 0xC0, 0x36, 0xF9, 0xB7,
  0x67, 0xCF, 0x00, 0x31, 0xC7, 0xDF, 0x6D, 0xBF, 0xFE, 0x3D, 0xE6, 0x38,
  0x79, 0xE0, 0x06, 0x0C, 0xF3, 0xE6, 0xDD, 0x9F, 0x34, 0x3D, 0xB7, 0xFE,
  0x69, 0xE0, 0x1E, 0x30, 0xF1, 0x83, 0x06, 0x0C, 0x18, 0x61, 0xC3, 0x00,
  0x36, 0xF9, 0xB7, 0x6F, 0xCF, 0x06, 0x7C, 0x60, 0x31, 0xC7, 0xDF, 0x6D,
  0xBE, 0xF7, 0x23, 0x16, 0x66, 0x6E, 0xC0, 0x10, 0xC0, 0x73, 0x18, 0xCE,
  0x63, 0x39, 0x80, 0x30, 0xE1, 0x9B, 0x67, 0x8F, 0x3F, 0x66, 0x37, 0x66,
  0x66, 0xEC, 0x7D, 0x9F, 0xF6, 0xCD, 0xB6, 0xED, 0xB7, 0x60, 0x7D, 0xF6,
  0xDB, 0xEF, 0x70, 0x3D, 0xB6, 0xFB, 0x7D, 0xE0, 0x7D, 0xF6, 0xDB, 0xFF,
  0xEC, 0x30, 0xC0, 0x36, 0xF9, 0xB7, 0x67, 0xCF, 0x06, 0x0C, 0x18, 0x7B,
  0xD8, 0xCE, 0x60, 0x7B, 0x5C, 0x7B, 0xF8, 0x33, 0xF8, 0xC6, 0x39, 0xC0,
  0xCF, 0x6D, 0xB6, 0xFB, 0xE0, 0xEE, 0xD9, 0xE3, 0xC7, 0x0E, 0x00, 0xDB,
  0xFD, 0xBA, 0x95, 0xCE, 0xC6, 0x60, 0x37, 0x36, 0x1C, 0x3C, 0x3C, 0xEE,
  0x77, 0x36, 0x3C, 0x3C, 0x38, 0x38, 0x30, 0xF0, 0xC0, 0x7D, 0xE3, 0x18,
  0xFB, 0xC0, 0x19, 0x88, 0xCE, 0x61, 0x88, 0x63, 0x00, 0xFF, 0xFF, 0xFC,
  0x31, 0x8C, 0x61, 0x9C, 0x8C, 0xE6, 0x00, 0x77, 0xF0,
};

const GFXglyph NotoSans_BlackItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 8, 3, 0, -8 },
  { 5, 5, 3, 5, 1, -8 },
  { 7, 7, 8, 7, 0, -8 },
  { 14, 6, 9, 6, 0, -8 },
  { 21, 9, 8, 10, 1, -8 },
  { 30, 8, 8, 8, 0, -8 },
  { 38, 2, 3, 3, 1, -8 },
  { 39, 5, 10, 4, 0, -8 },
  { 46, 5, 10, 4, -1, -8 },
  { 53, 5, 5, 6, 1, -8 },
  { 57, 6, 6, 6, 0, -7 },
  { 62, 3, 2, 3, -1, -1 },
  { 63, 3, 2, 4, 0, -4 },
  { 64, 2, 2, 3, 0, -2 },
  { 65, 6, 8, 5, 0, -8 },
  { 71, 6, 8, 6, 0, -8 },
  { 77, 5, 8, 6, 1, -8 },
  { 82, 6, 8, 6, 0, -8 },
  { 88, 6, 8, 6, 0, -8 },
  { 94, 6, 8, 6, 0, -8 },
  { 100, 6, 8, 6, 0, -8 },
  { 106, 6, 8, 6, 0, -8 },
  { 112, 7, 8, 6, 0, -8 },
  { 119, 6, 8, 6, 0, -8 },
  { 125, 5, 8, 6, 1, -8 },
  { 130, 3, 6, 3, 0, -6 },
  { 133, 4, 7, 3, -1, -6 },
  { 137, 6, 6, 6, 0, -7 },
  { 142, 6, 4, 6, 0, -6 },
  { 145, 6, 6, 6, 0, -7 },
  { 150, 5, 8, 5, 1, -8 },
  { 155, 10, 9, 10, 0, -8 },
  { 167, 8, 8, 7, -1, -8 },
  { 175, 7, 8, 7, 0, -8 },
  { 182, 6, 8, 7, 1, -8 },
  { 188, 7, 8, 8, 0, -8 },
  { 195, 7, 8, 6, 0, -8 },
  { 202, 6, 8, 6, 0, -8 },
  { 208, 7, 8, 8, 1, -8 },
  { 215, 8, 8, 8, 0, -8 },
  { 223, 5, 8, 5, 0, -8 },
  { 228, 6, 10, 4, -2, -8 },
  { 236, 8, 8, 7, 0, -8 },
  { 244, 5, 8, 6, 0, -8 },
  { 249, 10, 8, 10, 0, -8 },
  { 259, 9, 8, 9, 0, -8 },
  { 268, 7, 8, 8, 1, -8 },
  { 275, 7, 8, 7, 0, -8 },
  { 282, 7, 10, 8, 1, -8 },
  { 291, 7, 8, 7, 0, -8 },
  { 298, 6, 8, 6, 0, -8 },
  { 304, 6, 8, 6, 1, -8 },
  { 310, 7, 8, 8, 1, -8 },
  { 317, 7, 8, 7, 1, -8 },
  { 324, 10, 8, 10, 1, -8 },
  { 334, 9, 8, 7, -1, -8 },
  { 343, 7, 8, 7, 1, -8 },
  { 350, 8, 8, 6, -1, -8 },
  { 358, 5, 10, 4, 0, -8 },
  { 365, 3, 8, 5, 1, -8 },
  { 368, 5, 10, 4, -1, -8 },
  { 375, 6, 5, 6, 0, -8 },
  { 379, 5, 1, 5, -1, 1 },
  { 380, 2, 1, 4, 2, -8 },
  { 381, 7, 6, 7, 0, -6 },
  { 387, 6, 8, 7, 0, -8 },
  { 393, 6, 6, 6, 0, -6 },
  { 398, 7, 8, 7, 0, -8 },
  { 405, 6, 6, 6, 0, -6 },
  { 410, 7, 11, 5, -1, -8 },
  { 420, 7, 9, 7, 0, -6 },
  { 428, 6, 8, 7, 0, -8 },
  { 434, 4, 9, 4, 0, -9 },
  { 439, 5, 12, 4, -1, -9 },
  { 447, 7, 8, 7, 0, -8 },
  { 454, 4, 8, 4, 0, -8 },
  { 458, 10, 6, 10, 0, -6 },
  { 466, 6, 6, 7, 0, -6 },
  { 471, 6, 6, 7, 0, -6 },
  { 476, 6, 9, 7, 0, -6 },
  { 483, 7, 9, 7, 0, -6 },
  { 491, 5, 6, 5, 0, -6 },
  { 495, 5, 6, 6, 0, -6 },
  { 499, 5, 7, 5, 0, -7 },
  { 504, 6, 6, 7, 1, -6 },
  { 509, 7, 6, 6, 0, -6 },
  { 515, 9, 6, 9, 1, -6 },
  { 522, 8, 6, 6, -1, -6 },
  { 528, 8, 9, 6, -1, -6 },
  { 537, 6, 6, 5, 0, -6 },
  { 542, 5, 10, 4, 0, -8 },
  { 549, 2, 11, 6, 2, -8 },
  { 552, 5, 10, 4, -1, -8 },
  { 559, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_BlackItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_BLACKITALIC11PT7B_H_
