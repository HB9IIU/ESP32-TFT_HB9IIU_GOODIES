#ifndef _NOTOSANS_BLACKITALIC7PT7B_H_
#define _NOTOSANS_BLACKITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x80, 0xF8, 0x37, 0xD5, 0xEE, 0x00, 0x76, 0x6D, 0xE0, 0x6E,
  0xA7, 0xCB, 0x4C, 0x72, 0x9B, 0x6F, 0x80, 0xC0, 0x6B, 0x49, 0x80, 0x55,
  0x60, 0xCF, 0x00, 0x2F, 0x20, 0xE0, 0xC0, 0x80, 0x32, 0x44, 0x80, 0x75,
  0xDF, 0xE0, 0x79, 0x2C, 0x77, 0x24, 0xE0, 0x71, 0x63, 0xE0, 0x33, 0x6F,
  0x20, 0x74, 0x63, 0xE0, 0x74, 0xFF, 0x60, 0x73, 0x26, 0xC0, 0x75, 0x6B,
  0xE0, 0x7D, 0xF3, 0xE0, 0x42, 0x42, 0x80, 0x3C, 0x30, 0xF0, 0xF0, 0xC3,
  0xC0, 0x63, 0x60, 0xC0, 0x39, 0x7B, 0x6F, 0x40, 0xC0, 0x37, 0x5F, 0x90,
  0x75, 0x7D, 0xF0, 0x7A, 0x31, 0x87, 0x00, 0x72, 0xD7, 0xAE, 0x00, 0x74,
  0x7C, 0xE0, 0x74, 0x7C, 0xC0, 0x7A, 0x3F, 0xA7, 0x00, 0x6A, 0xDF, 0xAD,
  0x00, 0x69, 0x2C, 0x32, 0x22, 0x6C, 0x80, 0x7A, 0x99, 0xED, 0x00, 0x69,
  0x6E, 0x6D, 0xB7, 0x7F, 0xB8, 0x6D, 0xA6, 0xB6, 0x98, 0x7A, 0x73, 0xB7,
  0x00, 0x75, 0x7C, 0xC0, 0x7A, 0x73, 0xB7, 0x18, 0x75, 0x7F, 0xD0, 0x74,
  0x62, 0xE0, 0xEB, 0x48, 0x4A, 0xD5, 0xA7, 0x00, 0xBA, 0xEC, 0xC0, 0xA6,
  0xAE, 0xBE, 0xB0, 0x5B, 0x98, 0xE9, 0x00, 0xBE, 0xCC, 0x80, 0x72, 0x6C,
  0xE0, 0x69, 0x49, 0x80, 0xAA, 0xC0, 0x69, 0x25, 0x00, 0x26, 0xB0, 0xF0,
  0xC0, 0x7D, 0xFE, 0x67, 0x5F, 0xE0, 0x7C, 0xC6, 0x17, 0xDF, 0xE0, 0x7D,
  0xE6, 0x3B, 0x88, 0x46, 0x23, 0x00, 0x7D, 0xFE, 0xAC, 0x67, 0x5F, 0xF0,
  0x57, 0xC0, 0x32, 0x26, 0x64, 0xC0, 0x62, 0xD9, 0xCF, 0x00, 0x69, 0x6C,
  0x7D, 0x5D, 0x7F, 0x75, 0xFF, 0x7D, 0xF6, 0x75, 0xFE, 0x88, 0x7D, 0xFE,
  0x22, 0x6B, 0x60, 0x79, 0xF0, 0x5D, 0x6E, 0x55, 0xFF, 0xDE, 0x64, 0xF7,
  0xFF, 0x96, 0xD6, 0x6B, 0xDE, 0x64, 0xC8, 0x76, 0x4E, 0x6B, 0x6D, 0x80,
  0xFE, 0xC9, 0xA9, 0x00, 0xF0,
};

const GFXglyph NotoSans_BlackItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 3, 2, 3, 1, -5 },
  { 4, 5, 5, 5, 0, -5 },
  { 8, 4, 5, 4, 0, -5 },
  { 11, 6, 5, 7, 0, -5 },
  { 15, 5, 5, 5, 0, -5 },
  { 19, 1, 2, 2, 1, -5 },
  { 20, 3, 6, 3, 0, -5 },
  { 23, 2, 6, 3, 0, -5 },
  { 25, 3, 3, 4, 1, -5 },
  { 27, 4, 3, 4, 0, -4 },
  { 29, 2, 2, 2, 0, -1 },
  { 30, 2, 1, 2, 0, -2 },
  { 31, 1, 1, 2, 0, -1 },
  { 32, 4, 5, 3, 0, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 3, 5, 4, 1, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 4, 5, 4, 0, -5 },
  { 64, 2, 4, 2, 0, -4 },
  { 65, 2, 5, 2, 0, -4 },
  { 67, 4, 3, 4, 0, -4 },
  { 69, 4, 3, 4, 0, -4 },
  { 71, 4, 3, 4, 0, -4 },
  { 73, 4, 5, 3, 0, -5 },
  { 76, 6, 6, 6, 0, -5 },
  { 81, 4, 5, 5, 0, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 5, 5, 4, 0, -5 },
  { 91, 5, 5, 5, 0, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 5, 5, 5, 0, -5 },
  { 105, 5, 5, 5, 0, -5 },
  { 109, 3, 5, 3, 0, -5 },
  { 111, 4, 7, 3, -1, -5 },
  { 115, 5, 5, 5, 0, -5 },
  { 119, 3, 5, 4, 0, -5 },
  { 121, 6, 5, 6, 0, -5 },
  { 125, 6, 5, 6, 0, -5 },
  { 129, 5, 5, 5, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 5, 6, 5, 0, -5 },
  { 140, 4, 5, 5, 0, -5 },
  { 143, 4, 5, 4, 0, -5 },
  { 146, 3, 5, 4, 1, -5 },
  { 148, 5, 5, 5, 0, -5 },
  { 152, 4, 5, 4, 1, -5 },
  { 155, 6, 5, 7, 1, -5 },
  { 159, 5, 5, 5, 0, -5 },
  { 163, 4, 5, 4, 1, -5 },
  { 166, 4, 5, 4, 0, -5 },
  { 169, 3, 6, 3, 0, -5 },
  { 172, 2, 5, 3, 1, -5 },
  { 174, 3, 6, 3, 0, -5 },
  { 177, 4, 3, 4, 0, -5 },
  { 179, 4, 1, 3, -1, 0 },
  { 180, 2, 1, 2, 1, -5 },
  { 181, 4, 4, 4, 0, -4 },
  { 183, 4, 5, 4, 0, -5 },
  { 186, 4, 4, 4, 0, -4 },
  { 188, 4, 5, 4, 0, -5 },
  { 191, 4, 4, 4, 0, -4 },
  { 193, 5, 7, 3, -1, -5 },
  { 198, 4, 6, 4, 0, -4 },
  { 201, 4, 5, 4, 0, -5 },
  { 204, 2, 5, 2, 0, -5 },
  { 206, 4, 7, 2, -1, -5 },
  { 210, 5, 5, 4, 0, -5 },
  { 214, 3, 5, 2, 0, -5 },
  { 216, 6, 4, 6, 0, -4 },
  { 219, 4, 4, 4, 0, -4 },
  { 221, 4, 4, 4, 0, -4 },
  { 223, 4, 6, 4, 0, -4 },
  { 226, 4, 6, 4, 0, -4 },
  { 229, 3, 4, 3, 0, -4 },
  { 231, 3, 4, 4, 0, -4 },
  { 233, 3, 5, 3, 0, -5 },
  { 235, 4, 4, 4, 0, -4 },
  { 237, 4, 4, 4, 0, -4 },
  { 239, 6, 4, 6, 0, -4 },
  { 242, 4, 4, 4, 0, -4 },
  { 244, 4, 6, 4, 0, -4 },
  { 247, 4, 4, 3, 0, -4 },
  { 249, 3, 6, 3, 0, -5 },
  { 252, 1, 7, 4, 1, -5 },
  { 253, 3, 6, 3, 0, -5 },
  { 256, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_BlackItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_BLACKITALIC7PT7B_H_
