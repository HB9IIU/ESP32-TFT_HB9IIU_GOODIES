#ifndef _NOTOSANS_BLACKITALIC31PT7B_H_
#define _NOTOSANS_BLACKITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x83, 0xF8, 0x7F, 0x0F, 0xC0, 0xF8, 0x00, 0x7D, 0xFB, 0xEF, 0xBE,
  0x7D, 0xF3, 0xEF, 0x9E, 0x78, 0xF3, 0xC7, 0x9E, 0x78, 0x00, 0xF1, 0xE0,
  0x07, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3,
  0xC0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x3C, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x3E, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0x1F, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9F, 0x00, 0x3C,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xC4,
  0x3E, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xBE, 0x41, 0xDF, 0x3E, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x1F, 0xC0, 0x3E, 0x0F, 0xF0, 0x0F, 0x07, 0xFE, 0x07,
  0x81, 0xF7, 0x83, 0xE0, 0xF9, 0xE1, 0xF0, 0x3E, 0x78, 0x78, 0x0F, 0x1E,
  0x3C, 0x03, 0xCF, 0x9F, 0x00, 0xF3, 0xEF, 0x8C, 0x3D, 0xF3, 0xCF, 0xEF,
  0xFD, 0xE7, 0xF9, 0xFE, 0xFB, 0xFF, 0x7F, 0x7C, 0xF3, 0xC0, 0x1E, 0x7C,
  0xF0, 0x0F, 0x1E, 0x3C, 0x07, 0xC7, 0x8F, 0x01, 0xE1, 0xE7, 0xC0, 0xF0,
  0x79, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x07, 0xFE, 0x0F, 0x01, 0xFF, 0x0F,
  0x80, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xE0, 0x03,
  0xEF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x04, 0x3F, 0xE3, 0xF1, 0xFF,
  0xC7, 0xE7, 0xFF, 0xCF, 0x8F, 0xDF, 0xBF, 0x3F, 0x1F, 0xFC, 0x7E, 0x3F,
  0xF8, 0xFC, 0x3F, 0xE1, 0xFE, 0x7F, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0x7D, 0xFF, 0xBE, 0xFB, 0xCF,
  0x3C, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0x80, 0x01,
  0xF0, 0x01, 0xE0, 0x21, 0xE0, 0x79, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0x7F,
  0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xE0, 0x7F, 0xE0, 0x3C, 0xF0, 0x1C,
  0xF0, 0x08, 0xF8, 0x00, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x1F, 0x8F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0x7F, 0xDF,
  0xE7, 0xF9, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFB, 0xF1, 0xF9, 0xF9,
  0xFC, 0x7C, 0xFC, 0x3F, 0x7E, 0x1F, 0x3F, 0x1F, 0xBF, 0x0F, 0xDF, 0x87,
  0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7C,
  0x07, 0xF0, 0x7F, 0xC3, 0xFF, 0x3F, 0xFB, 0xFF, 0xE7, 0xFF, 0x9F, 0x7E,
  0x31, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xC1, 0xC3, 0xF0, 0x20, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xF0,
  0xF3, 0xF8, 0x20, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x07, 0xFF, 0x03, 0xFE,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x80, 0x7F, 0x7C, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0x83,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0x7C, 0x07, 0xFF, 0x03, 0xEF,
  0xC1, 0xF3, 0xE0, 0x78, 0xF8, 0x3E, 0x7E, 0x1F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x08, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x80, 0x7F, 0x3E, 0x7F, 0x8F, 0xFF, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF1, 0xFE, 0x11, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0xE0, 0x7D,
  0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xEF, 0xE3, 0xF7, 0xE1, 0xFB,
  0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x7E, 0x3F, 0x7F, 0x1F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0x80, 0x7F, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0xC3, 0xFF, 0xE1, 0xF1, 0xF9, 0xF8, 0xF8, 0xFC, 0x7C, 0x3F, 0x7E,
  0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0xC3, 0xF3,
  0xF3, 0xF1, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7E, 0x3F, 0x3F, 0xFF, 0x8F,
  0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3,
  0xFF, 0xEF, 0xE7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xEF, 0x87, 0x3F, 0x00, 0x7E,
  0x01, 0xF9, 0x1F, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x00,
  0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x80, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x80, 0xFE, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x1F, 0xF3, 0xFF, 0xE7, 0xFF,
  0xDF, 0xFF, 0x3C, 0xFC, 0x83, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0x80, 0xFC, 0x1F,
  0x80, 0x0F, 0x87, 0xC0, 0x01, 0xE3, 0xE1, 0xFF, 0x78, 0xF1, 0xFF, 0x8F,
  0x78, 0xFF, 0xE3, 0xDE, 0x3C, 0x78, 0xF7, 0x9F, 0x1E, 0x3F, 0xC7, 0x8F,
  0x8F, 0xF3, 0xE3, 0xC7, 0xBC, 0xF8, 0xF1, 0xEF, 0x3E, 0x7C, 0xFB, 0xCF,
  0xFF, 0xFC, 0xF1, 0xFF, 0xFE, 0x1E, 0x7F, 0x7F, 0x07, 0x87, 0x0F, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF8,
  0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xFC,
  0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xC0, 0x7E, 0xFC, 0x03,
  0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFC, 0xFE, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x3F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0x8F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFE, 0xF8, 0xFF,
  0x03, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x04, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x03,
  0xF3, 0xF0, 0x7F, 0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0x1F, 0xC7, 0xFF,
  0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF,
  0x83, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xFF, 0x7C, 0x7F, 0x01, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x8F, 0xFB, 0xF1, 0xFF, 0x7E, 0x3F, 0xEF, 0xCF, 0xFD, 0xF9, 0xFF,
  0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0xFF, 0xF1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x3F, 0x00, 0x0F, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0xF0, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x0F, 0xC3,
  0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF9, 0xF8,
  0x03, 0xF7, 0xF0, 0x07, 0xDF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x0F,
  0xCF, 0xC0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x80, 0xFC, 0x3F, 0x01, 0xF8,
  0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xFC, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF,
  0xE7, 0xFF, 0xDF, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xBE, 0x1F, 0x78, 0xFF,
  0xC1, 0xF7, 0x8F, 0x7C, 0x1F, 0x79, 0xF7, 0xC1, 0xF7, 0x9E, 0x7C, 0x3F,
  0x79, 0xEF, 0xC3, 0xF7, 0xBC, 0xF8, 0x3E, 0x7B, 0xCF, 0x83, 0xE7, 0xFC,
  0xF8, 0x3E, 0x7F, 0x9F, 0x87, 0xE7, 0xF9, 0xF8, 0x7E, 0x7F, 0x1F, 0x07,
  0xC7, 0xF1, 0xF0, 0x7C, 0x7E, 0x1F, 0x0F, 0xC7, 0xE3, 0xF0, 0x07, 0xF0,
  0x1F, 0x83, 0xFC, 0x0F, 0x81, 0xFE, 0x07, 0xC1, 0xFF, 0x03, 0xE0, 0xFF,
  0x83, 0xF0, 0x7F, 0xE1, 0xF0, 0x3F, 0xF0, 0xF8, 0x1E, 0xF8, 0x7C, 0x1F,
  0x7E, 0x3E, 0x0F, 0x9F, 0x3F, 0x07, 0xCF, 0x9F, 0x03, 0xE7, 0xCF, 0x83,
  0xF3, 0xF7, 0xC1, 0xF8, 0xFB, 0xE0, 0xF8, 0x7D, 0xF0, 0x7C, 0x3F, 0xF0,
  0x3E, 0x0F, 0xF8, 0x3F, 0x07, 0xFC, 0x1F, 0x83, 0xFE, 0x0F, 0x81, 0xFF,
  0x07, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF8, 0x7F, 0x7F, 0x03,
  0xF7, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC,
  0x1F, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xE3,
  0xF3, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF8, 0x7F, 0x7F, 0x03,
  0xF7, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC,
  0x1F, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFC, 0xFE, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0x8F,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xDF, 0x81, 0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xE7, 0xE0, 0xFD, 0xFC, 0x1F, 0xC0, 0x03, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0x9E, 0x3F, 0x02, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0xC0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF,
  0xEF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x07, 0xE3, 0xF0,
  0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0x7E,
  0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x3E, 0x07, 0xE7, 0xC1, 0xF8, 0xF8, 0x3F,
  0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x7E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0,
  0x3E, 0x7E, 0x07, 0xCF, 0x80, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0x07, 0xEF, 0xC1,
  0xFC, 0x1F, 0x3F, 0x07, 0xF0, 0xFC, 0xFC, 0x3F, 0xC3, 0xF3, 0xF0, 0xFF,
  0x0F, 0x87, 0xC3, 0xFC, 0x7E, 0x1F, 0x1F, 0xF1, 0xF0, 0x7C, 0x7F, 0xCF,
  0xC1, 0xF3, 0xFF, 0x3E, 0x07, 0xCF, 0x7C, 0xF8, 0x1F, 0x7D, 0xF7, 0xE0,
  0x7D, 0xF7, 0xDF, 0x01, 0xF7, 0x9F, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x1F,
  0xF1, 0xEF, 0x80, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xF8,
  0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80,
  0x7F, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xE7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1,
  0xF8, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0xC0, 0xFE,
  0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE3, 0xF0, 0x7E,
  0xFC, 0x0F, 0xDF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xF8, 0x3C,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x7C, 0x03,
  0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x70, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xFC,
  0x07, 0xBC, 0x0F, 0xBC, 0x0F, 0x1E, 0x1F, 0x1E, 0x3E, 0x1E, 0x3C, 0x1F,
  0x7C, 0x0F, 0xF8, 0x0F, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFE, 0x7E, 0x3E, 0x1E, 0x0F, 0x07, 0xE7, 0x87, 0xFF, 0xC7, 0xFF, 0xE7,
  0xFF, 0xF3, 0xFB, 0xF3, 0xF9, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0xFC, 0x3F,
  0x7E, 0x1F, 0x3F, 0x0F, 0x9F, 0x8F, 0xCF, 0xEF, 0xE3, 0xFF, 0xF1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0x7C, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0x7E, 0x1F, 0x9F, 0xC7,
  0xC3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x8F, 0x87, 0xE7, 0xE3,
  0xF1, 0xFD, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC3, 0xE7, 0xE0,
  0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE3, 0xF9, 0x8F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x4F, 0xF7,
  0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x3E, 0x7C, 0x0F, 0xEF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xDF,
  0xC7, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3E,
  0x1F, 0x87, 0xC3, 0xF1, 0xF8, 0x7F, 0x7F, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFB, 0xE0, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F,
  0xFF, 0x3F, 0x1F, 0x7E, 0x3F, 0x7E, 0x7F, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xF8, 0xFF, 0x00, 0xFC, 0x00, 0xFE, 0x0C, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x04, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x02, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF3, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0xDF, 0x8F, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E,
  0x1F, 0x9F, 0x87, 0xC7, 0xE1, 0xF1, 0xF8, 0xFC, 0x7F, 0x7F, 0x0F, 0xFF,
  0xC3, 0xFF, 0xE0, 0xFE, 0xF8, 0x1F, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC3,
  0x83, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0x7F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF3, 0xF0, 0xFC, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x87, 0xE0, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x82, 0x7F, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x0F, 0x87,
  0xE0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x01, 0xF7, 0xE0, 0x0F,
  0xBE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0,
  0x1F, 0xDF, 0x80, 0xFC, 0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8,
  0xFE, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87,
  0xE0, 0x0F, 0xBF, 0x0F, 0xC1, 0xFF, 0xF3, 0xFC, 0x7D, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF9, 0xF8, 0x7E, 0x3F, 0x3F, 0x0F, 0x87, 0xE7, 0xE3, 0xF0, 0xFC, 0xFC,
  0x7E, 0x3F, 0x3F, 0x0F, 0xC7, 0xE7, 0xE1, 0xF8, 0xFC, 0xFC, 0x7E, 0x1F,
  0x9F, 0x8F, 0xC3, 0xF3, 0xF1, 0xF8, 0xFC, 0xFC, 0x3F, 0x1F, 0x80, 0x0F,
  0xBF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xDF, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF9,
  0xF8, 0x7E, 0x7E, 0x1F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFC,
  0x3F, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xF3,
  0xF3, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF,
  0x0F, 0xDF, 0x8F, 0xCF, 0xE7, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0,
  0x1F, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFE, 0xFC, 0x1F, 0x9F, 0xC3, 0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xE3, 0xFB, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xC1, 0xF7, 0xF0, 0x7E, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE7, 0x87, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xFB, 0xF3, 0xF9,
  0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F,
  0x8F, 0xCF, 0xEF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFE, 0xF8, 0x3F, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xBE, 0x1F, 0xF8, 0x7D, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC3, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x07,
  0xFC, 0x3F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE3, 0xF0, 0x87, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xCC, 0x1F, 0x9F,
  0xFF, 0x3F, 0xFE, 0x7F, 0xF8, 0x7F, 0xC0, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x1F, 0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xF3, 0xF1, 0xF8, 0xFE, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFE, 0xF8, 0x3F, 0x3C, 0x00, 0xFC, 0x1F, 0xDF,
  0x07, 0xE7, 0xC3, 0xF1, 0xF0, 0xFC, 0x7C, 0x7E, 0x1F, 0x1F, 0x87, 0xCF,
  0xC1, 0xF3, 0xF0, 0x7D, 0xF8, 0x0F, 0xFC, 0x03, 0xDF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x7E, 0x1F, 0xFC, 0x3F, 0x0F, 0xBE, 0x3F, 0x8F, 0xDF, 0x1F, 0xC7,
  0xEF, 0x9F, 0xE3, 0xE7, 0xCF, 0xF3, 0xF3, 0xE7, 0xF9, 0xF1, 0xF7, 0xBD,
  0xF8, 0xFB, 0xDE, 0xF8, 0x7D, 0xEF, 0xFC, 0x3F, 0xE7, 0xFC, 0x1F, 0xF3,
  0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x01, 0xFC,
  0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xE3, 0xFC, 0x1F, 0x8F, 0xC0,
  0x7E, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0x7E, 0x03, 0xF9, 0xF8, 0x1F,
  0xC7, 0xE0, 0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x83, 0xE1,
  0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x01,
  0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xE1, 0xFE, 0x0F, 0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x3E, 0x01,
  0xF8, 0x1F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E,
  0x00, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x1F, 0xE1, 0xFF, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x3C, 0x00, 0x3E, 0x01, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0x80, 0x7C,
};

const GFXglyph NotoSans_BlackItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 22, 9, 0, -22 },
  { 32, 13, 8, 14, 3, -22 },
  { 45, 21, 22, 20, 0, -22 },
  { 103, 17, 26, 18, 1, -24 },
  { 159, 26, 22, 29, 2, -22 },
  { 231, 23, 22, 23, 0, -22 },
  { 295, 6, 8, 7, 3, -22 },
  { 301, 13, 28, 12, 1, -23 },
  { 347, 13, 28, 12, -2, -23 },
  { 393, 16, 16, 17, 2, -24 },
  { 425, 16, 16, 18, 1, -19 },
  { 457, 9, 8, 9, -2, -4 },
  { 466, 10, 5, 10, 0, -11 },
  { 473, 6, 5, 9, 0, -5 },
  { 477, 18, 22, 14, -1, -22 },
  { 527, 17, 22, 18, 1, -22 },
  { 574, 14, 22, 18, 2, -22 },
  { 613, 18, 22, 18, -1, -22 },
  { 663, 17, 22, 18, 0, -22 },
  { 710, 18, 22, 18, 0, -22 },
  { 760, 18, 22, 18, 0, -22 },
  { 810, 17, 22, 18, 1, -22 },
  { 857, 18, 22, 18, 1, -22 },
  { 907, 17, 22, 18, 1, -22 },
  { 954, 15, 22, 18, 2, -22 },
  { 996, 9, 17, 9, 0, -17 },
  { 1016, 11, 21, 9, -2, -17 },
  { 1045, 16, 17, 18, 1, -20 },
  { 1079, 16, 11, 18, 1, -16 },
  { 1101, 16, 17, 18, 1, -20 },
  { 1135, 14, 22, 15, 2, -22 },
  { 1174, 26, 25, 28, 1, -22 },
  { 1256, 21, 22, 21, -2, -22 },
  { 1314, 19, 22, 20, 0, -22 },
  { 1367, 19, 22, 20, 2, -22 },
  { 1420, 20, 22, 21, 0, -22 },
  { 1475, 18, 22, 17, 0, -22 },
  { 1525, 18, 22, 18, 0, -22 },
  { 1575, 19, 22, 22, 2, -22 },
  { 1628, 22, 22, 22, 0, -22 },
  { 1689, 16, 22, 13, -1, -22 },
  { 1733, 17, 29, 12, -5, -22 },
  { 1795, 23, 22, 21, 0, -22 },
  { 1859, 15, 22, 16, 0, -22 },
  { 1901, 28, 22, 28, 0, -22 },
  { 1978, 25, 22, 24, 0, -22 },
  { 2047, 20, 22, 23, 2, -22 },
  { 2102, 19, 22, 19, 0, -22 },
  { 2155, 20, 27, 23, 2, -22 },
  { 2223, 19, 22, 20, 0, -22 },
  { 2276, 16, 22, 17, 1, -22 },
  { 2320, 17, 22, 17, 2, -22 },
  { 2367, 20, 22, 22, 2, -22 },
  { 2422, 19, 22, 19, 2, -22 },
  { 2475, 30, 22, 29, 2, -22 },
  { 2558, 25, 22, 21, -2, -22 },
  { 2627, 19, 22, 19, 2, -22 },
  { 2680, 19, 22, 17, -1, -22 },
  { 2733, 14, 28, 11, -1, -23 },
  { 2782, 9, 22, 14, 3, -22 },
  { 2807, 14, 28, 11, -2, -23 },
  { 2856, 16, 14, 17, 0, -22 },
  { 2884, 15, 4, 14, -3, 2 },
  { 2892, 8, 5, 11, 4, -24 },
  { 2897, 17, 17, 19, 1, -17 },
  { 2934, 18, 24, 19, 0, -24 },
  { 2988, 15, 17, 16, 1, -17 },
  { 3020, 19, 24, 19, 1, -24 },
  { 3077, 16, 17, 18, 1, -17 },
  { 3111, 19, 31, 13, -3, -24 },
  { 3185, 18, 24, 19, 0, -17 },
  { 3239, 18, 24, 19, 0, -24 },
  { 3293, 11, 24, 10, 0, -24 },
  { 3326, 15, 31, 10, -4, -24 },
  { 3385, 21, 24, 19, 0, -24 },
  { 3448, 11, 24, 10, 0, -24 },
  { 3481, 27, 17, 29, 0, -17 },
  { 3539, 18, 17, 19, 0, -17 },
  { 3578, 17, 17, 19, 1, -17 },
  { 3615, 19, 24, 19, -1, -17 },
  { 3672, 17, 24, 19, 1, -17 },
  { 3723, 15, 17, 14, 0, -17 },
  { 3755, 15, 17, 16, 0, -17 },
  { 3787, 13, 21, 14, 1, -21 },
  { 3822, 18, 17, 19, 1, -17 },
  { 3861, 18, 17, 17, 1, -17 },
  { 3900, 25, 17, 26, 2, -17 },
  { 3954, 22, 17, 18, -2, -17 },
  { 4001, 21, 24, 17, -2, -17 },
  { 4064, 17, 17, 15, -1, -17 },
  { 4101, 13, 27, 11, 0, -22 },
  { 4145, 4, 30, 18, 7, -23 },
  { 4160, 13, 27, 11, -2, -22 },
  { 4204, 16, 6, 18, 1, -14 },
};

const GFXfont NotoSans_BlackItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_BLACKITALIC31PT7B_H_
