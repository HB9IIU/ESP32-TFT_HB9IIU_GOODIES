#ifndef _NOTOSANS_BLACKITALIC21PT7B_H_
#define _NOTOSANS_BLACKITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0xF9, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xF0, 0x03, 0x8F,
  0x1E, 0x3C, 0x00, 0x77, 0xFB, 0xB9, 0xDC, 0xEE, 0xE0, 0x07, 0x38, 0x1C,
  0xC0, 0x77, 0x01, 0x9C, 0x7F, 0xFD, 0xFF, 0xF0, 0xCE, 0x07, 0x38, 0x1C,
  0xC3, 0xFF, 0xEF, 0xFF, 0x8E, 0x60, 0x3B, 0x80, 0xCE, 0x07, 0x38, 0x00,
  0x03, 0x00, 0xE0, 0x7F, 0x9F, 0xF7, 0xEC, 0xFC, 0x1F, 0x83, 0xF0, 0x3F,
  0x81, 0xF8, 0x3F, 0x46, 0xEF, 0xFD, 0xFF, 0x3F, 0xC0, 0xC0, 0x18, 0x00,
  0x3E, 0x07, 0x1F, 0xC3, 0x87, 0x71, 0xC3, 0xDC, 0x70, 0xE7, 0x38, 0x39,
  0xDC, 0x0E, 0xEE, 0xFB, 0xFB, 0xFF, 0x7D, 0xDD, 0xC0, 0xE7, 0x70, 0x73,
  0x9C, 0x1C, 0xE7, 0x0E, 0x3B, 0x87, 0x07, 0xE3, 0x81, 0xF0, 0x07, 0xE0,
  0x1F, 0xE0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xFC, 0x03, 0xF0, 0x1F,
  0xCF, 0x7F, 0x9F, 0xE7, 0xFB, 0xCF, 0xE7, 0x8F, 0xCF, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0x7F, 0xEE, 0xE0, 0x0F, 0x1E, 0x1C, 0x38, 0x78, 0x70,
  0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70,
  0x0E, 0x0E, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0E,
  0x1E, 0x1C, 0x3C, 0x38, 0x78, 0xF0, 0x0E, 0x03, 0x8C, 0xE3, 0xF0, 0xFF,
  0xC7, 0xF3, 0xEF, 0xF8, 0x67, 0x09, 0xC0, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3D, 0xE7, 0x3C,
  0xE0, 0x7E, 0xFB, 0xF0, 0x7F, 0xFF, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x87, 0xF8, 0xFF, 0x3C, 0xF7, 0x9F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFE, 0x7B, 0xCF, 0x7B, 0xEF, 0xF9, 0xFE,
  0x1F, 0x80, 0x07, 0x8F, 0xCF, 0xFF, 0xEF, 0xF7, 0x79, 0x3C, 0x1E, 0x1E,
  0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x07, 0xE1, 0xFF, 0x1F, 0xF0,
  0xCF, 0x08, 0xF0, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xC0, 0x7F, 0xE7, 0xFE, 0xFF, 0xE0, 0x1F, 0xC3, 0xFE, 0x1F, 0xE1, 0x1F,
  0x00, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8, 0x1F, 0xC0, 0x1E, 0x01, 0xE8, 0x3E,
  0xFF, 0xCF, 0xFC, 0xFF, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0x1D, 0xE3, 0x9C, 0x73, 0xCF, 0xFF, 0xFF, 0xEF, 0xFE, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xC0, 0x3C, 0x03,
  0xF0, 0x3F, 0xC3, 0xFC, 0x23, 0xE0, 0x1E, 0x01, 0xE8, 0x3E, 0xFF, 0xCF,
  0xFC, 0xFF, 0x00, 0x07, 0xE3, 0xFC, 0xFF, 0xBE, 0x07, 0x80, 0xEF, 0x3F,
  0xF7, 0xFE, 0xF3, 0xDE, 0x7B, 0xCF, 0x79, 0xEF, 0xFC, 0xFF, 0x0F, 0xC0,
  0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0,
  0x00, 0x0F, 0xC1, 0xFE, 0x1F, 0xF3, 0xCF, 0x3C, 0xF1, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0xC7, 0x9E, 0x71, 0xEF, 0x1E, 0x7F, 0xE7, 0xFC, 0x3F, 0x80,
  0x1F, 0x87, 0xF9, 0xFF, 0x7C, 0xEF, 0x1F, 0xE3, 0xFC, 0xFF, 0xFE, 0x7D,
  0xC7, 0x78, 0x0F, 0x03, 0xCF, 0xF1, 0xFC, 0x3F, 0x00, 0x1C, 0xF3, 0xCF,
  0x00, 0x00, 0x00, 0x73, 0xCF, 0x3C, 0x0E, 0x3C, 0x78, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE3, 0xC7, 0x1E, 0x38, 0x00, 0x00, 0x40, 0x70, 0x7C,
  0x7C, 0x7C, 0x3C, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x70, 0x04, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xC0, 0x3C, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xF0, 0xFC, 0xFC, 0xFC, 0x3C, 0x08, 0x00, 0x7E, 0x7F, 0xBF,
  0xE8, 0xF0, 0x78, 0xF8, 0xF8, 0xF8, 0x78, 0x38, 0x00, 0x0C, 0x0F, 0x07,
  0x83, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x00, 0xF7, 0x1F,
  0xBB, 0x1F, 0xDF, 0x9C, 0xEF, 0xDC, 0x67, 0xEE, 0x73, 0xF7, 0x39, 0xFB,
  0xBD, 0xDD, 0xFF, 0xCE, 0x73, 0xC3, 0x80, 0x01, 0xF3, 0xC0, 0x7F, 0xE0,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xB8,
  0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x1E, 0x38, 0x7F, 0xE3, 0xFF, 0x8F, 0xFF,
  0x78, 0x3D, 0xE0, 0xFF, 0x03, 0xC0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFE, 0x3C,
  0xF1, 0xE7, 0x9E, 0x78, 0xFF, 0x87, 0xFC, 0x3F, 0xF1, 0xE7, 0x9E, 0x3C,
  0xF3, 0xE7, 0xFE, 0x3F, 0xF3, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xCF, 0xFC,
  0x7C, 0x67, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xF0, 0x87, 0xFC, 0x3F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x87, 0x9E, 0x1E, 0x7C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x78,
  0xF1, 0xE7, 0x8F, 0x9E, 0x7C, 0x7F, 0xE1, 0xFF, 0x0F, 0xF0, 0x00, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xE0, 0x1E, 0x03, 0xC0, 0x3F, 0xE3, 0xFC, 0x3F,
  0xC3, 0x80, 0x78, 0x07, 0x80, 0x7F, 0xC7, 0xFC, 0xFF, 0x80, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xE0, 0x1E, 0x03, 0xC0, 0x3F, 0xE3, 0xFC, 0x3F, 0xC3,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xF8, 0xFF,
  0xCF, 0xFE, 0x7C, 0x27, 0xC0, 0x3C, 0x03, 0xEF, 0xFE, 0x7E, 0xF3, 0xF7,
  0x87, 0xBC, 0x3D, 0xF1, 0xE7, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x1F, 0x1E,
  0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xE1, 0xE3, 0xC7, 0x87, 0x8F, 0xFF, 0x1F,
  0xFE, 0x3F, 0xF8, 0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x8F, 0x0F, 0x1E,
  0x3C, 0x3C, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x07, 0xF0, 0xFE, 0x3F, 0xC0,
  0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0xFE, 0x1F,
  0xC3, 0xF0, 0x78, 0x00, 0x1F, 0x1F, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0xF8,
  0x1F, 0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3D, 0xE0,
  0x79, 0xE0, 0x79, 0xF0, 0x79, 0xF0, 0x78, 0xF0, 0xF0, 0xF8, 0x1F, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0x7F, 0xDF, 0xFF, 0xF8, 0x1F, 0x83, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F,
  0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7F, 0x3B, 0x8F, 0xE7, 0xF1, 0xDD, 0xDE,
  0x3B, 0xBB, 0x87, 0x7E, 0x71, 0xEF, 0xDE, 0x3D, 0xF3, 0xC7, 0x3E, 0x78,
  0xE7, 0xCE, 0x3C, 0xF3, 0xC0, 0x1F, 0x07, 0x8F, 0xC3, 0x87, 0xE1, 0xC3,
  0xF1, 0xE1, 0xF8, 0xF1, 0xFE, 0x78, 0xFF, 0x38, 0x73, 0x9C, 0x39, 0xFE,
  0x1C, 0xFF, 0x1E, 0x3F, 0x0F, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE3, 0xC1,
  0xF0, 0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0x8F, 0x9F, 0x7C, 0x3D, 0xE0, 0xFF,
  0x83, 0xFC, 0x0F, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0xBE, 0x7C, 0x7F, 0xF1,
  0xFF, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x87, 0xFC, 0x3D, 0xF1, 0xE7,
  0x9E, 0x3C, 0xF3, 0xE7, 0xFE, 0x3F, 0xE1, 0xFC, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0x8F, 0x9F,
  0x7C, 0x3D, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F,
  0xBE, 0x7C, 0x7F, 0xF1, 0xFF, 0x81, 0xFC, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x1F, 0xC0, 0xFF, 0x87, 0xFE, 0x3C, 0xF1, 0xE7, 0x9E,
  0x3C, 0xFF, 0xC7, 0xFE, 0x3F, 0xC1, 0xFE, 0x1E, 0x78, 0xF3, 0xC7, 0x9F,
  0x3C, 0x7B, 0xC3, 0xE0, 0x0F, 0xE1, 0xFF, 0x3F, 0xE3, 0xC6, 0x3C, 0x03,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xCC, 0x3C, 0xFF, 0xCF,
  0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x01, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x00,
  0x3C, 0x3C, 0xF0, 0xF3, 0xC7, 0x8F, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF3, 0xC3, 0xCF, 0x1F, 0x3E, 0x78, 0x7F, 0xE1, 0xFF,
  0x03, 0xF8, 0x00, 0xE0, 0xFF, 0x87, 0xBC, 0x79, 0xE3, 0xCF, 0x3C, 0x79,
  0xE3, 0xDE, 0x1E, 0xF0, 0xF7, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x3E, 0x01, 0xE0, 0x00, 0xE0, 0xE1, 0xFC, 0x3C, 0x3F, 0x87, 0x8F, 0x71,
  0xF1, 0xEE, 0x3E, 0x39, 0xCF, 0xCF, 0x39, 0xF9, 0xE7, 0x3F, 0x78, 0xEE,
  0xEF, 0x1D, 0xDD, 0xC3, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF1,
  0xF8, 0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x87, 0x8F, 0x03, 0xCF, 0x81, 0xE7,
  0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xC7, 0x83, 0xC3, 0xC3, 0xE1, 0xF0,
  0xF0, 0xFF, 0x1E, 0xF1, 0xE7, 0x3C, 0x7F, 0x87, 0xF8, 0x7F, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x00, 0x1F,
  0xFC, 0x7F, 0xE1, 0xFF, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7F, 0xE3, 0xFF, 0x8F,
  0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x7C, 0x1F,
  0x0F, 0xC0, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x9E, 0x38, 0xE3, 0x8E, 0x3C,
  0xF1, 0xC0, 0x1F, 0x8F, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0xF8, 0x7C, 0x3E, 0x00,
  0x03, 0x00, 0xF0, 0x1E, 0x07, 0xC1, 0xDC, 0x3B, 0x8E, 0x73, 0x86, 0x70,
  0xFC, 0x1C, 0x7F, 0xFF, 0xFF, 0xFC, 0xF3, 0x8E, 0x1C, 0xF3, 0xFE, 0x7F,
  0xE7, 0xBE, 0xF9, 0xEF, 0x1C, 0xF1, 0xCF, 0x3C, 0xF3, 0xCF, 0xFC, 0xFF,
  0x87, 0xB8, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xC3, 0xFE, 0x3F,
  0xF3, 0xDF, 0x3C, 0xF3, 0x8F, 0x78, 0xF7, 0x9E, 0x79, 0xE7, 0xFE, 0x7F,
  0xCF, 0x78, 0x0F, 0x8F, 0xF7, 0xF9, 0xF6, 0xF8, 0x3C, 0x0F, 0x03, 0xC0,
  0xF1, 0x3F, 0xC7, 0xF0, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x1C,
  0xE3, 0xEE, 0x7F, 0xE7, 0xFE, 0xF9, 0xEF, 0x1C, 0xF1, 0xCF, 0x3C, 0xF3,
  0xCF, 0xFC, 0xFF, 0x87, 0xB8, 0x0F, 0x87, 0xF9, 0xFF, 0xBC, 0xFF, 0x1F,
  0xFF, 0xBF, 0xE7, 0xF0, 0xF0, 0x9F, 0xF1, 0xFE, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0x80, 0x7E, 0x0F, 0xF0, 0x7F, 0x80, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0x0E, 0x78, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE7, 0xCF, 0x3C, 0x71, 0xE3, 0x8F, 0x3C, 0x79, 0xE3,
  0xFF, 0x1F, 0xF0, 0x7F, 0x80, 0x3C, 0x43, 0xE3, 0xFE, 0x1F, 0xE0, 0x7E,
  0x00, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1D, 0xE3, 0xFF, 0x3F, 0xF3,
  0xEF, 0x3C, 0xF3, 0xCF, 0x78, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xEF,
  0x1E, 0x0E, 0x3C, 0x78, 0x01, 0xE7, 0x8F, 0x1E, 0x3C, 0x79, 0xE3, 0xC7,
  0x8F, 0x1E, 0x78, 0x01, 0xC0, 0x7C, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0xF0, 0x1E, 0x03, 0xC3, 0xF8, 0x7E, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x7C, 0xF1, 0xE3, 0xCF, 0x0F, 0x78, 0x3F, 0xC0,
  0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7B, 0xC1, 0xEF, 0x87, 0x9E, 0x3C, 0x7C,
  0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78,
  0x78, 0x78, 0x78, 0xF0, 0x1D, 0xE3, 0x8F, 0xFD, 0xF3, 0xFF, 0xFC, 0xFB,
  0xEF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0x8F, 0x3D, 0xE3, 0xCF, 0x79, 0xE3,
  0xDE, 0x79, 0xE7, 0x9E, 0x7B, 0xC7, 0x9E, 0x1D, 0xE3, 0xFF, 0x3F, 0xF3,
  0xEF, 0x3C, 0xF3, 0xCF, 0x78, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xEF,
  0x1E, 0x0F, 0x07, 0xF9, 0xFF, 0x3C, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x9E,
  0xF3, 0xDF, 0xF9, 0xFE, 0x1F, 0x00, 0x0E, 0xE0, 0xFF, 0x87, 0xFE, 0x3D,
  0xF1, 0xE7, 0x8E, 0x3C, 0xF1, 0xE7, 0x9E, 0x3C, 0xF1, 0xFF, 0x8F, 0xF8,
  0xF7, 0x87, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x1C, 0xF3,
  0xFE, 0x7F, 0xE7, 0xFE, 0xF9, 0xEF, 0x1C, 0xF1, 0xCF, 0x3C, 0xF3, 0xCF,
  0xFC, 0xFF, 0x87, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0x1C, 0xCF, 0xF3, 0xFC, 0xFE, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x83, 0xC0, 0x0F, 0x0F, 0xF3, 0xFD, 0xE2, 0x7C, 0x0F, 0xC1, 0xF8,
  0x3E, 0x87, 0xBF, 0xEF, 0xF3, 0xF8, 0x1C, 0x0E, 0x0F, 0xFF, 0xFF, 0xF3,
  0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1F, 0xCF, 0xE3, 0xF0, 0x3C, 0xF7,
  0x8F, 0x79, 0xE7, 0x9E, 0x79, 0xEF, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF,
  0xFC, 0xFF, 0xC7, 0xB8, 0xF1, 0xFF, 0x1E, 0xF3, 0xCF, 0x3C, 0xF3, 0x87,
  0x78, 0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF1, 0xE7,
  0xF9, 0xF3, 0xFC, 0xF9, 0xDE, 0xFD, 0xEF, 0x7E, 0xF7, 0xB6, 0xF3, 0xFB,
  0x79, 0xFD, 0xB8, 0x7C, 0xFC, 0x3E, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x00,
  0x1E, 0x7C, 0x79, 0xE1, 0xEF, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0xF7, 0x87, 0x9E, 0x3E, 0x7C, 0x3C, 0x7C, 0xF1,
  0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0x77, 0x81, 0xDC, 0x07, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x0F, 0xC0, 0x3E,
  0x00, 0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x03, 0xE0, 0xF8, 0x3E, 0x07,
  0x81, 0xE0, 0x78, 0x1F, 0xF3, 0xFE, 0x7F, 0x80, 0x07, 0x87, 0xC3, 0xE3,
  0xC1, 0xE0, 0xE0, 0x70, 0xF8, 0xF8, 0x78, 0x3E, 0x07, 0x03, 0x83, 0xC1,
  0xC0, 0xF8, 0x7C, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C,
  0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x0F, 0x87, 0x87, 0xC7,
  0x83, 0x81, 0xC0, 0xE1, 0xF0, 0xF0, 0x70, 0x00, 0xFC, 0x7F, 0xFC, 0xFE,
  0x04,
};

const GFXglyph NotoSans_BlackItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 15, 6, 0, -15 },
  { 15, 9, 5, 10, 2, -15 },
  { 21, 14, 15, 14, 0, -15 },
  { 48, 11, 17, 12, 1, -16 },
  { 72, 18, 15, 20, 1, -15 },
  { 106, 15, 15, 15, 0, -15 },
  { 135, 4, 5, 5, 2, -15 },
  { 138, 8, 18, 8, 1, -15 },
  { 156, 8, 18, 8, -1, -15 },
  { 174, 10, 10, 11, 2, -16 },
  { 187, 10, 11, 12, 1, -13 },
  { 201, 6, 5, 6, -1, -2 },
  { 205, 7, 3, 7, 0, -7 },
  { 208, 4, 4, 6, 0, -4 },
  { 210, 12, 15, 10, -1, -15 },
  { 233, 11, 15, 12, 1, -15 },
  { 254, 9, 15, 12, 2, -15 },
  { 271, 12, 15, 12, -1, -15 },
  { 294, 12, 15, 12, 0, -15 },
  { 317, 12, 15, 12, 0, -15 },
  { 340, 12, 15, 12, 0, -15 },
  { 363, 11, 15, 12, 1, -15 },
  { 384, 13, 15, 12, 0, -15 },
  { 409, 12, 15, 12, 0, -15 },
  { 432, 11, 15, 12, 1, -15 },
  { 453, 6, 12, 6, 0, -12 },
  { 462, 7, 15, 6, -1, -12 },
  { 476, 10, 11, 12, 1, -13 },
  { 490, 10, 7, 12, 1, -11 },
  { 499, 10, 11, 12, 1, -13 },
  { 513, 9, 15, 10, 2, -15 },
  { 530, 17, 17, 19, 1, -15 },
  { 567, 14, 15, 14, -1, -15 },
  { 594, 13, 15, 13, 0, -15 },
  { 619, 13, 15, 13, 1, -15 },
  { 644, 14, 15, 14, 0, -15 },
  { 671, 12, 15, 12, 0, -15 },
  { 694, 12, 15, 12, 0, -15 },
  { 717, 13, 15, 15, 1, -15 },
  { 742, 15, 15, 15, 0, -15 },
  { 771, 11, 15, 9, -1, -15 },
  { 792, 11, 20, 8, -3, -15 },
  { 820, 16, 15, 14, 0, -15 },
  { 850, 10, 15, 11, 0, -15 },
  { 869, 19, 15, 19, 0, -15 },
  { 905, 17, 15, 17, 0, -15 },
  { 937, 14, 15, 15, 1, -15 },
  { 964, 13, 15, 13, 0, -15 },
  { 989, 14, 19, 15, 1, -15 },
  { 1023, 13, 15, 14, 0, -15 },
  { 1048, 12, 15, 12, 0, -15 },
  { 1071, 11, 15, 12, 2, -15 },
  { 1092, 14, 15, 15, 1, -15 },
  { 1119, 13, 15, 13, 2, -15 },
  { 1144, 19, 15, 20, 2, -15 },
  { 1180, 17, 15, 14, -1, -15 },
  { 1212, 12, 15, 13, 2, -15 },
  { 1235, 14, 15, 11, -1, -15 },
  { 1262, 10, 19, 8, -1, -15 },
  { 1286, 6, 15, 10, 2, -15 },
  { 1298, 9, 19, 8, -1, -15 },
  { 1320, 11, 10, 11, 0, -15 },
  { 1334, 10, 3, 9, -2, 1 },
  { 1338, 5, 3, 7, 3, -16 },
  { 1340, 12, 12, 13, 1, -12 },
  { 1358, 12, 16, 13, 0, -16 },
  { 1382, 10, 12, 11, 1, -12 },
  { 1397, 12, 16, 13, 1, -16 },
  { 1421, 11, 12, 12, 1, -12 },
  { 1438, 13, 21, 9, -2, -16 },
  { 1473, 13, 17, 13, 0, -12 },
  { 1501, 12, 16, 13, 0, -16 },
  { 1525, 7, 16, 7, 0, -16 },
  { 1539, 11, 21, 7, -3, -16 },
  { 1568, 14, 16, 13, 0, -16 },
  { 1596, 8, 16, 7, 0, -16 },
  { 1612, 18, 12, 19, 0, -12 },
  { 1639, 12, 12, 13, 0, -12 },
  { 1657, 11, 12, 13, 1, -12 },
  { 1674, 13, 17, 13, -1, -12 },
  { 1702, 12, 17, 13, 1, -12 },
  { 1728, 10, 12, 9, 0, -12 },
  { 1743, 10, 12, 11, 0, -12 },
  { 1758, 9, 14, 10, 1, -14 },
  { 1774, 12, 12, 13, 1, -12 },
  { 1792, 12, 12, 11, 1, -12 },
  { 1810, 17, 12, 17, 1, -12 },
  { 1836, 14, 12, 12, -1, -12 },
  { 1857, 14, 17, 11, -1, -12 },
  { 1887, 11, 12, 10, 0, -12 },
  { 1904, 9, 18, 8, 0, -15 },
  { 1925, 2, 21, 12, 5, -16 },
  { 1931, 9, 18, 8, -1, -15 },
  { 1952, 10, 4, 12, 1, -9 },
};

const GFXfont NotoSans_BlackItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_BLACKITALIC21PT7B_H_
