#ifndef _NOTOSANS_BLACKITALIC45PT7B_H_
#define _NOTOSANS_BLACKITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0x08, 0x00, 0x7F, 0x9F, 0xEF, 0xF3, 0xF9,
  0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xE3,
  0xF1, 0xFC, 0xFE, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xC7, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8,
  0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFB, 0xCF, 0x07, 0xF9, 0xC0, 0x83, 0xFD, 0xE0, 0x01,
  0xFE, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xF7, 0xF8, 0x00, 0x7B,
  0xFC, 0xC0, 0x39, 0xFE, 0x7C, 0x3D, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x1F,
  0xC0, 0x3F, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0x07, 0xF3,
  0xF0, 0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0xFE, 0x00, 0xFE, 0x3F, 0x03, 0xF0,
  0x03, 0xF0, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0xFE, 0x00, 0x3F, 0x1F,
  0xC7, 0xF0, 0x00, 0xFC, 0x7F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0xFC, 0x1C,
  0x0F, 0xCF, 0xE7, 0xF3, 0xFE, 0x3F, 0xFF, 0xBF, 0x9F, 0xFC, 0xFF, 0xFC,
  0xFC, 0xFF, 0xFB, 0xFF, 0xE7, 0xE7, 0xFF, 0xE7, 0xFF, 0x3F, 0x9F, 0xFF,
  0xCF, 0xF9, 0xFC, 0xFE, 0x7F, 0x02, 0x07, 0xE3, 0xF8, 0xFC, 0x00, 0x3F,
  0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x7F,
  0x00, 0x3F, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x1F, 0xC7, 0xE0, 0x0F, 0xE0,
  0x7E, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xFE, 0x01, 0xF8, 0x00,
  0x7F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF1,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x8F, 0xFF, 0xF8,
  0x7F, 0x87, 0xFF, 0xFE, 0x7F, 0xC7, 0xFC, 0xFF, 0xBF, 0xE3, 0xFC, 0x7F,
  0xFF, 0xE3, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x8F, 0xFC, 0x00,
  0x7F, 0xBF, 0xDF, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0xFE, 0x7E, 0x3F,
  0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x06, 0x07, 0xE0, 0x0F,
  0x0F, 0x80, 0x3F, 0x9F, 0x00, 0x7F, 0xFE, 0x02, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF,
  0x8F, 0x07, 0xFF, 0x80, 0x3F, 0xDF, 0x00, 0xFF, 0xBF, 0x00, 0x7E, 0x7E,
  0x00, 0x78, 0xFE, 0x00, 0x70, 0xFC, 0x00, 0x41, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F,
  0x87, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF,
  0x9F, 0xFE, 0x7F, 0xFB, 0xFF, 0xE0, 0x1E, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x0F, 0xF9, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F,
  0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F,
  0xC0, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x81, 0xFF, 0x7F,
  0x81, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x83, 0xFE, 0xFF,
  0x83, 0xFE, 0xFF, 0x87, 0xFC, 0xFF, 0x87, 0xFC, 0x7F, 0x8F, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8,
  0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFE, 0xFF, 0x0F, 0xEF,
  0xF8, 0x7C, 0x7F, 0x81, 0xC3, 0xFC, 0x08, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xF0,
  0x7F, 0xC0, 0x38, 0x1F, 0xF0, 0x08, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xE3, 0xFF, 0x01, 0x80, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x80,
  0x03, 0xFE, 0x70, 0x03, 0xFF, 0x3F, 0x8F, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0xFE,
  0x7F, 0x80, 0x3F, 0xBF, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0xE3, 0xFC, 0x07,
  0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE2, 0x00, 0x0F, 0xF8, 0xE0, 0x07, 0xFE, 0x3F, 0x8F, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0x02, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x7F,
  0xBF, 0xF0, 0x7F, 0x7F, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xE7, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x83, 0xFC, 0xFF,
  0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFC, 0xFF,
  0x0F, 0xFC, 0xFF, 0x9F, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F,
  0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xFF, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xC7, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0xFF, 0x03, 0xFC, 0xFF,
  0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xF3,
  0xFE, 0x7F, 0xC3, 0xFE, 0xFF, 0x87, 0xFD, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xBF, 0xE7, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1,
  0xFF, 0xBF, 0xC1, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE3, 0x07, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0,
  0x7F, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x40, 0x00, 0x00,
  0x3E, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xF0,
  0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF3, 0xF1, 0xFF, 0x18, 0x0F, 0xF1, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xF7, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0x8F, 0xE0, 0x7F, 0xFC, 0xFC, 0x7E,
  0x0F, 0xFF, 0xE3, 0xF3, 0xF0, 0xFF, 0xFF, 0x1F, 0xBF, 0x0F, 0xFF, 0xF0,
  0xFD, 0xF8, 0x7F, 0x1F, 0x87, 0xEF, 0x87, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F,
  0x07, 0xE1, 0xFF, 0xE3, 0xF8, 0x3E, 0x0F, 0xFF, 0x1F, 0x83, 0xF0, 0x7F,
  0xF8, 0xFC, 0x1F, 0x83, 0xEF, 0xC7, 0xE0, 0xFC, 0x3F, 0x7E, 0x3F, 0x0F,
  0xC1, 0xFB, 0xF1, 0xF8, 0x7E, 0x1F, 0x9F, 0x8F, 0xEF, 0xFB, 0xF8, 0xFC,
  0x7F, 0xFF, 0xFF, 0xC7, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0xFD, 0xFF,
  0x80, 0xFC, 0x3F, 0x87, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x03, 0xFE, 0x01, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F,
  0xDF, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x03,
  0xFC, 0xFF, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x3F, 0xF8,
  0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0,
  0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F,
  0xC1, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x03, 0x81, 0xFF, 0x80, 0x08, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x04, 0x07, 0xFE, 0x01, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xC3, 0xFF,
  0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x0F,
  0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1, 0xFE, 0x01, 0xFF, 0x1F,
  0xE0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x07,
  0xFE, 0x3F, 0xC0, 0x7F, 0xC3, 0xFC, 0x1F, 0xFC, 0x7F, 0xC3, 0xFF, 0x87,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xC0, 0xFF, 0xC0, 0x02,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x0F, 0xFF, 0x8F, 0xF8, 0x7F, 0xFC, 0x7F, 0x83,
  0xFF, 0xE7, 0xFC, 0x3F, 0xFF, 0x3F, 0xE1, 0xFF, 0xF9, 0xFF, 0x0F, 0xFF,
  0x8F, 0xF8, 0x7F, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F,
  0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x83, 0xFF, 0x03, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x81,
  0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x1F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE,
  0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x83, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFC,
  0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xFC,
  0x7F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF9,
  0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xE7,
  0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x81,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFD, 0xFC, 0x0F, 0xEF, 0xC0, 0xFF, 0xFC, 0x0F, 0xEF, 0xC1,
  0xFB, 0xFC, 0x0F, 0xEF, 0xC1, 0xFB, 0xF8, 0x0F, 0xEF, 0xC3, 0xFB, 0xF8,
  0x1F, 0xEF, 0xC3, 0xF7, 0xF8, 0x1F, 0xEF, 0xC7, 0xF7, 0xF8, 0x1F, 0xEF,
  0xC7, 0xE7, 0xF8, 0x1F, 0xCF, 0xCF, 0xE7, 0xF0, 0x1F, 0xCF, 0xCF, 0xCF,
  0xF0, 0x3F, 0xCF, 0xCF, 0xCF, 0xF0, 0x3F, 0xCF, 0xDF, 0x8F, 0xF0, 0x3F,
  0xCF, 0xDF, 0x8F, 0xF0, 0x3F, 0x8F, 0xFF, 0x0F, 0xE0, 0x3F, 0x8F, 0xFF,
  0x1F, 0xE0, 0x7F, 0x8F, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xFE, 0x1F, 0xE0,
  0x7F, 0x8F, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F,
  0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x3F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x7F,
  0xF0, 0x03, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0xE0, 0x1F, 0xE0,
  0x3F, 0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0xF0, 0x0F,
  0xE0, 0x3F, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFD, 0xFC,
  0x0F, 0xF0, 0x3F, 0xBF, 0xC1, 0xFE, 0x07, 0xF7, 0xF8, 0x3F, 0x80, 0xFE,
  0x7F, 0x0F, 0xF0, 0x1F, 0xCF, 0xE1, 0xFE, 0x07, 0xF9, 0xFE, 0x3F, 0xC0,
  0xFF, 0x3F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x9F,
  0xC0, 0x7F, 0x0F, 0xF7, 0xF8, 0x1F, 0xE1, 0xFE, 0xFF, 0x03, 0xFC, 0x1F,
  0xFF, 0xC0, 0x7F, 0x83, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0x01, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0x01,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x80, 0x3F, 0xFC, 0x0F, 0xF0, 0x07, 0xFF,
  0x81, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xC0, 0x0F, 0xFC, 0x07, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F,
  0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0,
  0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x7F,
  0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xE1,
  0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xF8, 0x3F,
  0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xFC, 0x1F, 0xE1, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0xCF,
  0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F,
  0xFB, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xDF, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F,
  0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC,
  0x7F, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xEF, 0xF8,
  0x0F, 0xF9, 0xFF, 0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x1F, 0xF1, 0xFE, 0x07, 0xFC, 0xFF,
  0x81, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFC, 0x03, 0xFF,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFC, 0xFC,
  0x1F, 0xF0, 0x1C, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0xC0, 0x0F, 0xF0, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F,
  0xC0, 0x7F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xFC,
  0x1F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F,
  0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x07, 0xFC,
  0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x3F, 0xE7, 0xF8, 0x07, 0xFC, 0x7F, 0x80, 0x7F, 0xC7, 0xF8, 0x07, 0xF8,
  0x7F, 0x80, 0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC,
  0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0xFE, 0x01,
  0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xFC,
  0x0F, 0xF8, 0x7F, 0x03, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0xF0, 0x3F,
  0xC1, 0xFC, 0x1F, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xFF, 0xC1, 0xFE, 0x07,
  0xF0, 0x7F, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xFF, 0x0F, 0xF0, 0x1F, 0xC3,
  0xF7, 0xE1, 0xFE, 0x03, 0xF8, 0xFE, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0x9F,
  0x8F, 0xF0, 0x0F, 0xE7, 0xF3, 0xF3, 0xFC, 0x01, 0xFC, 0xFE, 0x7E, 0x7F,
  0x80, 0x3F, 0xBF, 0x8F, 0xCF, 0xE0, 0x07, 0xF7, 0xF1, 0xFB, 0xFC, 0x00,
  0xFE, 0xFC, 0x3F, 0x7F, 0x80, 0x1F, 0xFF, 0x87, 0xEF, 0xE0, 0x03, 0xFF,
  0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x03, 0xFC,
  0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF0,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFB, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0xFF,
  0x87, 0xF8, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xF1, 0xFF, 0x01, 0xFE,
  0x3F, 0xE0, 0x3F, 0xCF, 0xF8, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x7F, 0xC0,
  0x0F, 0xEF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xFD, 0xF0, 0x01, 0xF9, 0xF8, 0x03, 0xF1, 0xF8, 0x07,
  0xF1, 0xF8, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F,
  0x80, 0x7C, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE,
  0x00, 0x3F, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0xF8, 0x01, 0xFC, 0x3F, 0x81, 0xFF, 0x3F, 0xC1, 0xFF, 0xDF, 0xC1,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x7F, 0xC7, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F,
  0x9F, 0xF0, 0x3F, 0x8F, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F,
  0xF1, 0xFF, 0x07, 0xF8, 0xFF, 0x87, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xF7,
  0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x7F, 0xEF, 0xE0, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F,
  0xF8, 0xFF, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xF1,
  0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0x7F, 0x83, 0xFE, 0x3F, 0xC1, 0xFF,
  0x3F, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0xC7, 0xFE, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFE, 0xFF,
  0xF0, 0x7F, 0x3F, 0xF0, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0xFF, 0xEF, 0x8F, 0xFC, 0x04, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x04, 0x3F, 0xFB, 0xE1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0x9F, 0xF0,
  0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xE3, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x1F,
  0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF,
  0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xEF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xF7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xCF, 0xF8, 0x7F, 0x9F, 0xE0, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x43, 0xFE, 0x03, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x40, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x7F, 0xCF, 0xF0, 0x3F, 0xFB, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xC7,
  0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xF1, 0xFF,
  0x03, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xE1,
  0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFE, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x02, 0x00, 0x7F, 0xC0, 0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFB, 0xFF,
  0x0F, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC1,
  0xFF, 0x1F, 0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F,
  0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0,
  0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F,
  0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x81, 0xFF, 0x0F,
  0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x8F, 0xF8,
  0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF1, 0xFF,
  0x80, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0x07, 0xF3, 0xFF, 0x0F, 0xFC, 0x07, 0xF7, 0xFF, 0x9F, 0xFE, 0x07,
  0xF7, 0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0xFB, 0xFF, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xF0, 0x7F, 0x83,
  0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x3F,
  0xE0, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0xFF,
  0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x07, 0xF8,
  0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x7F, 0xC1,
  0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x0F,
  0xF0, 0x03, 0xF9, 0xFE, 0x01, 0xFC, 0xFF, 0xC0, 0x7F, 0x7F, 0xF8, 0x1F,
  0xDF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xEF, 0xFC,
  0x3F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07,
  0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xE1, 0xFE,
  0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F,
  0x87, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFC, 0xFF, 0x9F, 0xF0, 0xFF, 0x7F, 0xC1,
  0xFE, 0xFF, 0x83, 0xFD, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFD,
  0xFF, 0x0F, 0xFB, 0xFE, 0x3F, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xF0, 0x07, 0xF7, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xF1, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F,
  0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE,
  0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8,
  0x3F, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0xE0, 0x1F, 0xE7, 0xF0, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x3F, 0x81, 0xFF, 0x3F, 0xC1, 0xFF, 0xDF, 0xC1, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F,
  0xC7, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x9F,
  0xF0, 0x3F, 0x8F, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xF1,
  0xFF, 0x07, 0xF8, 0xFF, 0x87, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xF7, 0xFE,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0x7F, 0xDF, 0xE0, 0x1F, 0xDF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x1F, 0xCF, 0xE0,
  0x7F, 0x7F, 0x81, 0xFD, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFB, 0xF0, 0xFF, 0x83, 0x87, 0xFC, 0x04,
  0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE4,
  0x01, 0xFF, 0x38, 0x0F, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xFF,
  0x1F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0x83,
  0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF,
  0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xE1,
  0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE3, 0xFF, 0x0F, 0xFD,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xBF, 0x80, 0xFF, 0xCF, 0xE0, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0xDF, 0xF0, 0x7F, 0xC7, 0xF8,
  0x3F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F,
  0x8F, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x03,
  0xFB, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xF8, 0x1F, 0xEF, 0xF0, 0x7F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFF, 0x83, 0xFC,
  0x7F, 0x07, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xF8, 0x7F, 0x87, 0xF0, 0xFF,
  0xE3, 0xFE, 0x1F, 0xC7, 0xFF, 0x8F, 0xF0, 0x7F, 0x1F, 0xFE, 0x3F, 0xC1,
  0xFC, 0x7D, 0xF9, 0xFE, 0x07, 0xF3, 0xF7, 0xE7, 0xF8, 0x1F, 0xCF, 0xDF,
  0xBF, 0xC0, 0x7F, 0x3E, 0x7E, 0xFF, 0x01, 0xFD, 0xF9, 0xFB, 0xF8, 0x07,
  0xF7, 0xE7, 0xDF, 0xE0, 0x1F, 0xDF, 0x1F, 0x7F, 0x00, 0x7F, 0xFC, 0x7D,
  0xFC, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x1F,
  0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF,
  0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x1F, 0xF8,
  0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0x8F,
  0xF0, 0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xFC, 0x7F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0xFF,
  0x3F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x05, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x03, 0xFC,
};

const GFXglyph NotoSans_BlackItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 16, 33, 14, 0, -32 },
  { 67, 19, 11, 20, 4, -32 },
  { 94, 30, 32, 29, 0, -32 },
  { 214, 25, 37, 26, 1, -34 },
  { 330, 38, 33, 42, 3, -33 },
  { 487, 33, 33, 33, 0, -33 },
  { 624, 9, 11, 11, 4, -32 },
  { 637, 19, 40, 17, 1, -33 },
  { 732, 18, 40, 17, -3, -33 },
  { 822, 23, 23, 24, 3, -35 },
  { 889, 22, 22, 26, 2, -27 },
  { 950, 12, 11, 14, -2, -5 },
  { 967, 14, 6, 15, 0, -15 },
  { 978, 9, 9, 14, 0, -8 },
  { 989, 26, 33, 21, -2, -33 },
  { 1097, 24, 33, 26, 1, -33 },
  { 1196, 21, 32, 26, 3, -32 },
  { 1280, 26, 33, 26, -1, -33 },
  { 1388, 25, 33, 26, 0, -33 },
  { 1492, 26, 32, 26, 0, -32 },
  { 1596, 26, 32, 26, 0, -32 },
  { 1700, 24, 33, 26, 2, -33 },
  { 1799, 27, 32, 26, 1, -32 },
  { 1907, 24, 33, 26, 1, -33 },
  { 2006, 23, 33, 26, 2, -33 },
  { 2101, 14, 26, 14, 0, -25 },
  { 2147, 17, 31, 14, -3, -25 },
  { 2213, 22, 25, 26, 2, -29 },
  { 2282, 22, 16, 26, 2, -24 },
  { 2326, 22, 25, 26, 2, -29 },
  { 2395, 20, 34, 22, 3, -33 },
  { 2480, 37, 37, 40, 2, -33 },
  { 2652, 30, 32, 30, -3, -32 },
  { 2772, 27, 32, 29, 1, -32 },
  { 2880, 28, 33, 28, 2, -33 },
  { 2996, 28, 32, 31, 1, -32 },
  { 3108, 26, 32, 25, 1, -32 },
  { 3212, 25, 32, 26, 1, -32 },
  { 3312, 29, 33, 31, 2, -33 },
  { 3432, 31, 32, 32, 1, -32 },
  { 3556, 24, 32, 19, -2, -32 },
  { 3652, 24, 42, 17, -7, -32 },
  { 3778, 32, 32, 30, 1, -32 },
  { 3906, 20, 32, 24, 1, -32 },
  { 3986, 40, 32, 41, 1, -32 },
  { 4146, 35, 32, 36, 1, -32 },
  { 4286, 30, 33, 33, 2, -33 },
  { 4410, 27, 32, 28, 1, -32 },
  { 4518, 30, 41, 33, 2, -33 },
  { 4672, 26, 32, 29, 1, -32 },
  { 4776, 24, 33, 25, 1, -33 },
  { 4875, 25, 32, 25, 3, -32 },
  { 4975, 29, 32, 32, 3, -32 },
  { 5091, 28, 32, 28, 3, -32 },
  { 5203, 43, 32, 42, 3, -32 },
  { 5375, 36, 32, 30, -3, -32 },
  { 5519, 27, 32, 27, 4, -32 },
  { 5627, 29, 32, 24, -2, -32 },
  { 5743, 20, 41, 16, -1, -33 },
  { 5846, 12, 33, 21, 5, -33 },
  { 5896, 20, 41, 16, -3, -33 },
  { 5999, 24, 21, 24, 0, -32 },
  { 6062, 22, 5, 20, -4, 3 },
  { 6076, 11, 7, 16, 6, -34 },
  { 6086, 25, 25, 27, 2, -25 },
  { 6165, 25, 34, 27, 0, -34 },
  { 6272, 21, 25, 23, 2, -25 },
  { 6338, 27, 34, 27, 2, -34 },
  { 6453, 23, 25, 26, 2, -25 },
  { 6525, 28, 45, 18, -5, -34 },
  { 6683, 26, 36, 27, 1, -25 },
  { 6800, 26, 34, 28, 0, -34 },
  { 6911, 16, 35, 15, 0, -35 },
  { 6981, 22, 46, 15, -6, -35 },
  { 7108, 30, 34, 28, 0, -34 },
  { 7236, 16, 34, 15, 0, -34 },
  { 7304, 40, 25, 42, 0, -25 },
  { 7429, 26, 25, 28, 0, -25 },
  { 7511, 23, 25, 27, 2, -25 },
  { 7583, 27, 36, 27, -2, -25 },
  { 7705, 25, 36, 27, 2, -25 },
  { 7818, 22, 25, 20, 0, -25 },
  { 7887, 21, 25, 23, 1, -25 },
  { 7953, 20, 30, 21, 1, -30 },
  { 8028, 26, 25, 28, 2, -25 },
  { 8110, 25, 25, 24, 2, -25 },
  { 8189, 38, 25, 37, 2, -25 },
  { 8308, 31, 25, 25, -3, -25 },
  { 8405, 30, 36, 24, -3, -25 },
  { 8540, 24, 25, 22, -1, -25 },
  { 8615, 19, 39, 16, 0, -32 },
  { 8708, 6, 44, 25, 10, -34 },
  { 8741, 19, 39, 16, -3, -32 },
  { 8834, 22, 8, 26, 2, -20 },
};

const GFXfont NotoSans_BlackItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_BLACKITALIC45PT7B_H_
