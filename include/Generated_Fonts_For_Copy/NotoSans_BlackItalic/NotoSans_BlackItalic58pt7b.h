#ifndef _NOTOSANS_BLACKITALIC58PT7B_H_
#define _NOTOSANS_BLACKITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x3F, 0xF1,
  0xFF, 0x3F, 0xE3, 0xFF, 0x3F, 0xE3, 0xFF, 0x3F, 0xE3, 0xFE, 0x7F, 0xC3,
  0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0x87,
  0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF8, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0xFF, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xCF, 0x87,
  0x83, 0xFF, 0x9E, 0x01, 0x07, 0xFE, 0x7C, 0x00, 0x0F, 0xFC, 0xF8, 0x00,
  0x1F, 0xFD, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFB, 0xFF, 0x00, 0x01, 0xF3, 0xFE, 0x00, 0x03, 0xE7, 0xFC, 0x40, 0x07,
  0xCF, 0xF8, 0xF0, 0x0F, 0x1F, 0xF1, 0xFE, 0x3E, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x9F, 0xF0,
  0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC,
  0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC3, 0xFE, 0x0F, 0xF9, 0xFF, 0x1F, 0xE3, 0xFF, 0xE1,
  0xFF, 0xFF, 0xCF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFC, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF1, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFE, 0x7F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F, 0xE3, 0xFE,
  0x7F, 0x80, 0xFE, 0x0F, 0xF1, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F,
  0x87, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8,
  0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0x1F, 0xFF, 0x7F, 0xFB, 0xFF, 0xC7, 0xFF,
  0x9F, 0xFF, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0x00,
  0xB0, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x7F, 0xC7,
  0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x0C, 0x03, 0xF8,
  0x00, 0xF8, 0x3F, 0xC0, 0x07, 0xE1, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x9F, 0x81, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xBF, 0x80, 0x1F, 0xF9, 0xFE, 0x00, 0x7F,
  0xCF, 0xF0, 0x01, 0xFC, 0x7F, 0xC0, 0x03, 0xC1, 0xFE, 0x00, 0x0C, 0x0F,
  0xF8, 0x00, 0x20, 0x7F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFE, 0x00, 0x0F, 0xC3, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xE7, 0xFC, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x3F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF,
  0xE7, 0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFF,
  0x7F, 0xF8, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xFB,
  0xFF, 0x80, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0xBF,
  0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFD, 0xFF,
  0xC0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xCF, 0xFE,
  0x07, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0x7F, 0xF0, 0x7F, 0xCF, 0xFE, 0x07, 0xF1, 0xFF, 0xC0,
  0xF8, 0x3F, 0xF0, 0x0C, 0x0F, 0xFE, 0x01, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0xF0, 0x03,
  0xF0, 0x3F, 0xFC, 0x00, 0x78, 0x07, 0xFF, 0x00, 0x18, 0x01, 0xFF, 0x80,
  0x02, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x0F, 0xFF, 0x00, 0x60, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x80, 0x00, 0x3F, 0xFC, 0xF0,
  0x00, 0x7F, 0xFC, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xBF,
  0xF8, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x7F, 0xC7,
  0xFE, 0x00, 0x7F, 0xC7, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x3F, 0xE1,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0,
  0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x80, 0x00, 0x7F,
  0xF8, 0xE0, 0x00, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x3C, 0x00, 0x3F, 0xF9, 0xFF,
  0x80, 0x3F, 0xF3, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0xE0, 0x7F, 0xEF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xF8, 0xFF, 0xF8, 0x3F,
  0xF8, 0xFF, 0xF0, 0x3F, 0xF8, 0xFF, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F,
  0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F,
  0xF8, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF1, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x87,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x8F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xF8, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F,
  0xF8, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xFD, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xE3, 0xFF, 0xDF, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xBF, 0xF0,
  0xFF, 0xF9, 0xFF, 0x83, 0xFF, 0x9F, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0x86, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xE0, 0x7F, 0xF1, 0xE0, 0x1F,
  0xFC, 0x20, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x07,
  0xFF, 0xE1, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0xF8, 0xFF, 0x1F, 0xE0, 0x3F,
  0xFF, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x3F, 0xC0, 0xFF,
  0xFF, 0xF0, 0x7F, 0x3F, 0xC1, 0xFF, 0xDF, 0xF0, 0x7F, 0x3F, 0x83, 0xFE,
  0x0F, 0xE0, 0x7F, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x7F, 0x87, 0xFC,
  0x1F, 0xE0, 0x7F, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x7F, 0x0F, 0xF8,
  0x1F, 0xC0, 0xFF, 0x7F, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFE, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFE, 0xFF, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0xFF, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0xFF, 0x0F, 0xF9, 0xFF, 0xCF, 0xF8, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0x81, 0xFF,
  0x8F, 0xFF, 0x00, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x7F,
  0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x01,
  0xFF, 0xCF, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xFD, 0xFF,
  0xE0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x07, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0x01, 0xFF, 0xF0, 0x00, 0x30,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0x00, 0x7F, 0xFC, 0x01, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x00,
  0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFC,
  0x03, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0xF8, 0x00,
  0xE0, 0x3F, 0xFF, 0x00, 0x01, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x0F,
  0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0xFC, 0x7F,
  0xF8, 0x3F, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xFF, 0x1F, 0xFC, 0x1F, 0xFF,
  0xF8, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xF8,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x7F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x08, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00,
  0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xC3, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x7F,
  0xF8, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x9F, 0xFF, 0x00,
  0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0x1F,
  0xFD, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x01, 0xFF, 0xC7, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFE, 0xFE, 0x03, 0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xE0, 0x3F,
  0xDF, 0xF8, 0x07, 0xFE, 0xFE, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xE0,
  0x7F, 0xBF, 0xF0, 0x07, 0xFC, 0xFE, 0x0F, 0xF3, 0xFF, 0x00, 0xFF, 0xCF,
  0xE0, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFE, 0x1F, 0xF3, 0xFF, 0x00, 0xFF,
  0xCF, 0xE1, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0xFE, 0x1F, 0xE7, 0xFE, 0x00,
  0xFF, 0x8F, 0xE3, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFE, 0x3F, 0xC7, 0xFE,
  0x01, 0xFF, 0x8F, 0xE7, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0xFE, 0x7F, 0x8F,
  0xFC, 0x01, 0xFF, 0x8F, 0xEF, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFE, 0xFF,
  0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0x80, 0x3F, 0xF0,
  0xFF, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFC, 0x01, 0xFF,
  0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFB, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xDF,
  0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF,
  0x0F, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x7F, 0xE0,
  0x1F, 0xF8, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xDF, 0xF8, 0x07,
  0xFE, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0xCF,
  0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xFB, 0xFF,
  0x80, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xFF,
  0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x7F, 0xF8,
  0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x07, 0xFF,
  0x7F, 0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00,
  0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xEF,
  0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00,
  0xFF, 0xF3, 0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x3F, 0xFE, 0x3F,
  0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xCF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xF1,
  0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8,
  0x7F, 0xF0, 0x0F, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x7F,
  0xFB, 0xFF, 0x80, 0x1F, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x03,
  0xE0, 0x1F, 0xFC, 0x01, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x20, 0x00, 0x7F, 0xF8, 0x70, 0x00,
  0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8,
  0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x03,
  0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF,
  0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF,
  0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFE, 0x00,
  0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF8, 0x7F,
  0xE0, 0x07, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x3F,
  0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x9F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFE, 0x07,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFB, 0xFE, 0x1F, 0xF8, 0x03,
  0xFF, 0x1F, 0xF7, 0xFC, 0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xEF, 0xF8, 0xFF,
  0xC0, 0x0F, 0xF8, 0x7F, 0x9F, 0xF1, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x3F,
  0xE7, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x7F, 0xCF, 0xFC, 0x00, 0x7F, 0xCF,
  0xF8, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0x9F, 0xF1, 0xFF, 0x7F, 0xE0, 0x01,
  0xFF, 0x7F, 0xC3, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x87, 0xFB, 0xFF,
  0x00, 0x07, 0xFD, 0xFE, 0x0F, 0xF7, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x1F,
  0xEF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xDF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xEF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xF8, 0x07,
  0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF8, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xF0,
  0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x1F, 0xE0,
  0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0x3F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x9F, 0xFF,
  0x07, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x07,
  0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF9,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFD, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x87, 0x80, 0x03, 0xFF, 0x9F, 0xE0, 0x03, 0xFF, 0xBF, 0xF8,
  0x03, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0x9F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF,
  0x0F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFF,
  0x1F, 0xF8, 0x0F, 0xFF, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFE,
  0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xFC,
  0x7F, 0xFC, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x9F, 0xFF, 0x80, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xF0, 0x78, 0x3F, 0xFE, 0x00, 0x83, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x02,
  0x07, 0xFF, 0x00, 0xE0, 0x7F, 0xFC, 0x7E, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0x81, 0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xF0,
  0x01, 0xFF, 0xE7, 0xFE, 0x00, 0x7F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xDF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x3F,
  0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0,
  0x3F, 0xFC, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xEF, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0x1F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF1, 0xFF, 0xC0,
  0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFD, 0xFF, 0xE1, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x20, 0x7F, 0xF0, 0x03, 0x81, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFF,
  0x8F, 0xF8, 0x03, 0xFF, 0xF3, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFE, 0x07, 0xFE, 0x07, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF7, 0xFE,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x80, 0x01,
  0xFF, 0xC0, 0x38, 0x00, 0xFF, 0xE0, 0x0F, 0xFB, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x81, 0x80, 0x03, 0xFF, 0x9F,
  0xF8, 0x03, 0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0x7F, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xCF, 0xFF, 0x0F, 0xFF, 0x87,
  0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07,
  0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x07,
  0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F,
  0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F,
  0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x80,
  0x07, 0xFE, 0x3F, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0xFF, 0xEF,
  0xFF, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x1F,
  0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF,
  0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE3, 0xFF,
  0xC1, 0xFF, 0xF0, 0x0F, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0x03, 0xFE, 0xFF,
  0xFE, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x0F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xE1, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x7F, 0xFC, 0x03,
  0xFE, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xCF, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x0F,
  0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x1F,
  0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F,
  0xF8, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F,
  0xF0, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF,
  0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF9, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x80,
  0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x0F,
  0xFF, 0x7F, 0xF0, 0x1F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0xC0, 0x7F,
  0xF7, 0xFF, 0x80, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xDF, 0xFE, 0x07, 0xFF,
  0x3F, 0xFC, 0x1F, 0xFE, 0x7F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xF8,
  0x00, 0x3F, 0xEF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x9F, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0x7F, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0x80, 0x03,
  0xFF, 0x01, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xFC,
  0x7F, 0xC0, 0x3F, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x9F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF,
  0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x0F,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0x00, 0x1F, 0xFD, 0xFF,
  0x80, 0x07, 0xF9, 0xFF, 0xC0, 0x00, 0x40, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF8,
  0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC,
  0x0F, 0x83, 0xFF, 0x80, 0x60, 0x7F, 0xF0, 0x04, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xC4, 0x00, 0x3F, 0xF8, 0xE0, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x81,
  0xFF, 0xE3, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x0F,
  0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x1F,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F,
  0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFC, 0x7F,
  0xF0, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF,
  0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF3, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0x7F, 0xC0, 0x3F, 0xFE, 0x7F, 0xC0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xBF,
  0xF0, 0x07, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xC7,
  0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x1F, 0xFC,
  0x01, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFD, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFE, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFC, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xF8, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFB, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xFB, 0xF8, 0x7F,
  0xE0, 0x7F, 0xC3, 0xFB, 0xF8, 0xFF, 0xC0, 0x7F, 0xC7, 0xFB, 0xF8, 0xFF,
  0xC0, 0x7F, 0xC7, 0xF7, 0xF9, 0xFF, 0xC0, 0x7F, 0xCF, 0xF7, 0xF9, 0xFF,
  0x80, 0x7F, 0xCF, 0xF7, 0xF9, 0xFF, 0x80, 0x7F, 0xCF, 0xE7, 0xFB, 0xFF,
  0x00, 0x7F, 0xDF, 0xE7, 0xFB, 0xFF, 0x00, 0x7F, 0xDF, 0xC7, 0xFF, 0xFE,
  0x00, 0x7F, 0xDF, 0xC7, 0xF7, 0xFE, 0x00, 0x7F, 0xFF, 0xC7, 0xF7, 0xFC,
  0x00, 0x7F, 0xFF, 0x87, 0xF7, 0xFC, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x7F, 0xF1, 0xFF,
  0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00,
  0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x80,
  0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x80,
  0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x04, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x10, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x13, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x80, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_BlackItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 20, 42, 18, 0, -41 },
  { 106, 24, 15, 26, 5, -41 },
  { 151, 38, 41, 37, 0, -41 },
  { 346, 31, 47, 34, 2, -44 },
  { 529, 50, 43, 54, 3, -42 },
  { 798, 42, 43, 43, 0, -42 },
  { 1024, 12, 15, 14, 5, -41 },
  { 1047, 24, 52, 22, 2, -43 },
  { 1203, 24, 52, 22, -4, -43 },
  { 1359, 29, 28, 31, 4, -44 },
  { 1461, 28, 29, 34, 3, -35 },
  { 1563, 15, 14, 18, -3, -7 },
  { 1590, 17, 9, 19, 1, -20 },
  { 1610, 12, 11, 18, 0, -10 },
  { 1627, 34, 43, 27, -3, -42 },
  { 1810, 31, 43, 34, 2, -42 },
  { 1977, 27, 41, 34, 4, -41 },
  { 2116, 34, 42, 34, -2, -42 },
  { 2295, 32, 43, 34, 0, -42 },
  { 2467, 33, 41, 34, 0, -41 },
  { 2637, 32, 42, 34, 1, -41 },
  { 2805, 32, 43, 34, 2, -42 },
  { 2977, 35, 41, 34, 1, -41 },
  { 3157, 32, 43, 34, 1, -42 },
  { 3329, 29, 43, 34, 3, -42 },
  { 3485, 18, 33, 18, 0, -32 },
  { 3560, 21, 39, 18, -3, -32 },
  { 3663, 28, 32, 34, 3, -37 },
  { 3775, 28, 21, 34, 3, -31 },
  { 3849, 28, 32, 34, 3, -37 },
  { 3961, 26, 43, 28, 4, -42 },
  { 4101, 48, 47, 52, 2, -42 },
  { 4383, 38, 41, 39, -3, -41 },
  { 4578, 35, 41, 37, 1, -41 },
  { 4758, 36, 43, 37, 3, -42 },
  { 4952, 37, 41, 40, 1, -41 },
  { 5142, 33, 41, 33, 1, -41 },
  { 5312, 33, 41, 33, 1, -41 },
  { 5482, 37, 43, 40, 3, -42 },
  { 5681, 41, 41, 41, 1, -41 },
  { 5892, 30, 41, 25, -2, -41 },
  { 6046, 31, 54, 22, -9, -41 },
  { 6256, 42, 41, 39, 1, -41 },
  { 6472, 26, 41, 31, 1, -41 },
  { 6606, 52, 41, 53, 1, -41 },
  { 6873, 45, 41, 46, 1, -41 },
  { 7104, 38, 43, 43, 3, -42 },
  { 7309, 34, 41, 36, 1, -41 },
  { 7484, 38, 52, 43, 3, -42 },
  { 7731, 34, 41, 38, 1, -41 },
  { 7906, 31, 43, 32, 1, -42 },
  { 8073, 32, 41, 32, 4, -41 },
  { 8237, 37, 42, 41, 4, -41 },
  { 8432, 36, 41, 36, 4, -41 },
  { 8617, 55, 41, 54, 4, -41 },
  { 8899, 47, 41, 38, -4, -41 },
  { 9140, 35, 41, 35, 5, -41 },
  { 9320, 38, 41, 31, -3, -41 },
  { 9515, 27, 53, 21, -2, -43 },
  { 9694, 16, 43, 27, 6, -42 },
  { 9780, 26, 53, 21, -4, -43 },
  { 9953, 31, 27, 31, 0, -41 },
  { 10058, 28, 7, 26, -5, 4 },
  { 10083, 14, 9, 20, 8, -44 },
  { 10099, 33, 34, 35, 2, -33 },
  { 10240, 32, 45, 35, 1, -44 },
  { 10420, 28, 34, 29, 2, -33 },
  { 10539, 35, 45, 35, 2, -44 },
  { 10736, 30, 34, 34, 2, -33 },
  { 10864, 36, 58, 24, -6, -44 },
  { 11125, 34, 47, 35, 1, -33 },
  { 11325, 32, 44, 36, 1, -44 },
  { 11501, 20, 45, 19, 1, -45 },
  { 11614, 28, 59, 19, -7, -45 },
  { 11821, 38, 44, 36, 1, -44 },
  { 12030, 20, 44, 19, 1, -44 },
  { 12140, 50, 33, 54, 1, -33 },
  { 12347, 32, 33, 36, 1, -33 },
  { 12479, 31, 34, 35, 2, -33 },
  { 12611, 35, 47, 35, -2, -33 },
  { 12817, 33, 47, 35, 2, -33 },
  { 13011, 27, 33, 25, 1, -33 },
  { 13123, 27, 34, 29, 1, -33 },
  { 13238, 25, 40, 27, 2, -39 },
  { 13363, 32, 33, 36, 3, -32 },
  { 13495, 33, 32, 32, 2, -32 },
  { 13627, 48, 32, 48, 3, -32 },
  { 13819, 40, 32, 33, -3, -32 },
  { 13979, 39, 46, 32, -4, -32 },
  { 14204, 30, 32, 28, -1, -32 },
  { 14324, 25, 50, 21, 0, -41 },
  { 14481, 7, 57, 33, 13, -44 },
  { 14531, 24, 50, 21, -3, -41 },
  { 14681, 28, 11, 34, 3, -26 },
};

const GFXfont NotoSans_BlackItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_BLACKITALIC58PT7B_H_
