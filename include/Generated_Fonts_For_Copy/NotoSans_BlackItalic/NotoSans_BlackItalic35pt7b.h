#ifndef _NOTOSANS_BLACKITALIC35PT7B_H_
#define _NOTOSANS_BLACKITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7C, 0x00, 0x7E, 0x7E, 0xFC, 0xF9, 0xF1, 0xF3, 0xE7, 0xE7, 0xCF,
  0x8F, 0x9F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF0, 0x00, 0x7C, 0x78, 0x00,
  0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x1E,
  0x3E, 0x00, 0x7C, 0x78, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0x1F, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0xF8, 0xF0,
  0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0,
  0x3E, 0x7C, 0x00, 0x78, 0xF8, 0x01, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF0, 0xFF, 0xFE, 0x3F, 0x38, 0x47, 0xEE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0x3E, 0x40, 0xE7, 0xCF, 0x1D, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0xC0, 0x1E,
  0x03, 0xFF, 0x00, 0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0x7C, 0xF8, 0x3E, 0x01,
  0xF3, 0xE0, 0xF8, 0x0F, 0x8F, 0x87, 0xC0, 0x3E, 0x3E, 0x3E, 0x00, 0xF8,
  0xF9, 0xF0, 0x03, 0xE7, 0xC7, 0xC0, 0x0F, 0x9F, 0x3E, 0x7F, 0x3F, 0xFD,
  0xF3, 0xFE, 0xFF, 0xEF, 0x9F, 0xF9, 0xFF, 0x3E, 0xFF, 0xF3, 0xF9, 0xF3,
  0xE7, 0xC0, 0x0F, 0x9F, 0x1F, 0x00, 0x7C, 0x7C, 0x7C, 0x01, 0xF1, 0xF1,
  0xF0, 0x0F, 0x87, 0xCF, 0x80, 0x7C, 0x1F, 0x3E, 0x03, 0xE0, 0x7C, 0xF8,
  0x0F, 0x81, 0xFF, 0xC0, 0x7C, 0x07, 0xFF, 0x03, 0xE0, 0x0F, 0xF8, 0x1F,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE3, 0xF1, 0xFF, 0xC3, 0xF9, 0xFF, 0xF1, 0xFD, 0xFF,
  0xFD, 0xFC, 0xFE, 0xFE, 0xFE, 0xFE, 0x3F, 0xFE, 0x7F, 0x0F, 0xFE, 0x3F,
  0x87, 0xFF, 0x1F, 0xE1, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFD, 0xFE, 0x00, 0x7E, 0xFD,
  0xF3, 0xE7, 0xCF, 0xBE, 0x7C, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0x80,
  0x00, 0xFC, 0x00, 0x7C, 0x08, 0x3E, 0x07, 0x1E, 0x03, 0xEF, 0x03, 0xFF,
  0x87, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE7, 0xFE, 0x17,
  0xFF, 0x07, 0xF7, 0x80, 0xF3, 0xE0, 0x31, 0xF8, 0x08, 0x70, 0x00, 0x40,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x1F, 0xC7, 0xE3, 0xF8, 0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xF0,
  0xF8, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x3F, 0xEF, 0xFC, 0x3C, 0xFF, 0xFF,
  0xFF, 0xEF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x9F, 0x8F,
  0xE3, 0xF9, 0xFC, 0x7F, 0x7F, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF,
  0x07, 0xFF, 0xE0, 0xFD, 0xFC, 0x1F, 0xBF, 0x87, 0xF7, 0xF0, 0xFE, 0xFE,
  0x1F, 0xDF, 0xC7, 0xF3, 0xF8, 0xFE, 0x7F, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x01,
  0xFC, 0x0F, 0xF8, 0x7F, 0xF1, 0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0x7F, 0x7E,
  0x7D, 0xFC, 0xE3, 0xF0, 0x87, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x3F,
  0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7E, 0xFF, 0x03,
  0x87, 0xF0, 0x10, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0E,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFA, 0x00, 0x7F, 0x70, 0x1F, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xFC,
  0x07, 0xFF, 0xC0, 0xFD, 0xF8, 0x1F, 0x9F, 0x81, 0xF1, 0xF8, 0x3E, 0x3F,
  0x87, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x80,
  0x1F, 0xCE, 0x03, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x18, 0x07, 0xF7, 0xF0, 0x7E, 0xFF, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF,
  0xE1, 0xFC, 0xFE, 0x1F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE1,
  0xFF, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0xCF, 0xC3,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xF9, 0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF,
  0xFB, 0xF9, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0x7E, 0x7F, 0x7E,
  0x0E, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x90, 0x7F, 0xCF, 0xFF, 0xC7, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0x01, 0xF8, 0x3F,
  0x8F, 0xF1, 0xFC, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x03, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3E, 0x00,
  0x00, 0xC0, 0x1F, 0x80, 0xFE, 0x0F, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80,
  0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xC0,
  0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x01, 0xFC, 0x00,
  0xF8, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xF3, 0xFF,
  0xF7, 0xFF, 0xF7, 0xFF, 0xEF, 0x0F, 0xD0, 0x1F, 0x80, 0x7F, 0x01, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0xF8, 0x7E, 0x07, 0x07, 0xE7, 0xE1, 0xFF, 0x9F, 0x3E,
  0x1F, 0xFC, 0xF9, 0xE1, 0xFF, 0xE3, 0xDF, 0x1F, 0x9F, 0x1E, 0xF9, 0xF8,
  0xF0, 0xF7, 0x8F, 0x87, 0x87, 0xBC, 0x78, 0x7C, 0x3F, 0xE7, 0xC3, 0xE3,
  0xFF, 0x3E, 0x1E, 0x1E, 0xF9, 0xF1, 0xF1, 0xF7, 0xCF, 0xDF, 0x9F, 0x1E,
  0x3F, 0xFF, 0xF8, 0xF1, 0xFE, 0xFF, 0x87, 0xC7, 0xE7, 0xF0, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x06, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F,
  0x8F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF8, 0x07,
  0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0xFE, 0x00, 0x7E,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x87, 0xE3, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0xC7, 0xF0,
  0xFE, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF8, 0xFC, 0x7F, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xF0, 0xF8, 0xFF, 0x00,
  0x8F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x21, 0xFF, 0x0F, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0x3F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1,
  0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC,
  0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFE, 0x7F, 0x07, 0xF9, 0xFC,
  0x1F, 0xC7, 0xF0, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xC3, 0xC3, 0xFC, 0x01, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE3, 0xFF, 0xBF, 0x8F, 0xFE,
  0xFE, 0x3F, 0xF3, 0xF8, 0xFF, 0xCF, 0xE3, 0xFF, 0x3F, 0x9F, 0xFC, 0xFE,
  0x07, 0xF3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0xE3, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E,
  0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7E, 0x07, 0xF0,
  0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x0F, 0xE0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x3F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x83, 0xF0,
  0x7F, 0x83, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7E,
  0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F,
  0xDF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0x9F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xFE,
  0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFC, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x01, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0x7C, 0x1F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7D, 0xF1, 0xF7, 0xE1, 0xFB,
  0xE3, 0xEF, 0xC3, 0xF7, 0xCF, 0xBF, 0x07, 0xEF, 0x9F, 0x7E, 0x0F, 0xDF,
  0x7C, 0xFC, 0x1F, 0xBE, 0xF9, 0xF8, 0x7E, 0x7F, 0xE7, 0xE0, 0xFC, 0xFF,
  0xCF, 0xC1, 0xF9, 0xFF, 0x1F, 0x83, 0xF3, 0xFE, 0x3F, 0x07, 0xC7, 0xF8,
  0x7E, 0x1F, 0x8F, 0xF1, 0xF8, 0x3F, 0x1F, 0xE3, 0xF0, 0x7E, 0x3F, 0x87,
  0xE0, 0xFC, 0x7F, 0x0F, 0xC0, 0x07, 0xF8, 0x07, 0xE0, 0xFF, 0x00, 0xFC,
  0x3F, 0xE0, 0x3F, 0x07, 0xFE, 0x07, 0xE0, 0xFF, 0xC0, 0xFC, 0x1F, 0xF8,
  0x1F, 0x87, 0xFF, 0x87, 0xE0, 0xFF, 0xF0, 0xFC, 0x1F, 0xFE, 0x1F, 0x83,
  0xEF, 0xC3, 0xF0, 0x7C, 0xFC, 0x7E, 0x1F, 0x9F, 0x9F, 0x83, 0xF3, 0xF3,
  0xF0, 0x7E, 0x3F, 0x7E, 0x0F, 0xC7, 0xEF, 0xC1, 0xF8, 0xFD, 0xF8, 0x7E,
  0x1F, 0xBE, 0x0F, 0xC1, 0xFF, 0xC1, 0xF8, 0x3F, 0xF8, 0x3F, 0x07, 0xFF,
  0x07, 0xC0, 0x7F, 0xE1, 0xF8, 0x0F, 0xF8, 0x3F, 0x01, 0xFF, 0x07, 0xE0,
  0x3F, 0xE0, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x8F,
  0xF0, 0x7F, 0x3F, 0xC0, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80,
  0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x1F,
  0xE7, 0xFC, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0xFF, 0x1F, 0xC7, 0xF1,
  0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xFC, 0x7F, 0x1F, 0x8F, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xF0,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3,
  0xFE, 0x7F, 0x8F, 0xF0, 0x7F, 0x3F, 0xC0, 0x7F, 0x7F, 0x00, 0xFE, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xDF, 0xC0,
  0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07,
  0xF3, 0xF8, 0x1F, 0xC7, 0xFC, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFC, 0x7F, 0x1F, 0xC3, 0xF1, 0xFC, 0x3F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x8F, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0x3F, 0x07, 0xF3, 0xF8,
  0x7F, 0x3F, 0x87, 0xE1, 0xFC, 0x7E, 0x1F, 0xCF, 0xE1, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE0, 0xFE, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0x87, 0x0F, 0xE0, 0x21, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xE2, 0x01, 0xFC, 0x78, 0x7F, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF0,
  0xFE, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E, 0x1F,
  0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x7F, 0x03,
  0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF9, 0xFE,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x01, 0xFD, 0xF8,
  0x0F, 0xCF, 0xC0, 0xFE, 0x7E, 0x07, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF0,
  0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xE7,
  0xE0, 0x3F, 0x7F, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x7D, 0xF8, 0x03,
  0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0xFE, 0x03, 0xF0, 0x3F, 0xBF, 0x03, 0xF8, 0x1F, 0xDF, 0x81, 0xFC,
  0x0F, 0xCF, 0xC1, 0xFE, 0x0F, 0xE7, 0xE0, 0xFF, 0x07, 0xE3, 0xF0, 0x7F,
  0x83, 0xF1, 0xF8, 0x7F, 0xC3, 0xF0, 0xFC, 0x3F, 0xE1, 0xF8, 0x7E, 0x3F,
  0xF1, 0xFC, 0x3F, 0x1F, 0xF8, 0xFC, 0x1F, 0x9F, 0x7C, 0x7E, 0x0F, 0xCF,
  0xBE, 0x7E, 0x07, 0xEF, 0xDF, 0x3F, 0x03, 0xF7, 0xCF, 0xBF, 0x01, 0xFB,
  0xE7, 0xDF, 0x80, 0xFF, 0xE3, 0xEF, 0xC0, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F,
  0xF8, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07,
  0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x81, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x1F,
  0xC7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xBF, 0x83, 0xF8, 0xFC, 0x1F, 0xC7, 0xE1, 0xFC, 0x3F, 0x9F,
  0xC0, 0xFC, 0xFE, 0x07, 0xEF, 0xE0, 0x3F, 0x7E, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xF8, 0x7C, 0x3F, 0x1F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7E, 0x3F, 0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC,
  0x7E, 0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0x0F, 0x80,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xCF, 0x03, 0xE3, 0xC0, 0xF8,
  0xF8, 0x7C, 0x3E, 0x3E, 0x07, 0x8F, 0x81, 0xF7, 0xC0, 0x7F, 0xF0, 0x0F,
  0x7F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0xFE, 0x7E, 0x7E,
  0x3F, 0x1F, 0x0F, 0x01, 0xC0, 0x00, 0x7F, 0x3F, 0x0F, 0xFB, 0xE1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x8F, 0xE7, 0xF0, 0xFC, 0x7F,
  0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE1, 0xFC, 0xFE, 0x1F, 0x8F,
  0xE1, 0xF8, 0xFF, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0x3F, 0xDF, 0x01, 0xFB, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x70, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xF3,
  0xF0, 0x7F, 0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xE3, 0xF9, 0xFC,
  0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xDF, 0xF0, 0xFC, 0xFC,
  0x00, 0x00, 0x78, 0x01, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xF1,
  0xFF, 0xF0, 0xFE, 0x08, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x30, 0xFF, 0xF8, 0x7F,
  0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x38, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x0F,
  0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x87, 0xF1, 0xFC, 0x3F,
  0x0F, 0xE1, 0xF8, 0x7F, 0x9F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x01, 0xFE, 0xF8, 0x07, 0xEF, 0xC0, 0x00, 0x78, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x1F, 0xCF, 0xE3, 0xF3,
  0xF8, 0x7E, 0x7F, 0x7F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F,
  0xFF, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x83, 0xFD, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFE, 0x40,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0xCF, 0xC1, 0xFF, 0x7C, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1,
  0xF8, 0x7E, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xFE, 0x7F, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x83, 0x01, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x78, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xE3, 0xF8, 0xFE,
  0x3F, 0x0F, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x1F,
  0xC7, 0xE1, 0xFC, 0xFE, 0x1F, 0xC0, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x1F, 0xC7, 0xF8, 0x3F,
  0x0F, 0xE0, 0x7E, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xEF,
  0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0xC7, 0xF0,
  0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xC0,
  0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x60,
  0x1F, 0xBF, 0xC7, 0xF0, 0x3F, 0xFF, 0x9F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xF9, 0xFE, 0x3F, 0x8F,
  0xE3, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x0F, 0xE1, 0xF8, 0xFE,
  0x1F, 0xC3, 0xF1, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0xC7, 0xE1,
  0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0x7E, 0x3F, 0x87, 0xF0, 0xFC, 0x7F, 0x0F,
  0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE,
  0x1F, 0x80, 0x00, 0x03, 0x80, 0xFD, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0,
  0xFE, 0x3F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF1, 0xFC, 0x7E,
  0x1F, 0xCF, 0xE1, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xBF, 0xCF, 0xE3, 0xFB, 0xF8, 0x7F, 0x7F,
  0x0F, 0xEF, 0xE1, 0xFD, 0xF8, 0x3F, 0xFF, 0x07, 0xEF, 0xE1, 0xFD, 0xFC,
  0x3F, 0x9F, 0x8F, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x3F, 0x7F, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0x8F, 0xE1, 0xF8,
  0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xE1,
  0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x3F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xDF, 0xE0, 0xFE, 0x7C, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x3F, 0x0F,
  0xFB, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x8F, 0xE7,
  0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE1, 0xFC,
  0xFE, 0x1F, 0x8F, 0xE1, 0xF8, 0xFF, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF,
  0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xF7, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x87, 0xEF, 0xC3, 0xF7, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x01,
  0xE0, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0x0C, 0x7F,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x03,
  0xFC, 0x01, 0xFC, 0x81, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x01, 0xFF,
  0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x21, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F,
  0x87, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xF0, 0xFC, 0xFE,
  0x1F, 0x9F, 0x87, 0xF3, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xF3, 0xF8,
  0xFE, 0x7E, 0x1F, 0xCF, 0xC3, 0xF9, 0xFC, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xF7, 0xE0, 0xFC, 0xF8, 0x00, 0xFE, 0x07, 0xF7,
  0xE0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE1, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF8,
  0x7E, 0x3F, 0x03, 0xE7, 0xF0, 0x3E, 0x7E, 0x03, 0xEF, 0xE0, 0x3E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0xC3,
  0xFF, 0xE1, 0xFE, 0x3F, 0xBF, 0x0F, 0xE1, 0xF9, 0xF8, 0xFF, 0x0F, 0xCF,
  0xC7, 0xF8, 0xFC, 0x7E, 0x7F, 0xC7, 0xE3, 0xF3, 0xDE, 0x7F, 0x1F, 0x9E,
  0xF3, 0xF0, 0xFD, 0xF7, 0x9F, 0x87, 0xEF, 0x3D, 0xF8, 0x3F, 0x79, 0xEF,
  0xC1, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFE, 0x01,
  0xFF, 0x3F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xF8,
  0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x07, 0xF1, 0xFE,
  0x03, 0xF3, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x0F, 0xEF, 0xC0, 0x1F, 0xCF, 0xE0, 0x3F, 0x8F, 0xE0, 0x7F, 0x8F, 0xE0,
  0xFF, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xF0,
  0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF9, 0xF8, 0x03,
  0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x7E,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0x80, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x01,
  0xF8,
};

const GFXglyph NotoSans_BlackItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 25, 11, 0, -25 },
  { 39, 15, 9, 16, 3, -25 },
  { 56, 23, 25, 23, 0, -25 },
  { 128, 19, 29, 20, 1, -27 },
  { 197, 30, 25, 33, 2, -25 },
  { 291, 25, 25, 26, 0, -25 },
  { 370, 7, 9, 8, 3, -25 },
  { 378, 14, 32, 13, 1, -26 },
  { 434, 14, 32, 13, -2, -26 },
  { 490, 17, 18, 19, 3, -27 },
  { 529, 17, 17, 21, 2, -21 },
  { 566, 10, 9, 11, -2, -4 },
  { 578, 11, 5, 12, 0, -12 },
  { 585, 7, 6, 11, 0, -6 },
  { 591, 21, 25, 16, -2, -25 },
  { 657, 19, 25, 20, 1, -25 },
  { 717, 15, 25, 20, 3, -25 },
  { 764, 20, 25, 20, -1, -25 },
  { 827, 19, 25, 20, 0, -25 },
  { 887, 20, 25, 20, 0, -25 },
  { 950, 20, 25, 20, 0, -25 },
  { 1013, 20, 25, 20, 1, -25 },
  { 1076, 21, 25, 20, 1, -25 },
  { 1142, 19, 25, 20, 1, -25 },
  { 1202, 17, 25, 20, 2, -25 },
  { 1256, 11, 20, 11, 0, -20 },
  { 1284, 13, 25, 11, -2, -20 },
  { 1325, 17, 19, 21, 2, -22 },
  { 1366, 17, 13, 21, 2, -19 },
  { 1394, 17, 19, 21, 2, -22 },
  { 1435, 15, 25, 17, 3, -25 },
  { 1482, 29, 28, 31, 1, -25 },
  { 1584, 23, 25, 24, -2, -25 },
  { 1656, 21, 25, 22, 1, -25 },
  { 1722, 21, 25, 22, 2, -25 },
  { 1788, 22, 25, 24, 1, -25 },
  { 1857, 20, 25, 20, 1, -25 },
  { 1920, 20, 25, 20, 1, -25 },
  { 1983, 22, 25, 24, 2, -25 },
  { 2052, 24, 25, 25, 1, -25 },
  { 2127, 18, 25, 15, -1, -25 },
  { 2184, 19, 33, 13, -6, -25 },
  { 2263, 25, 25, 23, 1, -25 },
  { 2342, 16, 25, 18, 1, -25 },
  { 2392, 31, 25, 32, 1, -25 },
  { 2489, 27, 25, 28, 1, -25 },
  { 2574, 23, 25, 26, 2, -25 },
  { 2646, 20, 25, 22, 1, -25 },
  { 2709, 23, 31, 26, 2, -25 },
  { 2799, 20, 25, 23, 1, -25 },
  { 2862, 19, 25, 19, 1, -25 },
  { 2922, 18, 25, 19, 3, -25 },
  { 2979, 23, 25, 25, 2, -25 },
  { 3051, 21, 25, 22, 3, -25 },
  { 3117, 33, 25, 33, 3, -25 },
  { 3221, 28, 25, 23, -2, -25 },
  { 3309, 21, 25, 21, 3, -25 },
  { 3375, 23, 25, 19, -2, -25 },
  { 3447, 16, 32, 13, -1, -26 },
  { 3511, 9, 25, 16, 4, -25 },
  { 3540, 15, 32, 13, -2, -26 },
  { 3600, 18, 16, 19, 0, -25 },
  { 3636, 17, 4, 16, -3, 2 },
  { 3645, 8, 6, 12, 5, -27 },
  { 3651, 20, 20, 21, 1, -20 },
  { 3701, 20, 27, 21, 0, -27 },
  { 3769, 17, 20, 18, 1, -20 },
  { 3812, 21, 27, 21, 1, -27 },
  { 3883, 19, 20, 20, 1, -20 },
  { 3931, 22, 35, 14, -4, -27 },
  { 4028, 21, 28, 21, 0, -20 },
  { 4102, 20, 27, 22, 0, -27 },
  { 4170, 12, 27, 11, 0, -27 },
  { 4211, 18, 35, 11, -5, -27 },
  { 4290, 23, 27, 22, 0, -27 },
  { 4368, 13, 27, 11, 0, -27 },
  { 4412, 31, 20, 32, 0, -20 },
  { 4490, 20, 20, 22, 0, -20 },
  { 4540, 19, 20, 21, 1, -20 },
  { 4588, 21, 28, 21, -1, -20 },
  { 4662, 20, 28, 21, 1, -20 },
  { 4732, 17, 20, 15, 0, -20 },
  { 4775, 16, 20, 18, 1, -20 },
  { 4815, 15, 23, 16, 1, -23 },
  { 4859, 19, 19, 22, 2, -19 },
  { 4905, 20, 19, 19, 1, -19 },
  { 4953, 29, 19, 29, 2, -19 },
  { 5022, 24, 19, 20, -2, -19 },
  { 5079, 23, 27, 19, -2, -19 },
  { 5157, 19, 19, 17, -1, -19 },
  { 5203, 15, 31, 13, 0, -25 },
  { 5262, 4, 34, 20, 8, -26 },
  { 5279, 15, 31, 13, -2, -25 },
  { 5338, 17, 7, 21, 2, -16 },
};

const GFXfont NotoSans_BlackItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_BLACKITALIC35PT7B_H_
