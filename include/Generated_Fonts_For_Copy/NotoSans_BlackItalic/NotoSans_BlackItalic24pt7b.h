#ifndef _NOTOSANS_BLACKITALIC24PT7B_H_
#define _NOTOSANS_BLACKITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x78,
  0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF0, 0x7B, 0xDE, 0xF7, 0x3B, 0xCE, 0xF7,
  0xB9, 0xE0, 0x03, 0x9E, 0x03, 0x9C, 0x03, 0x9C, 0x07, 0x3C, 0x3F, 0xFF,
  0x3F, 0xFF, 0x7F, 0xFF, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0xFF, 0xFE,
  0xFF, 0xFE, 0x1C, 0xE0, 0x3C, 0xE0, 0x39, 0xC0, 0x39, 0xC0, 0x79, 0xC0,
  0x01, 0x80, 0x1E, 0x07, 0xFE, 0x7F, 0xE7, 0xFF, 0x3D, 0x89, 0xEC, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x6F, 0x63, 0xF3, 0xFF,
  0x9F, 0xF8, 0xFF, 0x80, 0x60, 0x06, 0x00, 0x1F, 0x01, 0xE1, 0xFC, 0x1C,
  0x1F, 0xE1, 0xE0, 0xE7, 0x1E, 0x07, 0x38, 0xE0, 0x79, 0xCE, 0x03, 0xDE,
  0xF1, 0x1F, 0xEF, 0x7E, 0x7F, 0x77, 0xF3, 0xF7, 0x3B, 0xC0, 0x7B, 0xDE,
  0x03, 0x9E, 0xF0, 0x38, 0xE7, 0x83, 0xC7, 0x38, 0x3C, 0x3F, 0xC1, 0xC1,
  0xFC, 0x3C, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xE7,
  0x81, 0xE3, 0xC0, 0xFB, 0xC0, 0x3F, 0xE0, 0x1F, 0xCF, 0x3F, 0xC7, 0xBF,
  0xF7, 0xFE, 0xFF, 0xDF, 0x3F, 0xEF, 0x8F, 0xE7, 0xE7, 0xE3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7B, 0xDD, 0xEF, 0x70, 0x03, 0xC1, 0xE0,
  0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x1E,
  0x00, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC1,
  0xE0, 0xF0, 0x38, 0x3E, 0x00, 0x07, 0x80, 0x70, 0x47, 0x0F, 0x70, 0xFF,
  0xF7, 0xFF, 0x1F, 0xE3, 0xF0, 0xFF, 0x07, 0x38, 0x13, 0x80, 0x20, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x3D, 0xF7, 0x9E, 0xF3, 0xC0, 0x7E, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0xFF,
  0x0F, 0xFC, 0x7D, 0xE7, 0xCF, 0x3C, 0x7F, 0xE3, 0xFF, 0x1E, 0xF8, 0xF7,
  0x8F, 0xBC, 0x7D, 0xE3, 0xEF, 0x3E, 0x7F, 0xF3, 0xFF, 0x0F, 0xF0, 0x3F,
  0x00, 0x03, 0xE1, 0xF8, 0x7F, 0x3F, 0xEF, 0xFD, 0xEF, 0x19, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xC3, 0xFF, 0x04, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xFF, 0xE7, 0xFF, 0x9F, 0xFC, 0xFF, 0xF0, 0x0F, 0xE1, 0xFF, 0xC7, 0xFE,
  0x39, 0xF0, 0x07, 0x80, 0x7C, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x7F, 0x80,
  0x7C, 0x01, 0xE8, 0x0F, 0x79, 0xFB, 0xFF, 0xDF, 0xFC, 0x7F, 0x80, 0x00,
  0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07,
  0xBC, 0x3D, 0xF1, 0xE7, 0xC7, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFE,
  0x1E, 0x00, 0x78, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x4F, 0xC0, 0x0F,
  0x00, 0x3C, 0x81, 0xF3, 0xCF, 0xCF, 0xFE, 0x3F, 0xF8, 0x7F, 0x80, 0x07,
  0xF8, 0x7F, 0xC7, 0xFE, 0x7F, 0x17, 0xC0, 0x3C, 0x01, 0xFF, 0x9E, 0xFC,
  0xFF, 0xF7, 0xCF, 0xBE, 0x7D, 0xE3, 0xEF, 0x1F, 0x7D, 0xF1, 0xFF, 0x8F,
  0xF8, 0x3F, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0xFF, 0x8F, 0xFC, 0x79, 0xF3, 0xCF, 0x1E, 0x78, 0xFF, 0x83, 0xF8,
  0x1F, 0xC3, 0xFF, 0x3E, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0xFF, 0x9F,
  0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xFE, 0x7F, 0xF7, 0xDF, 0xF8, 0xFF, 0x8F,
  0xF9, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0x3F, 0xF0, 0x1E, 0x03, 0xE9, 0xFC,
  0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0x1E, 0x7C, 0xF8, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xF3, 0xE7, 0xCF, 0x00, 0x0F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xE0, 0x00, 0x30, 0x0F,
  0x03, 0xF0, 0xFE, 0x3F, 0x8F, 0xE0, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x03, 0xF0, 0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x0F, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF0, 0x7F, 0x3F, 0xCF, 0xF0, 0xFC, 0x0E,
  0x00, 0x80, 0x00, 0x7F, 0xBF, 0xFF, 0xFD, 0xCF, 0x43, 0xC1, 0xF0, 0xF8,
  0xFC, 0x3E, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x0F, 0x83, 0xE0, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0x87, 0xC3, 0xE0, 0x1E, 0x38,
  0x38, 0xE7, 0x9F, 0xEF, 0x73, 0xFE, 0x7F, 0x39, 0xC7, 0xE7, 0x9C, 0x7E,
  0x71, 0xCF, 0xE7, 0x3C, 0xEE, 0x73, 0xDE, 0xE7, 0xFF, 0xCF, 0x7F, 0xF8,
  0x71, 0x04, 0x07, 0x80, 0x40, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xDE, 0x03, 0xDE, 0x07,
  0xDE, 0x07, 0x9E, 0x0F, 0x9E, 0x0F, 0x1E, 0x1F, 0x1E, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0x0F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xF8, 0xFB, 0xF1, 0xF3, 0xE3, 0xC7, 0xC7, 0xFF,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xF1, 0xF1, 0xE3, 0xE7, 0xC7, 0xCF,
  0xFF, 0x1F, 0xFE, 0x3F, 0xF8, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xFC, 0x7F,
  0xF1, 0xFD, 0xE3, 0xE0, 0x4F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x81, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F,
  0x3E, 0x1E, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3C,
  0x3E, 0x3C, 0x3E, 0x7C, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x80, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC7, 0xFE, 0x1F, 0x00, 0x78, 0x01,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF,
  0xC7, 0xFE, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFE, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xDC, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x79, 0xFE, 0xF9, 0xFC, 0xF9, 0xFC, 0xF9, 0xFC, 0xF8,
  0x7C, 0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F,
  0x87, 0x87, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xE1, 0xF0, 0xF0, 0xF0, 0xF8,
  0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0x0F, 0x87, 0x87,
  0xC7, 0xC3, 0xE3, 0xE1, 0xE1, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0x7C, 0x00,
  0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x81, 0xFE,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x27, 0xE1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0x8F, 0xC3, 0xC7, 0xE1, 0xF3, 0xF0, 0x7C,
  0xF8, 0x1F, 0x7C, 0x07, 0xBE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07,
  0xC7, 0xC1, 0xE1, 0xF0, 0xF8, 0x7E, 0x00, 0x0F, 0x81, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07,
  0xC0, 0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0xE0, 0x0F, 0xC1, 0xFC, 0x3F, 0x07,
  0xF1, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE1,
  0xFC, 0x7F, 0x8F, 0x73, 0xFC, 0x3D, 0xCE, 0xF0, 0xF7, 0x7B, 0xC3, 0xDD,
  0xCF, 0x0F, 0x7F, 0x78, 0x79, 0xF9, 0xE1, 0xE7, 0xE7, 0x87, 0x9F, 0x1E,
  0x1E, 0x7C, 0xF8, 0xF9, 0xE3, 0xC0, 0x0F, 0xC1, 0xE1, 0xF8, 0x3C, 0x7F,
  0x0F, 0x8F, 0xE1, 0xE1, 0xFE, 0x3C, 0x3F, 0xC7, 0x87, 0x78, 0xF1, 0xEF,
  0xBC, 0x3C, 0xF7, 0x87, 0x9E, 0xF0, 0xF3, 0xDE, 0x1E, 0x3F, 0xC7, 0x87,
  0xF0, 0xF0, 0xFE, 0x1E, 0x1F, 0xC3, 0xC1, 0xF8, 0xF8, 0x3F, 0x00, 0x03,
  0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xBF, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8,
  0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xF3, 0xE3, 0xC7, 0xC7, 0x8F, 0x9F, 0x7E,
  0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0x81, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F,
  0xFF, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x0F,
  0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0xFB, 0xF1, 0xF3, 0xE3, 0xC7, 0xC7, 0x9F,
  0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xEF, 0x87, 0xCF, 0x0F,
  0x9F, 0x1F, 0x1E, 0x3C, 0x3E, 0xF8, 0x7C, 0x07, 0xF8, 0x7F, 0xC7, 0xFE,
  0x7E, 0xE3, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xC8, 0x1E, 0x7F, 0xF3, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xE1, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x00, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1E, 0x3E, 0x1E, 0x3E,
  0x3E, 0x3C, 0x3E, 0x3C, 0x3E, 0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x7C, 0x78,
  0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xC0, 0xF0, 0x7F, 0xE0, 0xFB, 0xC1, 0xE7, 0x87, 0xCF, 0x0F, 0x1E, 0x3E,
  0x3C, 0x78, 0x79, 0xF0, 0xFB, 0xC1, 0xF7, 0x81, 0xFE, 0x03, 0xFC, 0x07,
  0x70, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x78, 0x3F,
  0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xBC, 0x3E, 0x3E, 0xF1, 0xF8, 0xF3, 0xC7,
  0xE3, 0xCF, 0x3F, 0x9F, 0x3C, 0xEE, 0x78, 0xF7, 0xB9, 0xE3, 0xDE, 0xEF,
  0x0F, 0x73, 0xBC, 0x3F, 0xCF, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F,
  0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x00, 0x0F, 0x87, 0xE1, 0xF1,
  0xF8, 0x3E, 0x3E, 0x03, 0xCF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBE,
  0x01, 0xF7, 0xC0, 0x7C, 0xF8, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E,
  0x00, 0xF8, 0x7F, 0xE3, 0xE7, 0x8F, 0x9E, 0x7C, 0x79, 0xE1, 0xFF, 0x83,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0x3F, 0xFE, 0x7F,
  0xF8, 0xFF, 0xF0, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3F, 0x07, 0xE1, 0xFC, 0x00, 0xE3, 0xCF,
  0x3C, 0xF1, 0xC7, 0x1E, 0x79, 0xE7, 0x9E, 0x38, 0xF3, 0xCF, 0x3C, 0x07,
  0xE0, 0xFC, 0x1F, 0x84, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x38, 0x3F, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0xFE, 0x07, 0x70, 0x73, 0x87, 0x9E, 0x38, 0x73, 0x83, 0xBC, 0x1E,
  0xFF, 0xFF, 0xFC, 0xF8, 0xF3, 0xC0, 0x04, 0x00, 0xFB, 0xCF, 0xFE, 0xFF,
  0xF7, 0xCF, 0xBC, 0x7B, 0xE3, 0xDF, 0x1E, 0xF9, 0xF7, 0xCF, 0x3E, 0xF9,
  0xFF, 0xC7, 0xFE, 0x3E, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x40, 0x7B, 0xC1, 0xFF, 0x8F, 0xFE, 0x3E, 0x7C, 0xF1, 0xF3, 0xC7,
  0xCF, 0x1E, 0x7C, 0xF9, 0xF3, 0xE7, 0xDF, 0x1F, 0xFC, 0x7F, 0xE3, 0xDF,
  0x00, 0x01, 0x03, 0xFC, 0xFF, 0xBF, 0xF7, 0xC5, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xF6, 0x7F, 0xC7, 0xF8, 0x7F, 0x00, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x04, 0x78, 0x7D, 0xE3, 0xFF, 0x9F, 0xFE, 0x7C,
  0xF9, 0xE3, 0xCF, 0x8F, 0x3E, 0x3C, 0xF9, 0xF3, 0xE7, 0x8F, 0xBE, 0x3F,
  0xF8, 0x7F, 0xE1, 0xF7, 0x80, 0x01, 0x00, 0xFE, 0x3F, 0xF3, 0xFF, 0x7C,
  0xF7, 0x8F, 0xFF, 0xFF, 0xFE, 0xFF, 0x8F, 0x80, 0xF8, 0x4F, 0xFC, 0x7F,
  0xC3, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x03, 0xC0, 0x3F,
  0xE1, 0xFF, 0x07, 0xFC, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3C, 0x00, 0x02, 0x00, 0x3E, 0xF1,
  0xFF, 0xCF, 0xFF, 0x3E, 0x7C, 0xF1, 0xE7, 0xC7, 0x9F, 0x1E, 0x7C, 0xF9,
  0xF3, 0xC7, 0xDF, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x1E, 0x20, 0xF8,
  0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x20, 0x7B, 0xE1, 0xFF, 0x8F, 0xFF, 0x3E, 0x7C, 0xF9,
  0xF3, 0xC7, 0xCF, 0x1E, 0x7C, 0x79, 0xF3, 0xE7, 0xCF, 0x9E, 0x3E, 0x78,
  0xF3, 0xE7, 0xC0, 0x02, 0x07, 0x83, 0xE1, 0xE0, 0x00, 0x00, 0x7C, 0x3C,
  0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3E,
  0x00, 0x00, 0x40, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x3F, 0x1E, 0x7C, 0x3E, 0x78, 0x3E, 0xF8, 0x3D, 0xF0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7D, 0xF0, 0x78, 0xF0, 0x78,
  0xF8, 0xF8, 0xFC, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C,
  0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x00,
  0x00, 0x20, 0x40, 0xF7, 0xCF, 0x87, 0xFE, 0xFE, 0x7F, 0xFF, 0xF3, 0xE7,
  0xEF, 0x9F, 0x3E, 0x7C, 0xF1, 0xF3, 0xE7, 0x8F, 0x1F, 0x7C, 0x78, 0xFB,
  0xE7, 0xC7, 0x9F, 0x3E, 0x3C, 0xF1, 0xF3, 0xE7, 0x8F, 0x1F, 0x7C, 0x78,
  0xF0, 0x00, 0x20, 0x7F, 0xE1, 0xFF, 0x8F, 0xFF, 0x3E, 0x7C, 0xF9, 0xF3,
  0xC7, 0xCF, 0x1E, 0x7C, 0x79, 0xF3, 0xE7, 0xCF, 0x9E, 0x3E, 0x78, 0xF3,
  0xE7, 0xC0, 0x01, 0x00, 0x7F, 0x0F, 0xFC, 0x7F, 0xE7, 0xCF, 0x3C, 0x7F,
  0xE3, 0xFF, 0x1E, 0xF9, 0xF7, 0xCF, 0xBE, 0xF9, 0xFF, 0xC7, 0xFC, 0x1F,
  0x80, 0x00, 0x20, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xF3, 0xE3, 0xC7,
  0xC7, 0x8F, 0x8F, 0x1E, 0x3E, 0x3C, 0x7C, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3,
  0xFF, 0x0F, 0xBC, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x04, 0x00, 0xFB, 0xCF, 0xFE, 0xFF, 0xF7, 0xCF, 0xBC,
  0x7B, 0xE3, 0xDF, 0x1E, 0xF9, 0xF7, 0xCF, 0x3E, 0xF9, 0xFF, 0xC7, 0xFE,
  0x1F, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x31, 0xEE, 0x1F, 0xE3, 0xFE, 0x3F, 0xE3, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x01, 0x01, 0xFF,
  0x3F, 0xE3, 0xFE, 0x3C, 0x23, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x3C,
  0xC3, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0x0E, 0x03, 0x81, 0xE1, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xFB, 0x3F, 0xCF,
  0xF1, 0xFC, 0x3C, 0x7C, 0xF1, 0xE7, 0xC7, 0x9F, 0x3E, 0x78, 0xF9, 0xE3,
  0xCF, 0x8F, 0x3E, 0x7C, 0xF9, 0xF3, 0xEF, 0xCF, 0xFE, 0x1F, 0xF8, 0x7D,
  0xE0, 0xF8, 0xFF, 0xC7, 0xFE, 0x7C, 0xF3, 0xC7, 0xBE, 0x3D, 0xE1, 0xFF,
  0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0x7C, 0x03, 0xE0, 0x00, 0xF1,
  0xF1, 0xFF, 0x1F, 0x1E, 0xF1, 0xF3, 0xEF, 0x3F, 0x3C, 0xF3, 0xF3, 0xC7,
  0x7F, 0x78, 0x77, 0x77, 0x87, 0x77, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x00, 0x1F, 0x3F, 0x1F, 0x3E,
  0x0F, 0x7C, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x3E, 0xF0, 0x7C, 0xF8, 0xF8, 0xF8, 0x1F, 0x1F,
  0x1F, 0x1E, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x3E, 0x07, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xC0, 0x03, 0xC1, 0xF0, 0xFC,
  0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x7E, 0x3F, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x07, 0xC1, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xF0, 0x78, 0x7E, 0x1E,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x3E, 0x0F, 0x83, 0xC0, 0xC0, 0x00, 0x38,
  0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0x81, 0xE0,
};

const GFXglyph NotoSans_BlackItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 17, 7, 0, -17 },
  { 18, 10, 6, 11, 2, -17 },
  { 26, 16, 17, 16, 0, -17 },
  { 60, 13, 19, 14, 1, -18 },
  { 91, 21, 17, 22, 1, -17 },
  { 136, 17, 17, 18, 0, -17 },
  { 173, 5, 6, 6, 2, -17 },
  { 177, 10, 22, 9, 1, -18 },
  { 205, 10, 22, 9, -2, -18 },
  { 233, 12, 12, 13, 2, -18 },
  { 251, 12, 11, 14, 1, -14 },
  { 268, 6, 6, 7, -1, -3 },
  { 273, 7, 3, 8, 0, -8 },
  { 276, 5, 4, 7, 0, -4 },
  { 279, 14, 17, 11, -1, -17 },
  { 309, 13, 17, 14, 1, -17 },
  { 337, 11, 17, 14, 2, -17 },
  { 361, 14, 17, 14, -1, -17 },
  { 391, 13, 17, 14, 0, -17 },
  { 419, 14, 17, 14, 0, -17 },
  { 449, 14, 17, 14, 0, -17 },
  { 479, 13, 17, 14, 1, -17 },
  { 507, 15, 17, 14, 0, -17 },
  { 539, 13, 17, 14, 1, -17 },
  { 567, 12, 17, 14, 1, -17 },
  { 593, 7, 13, 7, 0, -13 },
  { 605, 8, 16, 7, -1, -13 },
  { 621, 12, 13, 14, 1, -15 },
  { 641, 12, 9, 14, 1, -13 },
  { 655, 12, 13, 14, 1, -15 },
  { 675, 10, 17, 12, 2, -17 },
  { 697, 20, 19, 22, 1, -17 },
  { 745, 16, 17, 16, -1, -17 },
  { 779, 15, 17, 15, 0, -17 },
  { 811, 15, 17, 15, 1, -17 },
  { 843, 16, 17, 16, 0, -17 },
  { 877, 14, 17, 13, 0, -17 },
  { 907, 14, 17, 14, 0, -17 },
  { 937, 16, 17, 17, 1, -17 },
  { 971, 17, 17, 17, 0, -17 },
  { 1008, 13, 17, 10, -1, -17 },
  { 1036, 13, 22, 9, -4, -17 },
  { 1072, 18, 17, 16, 0, -17 },
  { 1111, 11, 17, 13, 0, -17 },
  { 1135, 22, 17, 22, 0, -17 },
  { 1182, 19, 17, 19, 0, -17 },
  { 1223, 16, 17, 18, 1, -17 },
  { 1257, 15, 17, 15, 0, -17 },
  { 1289, 16, 21, 18, 1, -17 },
  { 1331, 15, 17, 16, 0, -17 },
  { 1363, 13, 17, 13, 0, -17 },
  { 1391, 13, 17, 13, 2, -17 },
  { 1419, 16, 17, 17, 1, -17 },
  { 1453, 15, 17, 15, 2, -17 },
  { 1485, 22, 17, 22, 2, -17 },
  { 1532, 19, 17, 16, -1, -17 },
  { 1573, 14, 17, 15, 2, -17 },
  { 1603, 15, 17, 13, -1, -17 },
  { 1635, 11, 22, 9, -1, -18 },
  { 1666, 6, 17, 11, 3, -17 },
  { 1679, 11, 22, 9, -2, -18 },
  { 1710, 13, 11, 13, 0, -17 },
  { 1728, 11, 2, 11, -2, 2 },
  { 1731, 6, 3, 8, 3, -18 },
  { 1734, 13, 14, 15, 1, -14 },
  { 1757, 14, 18, 15, 0, -18 },
  { 1789, 11, 14, 12, 1, -14 },
  { 1809, 14, 18, 15, 1, -18 },
  { 1841, 12, 14, 14, 1, -14 },
  { 1862, 14, 24, 10, -2, -18 },
  { 1904, 14, 20, 15, 0, -14 },
  { 1939, 14, 18, 15, 0, -18 },
  { 1971, 9, 19, 8, 0, -19 },
  { 1993, 12, 25, 8, -3, -19 },
  { 2031, 16, 18, 15, 0, -18 },
  { 2067, 9, 18, 8, 0, -18 },
  { 2088, 21, 14, 22, 0, -14 },
  { 2125, 14, 14, 15, 0, -14 },
  { 2150, 13, 14, 15, 1, -14 },
  { 2173, 15, 20, 15, -1, -14 },
  { 2211, 13, 20, 15, 1, -14 },
  { 2244, 12, 14, 10, 0, -14 },
  { 2265, 12, 14, 12, 0, -14 },
  { 2286, 10, 16, 11, 1, -16 },
  { 2306, 14, 13, 15, 1, -13 },
  { 2329, 13, 13, 13, 1, -13 },
  { 2351, 20, 13, 20, 1, -13 },
  { 2384, 16, 13, 14, -1, -13 },
  { 2410, 16, 19, 13, -2, -13 },
  { 2448, 12, 13, 12, 0, -13 },
  { 2468, 10, 21, 9, 0, -17 },
  { 2495, 3, 23, 14, 5, -18 },
  { 2504, 10, 21, 9, -1, -17 },
  { 2531, 12, 5, 14, 1, -11 },
};

const GFXfont NotoSans_BlackItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_BLACKITALIC24PT7B_H_
