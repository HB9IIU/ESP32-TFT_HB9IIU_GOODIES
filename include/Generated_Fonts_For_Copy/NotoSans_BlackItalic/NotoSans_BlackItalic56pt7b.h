#ifndef _NOTOSANS_BLACKITALIC56PT7B_H_
#define _NOTOSANS_BLACKITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x7F, 0xC7, 0xFC, 0xFF, 0x8F, 0xFB,
  0xFE, 0x1F, 0xE7, 0xFC, 0x7F, 0xCF, 0xF8, 0xFF, 0x9F, 0xE1, 0xFE, 0x3F,
  0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xC7, 0xF8,
  0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFD,
  0xF1, 0xF0, 0x7F, 0xE7, 0xC0, 0xC1, 0xFF, 0x9E, 0x00, 0x07, 0xFE, 0x78,
  0x00, 0x1F, 0xFB, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0x3F, 0xE0, 0x00, 0x3C, 0xFF, 0x88, 0x01, 0xF3, 0xFE, 0x38, 0x07, 0xCF,
  0xF8, 0xFC, 0x1F, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0xE7, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x07, 0xF8, 0x00,
  0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x00,
  0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0x00,
  0xFF, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF1, 0xFE, 0x01, 0x00,
  0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xF0, 0xFF, 0xBF, 0xE3, 0xFC, 0x7F, 0xF8,
  0xFF, 0xFF, 0xE7, 0xF8, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xF1, 0xFF, 0xFE,
  0x7F, 0xFF, 0x8F, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xE7, 0xFF, 0xFE,
  0x1F, 0xFE, 0x3F, 0xC7, 0xFC, 0xFF, 0x0F, 0xFC, 0x7F, 0x8F, 0xF8, 0xFF,
  0x01, 0x80, 0x7F, 0x8F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFF,
  0x00, 0x01, 0xFE, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0xFF,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE,
  0x00, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE7, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x20, 0x1F, 0xFF, 0xF8, 0x7F,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F,
  0xFF, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFC, 0x3F, 0xFC, 0xFF, 0xEF, 0xFE, 0x1F, 0xFC, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x7F, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0xBF, 0xE7,
  0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0x00, 0xFF, 0x00, 0x3C,
  0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xFE, 0xFC,
  0x00, 0x7F, 0xFF, 0xC7, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFE, 0x3E, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xF7, 0xF0, 0x07, 0xFF, 0x7F, 0x80, 0x1F, 0xE3, 0xF8, 0x00, 0xFC,
  0x3F, 0xC0, 0x03, 0x83, 0xFC, 0x00, 0x18, 0x3F, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x07,
  0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x83, 0xFE, 0x7F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xE7, 0xF8, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC,
  0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x1F,
  0xFC, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xDF, 0xFC, 0x07, 0xFF,
  0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0x9F,
  0xF8, 0x07, 0xFE, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xEF, 0xFE,
  0x03, 0xFF, 0xBF, 0xF8, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF, 0x81,
  0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0x3F, 0xF0, 0x1F, 0xFC, 0xFF, 0xC0, 0xFF,
  0xE3, 0xFF, 0x83, 0xFF, 0x8F, 0xFC, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xF7, 0xFE, 0x0F, 0xF1, 0xFF, 0x83,
  0xF8, 0xFF, 0xE0, 0x78, 0x3F, 0xF0, 0x0C, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xC1, 0xFF, 0xE0, 0x07, 0x80,
  0x7F, 0xE0, 0x01, 0x80, 0x3F, 0xF0, 0x00, 0x80, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xF0, 0x3F, 0xFC, 0x01, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x20, 0x00,
  0x0F, 0xFE, 0x70, 0x00, 0x3F, 0xFC, 0xFC, 0x01, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0x3F, 0xF0, 0x01, 0xFE, 0x3F,
  0xF0, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xF0, 0x0F, 0xF8, 0x7F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x10, 0x00, 0x1F, 0xFE, 0x30, 0x00, 0x7F,
  0xF8, 0x7C, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x10, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x1F, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0x80, 0xFF, 0xDF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F,
  0xF8, 0xFF, 0xF0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x81, 0xFF,
  0xC7, 0xFF, 0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE,
  0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x8F, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xC7, 0xFE, 0x01,
  0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x01,
  0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x0F,
  0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x7F, 0xF0, 0x7F, 0xF7, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x7F, 0xE1,
  0xFF, 0xE7, 0xFE, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x01, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x8F, 0xC1, 0xFF, 0xC7, 0x00, 0x7F, 0xE2, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0xFC, 0x3F,
  0xC3, 0xFC, 0x07, 0xFF, 0xFC, 0x7F, 0x87, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F,
  0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0xFE, 0x3F, 0xC1, 0xFF, 0xFF, 0xE1, 0xFC,
  0x7F, 0x07, 0xFE, 0x3F, 0x83, 0xF9, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xFB,
  0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xCF,
  0xE1, 0xFE, 0x07, 0xF0, 0x3F, 0x9F, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F, 0x7F,
  0x87, 0xF0, 0x1F, 0xC0, 0xFE, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFD, 0xFC,
  0x3F, 0xC0, 0xFE, 0x07, 0xF3, 0xF8, 0x7F, 0x81, 0xFC, 0x1F, 0xE7, 0xF0,
  0xFF, 0x07, 0xF8, 0x3F, 0x8F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x1F, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x87,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x07, 0xFF, 0xBF, 0xFF, 0x00, 0xFF, 0x07,
  0xFE, 0x3F, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x0F, 0xFD,
  0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF,
  0x80, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xE0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00,
  0x3F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xF8, 0x01, 0xE0, 0x7F, 0xFC, 0x00,
  0x18, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x02, 0x01, 0xFF, 0xE0,
  0x07, 0x80, 0x7F, 0xFE, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE,
  0x0F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF,
  0x80, 0x7F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC7, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0x01, 0xFF, 0xF0, 0x00, 0x10, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0xF8, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8F, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x30,
  0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xFC,
  0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x01,
  0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x7F, 0xF3,
  0xFF, 0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0xE0,
  0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x87, 0xFF, 0x80, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xF7, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0xFF, 0x80, 0x7F,
  0xDF, 0xE0, 0x7F, 0xBF, 0xE0, 0x1F, 0xF7, 0xF8, 0x1F, 0xDF, 0xF8, 0x07,
  0xFD, 0xFE, 0x0F, 0xF7, 0xFE, 0x01, 0xFF, 0x7F, 0x83, 0xFD, 0xFF, 0x00,
  0xFF, 0xDF, 0xE1, 0xFE, 0x7F, 0xC0, 0x3F, 0xF7, 0xF8, 0x7F, 0xBF, 0xF0,
  0x0F, 0xF9, 0xFE, 0x3F, 0xCF, 0xFC, 0x03, 0xFE, 0x7F, 0x8F, 0xF3, 0xFF,
  0x00, 0xFF, 0x9F, 0xE7, 0xF8, 0xFF, 0x80, 0x7F, 0xE7, 0xF9, 0xFE, 0x3F,
  0xE0, 0x1F, 0xF9, 0xFE, 0x7F, 0x1F, 0xF8, 0x07, 0xFC, 0x7F, 0xBF, 0xC7,
  0xFE, 0x01, 0xFF, 0x1F, 0xEF, 0xE1, 0xFF, 0x80, 0x7F, 0xC7, 0xFF, 0xF8,
  0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xFF,
  0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFF,
  0xE0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F,
  0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0,
  0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xF8, 0x03,
  0xFD, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xDF, 0xF8, 0x1F, 0xF8, 0x07, 0xFD,
  0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0xFF,
  0xC3, 0xFF, 0x00, 0x7F, 0xCF, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xC3,
  0xFF, 0x00, 0xFF, 0xC7, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE3, 0xFE,
  0x00, 0xFF, 0x87, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE7, 0xFE, 0x01,
  0xFF, 0x83, 0xFF, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF7, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC,
  0x3F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFF, 0x7F,
  0xF8, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xF0,
  0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00,
  0x3F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xFC, 0x7F,
  0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x9F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC,
  0x3F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFF, 0x7F,
  0xF0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xF0,
  0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00,
  0x7F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xFC, 0x7F,
  0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x5F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x1F, 0xFC,
  0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F,
  0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xC7, 0xFE, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0x1F, 0x80, 0x7F, 0xE0, 0x0E, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xC2, 0x00, 0x07, 0xFF, 0x0C, 0x00, 0x1F, 0xFC, 0x3E, 0x00,
  0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x01,
  0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF8,
  0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xC0,
  0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0x80, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFD, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0x80, 0x7F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x7F, 0x87, 0xFE, 0x00, 0xFF, 0x87, 0xFB,
  0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xDF, 0xE3, 0xFF, 0x00, 0x3F, 0xE3,
  0xFC, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x3F, 0xE7, 0xF8, 0xFF, 0x80, 0x0F,
  0xF9, 0xFE, 0x3F, 0xCF, 0xFC, 0x00, 0x7F, 0xCF, 0xF1, 0xFE, 0x7F, 0xE0,
  0x03, 0xFE, 0xFF, 0x8F, 0xF3, 0xFE, 0x00, 0x1F, 0xF7, 0xF8, 0x7F, 0xBF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC3, 0xFD, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xEF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xEF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF,
  0xDF, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x3F,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x07, 0xFE,
  0x1F, 0xFC, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x0F,
  0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F,
  0xBF, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x87,
  0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC3,
  0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFB, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0,
  0xFF, 0x03, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x03,
  0xFF, 0x8F, 0xF8, 0x0F, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF, 0xBF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC0,
  0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x07,
  0xFE, 0x3F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F,
  0xE3, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0x0F, 0xFE, 0x07, 0xFE,
  0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xF0, 0x07,
  0xFF, 0xBF, 0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x30, 0x00, 0x3F, 0xF3,
  0xFC, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF,
  0xC3, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0x0F, 0xF8, 0x0F, 0xFE,
  0x3F, 0xF0, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1,
  0xFF, 0x01, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0x1F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF,
  0xE3, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF,
  0xFF, 0x01, 0xFF, 0x3F, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xE0,
  0xFF, 0xF0, 0x04, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x03, 0x03, 0xFF, 0x81, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x18, 0x1F, 0xFC, 0x00, 0x3F, 0xC7,
  0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x1F, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF,
  0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x0F,
  0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x7F, 0x80,
  0x07, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x1F, 0xF8, 0xFF, 0xE0,
  0xFF, 0xCF, 0xFE, 0x07, 0xFE, 0x7F, 0xF0, 0x3F, 0xF3, 0xFF, 0x03, 0xFF,
  0xBF, 0xF8, 0x7F, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x02,
  0x0F, 0xFE, 0x00, 0x60, 0x7F, 0xF8, 0x1F, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xE1, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x04, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0x00, 0xFF, 0xF9, 0xFF, 0x01, 0xFF,
  0xFD, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0,
  0x1F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x03, 0xF8,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x80, 0x03, 0xFF, 0x80, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x18, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x7F, 0xEF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x87,
  0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F,
  0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0xC7, 0xFF,
  0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x81,
  0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x1F,
  0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x87, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x7F, 0xF0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x01,
  0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x80, 0x03,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x7F, 0xF8, 0x3F, 0xFC, 0x03,
  0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x07,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x0F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF9, 0xFF, 0xE0, 0x1F, 0xE7, 0xFF, 0xE0, 0x7F, 0xDF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0xC7,
  0xFF, 0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF,
  0x81, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8,
  0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0x80,
  0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x0F,
  0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF,
  0xC1, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0,
  0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x3F,
  0xFB, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x0F, 0xFE,
  0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0x1F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xFB, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xF9,
  0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC,
  0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xF8, 0x01, 0xFF, 0x9F, 0xFC,
  0x00, 0x7F, 0xE3, 0xFC, 0x00, 0x3F, 0xF8, 0x10, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFF, 0x8F,
  0xF8, 0x0F, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xC3,
  0xFF, 0x81, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x07, 0xFE, 0x3F,
  0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF,
  0x80, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x7F,
  0xE0, 0x03, 0xFC, 0xFF, 0xC0, 0x01, 0x83, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0xFF, 0x87, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF3, 0xFE, 0x07, 0xFD, 0xFF,
  0x81, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0x07, 0xFF, 0x01,
  0x81, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x88, 0x00, 0x7F, 0xE3, 0x00, 0x3F, 0xF8, 0xFC, 0x1F,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0,
  0x7F, 0xF1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x8F, 0xFE, 0x07,
  0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F,
  0xF0, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x03, 0xFF,
  0x8F, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8,
  0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x87,
  0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xF8, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xEF, 0xF8, 0x07, 0xFF, 0x9F, 0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xE0,
  0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE1,
  0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xBF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xCF, 0xFC, 0x1F, 0xFF, 0x07, 0xFE, 0x3F, 0xF0,
  0xFF, 0xFC, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0x7F, 0x1F, 0xF8, 0x3F, 0xF1, 0xFD,
  0xFC, 0x7F, 0xE0, 0x7F, 0xC7, 0xF7, 0xF1, 0xFF, 0x01, 0xFF, 0x3F, 0x9F,
  0xCF, 0xFC, 0x07, 0xFC, 0xFE, 0x7F, 0x3F, 0xE0, 0x1F, 0xF7, 0xFB, 0xFD,
  0xFF, 0x80, 0x7F, 0xDF, 0xCF, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0x3F, 0x9F,
  0xF0, 0x07, 0xFF, 0xFC, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xE3, 0xFB, 0xFE,
  0x00, 0x7F, 0xBF, 0x8F, 0xEF, 0xF8, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x07, 0xFF,
  0x3F, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x07,
  0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0xE1, 0xFF,
  0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFE, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x01,
  0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03,
  0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFE,
  0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x2F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xD0, 0x00, 0x7F, 0xF2, 0x00, 0x00, 0x20, 0x00,
};

const GFXglyph NotoSans_BlackItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 19, 41, 17, 0, -40 },
  { 99, 23, 14, 25, 5, -40 },
  { 140, 37, 40, 36, 0, -40 },
  { 325, 30, 46, 32, 2, -43 },
  { 498, 48, 42, 52, 3, -41 },
  { 750, 41, 42, 41, 0, -41 },
  { 966, 11, 14, 13, 5, -40 },
  { 986, 23, 50, 21, 2, -41 },
  { 1130, 23, 50, 21, -4, -41 },
  { 1274, 28, 28, 30, 4, -43 },
  { 1372, 27, 27, 33, 3, -33 },
  { 1464, 15, 14, 17, -3, -7 },
  { 1491, 16, 8, 18, 1, -19 },
  { 1507, 12, 11, 17, 0, -10 },
  { 1524, 32, 42, 26, -2, -41 },
  { 1692, 30, 42, 32, 2, -41 },
  { 1850, 26, 40, 32, 4, -40 },
  { 1980, 33, 41, 32, -2, -41 },
  { 2150, 31, 42, 32, 0, -41 },
  { 2313, 32, 40, 32, 0, -40 },
  { 2473, 31, 41, 32, 1, -40 },
  { 2632, 31, 42, 32, 2, -41 },
  { 2795, 34, 40, 32, 1, -40 },
  { 2965, 31, 42, 32, 1, -41 },
  { 3128, 28, 42, 32, 3, -41 },
  { 3275, 17, 32, 17, 0, -31 },
  { 3343, 20, 38, 17, -3, -31 },
  { 3438, 27, 31, 33, 3, -36 },
  { 3543, 27, 20, 33, 3, -30 },
  { 3611, 27, 31, 33, 3, -36 },
  { 3716, 25, 42, 27, 4, -41 },
  { 3848, 47, 46, 50, 2, -41 },
  { 4119, 37, 40, 38, -3, -40 },
  { 4304, 34, 40, 36, 1, -40 },
  { 4474, 34, 42, 35, 3, -41 },
  { 4653, 36, 40, 38, 1, -40 },
  { 4833, 32, 40, 31, 1, -40 },
  { 4993, 32, 40, 32, 1, -40 },
  { 5153, 36, 42, 39, 3, -41 },
  { 5342, 39, 40, 40, 1, -40 },
  { 5537, 29, 40, 24, -2, -40 },
  { 5682, 30, 53, 21, -9, -40 },
  { 5881, 41, 40, 37, 1, -40 },
  { 6086, 25, 40, 30, 1, -40 },
  { 6211, 50, 40, 51, 1, -40 },
  { 6461, 44, 40, 44, 1, -40 },
  { 6681, 37, 42, 41, 3, -41 },
  { 6876, 33, 40, 35, 1, -40 },
  { 7041, 37, 51, 41, 3, -41 },
  { 7277, 33, 40, 36, 1, -40 },
  { 7442, 30, 42, 31, 1, -41 },
  { 7600, 30, 40, 31, 4, -40 },
  { 7750, 37, 41, 39, 3, -40 },
  { 7940, 35, 40, 35, 4, -40 },
  { 8115, 53, 40, 52, 4, -40 },
  { 8380, 44, 40, 37, -3, -40 },
  { 8600, 34, 40, 34, 4, -40 },
  { 8770, 36, 40, 30, -3, -40 },
  { 8950, 25, 50, 20, -1, -41 },
  { 9107, 15, 42, 26, 6, -41 },
  { 9186, 26, 50, 20, -4, -41 },
  { 9349, 30, 26, 30, 0, -40 },
  { 9447, 27, 6, 25, -5, 4 },
  { 9468, 13, 9, 20, 8, -43 },
  { 9483, 31, 33, 34, 2, -32 },
  { 9611, 31, 44, 34, 1, -43 },
  { 9782, 27, 33, 28, 2, -32 },
  { 9894, 34, 44, 34, 2, -43 },
  { 10081, 29, 33, 32, 2, -32 },
  { 10201, 35, 56, 23, -6, -43 },
  { 10446, 32, 45, 34, 1, -32 },
  { 10626, 31, 43, 35, 1, -43 },
  { 10793, 19, 44, 18, 1, -44 },
  { 10898, 27, 57, 18, -7, -44 },
  { 11091, 37, 43, 35, 1, -43 },
  { 11290, 19, 43, 18, 1, -43 },
  { 11393, 48, 32, 52, 1, -32 },
  { 11585, 31, 32, 35, 1, -32 },
  { 11709, 30, 33, 34, 2, -32 },
  { 11833, 34, 45, 34, -2, -32 },
  { 12025, 31, 45, 34, 2, -32 },
  { 12200, 26, 32, 24, 1, -32 },
  { 12304, 26, 33, 28, 1, -32 },
  { 12412, 24, 38, 26, 2, -37 },
  { 12526, 31, 32, 35, 3, -31 },
  { 12650, 32, 31, 30, 2, -31 },
  { 12774, 46, 31, 46, 3, -31 },
  { 12953, 38, 31, 32, -3, -31 },
  { 13101, 38, 44, 30, -4, -31 },
  { 13310, 29, 31, 27, -1, -31 },
  { 13423, 24, 49, 20, 0, -40 },
  { 13570, 7, 55, 32, 12, -42 },
  { 13619, 23, 49, 20, -3, -40 },
  { 13760, 27, 11, 33, 3, -25 },
};

const GFXfont NotoSans_BlackItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_BLACKITALIC56PT7B_H_
