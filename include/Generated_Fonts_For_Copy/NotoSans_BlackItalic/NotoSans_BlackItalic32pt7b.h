#ifndef _NOTOSANS_BLACKITALIC32PT7B_H_
#define _NOTOSANS_BLACKITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0x01, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0x00, 0x7C, 0xFB, 0xE7,
  0xDF, 0x3F, 0xF3, 0xEF, 0x9F, 0x7C, 0xFB, 0xC7, 0x9E, 0x3C, 0x00, 0xF9,
  0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE7, 0xC0, 0x1E, 0x3C, 0x00,
  0xF1, 0xE0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC1, 0xF3, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0xF9, 0xF0, 0x07, 0x8F, 0x00,
  0x3C, 0x78, 0x01, 0xE7, 0xC0, 0x1F, 0x3C, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFD, 0x9C, 0x7E, 0xC0, 0x3E, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0x9F, 0x60,
  0xDF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC0, 0x7F, 0x80,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x07, 0xFC,
  0x03, 0xC0, 0xFF, 0x80, 0xF0, 0x3F, 0xF0, 0x3E, 0x07, 0x9F, 0x0F, 0x81,
  0xF3, 0xE1, 0xE0, 0x3E, 0x7C, 0x78, 0x07, 0x8F, 0x1F, 0x00, 0xF1, 0xE7,
  0xC0, 0x1E, 0x7C, 0xF3, 0xF3, 0xFF, 0xBC, 0xFF, 0x7F, 0xEF, 0xBF, 0xE7,
  0xFB, 0xEF, 0xFE, 0x7E, 0x79, 0xF3, 0xC0, 0x1F, 0x3C, 0x78, 0x07, 0xCF,
  0x9F, 0x01, 0xF1, 0xF3, 0xE0, 0x3C, 0x3E, 0x7C, 0x0F, 0x87, 0xCF, 0x03,
  0xE0, 0xFB, 0xE0, 0xF8, 0x0F, 0xF8, 0x1E, 0x01, 0xFF, 0x07, 0xC0, 0x1F,
  0x80, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x03, 0xE7, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF9, 0xF8, 0xFF, 0xC3, 0xF3,
  0xFF, 0xCF, 0xCF, 0xFF, 0x9F, 0x9F, 0x9F, 0xFF, 0x7E, 0x3F, 0xFC, 0xFC,
  0x3F, 0xF1, 0xFC, 0x3F, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFE, 0xFE, 0x00, 0x7D, 0xF7, 0xFE, 0xFB,
  0xEF, 0x3C, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x00, 0x01, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x21, 0xE0, 0x31, 0xE0, 0x7D, 0xE0, 0x7F, 0xDF,
  0xFF, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x1F, 0xE7, 0x3F, 0xF0, 0x7E, 0xF0,
  0x3C, 0xF8, 0x0C, 0xF8, 0x00, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x1F, 0x8F, 0x8F, 0xC7, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0x7F, 0xDF, 0xF7,
  0xF9, 0xFE, 0xFF, 0x80, 0x18, 0xFB, 0xFF, 0xFF, 0xDF, 0x80, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF9, 0xFC, 0xFC, 0xFC, 0x7E, 0xFE, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E,
  0xFC, 0x7F, 0x7E, 0x3F, 0x3F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF,
  0xCF, 0xFF, 0xBF, 0xFF, 0x3F, 0x7C, 0x39, 0xF8, 0x63, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xE3,
  0xF0, 0x20, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC1, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x81,
  0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xA0, 0x0F, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFE, 0x03, 0xDF, 0x01, 0xF7, 0xC0, 0xFB, 0xF0, 0x7C, 0xFC, 0x3E, 0x3F,
  0x0F, 0x9F, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x20, 0x1F, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x1F, 0xFF, 0x87, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0xFC, 0x1F,
  0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x8F, 0xCF, 0xE3,
  0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF1, 0xF9,
  0xF8, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x3F, 0x1F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF1, 0xF9, 0xF9, 0xF8, 0x7E,
  0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x1F, 0x9F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF,
  0xC0, 0x7F, 0xC0, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFE, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xFC, 0xDF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0x00, 0x07, 0x83, 0xE1, 0xFC, 0x7F, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x1F, 0x0F, 0xE3, 0xF8, 0xFC, 0x3F, 0x00,
  0x01, 0xE0, 0x3E, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x00, 0x03, 0x00,
  0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF,
  0x80, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF0,
  0x00, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF,
  0xE6, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0xFF,
  0xC0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x8F, 0x83, 0xF8, 0xF1, 0xE1,
  0xFF, 0x9E, 0x7C, 0x7F, 0xF3, 0xEF, 0x1F, 0xBE, 0x3D, 0xE3, 0xC7, 0xC7,
  0xBC, 0xF8, 0xF0, 0xFF, 0x9E, 0x1E, 0x3D, 0xE3, 0xC3, 0xC7, 0xBC, 0x78,
  0xF8, 0xF7, 0x8F, 0x1E, 0x3C, 0xF1, 0xFF, 0xFF, 0x9F, 0x3F, 0xFF, 0xE1,
  0xE3, 0xF7, 0xF8, 0x3E, 0x38, 0x38, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F,
  0x7C, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xC0, 0x7E, 0x7F, 0x01,
  0xF9, 0xF8, 0x03, 0xEF, 0xE0, 0x0F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0x1F, 0xC7, 0xE3, 0xF8,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7E, 0xFF, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC7, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7F, 0x83, 0x9F, 0xC0, 0x23, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0xC3, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xF8, 0xFE,
  0x1F, 0x87, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF3, 0xF8, 0x3F, 0x3F, 0x03,
  0xF3, 0xF0, 0x3F, 0x3F, 0x07, 0xF3, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0,
  0xFE, 0x7E, 0x1F, 0xC7, 0xE3, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x87, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xFC, 0x0C, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x7F, 0xEF, 0xC7, 0xFE, 0xFC, 0x7F, 0xCF,
  0xC7, 0xFC, 0xFC, 0x8F, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xE1, 0xF8,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7E,
  0x1F, 0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1,
  0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x7F, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xC1, 0xFE, 0x1F, 0x83,
  0xF8, 0x3F, 0x0F, 0xE0, 0x7E, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xF1, 0xF8,
  0x07, 0xE7, 0xF0, 0x0F, 0xDF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xDF, 0x80, 0x3F, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7F, 0x03, 0xF8,
  0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x3F,
  0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0x07, 0xFE, 0x1F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0x7C, 0x3E, 0xF1, 0xF7, 0xC3, 0xEF, 0x1E,
  0xFC, 0x3E, 0xF3, 0xEF, 0xC3, 0xEF, 0x3C, 0xF8, 0x7E, 0xF7, 0xCF, 0x87,
  0xEF, 0x79, 0xF8, 0x7C, 0xFF, 0x9F, 0x87, 0xCF, 0xF9, 0xF8, 0xFC, 0xFF,
  0x1F, 0x0F, 0xCF, 0xF1, 0xF0, 0xF8, 0xFE, 0x3F, 0x0F, 0x8F, 0xE3, 0xF0,
  0xF8, 0xFC, 0x3E, 0x00, 0x0F, 0xF0, 0x1F, 0x0F, 0xF0, 0x1F, 0x0F, 0xF0,
  0x3F, 0x0F, 0xF0, 0x3F, 0x1F, 0xF8, 0x3F, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8,
  0x3E, 0x1F, 0xFC, 0x7E, 0x1F, 0xFC, 0x7E, 0x3F, 0x7C, 0x7C, 0x3E, 0x7C,
  0x7C, 0x3E, 0x7E, 0x7C, 0x3E, 0x3E, 0xFC, 0x3E, 0x3E, 0xFC, 0x7E, 0x3F,
  0xF8, 0x7E, 0x3F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0xFC, 0x1F,
  0xF8, 0xFC, 0x0F, 0xF0, 0xFC, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x1F, 0xE3, 0xF9, 0xFC, 0x0F, 0xCF, 0xE0, 0x7F, 0x7E, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E,
  0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0xFC, 0xFC, 0x0F, 0xE7, 0xF0, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F, 0xC7,
  0xE1, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFF, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xE3,
  0xF9, 0xFC, 0x0F, 0xCF, 0xE0, 0x7F, 0x7E, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x1F,
  0xDF, 0x80, 0xFC, 0xFC, 0x0F, 0xE7, 0xF0, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0x1F, 0x87, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xF3, 0xF8, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xF3,
  0xF0, 0x7E, 0x7E, 0x0F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0xCF, 0xC1,
  0xF9, 0xF8, 0x3F, 0xBF, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0xC3, 0xFF,
  0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xF8, 0x30, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x01, 0xF8, 0x80, 0xFC, 0x60, 0x7E, 0x3F, 0xFF, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xA1, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x1F,
  0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0,
  0x3F, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE3,
  0xF0, 0x7F, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0xFC, 0x7C, 0x0F,
  0xC7, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3,
  0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x07,
  0xC0, 0xFF, 0xF8, 0x1F, 0x81, 0xFB, 0xF0, 0x3F, 0x03, 0xF7, 0xE0, 0xFE,
  0x0F, 0xC7, 0xC1, 0xFC, 0x1F, 0x8F, 0x83, 0xF8, 0x7E, 0x1F, 0x0F, 0xF0,
  0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0x7C, 0x7F, 0xC7, 0xE0, 0xF8, 0xF7, 0x8F,
  0xC1, 0xF3, 0xEF, 0x3F, 0x03, 0xE7, 0xDE, 0x7E, 0x07, 0xCF, 0x3C, 0xF8,
  0x0F, 0xBE, 0x7B, 0xF0, 0x1F, 0x7C, 0xF7, 0xC0, 0x3F, 0xF1, 0xEF, 0x80,
  0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F,
  0x07, 0xF0, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x7F, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE7, 0xE0, 0x03,
  0xF9, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF0,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x0F, 0xFF, 0x83, 0xFB,
  0xF0, 0x7E, 0x7E, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0xFC, 0x1F, 0xBF, 0x81,
  0xF7, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00,
  0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0xF8, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0,
  0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x03, 0xFC, 0x0F, 0xF0, 0x7F,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0x3C, 0x0F, 0x9E, 0x07, 0x8F, 0x07, 0xC7, 0xC7, 0xC1, 0xE3, 0xC0, 0xF3,
  0xE0, 0x7B, 0xE0, 0x3E, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFD, 0xF9, 0xF1, 0xF3, 0xE3, 0xC0, 0x03, 0xC7, 0xC3, 0xFD, 0xF1, 0xFF,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xC7, 0xE7, 0xF1, 0xF9, 0xF8, 0x7E,
  0x7E, 0x1F, 0x3F, 0x87, 0xCF, 0xE3, 0xF3, 0xF0, 0xFC, 0xFE, 0x7F, 0x3F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xBE, 0x07, 0xDF, 0x00, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFD, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F,
  0x1F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF,
  0x87, 0xFF, 0xC3, 0xE3, 0xE0, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0x04, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x08, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xF3, 0xF0, 0x7F, 0x7E,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x8F, 0xC7, 0xF1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x87, 0xC7, 0xF0, 0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xE3,
  0xF9, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xEF, 0x80,
  0xFB, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF3, 0xF9,
  0xF9, 0xF8, 0xFD, 0xF8, 0x7E, 0xFD, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F,
  0xFE, 0x1F, 0x80, 0x0F, 0xC0, 0x23, 0xF0, 0x61, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xE4, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xE3, 0xE0,
  0xFF, 0x7C, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x1F, 0x8F,
  0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x8F, 0xE1, 0xF1, 0xFC, 0x7E, 0x3F,
  0x0F, 0xC7, 0xF3, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x01, 0xF7, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x0C, 0x0F, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFD, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x8F,
  0xE7, 0xE3, 0xF3, 0xF8, 0xFC, 0x01, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x03, 0x00, 0x00, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x0F,
  0xE1, 0xF8, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F,
  0x7F, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0xFC, 0x7E, 0x07, 0xE3,
  0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x0F, 0x9F, 0x07,
  0xC0, 0xFB, 0xF8, 0xFE, 0x0F, 0xFF, 0xDF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF1, 0xFC, 0xFE, 0x3F, 0x1F, 0x8F, 0xE3, 0xF1, 0xF8, 0xFC,
  0x3F, 0x3F, 0x0F, 0xC3, 0xF3, 0xF0, 0xFC, 0x3F, 0x3F, 0x0F, 0xC7, 0xE3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0x87, 0xE7, 0xE1, 0xF8, 0x7E, 0x7E, 0x1F,
  0x8F, 0xE7, 0xE1, 0xF8, 0xFC, 0x7E, 0x3F, 0x0F, 0xCF, 0xE3, 0xF0, 0xFC,
  0x0F, 0x9F, 0x03, 0xEF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0xFE,
  0x7E, 0x3F, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0xFD, 0xFC, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F,
  0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0x87, 0xEF, 0xE3, 0xF7, 0xF7, 0xF1, 0xFF,
  0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7,
  0xE1, 0xF9, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3E, 0xFE,
  0x0F, 0xCF, 0x81, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC7,
  0xC3, 0xFD, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xC7, 0xE7,
  0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x3F, 0x87, 0xCF, 0xE3, 0xF3, 0xF0,
  0xFC, 0xFE, 0x7F, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE,
  0x07, 0xDF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x9E, 0x1F,
  0x7C, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x87, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF3, 0xF9, 0xC7, 0xE0, 0x8F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE8, 0x0F, 0xDC, 0x3F, 0xBF, 0xFE, 0x7F,
  0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xFF,
  0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x1F, 0x8F, 0xE3, 0xF1, 0xF8, 0xFC,
  0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xE7,
  0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xBE, 0x07, 0xE7,
  0xC0, 0xFC, 0x0F, 0xDF, 0x07, 0xF7, 0xC1, 0xF9, 0xF8, 0xFE, 0x7E, 0x3F,
  0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xFB, 0xF0, 0x7E, 0xFC, 0x0F, 0xBE, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x7F, 0x0F, 0xFE, 0x1F, 0xC3,
  0xFF, 0x87, 0xF1, 0xFB, 0xE3, 0xFC, 0x7E, 0xF8, 0xFF, 0x3F, 0x3E, 0x3F,
  0xCF, 0xCF, 0x9E, 0xF3, 0xE3, 0xE7, 0xFD, 0xF8, 0xFB, 0xFF, 0x7C, 0x3E,
  0xF7, 0xBF, 0x0F, 0xBD, 0xEF, 0x83, 0xFF, 0x7B, 0xE0, 0xFF, 0x9F, 0xF0,
  0x3F, 0xE7, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x1F,
  0xC0, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x1F, 0x8F, 0xE0, 0x7E,
  0x3F, 0x01, 0xFD, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0x7E, 0x01, 0xF9, 0xF8, 0x0F, 0xE7,
  0xE0, 0x7F, 0x1F, 0xC3, 0xFC, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0xFC, 0x1F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F,
  0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xE1, 0xFF, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xF1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x80, 0x1F, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xFC, 0x07,
  0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3E,
  0x00, 0x3F, 0x01, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x80,
  0x38,
};

const GFXglyph NotoSans_BlackItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 23, 10, 0, -23 },
  { 33, 13, 8, 15, 3, -23 },
  { 46, 21, 23, 21, 0, -23 },
  { 107, 17, 26, 19, 1, -24 },
  { 163, 27, 23, 30, 2, -23 },
  { 241, 23, 23, 23, 0, -23 },
  { 308, 6, 8, 8, 3, -23 },
  { 314, 13, 28, 12, 1, -23 },
  { 360, 13, 28, 12, -2, -23 },
  { 406, 16, 16, 17, 2, -25 },
  { 438, 16, 15, 19, 1, -19 },
  { 468, 9, 8, 10, -2, -4 },
  { 477, 10, 5, 11, 0, -11 },
  { 484, 7, 6, 10, 0, -6 },
  { 490, 18, 23, 15, -1, -23 },
  { 542, 17, 23, 19, 1, -23 },
  { 591, 15, 23, 19, 2, -23 },
  { 635, 18, 23, 19, -1, -23 },
  { 687, 18, 23, 19, 0, -23 },
  { 739, 18, 23, 19, 0, -23 },
  { 791, 18, 23, 19, 0, -23 },
  { 843, 18, 23, 19, 1, -23 },
  { 895, 19, 23, 19, 1, -23 },
  { 950, 17, 23, 19, 1, -23 },
  { 999, 16, 23, 19, 2, -23 },
  { 1045, 10, 18, 10, 0, -18 },
  { 1068, 12, 22, 10, -2, -18 },
  { 1101, 16, 17, 19, 1, -20 },
  { 1135, 16, 11, 19, 1, -17 },
  { 1157, 16, 17, 19, 1, -20 },
  { 1191, 15, 23, 16, 2, -23 },
  { 1235, 27, 26, 29, 1, -23 },
  { 1323, 22, 23, 22, -2, -23 },
  { 1387, 19, 23, 20, 1, -23 },
  { 1442, 19, 23, 20, 2, -23 },
  { 1497, 20, 23, 22, 1, -23 },
  { 1555, 18, 23, 18, 1, -23 },
  { 1607, 18, 23, 18, 1, -23 },
  { 1659, 20, 23, 22, 2, -23 },
  { 1717, 22, 23, 23, 1, -23 },
  { 1781, 16, 23, 14, -1, -23 },
  { 1827, 17, 30, 12, -5, -23 },
  { 1891, 23, 23, 21, 1, -23 },
  { 1958, 14, 23, 17, 1, -23 },
  { 1999, 28, 23, 29, 1, -23 },
  { 2080, 24, 23, 25, 1, -23 },
  { 2149, 21, 23, 24, 2, -23 },
  { 2210, 19, 23, 20, 1, -23 },
  { 2265, 21, 28, 24, 2, -23 },
  { 2339, 19, 23, 21, 1, -23 },
  { 2394, 17, 23, 18, 1, -23 },
  { 2443, 18, 23, 18, 2, -23 },
  { 2495, 21, 23, 22, 2, -23 },
  { 2556, 20, 23, 20, 2, -23 },
  { 2614, 31, 23, 30, 2, -23 },
  { 2704, 26, 23, 21, -2, -23 },
  { 2779, 19, 23, 19, 3, -23 },
  { 2834, 20, 23, 17, -1, -23 },
  { 2892, 15, 28, 12, -1, -23 },
  { 2945, 9, 23, 15, 3, -23 },
  { 2971, 14, 28, 12, -2, -23 },
  { 3020, 17, 15, 17, 0, -23 },
  { 3052, 16, 4, 14, -3, 2 },
  { 3060, 7, 6, 11, 5, -25 },
  { 3066, 18, 18, 19, 1, -18 },
  { 3107, 18, 24, 19, 0, -24 },
  { 3161, 16, 18, 16, 1, -18 },
  { 3197, 19, 24, 19, 1, -24 },
  { 3254, 17, 18, 19, 1, -18 },
  { 3293, 19, 32, 13, -3, -24 },
  { 3369, 19, 26, 19, 0, -18 },
  { 3431, 18, 24, 20, 0, -24 },
  { 3485, 11, 25, 10, 0, -25 },
  { 3520, 15, 33, 10, -4, -25 },
  { 3582, 21, 24, 20, 0, -24 },
  { 3645, 12, 24, 10, 0, -24 },
  { 3681, 28, 18, 30, 0, -18 },
  { 3744, 18, 18, 20, 0, -18 },
  { 3785, 17, 18, 19, 1, -18 },
  { 3824, 19, 26, 19, -1, -18 },
  { 3886, 18, 26, 19, 1, -18 },
  { 3945, 15, 18, 14, 0, -18 },
  { 3979, 15, 18, 16, 0, -18 },
  { 4013, 14, 21, 15, 1, -21 },
  { 4050, 19, 18, 20, 1, -18 },
  { 4093, 18, 18, 17, 1, -18 },
  { 4134, 26, 18, 26, 2, -18 },
  { 4193, 22, 18, 18, -2, -18 },
  { 4243, 21, 26, 17, -2, -18 },
  { 4312, 17, 18, 16, -1, -18 },
  { 4351, 14, 28, 11, 0, -23 },
  { 4400, 4, 31, 18, 7, -24 },
  { 4416, 14, 28, 11, -2, -23 },
  { 4465, 16, 6, 19, 1, -14 },
};

const GFXfont NotoSans_BlackItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_BLACKITALIC32PT7B_H_
