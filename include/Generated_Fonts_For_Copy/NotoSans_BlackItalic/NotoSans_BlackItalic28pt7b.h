#ifndef _NOTOSANS_BLACKITALIC28PT7B_H_
#define _NOTOSANS_BLACKITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x7C, 0x3F, 0x0F,
  0xC1, 0xE0, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0xF1,
  0xC0, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x1C, 0x01, 0xE7, 0x80, 0x3C,
  0xF0, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0xE3,
  0x80, 0x3C, 0xF0, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE0, 0xF3, 0xC0, 0x1C, 0x70, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x70,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x1F, 0xF0, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF,
  0x8F, 0x70, 0x1E, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0x80, 0x6F, 0x80, 0xDF, 0x61, 0xBE, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF,
  0xC3, 0xFE, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x1F, 0x00, 0x78,
  0x7F, 0x01, 0xE1, 0xFF, 0x07, 0x87, 0xDE, 0x1E, 0x0F, 0x3C, 0x3C, 0x1E,
  0x78, 0xF0, 0x3C, 0xF3, 0xC0, 0x7B, 0xEF, 0x00, 0xF7, 0x9E, 0xFD, 0xFF,
  0x7B, 0xFF, 0xFD, 0xEF, 0xFB, 0xF7, 0x9E, 0xF0, 0x0F, 0x7D, 0xE0, 0x3C,
  0xF3, 0xC0, 0xF1, 0xE7, 0x83, 0xC3, 0xCF, 0x07, 0x87, 0xBE, 0x1E, 0x0F,
  0xF8, 0x78, 0x0F, 0xE1, 0xE0, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0xFD, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0xBF,
  0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x1F, 0x3F, 0xF3, 0xF7, 0xFF,
  0xBE, 0xFD, 0xFF, 0xEF, 0xCF, 0xFC, 0xF8, 0x7F, 0xCF, 0xC3, 0xF8, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFE, 0xFE, 0x7D, 0xF7, 0x9E,
  0x79, 0xEF, 0x00, 0x01, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F,
  0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x3C, 0x00, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0xFC,
  0x00, 0x03, 0xC0, 0x0F, 0x04, 0x3C, 0x1C, 0xE0, 0x7F, 0x87, 0xFF, 0xF3,
  0xFF, 0xC3, 0xFF, 0x3F, 0xC5, 0xFF, 0x07, 0xDE, 0x06, 0x78, 0x09, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x3E, 0xF9, 0xF3, 0xCF, 0x9E, 0x3C, 0x00, 0x7F, 0xBF, 0xDF, 0xCF,
  0xEF, 0xF0, 0x3B, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xF7, 0xEF, 0xCF, 0xDF, 0x1F, 0xBE,
  0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE1, 0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0x1F,
  0xBE, 0x3E, 0x7C, 0xFC, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0x81, 0xFC, 0x00,
  0x00, 0xF8, 0x1F, 0x83, 0xFC, 0x3F, 0xE7, 0xFF, 0x7F, 0xF9, 0xFF, 0x8E,
  0x7C, 0x23, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0x3F, 0x06, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF,
  0xFC, 0x07, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0xC3, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x7E, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x60, 0x7E, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF,
  0xC3, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x7C, 0x1F, 0x7C, 0x3E,
  0x7C, 0x7C, 0xF8, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFE, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x10, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0xC0, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x01,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF3, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0xF8, 0x7B, 0xF9, 0xFF, 0xFB, 0xFF, 0xF7, 0xE3, 0xEF, 0xC7, 0xDF,
  0x0F, 0xBE, 0x3F, 0x7E, 0x7E, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFE,
  0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF2, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xF8,
  0x7F, 0xF1, 0xFF, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x1F, 0xFE, 0x1F,
  0xF8, 0x1F, 0xC0, 0xFF, 0xC3, 0xFF, 0xCF, 0xCF, 0x9F, 0x1F, 0xBE, 0x1F,
  0x7C, 0x7C, 0xFF, 0xF9, 0xFF, 0xF1, 0xFF, 0xC1, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xE7, 0xCF, 0x8F, 0x9F, 0x1F, 0xFE,
  0x3F, 0xFC, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE3, 0xF7, 0xC0, 0x1F,
  0x00, 0x7E, 0x01, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x00,
  0x06, 0x1F, 0x1F, 0x1F, 0x1F, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0xFC, 0xFC, 0xFC, 0xF8, 0x01, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0xF8,
  0x3C, 0x1F, 0x07, 0x83, 0xC0, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F,
  0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x1F, 0xF1, 0xFF, 0x3F, 0xE0,
  0xFE, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x3F, 0xC7, 0xFF, 0x1F, 0xFC,
  0xFF, 0xE7, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7C, 0x07, 0xE1, 0xE0, 0x03, 0xC7, 0x83, 0xE3, 0xCF, 0x1F, 0xF7,
  0xBC, 0x7F, 0xC7, 0x71, 0xF7, 0x8F, 0xE7, 0x8F, 0x1F, 0xCF, 0x1E, 0x3F,
  0x9E, 0x38, 0xFF, 0x38, 0xF1, 0xFE, 0x79, 0xE7, 0xBC, 0xFF, 0xFE, 0x79,
  0xFF, 0xF8, 0x79, 0xF3, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x04, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x1F,
  0x0F, 0x03, 0xE1, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x3E, 0x03, 0xE7, 0xC0, 0x7D, 0xF8, 0x0F, 0xFE, 0x01, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xF9, 0xF8, 0x7C, 0x7C,
  0x7E, 0x3E, 0x3E, 0x7E, 0x1F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF,
  0xE3, 0xE3, 0xF1, 0xF0, 0xF8, 0xF8, 0xFC, 0xFC, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x3F, 0xC7, 0x0F, 0xC0, 0x43, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x70, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0x9F, 0xC3, 0xE3, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7,
  0xC1, 0xF3, 0xF0, 0x7C, 0xFC, 0x3F, 0x3E, 0x0F, 0xCF, 0x87, 0xE3, 0xE1,
  0xF9, 0xFB, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x80,
  0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xC3, 0x8F, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x7F, 0x9F, 0x1F, 0xE7, 0xC7, 0xFB,
  0xF3, 0xFE, 0xFC, 0x1F, 0x3F, 0x07, 0xC7, 0xC1, 0xF1, 0xF8, 0x7C, 0x7F,
  0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xC1, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F,
  0x87, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC1, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x3F, 0xF0, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xC3,
  0xF8, 0x7E, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x1F, 0x80, 0xF9, 0xF8, 0x07,
  0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3F, 0x00, 0xF9,
  0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xC1,
  0xF8, 0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0,
  0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0x1E, 0xF0, 0x7F,
  0xC7, 0xFC, 0x1E, 0xF3, 0xDF, 0x07, 0xBC, 0xF7, 0xC3, 0xEF, 0x39, 0xE0,
  0xFB, 0xDE, 0xF8, 0x3E, 0xF7, 0xBE, 0x0F, 0xBF, 0xCF, 0x83, 0xCF, 0xF3,
  0xE1, 0xF3, 0xF9, 0xF0, 0x7C, 0xFE, 0x7C, 0x1F, 0x3F, 0x1F, 0x07, 0xCF,
  0xC7, 0xC3, 0xE3, 0xE1, 0xE0, 0x07, 0xE0, 0x7C, 0x3F, 0x81, 0xF0, 0xFF,
  0x07, 0xC3, 0xFC, 0x1F, 0x0F, 0xF0, 0x78, 0x3F, 0xC3, 0xE1, 0xFF, 0x8F,
  0x87, 0xFE, 0x3E, 0x1E, 0x78, 0xF0, 0x79, 0xF7, 0xC3, 0xE7, 0xDF, 0x0F,
  0x9F, 0x7C, 0x3E, 0x3F, 0xF0, 0xF8, 0xFF, 0x83, 0xC3, 0xFE, 0x1F, 0x07,
  0xF8, 0x7C, 0x1F, 0xE1, 0xF0, 0x7F, 0x87, 0xC1, 0xFC, 0x3E, 0x03, 0xF0,
  0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0xFC,
  0x7E, 0x0F, 0xCF, 0x81, 0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xEF, 0x80, 0xFD,
  0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0x9F, 0x07, 0xE3,
  0xF1, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xF9, 0xF8, 0x7C,
  0x7C, 0x7E, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x8F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xC3, 0xFF, 0x81, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0xFC, 0x7E, 0x0F, 0xCF, 0x81, 0xFB,
  0xF0, 0x3F, 0x7C, 0x07, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0x7E, 0x03, 0xEF,
  0xC0, 0xFD, 0xF8, 0x1F, 0x9F, 0x07, 0xE3, 0xF1, 0xFC, 0x7F, 0xFF, 0x07,
  0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0xF9, 0xF8, 0x7C, 0x7C, 0x7E, 0x3E, 0x3E, 0x3F,
  0x1F, 0x3F, 0x8F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC1, 0xF3,
  0xE0, 0xF9, 0xF0, 0xFC, 0xFC, 0x7E, 0x3E, 0x3E, 0x1F, 0x9F, 0x0F, 0xDF,
  0x83, 0xF0, 0x07, 0xF8, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE3, 0xE1, 0x87,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x3E, 0x20, 0x7C, 0x71, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3,
  0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xE0,
  0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x9F, 0x87, 0xE7, 0xE1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x0F, 0x8F, 0x87, 0xE3, 0xF3, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0x80, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x07, 0xEF,
  0x83, 0xE7, 0xC3, 0xF1, 0xE1, 0xF0, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C,
  0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xF8, 0x1F,
  0x07, 0xFF, 0x07, 0xE0, 0xFB, 0xE0, 0xFC, 0x3F, 0x7C, 0x1F, 0x87, 0xCF,
  0x87, 0xF1, 0xF9, 0xF0, 0xFE, 0x3E, 0x3E, 0x3F, 0xC7, 0xC7, 0xC7, 0xF9,
  0xF0, 0xF9, 0xEF, 0x3E, 0x1F, 0x3D, 0xE7, 0x83, 0xE7, 0xBD, 0xF0, 0x7D,
  0xE7, 0xBE, 0x0F, 0xBC, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8,
  0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8,
  0x0F, 0x87, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3E, 0x00, 0x3E, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xF7,
  0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x1F,
  0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xBE, 0x1F, 0x9F, 0x0F, 0xCF, 0x8F,
  0xC7, 0xC7, 0xC1, 0xF7, 0xC0, 0xFB, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x03, 0xF8, 0x3F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xFC, 0x0F, 0xE0, 0x7F,
  0x07, 0xF8, 0x00, 0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x03,
  0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x81, 0xFC,
  0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x03, 0xDE, 0x07, 0xBC, 0x1E, 0x38, 0x78,
  0x78, 0xF0, 0xF3, 0xC0, 0xEF, 0x01, 0xE0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0xF8, 0xF0, 0xF0, 0x07, 0x81, 0x0F, 0xDE, 0x1F, 0xFE, 0x3F,
  0xFE, 0x7F, 0xFE, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0x7C, 0xFC, 0x7C, 0xFC,
  0x7C, 0xFC, 0xFC, 0xFC, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3E,
  0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0xB8, 0x1F, 0x7E, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x3F, 0x3E,
  0x3F, 0x3E, 0x3F, 0x3E, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7F,
  0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0xFB, 0xF0, 0x01, 0xE0, 0x7F, 0xC7, 0xFE,
  0x7F, 0xF7, 0xF7, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x4F, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xF8, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x39, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0x9F, 0x8F, 0x8F, 0x8F, 0xC7,
  0xC7, 0xE3, 0xE3, 0xF1, 0xF1, 0xF9, 0xF8, 0xFC, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x03, 0xEF, 0x80, 0x01, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1,
  0xFF, 0xE3, 0xE3, 0xEF, 0x8F, 0xDF, 0x3F, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF,
  0xC3, 0xE0, 0x07, 0xE0, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x0F,
  0xC8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x04, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x83, 0xF7, 0x83, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xF9,
  0xF8, 0xF8, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F, 0x9F, 0x8F,
  0xCF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x38, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0xBC, 0x1F, 0x7E, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F, 0x3F,
  0x1F, 0x3E, 0x3F, 0x3E, 0x3F, 0x3E, 0x3E, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C,
  0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0xFC, 0x7C, 0x03, 0x01, 0xF0, 0xFC, 0x3F,
  0x07, 0x80, 0x00, 0x00, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F,
  0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x00, 0x00,
  0x30, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0x80,
  0x78, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x47, 0xE3, 0xF0, 0xF8, 0xFC, 0x1F, 0x3F, 0x03,
  0xEF, 0xC0, 0xFD, 0xF0, 0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0x8F, 0x81, 0xF1, 0xF8, 0x3E,
  0x3F, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE1,
  0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE1, 0xF8,
  0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x00, 0x00, 0x3C, 0x1C, 0x0F, 0xBF,
  0x3F, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xF8,
  0xFC, 0xFC, 0xFC, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F,
  0x1F, 0x0F, 0x9F, 0x8F, 0x8F, 0xCF, 0xC7, 0xC7, 0xE7, 0xC3, 0xE3, 0xE3,
  0xE3, 0xF1, 0xF1, 0xF1, 0xF0, 0xF9, 0xF8, 0xF8, 0xFC, 0x00, 0x3C, 0x1F,
  0x7E, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F, 0x3F, 0x1F, 0x3E,
  0x3F, 0x3E, 0x3F, 0x3E, 0x3E, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x7E, 0x7C,
  0x7E, 0x7C, 0x7C, 0xFC, 0x7C, 0x01, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF,
  0xE3, 0xF7, 0xEF, 0xCF, 0xDF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFB,
  0xF1, 0xF7, 0xE7, 0xEF, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x0F, 0xE0, 0x00,
  0x1C, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7C, 0xFC,
  0x7C, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F, 0x8F, 0x8F, 0x8F, 0xC7, 0xC7, 0xE7,
  0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0xFD, 0xF0, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x07, 0x81, 0x0F, 0xDE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x7E,
  0x7C, 0x7C, 0xFC, 0x7C, 0xFC, 0x7C, 0xFC, 0x7C, 0xFC, 0xFC, 0xFC, 0xF8,
  0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x38,
  0xFB, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xC4, 0xFC, 0x07, 0xE0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0x03, 0xC0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x3E, 0x10, 0xFC, 0x03, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x3F, 0x20, 0x7C, 0xFF, 0xF3, 0xFF,
  0xCF, 0xFE, 0x1F, 0xE0, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x4F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0x3F, 0x1F, 0x3E,
  0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0xFC, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x7F,
  0x78, 0x3E, 0x78, 0xFC, 0x3F, 0xFC, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0x7C,
  0xF8, 0x7D, 0xF8, 0x7D, 0xF0, 0x7D, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x7E, 0x3F,
  0x78, 0xFE, 0x3E, 0x78, 0xFE, 0x7C, 0x78, 0xFC, 0x7C, 0x79, 0xFC, 0xF8,
  0x79, 0xDC, 0xF8, 0x7B, 0xDD, 0xF0, 0x7B, 0xDD, 0xF0, 0x7B, 0x9D, 0xE0,
  0x7F, 0x9F, 0xE0, 0x7F, 0x9F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x7C, 0xFC, 0x07,
  0xEF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFB, 0xE0,
  0x3F, 0x3E, 0x03, 0xF3, 0xF0, 0xFE, 0x3F, 0x00, 0x1F, 0x87, 0xE3, 0xF1,
  0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xEF,
  0x80, 0x7D, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0x80, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xC7,
  0xFF, 0x8F, 0xFE, 0x3F, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0x7E,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0xFF, 0x0F, 0xE0,
  0xF8, 0x0F, 0xC0, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x3E, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0xFC, 0x0F,
  0xC0, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x0F, 0xC0, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0x10, 0x05, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0x03, 0xC0,
};

const GFXglyph NotoSans_BlackItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 20, 9, 0, -20 },
  { 26, 12, 7, 13, 2, -20 },
  { 37, 19, 20, 18, 0, -20 },
  { 85, 15, 23, 16, 1, -21 },
  { 129, 23, 20, 26, 2, -20 },
  { 187, 20, 20, 21, 0, -20 },
  { 237, 6, 7, 7, 2, -20 },
  { 243, 11, 25, 10, 1, -21 },
  { 278, 11, 25, 10, -2, -21 },
  { 313, 14, 13, 15, 2, -21 },
  { 336, 14, 14, 16, 1, -17 },
  { 361, 7, 7, 9, -1, -3 },
  { 368, 9, 5, 9, 0, -10 },
  { 374, 6, 5, 9, 0, -5 },
  { 378, 16, 20, 13, -1, -20 },
  { 418, 15, 20, 16, 1, -20 },
  { 456, 13, 20, 16, 2, -20 },
  { 489, 16, 20, 16, -1, -20 },
  { 529, 15, 20, 16, 0, -20 },
  { 567, 16, 20, 16, 0, -20 },
  { 607, 16, 20, 16, 0, -20 },
  { 647, 15, 20, 16, 1, -20 },
  { 685, 17, 20, 16, 0, -20 },
  { 728, 15, 20, 16, 1, -20 },
  { 766, 15, 20, 16, 1, -20 },
  { 804, 8, 16, 9, 0, -16 },
  { 820, 10, 20, 9, -2, -16 },
  { 845, 14, 16, 16, 1, -18 },
  { 873, 14, 10, 16, 1, -15 },
  { 891, 14, 16, 16, 1, -18 },
  { 919, 13, 20, 14, 2, -20 },
  { 952, 23, 23, 25, 1, -20 },
  { 1019, 19, 20, 19, -2, -20 },
  { 1067, 17, 20, 18, 0, -20 },
  { 1110, 18, 20, 18, 1, -20 },
  { 1155, 18, 20, 19, 0, -20 },
  { 1200, 17, 20, 16, 0, -20 },
  { 1243, 16, 20, 16, 0, -20 },
  { 1283, 18, 20, 20, 1, -20 },
  { 1328, 20, 20, 20, 0, -20 },
  { 1378, 14, 20, 12, -1, -20 },
  { 1413, 15, 26, 10, -4, -20 },
  { 1462, 21, 20, 19, 0, -20 },
  { 1515, 13, 20, 15, 0, -20 },
  { 1548, 26, 20, 25, 0, -20 },
  { 1613, 22, 20, 22, 0, -20 },
  { 1668, 19, 20, 21, 1, -20 },
  { 1716, 17, 20, 17, 0, -20 },
  { 1759, 19, 25, 21, 1, -20 },
  { 1819, 17, 20, 18, 0, -20 },
  { 1862, 15, 20, 15, 1, -20 },
  { 1900, 15, 20, 15, 2, -20 },
  { 1938, 18, 20, 20, 2, -20 },
  { 1983, 17, 20, 17, 2, -20 },
  { 2026, 27, 20, 26, 2, -20 },
  { 2094, 23, 20, 19, -2, -20 },
  { 2152, 17, 20, 17, 2, -20 },
  { 2195, 18, 20, 15, -1, -20 },
  { 2240, 13, 26, 10, -1, -21 },
  { 2283, 8, 20, 13, 3, -20 },
  { 2303, 13, 26, 10, -2, -21 },
  { 2346, 15, 13, 15, 0, -20 },
  { 2371, 14, 3, 13, -3, 2 },
  { 2377, 7, 4, 10, 4, -21 },
  { 2381, 16, 16, 17, 1, -16 },
  { 2413, 16, 21, 17, 0, -21 },
  { 2455, 13, 16, 14, 1, -16 },
  { 2481, 17, 21, 17, 1, -21 },
  { 2526, 15, 16, 16, 1, -16 },
  { 2556, 17, 28, 11, -3, -21 },
  { 2616, 17, 23, 17, 0, -16 },
  { 2665, 16, 21, 17, 0, -21 },
  { 2707, 10, 22, 9, 0, -22 },
  { 2735, 14, 29, 9, -4, -22 },
  { 2786, 19, 21, 17, 0, -21 },
  { 2836, 10, 21, 9, 0, -21 },
  { 2863, 25, 16, 26, 0, -16 },
  { 2913, 16, 16, 17, 0, -16 },
  { 2945, 15, 16, 17, 1, -16 },
  { 2975, 17, 23, 17, -1, -16 },
  { 3024, 16, 23, 17, 1, -16 },
  { 3070, 13, 16, 12, 0, -16 },
  { 3096, 14, 16, 14, 0, -16 },
  { 3124, 12, 19, 13, 1, -19 },
  { 3153, 16, 15, 17, 1, -15 },
  { 3183, 16, 15, 15, 1, -15 },
  { 3213, 24, 15, 23, 1, -15 },
  { 3258, 20, 15, 16, -2, -15 },
  { 3296, 19, 22, 15, -2, -15 },
  { 3349, 15, 15, 14, -1, -15 },
  { 3378, 12, 24, 10, 0, -20 },
  { 3414, 4, 27, 16, 6, -21 },
  { 3428, 12, 24, 10, -2, -20 },
  { 3464, 14, 6, 16, 1, -13 },
};

const GFXfont NotoSans_BlackItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_BLACKITALIC28PT7B_H_
