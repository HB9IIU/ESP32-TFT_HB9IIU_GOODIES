#ifndef _NOTOSANS_BLACKITALIC25PT7B_H_
#define _NOTOSANS_BLACKITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E,
  0x0F, 0x07, 0x80, 0x00, 0x01, 0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0x7B, 0xEF,
  0x79, 0xEF, 0x39, 0xEF, 0x39, 0xE7, 0x38, 0xE0, 0x03, 0xCE, 0x01, 0xE7,
  0x00, 0xE7, 0x80, 0x73, 0x80, 0x79, 0xC1, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFE, 0x0E, 0x38, 0x07, 0x3C, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0,
  0xE7, 0x00, 0xF3, 0x80, 0x79, 0xC0, 0x39, 0xE0, 0x3C, 0xE0, 0x00, 0x00,
  0xC0, 0x06, 0x03, 0xFE, 0x3F, 0xF3, 0xFF, 0xBE, 0xC9, 0xFE, 0x0F, 0xE0,
  0x3F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x6F, 0x43, 0x7B, 0xDF, 0xDF,
  0xFC, 0xFF, 0xE3, 0xFC, 0x03, 0x00, 0x38, 0x00, 0x1F, 0x00, 0xE0, 0xFE,
  0x07, 0x07, 0xF8, 0x3C, 0x1E, 0xF1, 0xE0, 0x73, 0xC7, 0x03, 0xCF, 0x38,
  0x0F, 0x39, 0xE0, 0x3D, 0xEF, 0x3C, 0x7F, 0xBB, 0xF9, 0xFD, 0xEF, 0xE3,
  0xEF, 0x7B, 0xC0, 0x79, 0xCF, 0x01, 0xC7, 0x3C, 0x0F, 0x3C, 0xE0, 0x78,
  0xF7, 0x83, 0xC1, 0xFE, 0x0E, 0x07, 0xF0, 0x78, 0x0F, 0x80, 0x03, 0xF0,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xE7, 0xCF, 0xF9, 0xF7, 0xFE, 0xFB, 0xE7,
  0xFE, 0xF9, 0xFF, 0x3E, 0x3F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF,
  0x07, 0xF7, 0xE0, 0x7B, 0xDE, 0xEF, 0x7B, 0x80, 0x07, 0xC3, 0xC0, 0xF0,
  0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x00,
  0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0,
  0xF0, 0x3C, 0x3E, 0x00, 0x07, 0x80, 0x78, 0x47, 0x07, 0x70, 0xFF, 0x7F,
  0xFF, 0x1F, 0xF3, 0xF7, 0x7F, 0x8F, 0xB8, 0x33, 0xC1, 0x38, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x3D, 0xF7, 0x9E, 0xF3, 0xC0, 0x7F,
  0x7F, 0x7E, 0xFE, 0x7F, 0xFF, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFC, 0x7F, 0xF7, 0xCF, 0xBE, 0x7D,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xEF, 0x9F, 0x7C,
  0xFB, 0xFF, 0x9F, 0xF8, 0x7F, 0xC1, 0xF8, 0x00, 0x01, 0xE0, 0xFC, 0x3F,
  0x9F, 0xFF, 0xFD, 0xF7, 0x9D, 0xF2, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x03, 0xF0, 0x1F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xE3, 0xE0, 0x87, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF0, 0x07, 0xE0, 0xFF, 0xE1, 0xFF,
  0x87, 0xFF, 0x08, 0x7C, 0x01, 0xF0, 0x0F, 0x83, 0xFC, 0x0F, 0xC0, 0x3F,
  0x80, 0xFF, 0x00, 0x3E, 0x00, 0xFA, 0x03, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF,
  0xE1, 0xFE, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xF8,
  0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x1E, 0xF0, 0xF3, 0xC7, 0x9F, 0x3F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFF, 0x1F, 0x00, 0x78, 0x01, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFA, 0x03, 0xEF,
  0xFF, 0x3F, 0xFC, 0xFF, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE1, 0xFF,
  0x8F, 0xFE, 0x3E, 0x01, 0xF0, 0x07, 0xBC, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF,
  0xCF, 0x8F, 0xBE, 0x3C, 0xF8, 0xF3, 0xE7, 0xCF, 0xFF, 0x1F, 0xF8, 0x7F,
  0xC0, 0x7E, 0x00, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0x8F, 0xFE, 0x7D, 0xF3, 0xC7, 0x9E,
  0x7C, 0xFB, 0xC7, 0xFC, 0x1F, 0xC1, 0xFF, 0x1F, 0xF9, 0xF3, 0xEF, 0x0F,
  0x78, 0x7B, 0xE7, 0xDF, 0xFC, 0x7F, 0xE1, 0xFC, 0x00, 0x0F, 0xC0, 0xFF,
  0x0F, 0xFC, 0xFF, 0xE7, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xFF, 0xFB,
  0xFF, 0xDF, 0xFC, 0x7D, 0xE0, 0x1F, 0x01, 0xF3, 0x7F, 0x9F, 0xF8, 0xFF,
  0x87, 0xF0, 0x00, 0x1E, 0x1F, 0x3F, 0x3E, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xF8, 0xF8, 0xF8, 0x0F, 0x07, 0xC7, 0xE3, 0xE0, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0,
  0x00, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xE3, 0xF8, 0xFC, 0x0F,
  0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x1F, 0x0F, 0xF3, 0xFC, 0xFF, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x3F, 0x9F,
  0xFB, 0xFF, 0xBF, 0xF4, 0x3E, 0x07, 0xC1, 0xF0, 0xFE, 0x3F, 0x07, 0xC1,
  0xF0, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3E, 0x03, 0xC3, 0xC0, 0x0F,
  0x3C, 0x7F, 0xB9, 0xC7, 0xF9, 0xEE, 0x7D, 0xCF, 0xF3, 0x8E, 0x7F, 0x3C,
  0xF3, 0xF9, 0xC7, 0x9D, 0xCE, 0x38, 0xEE, 0x7B, 0xCE, 0x73, 0xFF, 0xF3,
  0xCF, 0xBE, 0x0E, 0x00, 0x00, 0x78, 0x02, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xDE, 0x07, 0xDE, 0x07, 0x9E, 0x0F, 0x9E, 0x0F, 0x1F,
  0x1F, 0x1F, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7C, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE,
  0x1F, 0x3F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFC, 0x07, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE,
  0x3F, 0x0C, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x10, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF,
  0x1F, 0x3F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x3E, 0x7C, 0x7E, 0x7F, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF,
  0xC1, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE1,
  0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0x06, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0xFE, 0xF9, 0xFE, 0xF9, 0xFE, 0xF8, 0x3E,
  0xF8, 0x3C, 0x7C, 0x7C, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x3E, 0x1F, 0x00, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x1F, 0xC0,
  0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0xF8, 0xFF, 0xC7, 0xFC, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE1, 0x3F, 0x0F, 0xF8, 0x7F, 0x83, 0xF8,
  0x0E, 0x00, 0x0F, 0x87, 0xE1, 0xF1, 0xF0, 0x3C, 0x7E, 0x0F, 0x9F, 0x81,
  0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x03, 0xCF, 0x80, 0xF9, 0xF8, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0x78, 0x7E, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7F, 0xF7, 0xFF, 0x7F, 0xEF, 0xFE,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xE1,
  0xFE, 0x3F, 0xC3, 0xFC, 0x77, 0x87, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x3F,
  0xE7, 0x78, 0x7B, 0xDE, 0xF0, 0xF7, 0xBB, 0xE1, 0xEF, 0xF7, 0x83, 0xDF,
  0xCF, 0x0F, 0xBF, 0x9E, 0x1E, 0x7E, 0x7C, 0x3C, 0xFC, 0xF8, 0x79, 0xF1,
  0xE1, 0xF3, 0xE3, 0xC0, 0x0F, 0xC0, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xE1,
  0xFE, 0x1E, 0x1F, 0xE1, 0xE1, 0xFE, 0x3E, 0x1F, 0xF3, 0xE1, 0xEF, 0x3C,
  0x3E, 0xF3, 0xC3, 0xCF, 0x3C, 0x3C, 0xFB, 0xC3, 0xC7, 0xF8, 0x3C, 0x7F,
  0x87, 0xC7, 0xF8, 0x78, 0x3F, 0x87, 0x83, 0xF8, 0x78, 0x3F, 0x0F, 0x83,
  0xF0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1, 0xF3,
  0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x78, 0x0F, 0xFC, 0x07, 0xBE, 0x07,
  0xDF, 0x03, 0xEF, 0x83, 0xF3, 0xE3, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xF1,
  0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x1F, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF,
  0xE1, 0xFF, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1,
  0xF3, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x78, 0x0F, 0xFC, 0x0F, 0xBE,
  0x07, 0xDF, 0x03, 0xEF, 0x83, 0xE3, 0xE3, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF1, 0xF3, 0xE3, 0xE7,
  0xC7, 0xCF, 0x8F, 0x3F, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83,
  0xCF, 0x8F, 0x9F, 0x1F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7D, 0xF0, 0x7C, 0x07,
  0xE0, 0xFF, 0xCF, 0xFC, 0x7F, 0xE7, 0xC1, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x41, 0xF3, 0xFF, 0x9F,
  0xF8, 0xFF, 0x87, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x3E,
  0x1F, 0x3E, 0x1E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3C, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF0, 0xF8, 0xF0,
  0xF8, 0xF0, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE1, 0xF7, 0xC3, 0xEF, 0x8F, 0x9F, 0x1F, 0x3E, 0x7C,
  0x7C, 0xF8, 0xF9, 0xE1, 0xF7, 0xC1, 0xEF, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x3C, 0x1F,
  0xF0, 0x7C, 0x3E, 0xF0, 0x7C, 0x3C, 0xF0, 0xFC, 0x7C, 0xF0, 0xFC, 0x7C,
  0xF1, 0xFC, 0x78, 0xF1, 0xFC, 0xF8, 0xF3, 0xFC, 0xF0, 0xF3, 0xFD, 0xF0,
  0xF3, 0xBD, 0xE0, 0xF7, 0xBD, 0xE0, 0xF7, 0xBF, 0xE0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0x3E,
  0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0xFB, 0xE0, 0x1F, 0x1F, 0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x8F, 0xC0, 0xF8,
  0xF8, 0x3F, 0xF0, 0xF9, 0xE3, 0xF3, 0xC7, 0xC7, 0xDF, 0x0F, 0xBE, 0x0F,
  0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x3E, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x78, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xF1, 0xE3, 0xC7, 0x8F, 0x0E,
  0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7C, 0x07,
  0xF0, 0x7E, 0x0F, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x7B, 0xC3, 0x8E, 0x3C, 0x73, 0xC3,
  0xDC, 0x1F, 0xE0, 0x70, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xF9, 0xE7, 0x8F,
  0x0F, 0x3C, 0x7E, 0xF3, 0xFF, 0x9F, 0xFE, 0x7C, 0xF9, 0xF3, 0xEF, 0x8F,
  0xBE, 0x3C, 0xF8, 0xF3, 0xE7, 0xCF, 0xFF, 0x3F, 0xFC, 0x7F, 0xE0, 0xF7,
  0x80, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7F, 0xC1,
  0xFF, 0x87, 0xFF, 0x3F, 0xFC, 0xF9, 0xF3, 0xE7, 0xCF, 0x1F, 0x3C, 0x7D,
  0xF1, 0xF7, 0xCF, 0x9F, 0xFE, 0x7F, 0xF1, 0xFF, 0xCF, 0x3C, 0x00, 0x07,
  0xE1, 0xFF, 0x3F, 0xE7, 0xFE, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x84, 0xFF, 0xC7, 0xFC, 0x7F, 0xC3, 0xF8, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC1, 0xEF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F,
  0xF8, 0xF9, 0xF1, 0xF3, 0xE7, 0xC7, 0xCF, 0x8F, 0x1F, 0x1E, 0x3E, 0x7C,
  0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xF7, 0x80, 0x07, 0xE0, 0xFF, 0x8F,
  0xFE, 0xFD, 0xF7, 0xCF, 0xBC, 0xFF, 0xFF, 0xDF, 0xFC, 0xFF, 0x87, 0xC0,
  0x3F, 0x18, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFA, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0x9E, 0x1F,
  0xBC, 0x7F, 0xF1, 0xFF, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x1F, 0x3E, 0x3C,
  0x7C, 0x78, 0xF9, 0xF1, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x03, 0xDE, 0x00,
  0x7C, 0x40, 0xF8, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7D, 0xE1, 0xFF, 0xC7,
  0xFF, 0x3F, 0xFC, 0xF8, 0xF3, 0xE3, 0xCF, 0x9F, 0x3C, 0x7D, 0xF1, 0xF7,
  0xC7, 0xDF, 0x1E, 0x7C, 0xF9, 0xE3, 0xEF, 0x8F, 0x80, 0x0F, 0x87, 0xC3,
  0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x0E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0xFC, 0x7C, 0xFC,
  0x3C, 0xFC, 0x3E, 0x7C, 0x1F, 0x7C, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3C, 0x7C, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x00,
  0x1E, 0x78, 0xF8, 0x7F, 0xF7, 0xE1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3E,
  0x3E, 0x7C, 0xF8, 0xF1, 0xF3, 0xE7, 0xC7, 0xCF, 0x1F, 0x1F, 0x7C, 0x7C,
  0x79, 0xF1, 0xF3, 0xE7, 0xC7, 0x8F, 0x9F, 0x3E, 0x3E, 0x78, 0xF8, 0xF3,
  0xE3, 0xE7, 0xC0, 0x1E, 0xF8, 0x7F, 0xF1, 0xFF, 0xCF, 0xFF, 0x3E, 0x3C,
  0xF8, 0xF3, 0xE7, 0xCF, 0x1F, 0x7C, 0x7D, 0xF1, 0xF7, 0xC7, 0x9F, 0x3E,
  0x78, 0xFB, 0xE3, 0xE0, 0x07, 0xE0, 0xFF, 0x8F, 0xFE, 0xFF, 0xF7, 0xCF,
  0xBC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xCF, 0xBF, 0xFD, 0xFF, 0xC7,
  0xFC, 0x1F, 0xC0, 0x0F, 0x78, 0x1F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF1, 0xF3,
  0xE3, 0xE7, 0xC7, 0x8F, 0x8F, 0x1F, 0x3E, 0x3E, 0x7C, 0xF8, 0xFF, 0xF1,
  0xFF, 0xC3, 0xFF, 0x8F, 0xBC, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x3C, 0x7E, 0xF3, 0xFF, 0x9F, 0xFE,
  0x7C, 0xF9, 0xF3, 0xEF, 0x8F, 0xBE, 0x3C, 0xF8, 0xF3, 0xE7, 0xCF, 0xFF,
  0x3F, 0xFC, 0x7F, 0xE0, 0xF7, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x1E, 0x71, 0xFF, 0x1F, 0xE3, 0xFE, 0x3F, 0xA3,
  0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0x0F, 0xE1, 0xFF, 0x3F, 0xE3, 0xE6, 0x3E, 0x03, 0xF8, 0x3F, 0xC1,
  0xFE, 0x07, 0xE0, 0x3E, 0xC3, 0xEF, 0xFC, 0xFF, 0xCF, 0xF0, 0x07, 0x01,
  0xE0, 0x78, 0x1F, 0xFF, 0xFD, 0xFF, 0xBF, 0xF3, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3C, 0x0F, 0x81, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x00, 0x3E, 0x7C,
  0xF1, 0xF3, 0xC7, 0xDF, 0x1F, 0x7C, 0x79, 0xF3, 0xE7, 0x8F, 0xBE, 0x3E,
  0xF8, 0xFB, 0xE7, 0xCF, 0xFF, 0x3F, 0xFC, 0x7E, 0xF1, 0xF3, 0x80, 0xF8,
  0x7F, 0xE3, 0xEF, 0x8F, 0x9E, 0x7C, 0x79, 0xF1, 0xE7, 0x87, 0xBE, 0x1E,
  0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00,
  0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xBE, 0x7E, 0x7D, 0xF3, 0xF3, 0xCF, 0xBB,
  0xBE, 0x3D, 0xDD, 0xE1, 0xEF, 0xEF, 0x0F, 0xFF, 0xF8, 0x7F, 0x7F, 0x83,
  0xFB, 0xBC, 0x1F, 0x9F, 0xC0, 0xFC, 0xFE, 0x07, 0xE7, 0xE0, 0x3E, 0x3F,
  0x00, 0x1F, 0x1F, 0x8F, 0x9F, 0x83, 0xEF, 0x81, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xBC,
  0x07, 0xDF, 0x07, 0xCF, 0x87, 0xC7, 0xE0, 0x1F, 0x0F, 0x8F, 0x8F, 0x87,
  0xC7, 0xC3, 0xE7, 0xC0, 0xF3, 0xE0, 0x79, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x7F,
  0xE3, 0xFF, 0x80, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xF0, 0x1E, 0x03,
  0xC0, 0xF0, 0x1E, 0x1F, 0xC3, 0xF0, 0x7C, 0x0F, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xF8, 0x3F, 0x03, 0xE0, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xFC, 0x0F, 0x83, 0xF0, 0xFE, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC1,
  0xF0, 0x7E, 0x0F, 0x81, 0xE0, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xE8, 0x04, 0x00,
};

const GFXglyph NotoSans_BlackItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 18, 8, 0, -18 },
  { 22, 11, 7, 11, 2, -18 },
  { 32, 17, 18, 16, 0, -18 },
  { 71, 13, 20, 15, 1, -19 },
  { 104, 22, 18, 23, 1, -18 },
  { 154, 18, 18, 18, 0, -18 },
  { 195, 5, 7, 6, 2, -18 },
  { 200, 10, 22, 9, 1, -18 },
  { 228, 10, 22, 9, -2, -18 },
  { 256, 12, 12, 14, 2, -19 },
  { 274, 13, 12, 15, 1, -15 },
  { 294, 6, 6, 8, -1, -3 },
  { 299, 8, 4, 8, 0, -9 },
  { 303, 5, 4, 8, 0, -4 },
  { 306, 14, 18, 12, -1, -18 },
  { 338, 13, 18, 15, 1, -18 },
  { 368, 11, 18, 15, 2, -18 },
  { 393, 15, 18, 15, -1, -18 },
  { 427, 14, 18, 15, 0, -18 },
  { 459, 14, 18, 15, 0, -18 },
  { 491, 14, 18, 15, 0, -18 },
  { 523, 14, 18, 15, 1, -18 },
  { 555, 16, 18, 15, 0, -18 },
  { 591, 13, 18, 15, 1, -18 },
  { 621, 13, 18, 15, 1, -18 },
  { 651, 8, 14, 8, 0, -14 },
  { 665, 9, 17, 8, -1, -14 },
  { 685, 12, 14, 15, 1, -16 },
  { 706, 13, 9, 15, 1, -13 },
  { 721, 12, 14, 15, 1, -16 },
  { 742, 11, 18, 12, 2, -18 },
  { 767, 21, 20, 22, 1, -18 },
  { 820, 16, 18, 17, -1, -18 },
  { 856, 16, 18, 16, 0, -18 },
  { 892, 16, 18, 16, 1, -18 },
  { 928, 16, 18, 17, 0, -18 },
  { 964, 15, 18, 14, 0, -18 },
  { 998, 15, 18, 14, 0, -18 },
  { 1032, 16, 18, 17, 1, -18 },
  { 1068, 18, 18, 18, 0, -18 },
  { 1109, 13, 18, 11, -1, -18 },
  { 1139, 13, 24, 9, -4, -18 },
  { 1178, 19, 18, 17, 0, -18 },
  { 1221, 12, 18, 13, 0, -18 },
  { 1248, 23, 18, 23, 0, -18 },
  { 1300, 20, 18, 20, 0, -18 },
  { 1345, 17, 18, 18, 1, -18 },
  { 1384, 15, 18, 16, 0, -18 },
  { 1418, 17, 22, 18, 1, -18 },
  { 1465, 15, 18, 16, 0, -18 },
  { 1499, 13, 18, 14, 1, -18 },
  { 1529, 13, 18, 14, 2, -18 },
  { 1559, 16, 18, 18, 2, -18 },
  { 1595, 15, 18, 15, 2, -18 },
  { 1629, 24, 18, 23, 2, -18 },
  { 1683, 20, 18, 17, -2, -18 },
  { 1728, 15, 18, 15, 2, -18 },
  { 1762, 16, 18, 13, -1, -18 },
  { 1798, 12, 22, 9, -1, -18 },
  { 1831, 7, 18, 12, 3, -18 },
  { 1847, 12, 22, 9, -2, -18 },
  { 1880, 13, 12, 13, 0, -18 },
  { 1900, 12, 3, 11, -2, 2 },
  { 1905, 6, 4, 9, 4, -19 },
  { 1908, 14, 14, 15, 1, -14 },
  { 1933, 14, 19, 15, 0, -19 },
  { 1967, 12, 14, 13, 1, -14 },
  { 1988, 15, 19, 15, 1, -19 },
  { 2024, 13, 14, 14, 1, -14 },
  { 2047, 16, 25, 10, -3, -19 },
  { 2097, 15, 20, 15, 0, -14 },
  { 2135, 14, 19, 16, 0, -19 },
  { 2169, 9, 19, 8, 0, -19 },
  { 2191, 12, 25, 8, -3, -19 },
  { 2229, 17, 19, 15, 0, -19 },
  { 2270, 9, 19, 8, 0, -19 },
  { 2292, 22, 14, 23, 0, -14 },
  { 2331, 14, 14, 16, 0, -14 },
  { 2356, 13, 14, 15, 1, -14 },
  { 2379, 15, 20, 15, -1, -14 },
  { 2417, 14, 20, 15, 1, -14 },
  { 2452, 12, 14, 11, 0, -14 },
  { 2473, 12, 14, 13, 0, -14 },
  { 2494, 11, 17, 11, 1, -17 },
  { 2518, 14, 14, 16, 1, -14 },
  { 2543, 14, 14, 14, 1, -14 },
  { 2568, 21, 14, 21, 1, -14 },
  { 2605, 17, 14, 14, -1, -14 },
  { 2635, 17, 20, 14, -2, -14 },
  { 2678, 14, 14, 12, -1, -14 },
  { 2703, 11, 22, 9, 0, -18 },
  { 2734, 4, 25, 14, 5, -19 },
  { 2747, 11, 22, 9, -2, -18 },
  { 2778, 13, 5, 15, 1, -11 },
};

const GFXfont NotoSans_BlackItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_BLACKITALIC25PT7B_H_
