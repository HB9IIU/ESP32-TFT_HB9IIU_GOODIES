#ifndef _NOTOSANS_BLACKITALIC55PT7B_H_
#define _NOTOSANS_BLACKITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xE0, 0x00,
  0x3F, 0xE3, 0xFE, 0x7F, 0x8F, 0xF9, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0xE7,
  0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F,
  0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE,
  0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8,
  0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xCF, 0x07, 0x01, 0xFF, 0x9E, 0x00, 0x03, 0xFE, 0x7C, 0x00, 0x07,
  0xFE, 0xF8, 0x00, 0x0F, 0xFD, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3D,
  0xFF, 0x80, 0x00, 0xF9, 0xFF, 0x10, 0x01, 0xF3, 0xFE, 0x18, 0x03, 0xC7,
  0xFC, 0x3E, 0x07, 0x9F, 0xF8, 0x7F, 0xEF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x40, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xC7, 0xF0, 0x0F, 0xF0,
  0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x80,
  0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x3F, 0xC0, 0x00,
  0x7F, 0x87, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE3, 0xFC, 0x1F, 0xC1,
  0xFE, 0x3F, 0xC7, 0xF0, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xE7, 0xFF, 0xE3,
  0xFF, 0xFE, 0x7F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFE, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xCF, 0xF3, 0xFE, 0xFF, 0x87,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x03, 0xF0, 0xFF, 0x0F, 0xF1, 0xFE, 0x00,
  0x01, 0xFE, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x00,
  0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0x0F,
  0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC7, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0xFF, 0x87,
  0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x9F, 0xFC, 0x7F, 0xFB, 0xFF,
  0x9F, 0xF8, 0x7F, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xE7,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3,
  0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x60,
  0x1F, 0xC0, 0x0F, 0x03, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0xDF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0x0C, 0x3F, 0xFF, 0x80, 0x0F, 0xFB,
  0xF8, 0x07, 0xFE, 0x7F, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xF1, 0xFE, 0x00,
  0x3C, 0x1F, 0xE0, 0x03, 0x83, 0xFC, 0x00, 0x20, 0x7E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x07, 0xF9, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x70, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF1,
  0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF3, 0xFF, 0x81, 0xFF,
  0x9F, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xEF, 0xFE, 0x03, 0xFF, 0x7F,
  0xF0, 0x3F, 0xFB, 0xFF, 0x01, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFB, 0xFF, 0x80, 0xFF,
  0xDF, 0xF8, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xF7, 0xFE, 0x03, 0xFF, 0xBF,
  0xF0, 0x3F, 0xF9, 0xFF, 0x81, 0xFF, 0xCF, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0,
  0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0xC1, 0xFC,
  0x7F, 0xE0, 0x7C, 0x3F, 0xF0, 0x38, 0x3F, 0xF8, 0x08, 0x1F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x8F, 0xFF,
  0x00, 0x3E, 0x07, 0xFF, 0x00, 0x38, 0x03, 0xFF, 0x00, 0x10, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xC0,
  0x7F, 0xF0, 0x04, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF2, 0x00, 0x01, 0xFF, 0xCC, 0x00, 0x07, 0xFF, 0x3E, 0x00, 0x7F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xDF, 0xF8,
  0x00, 0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80,
  0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFE, 0x0F, 0xFC, 0x07,
  0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFD, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x10, 0x00,
  0x3F, 0xFC, 0x3C, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x54, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x1F,
  0xE0, 0x0F, 0xF9, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0x1F, 0xFC, 0xFF,
  0xE0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x3F, 0xF8,
  0x1F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0x0F,
  0xFE, 0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x07,
  0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF,
  0xCF, 0xFC, 0x03, 0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFD,
  0xFF, 0xE7, 0xFF, 0x07, 0xFE, 0x7F, 0xF0, 0x7F, 0xEF, 0xFE, 0x07, 0xFE,
  0xFF, 0xE0, 0x7F, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x0F, 0xFE, 0xFF, 0xF3, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xF7, 0xFC, 0x1F, 0xFE, 0xFF, 0xC0, 0xFF, 0xCF,
  0xFC, 0x07, 0xF0, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x08, 0x03, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x01, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0x03, 0xFF, 0x18, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFF,
  0x81, 0xFE, 0x1F, 0xF0, 0x1F, 0xFF, 0xC7, 0xF8, 0x7F, 0x81, 0xFF, 0xFF,
  0x8F, 0xE1, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0x8F, 0xF0, 0x7F, 0xFF, 0xF0,
  0xFF, 0x3F, 0x83, 0xFF, 0xFF, 0xC1, 0xFD, 0xFE, 0x0F, 0xF0, 0xFF, 0x07,
  0xF7, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xDF, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F,
  0x7F, 0x0F, 0xF0, 0x3F, 0x83, 0xF9, 0xFC, 0x3F, 0x81, 0xFE, 0x0F, 0xEF,
  0xE1, 0xFE, 0x07, 0xF0, 0x3F, 0xBF, 0x87, 0xF8, 0x1F, 0xC0, 0xFE, 0xFE,
  0x1F, 0xE0, 0x7F, 0x07, 0xF3, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xCF, 0xE1,
  0xFE, 0x0F, 0xE0, 0xFF, 0x3F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xC3, 0xFF, 0xEF, 0xFF, 0xC0, 0x7F, 0x87, 0xFF,
  0x3F, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00,
  0xFF, 0xDF, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01,
  0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0x87, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE,
  0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0x81, 0xFF, 0xF0, 0x01, 0xC0, 0x7F, 0xF8, 0x00, 0x10, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x08, 0x0F, 0xFF, 0x00, 0x1C, 0x01, 0xFF, 0xF0, 0x3F, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0x8F, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF,
  0x87, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xFE, 0x1F,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x3F, 0xFE, 0x00, 0x18,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0xF3, 0xFF, 0x83, 0xFF, 0xFE, 0x7F,
  0xF0, 0x7F, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0xFE,
  0x3F, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF0,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x0E, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF,
  0x83, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFF,
  0x80, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0x80, 0x7F, 0x7F, 0xC0, 0x7F,
  0xDF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xE0, 0x3F, 0xBF, 0xE0, 0x1F,
  0xF7, 0xF0, 0x3F, 0xDF, 0xF0, 0x0F, 0xFB, 0xF8, 0x1F, 0xEF, 0xF8, 0x07,
  0xFD, 0xFC, 0x1F, 0xEF, 0xFC, 0x07, 0xFE, 0xFE, 0x0F, 0xF7, 0xFC, 0x03,
  0xFE, 0x7F, 0x0F, 0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0x87, 0xF9, 0xFF, 0x00,
  0xFF, 0x9F, 0xC3, 0xF9, 0xFF, 0x80, 0x7F, 0xCF, 0xE3, 0xFC, 0xFF, 0xC0,
  0x7F, 0xE7, 0xF1, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xF9, 0xFE, 0x3F, 0xE0,
  0x1F, 0xF1, 0xFC, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0xFE, 0xFF, 0x1F, 0xF8,
  0x07, 0xFC, 0x7F, 0x7F, 0x0F, 0xFC, 0x07, 0xFE, 0x3F, 0xFF, 0x87, 0xFC,
  0x03, 0xFE, 0x1F, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF,
  0x00, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0x80, 0x7F, 0xE1, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xF0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFC, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xDF, 0xF0, 0x1F, 0xF0, 0x0F, 0xFB, 0xFE, 0x07, 0xFE, 0x01,
  0xFF, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE7, 0xFC, 0x1F, 0xF0, 0x07, 0xFC,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF,
  0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x7F,
  0xC0, 0x1F, 0xF0, 0xFF, 0xCF, 0xF8, 0x07, 0xFE, 0x0F, 0xF9, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF7, 0xFC, 0x03, 0xFE,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x1F,
  0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0x7F,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xEF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFC, 0x00,
  0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xFC, 0xFF,
  0xC0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF,
  0x8F, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xC3,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x00,
  0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF,
  0x80, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x07, 0xFF,
  0x7F, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFE,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFE,
  0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x01,
  0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFE,
  0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFE, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC,
  0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F,
  0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0xCF, 0xFE, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0x80,
  0xFF, 0xE0, 0x04, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x83, 0x00,
  0x07, 0xFE, 0x0F, 0x00, 0x3F, 0xF8, 0x3F, 0x81, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0,
  0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF8, 0x3F,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7F,
  0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xFB,
  0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF0, 0x03, 0xFF,
  0x87, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xE0,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFC,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xF8, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFC, 0x07, 0xFC,
  0x1F, 0xFF, 0xE1, 0xFF, 0x80, 0x7F, 0xC3, 0xFD, 0xFE, 0x1F, 0xF8, 0x07,
  0xFC, 0x3F, 0xDF, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFD, 0xFE, 0x3F, 0xF0,
  0x07, 0xFC, 0x7F, 0x9F, 0xE3, 0xFF, 0x00, 0x7F, 0xC7, 0xF9, 0xFE, 0x3F,
  0xE0, 0x07, 0xFC, 0xFF, 0x1F, 0xE7, 0xFE, 0x00, 0x7F, 0xCF, 0xF1, 0xFE,
  0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x1F, 0xEF, 0xFC, 0x00, 0x7F, 0xDF, 0xE1,
  0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xBF,
  0xC1, 0xFF, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xBF, 0xC1, 0xFD, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0xF8,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF7, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE7,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xF1, 0xFF,
  0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xF0,
  0x07, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE7, 0xFF,
  0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x01, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00,
  0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x03,
  0xF8, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x87, 0xFC,
  0x07, 0xFF, 0xCF, 0xF0, 0x1F, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF,
  0xC1, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0xC0,
  0x7F, 0xC3, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xF8, 0x03, 0xFF, 0xDF, 0xF0,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC7, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xEF, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFE,
  0x07, 0xFF, 0x1F, 0xF8, 0x1F, 0xFC, 0x7F, 0xE0, 0x7F, 0xF1, 0xFF, 0x01,
  0xFF, 0xC7, 0xFC, 0x07, 0xFF, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF,
  0xE3, 0xFF, 0x03, 0xFF, 0x8F, 0xFC, 0x1F, 0xFE, 0x3F, 0xF0, 0x7F, 0xF1,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xEF,
  0xFF, 0xC0, 0xFF, 0x1F, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0x1F, 0x0F, 0xFF, 0x00, 0x83, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x03, 0x07, 0xFF, 0x03, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0xFF, 0xC0,
  0x07, 0xFC, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFD, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0x80, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFC, 0x1F, 0xF9, 0xFF, 0xC0, 0xFF, 0xCF, 0xFE, 0x0F, 0xFC,
  0x7F, 0xE0, 0x7F, 0xE7, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x83, 0xFF, 0x80, 0x0C, 0x0F, 0xFE, 0x03, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC1, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x08, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0xF1, 0xFE, 0x01, 0xFF,
  0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xBF, 0xFC, 0x1F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x03, 0xF9,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x80, 0x03, 0xFF, 0x00, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x7F, 0xDF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFC, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0x87, 0xFF,
  0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x01,
  0xFF, 0x87, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x81, 0xFF,
  0xC0, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x04, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF8,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0xFF, 0xE0, 0x7F, 0xE0,
  0x0F, 0xF3, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xEF, 0xFF, 0xC7, 0xFF, 0xE0,
  0x7F, 0xDF, 0xFF, 0xDF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC7, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x1F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x1F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x8F, 0xFE, 0x07, 0xFE,
  0x07, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0xFF, 0xE0, 0x0F,
  0xF3, 0xFF, 0xE0, 0x3F, 0xEF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0x9F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x03,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0x87, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0xC7,
  0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x3F,
  0xF9, 0xFF, 0xE1, 0xFF, 0xCF, 0xFE, 0x0F, 0xFE, 0x7F, 0xE0, 0x7F, 0xF7,
  0xFF, 0x03, 0xFF, 0xBF, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0, 0xFF, 0xEF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xBF, 0xF8, 0x1F,
  0xFD, 0xFF, 0xC0, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x7F, 0xF3,
  0xFF, 0x87, 0xFF, 0x8F, 0xFE, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xCF, 0xFC, 0x00, 0x1F, 0xEF, 0xFF,
  0x00, 0x1F, 0xF7, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF7,
  0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0,
  0x7F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x7F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xFE, 0x00,
  0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xE3, 0xFC, 0x00, 0x7F, 0xF0, 0x70, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x07, 0xFF,
  0x8F, 0xF0, 0x1F, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x7F,
  0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF,
  0x87, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0xC0, 0x7F, 0xC3,
  0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0xF0, 0x01, 0xFE,
  0xFF, 0xC0, 0x00, 0xE1, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xFE, 0x1F, 0xC0,
  0xFF, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xDF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xE0, 0x41, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0xF8, 0x1F, 0xF8, 0x0E, 0x07,
  0xFE, 0x00, 0x81, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x20, 0x03, 0xFF, 0x8C, 0x00, 0xFF, 0xE3, 0xE0, 0x7F, 0xF8,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x40, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01, 0x40, 0x00, 0x1F, 0xFC, 0x0F, 0xFE,
  0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xE1,
  0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF1, 0xFF,
  0xC0, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0,
  0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xCF, 0xF8,
  0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x01, 0xFF,
  0xC7, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x80,
  0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x07,
  0xFC, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x1F,
  0xEF, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xBF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFD, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xCF, 0xFC, 0x1F, 0xFF, 0x07, 0xFE, 0x7F, 0xE0,
  0xFF, 0xF8, 0x3F, 0xF3, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x7F,
  0xFC, 0x1F, 0xF8, 0xFF, 0xC7, 0xF7, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xF8, 0xFF, 0xC1, 0xFF, 0x9F, 0xDF, 0xC7,
  0xFE, 0x0F, 0xFC, 0xFE, 0xFE, 0x3F, 0xE0, 0x3F, 0xE7, 0xF7, 0xF3, 0xFF,
  0x01, 0xFF, 0x7F, 0x3F, 0x9F, 0xF0, 0x0F, 0xFB, 0xF9, 0xFD, 0xFF, 0x80,
  0x7F, 0x9F, 0xCF, 0xEF, 0xF8, 0x03, 0xFD, 0xFC, 0x7F, 0x7F, 0xC0, 0x1F,
  0xEF, 0xE3, 0xFF, 0xFC, 0x00, 0xFF, 0x7E, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC,
  0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x7F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xCF, 0xFE,
  0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x01, 0x00, 0x00, 0x11, 0xFF, 0x80, 0x03, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xEC, 0x00,
  0x3F, 0xFC, 0x80, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_BlackItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 19, 40, 17, 0, -39 },
  { 96, 23, 14, 25, 5, -39 },
  { 137, 36, 39, 36, 0, -39 },
  { 313, 31, 45, 32, 1, -42 },
  { 488, 47, 41, 51, 3, -40 },
  { 729, 40, 41, 40, 0, -40 },
  { 934, 11, 14, 13, 5, -39 },
  { 954, 22, 49, 21, 2, -40 },
  { 1089, 23, 49, 21, -4, -40 },
  { 1230, 27, 27, 30, 4, -42 },
  { 1322, 28, 27, 32, 2, -33 },
  { 1417, 15, 13, 17, -3, -6 },
  { 1442, 16, 8, 18, 1, -19 },
  { 1458, 11, 11, 17, 0, -10 },
  { 1474, 31, 41, 26, -2, -40 },
  { 1633, 29, 41, 32, 2, -40 },
  { 1782, 25, 39, 32, 4, -39 },
  { 1904, 32, 40, 32, -2, -40 },
  { 2064, 30, 41, 32, 0, -40 },
  { 2218, 31, 39, 32, 0, -39 },
  { 2370, 31, 40, 32, 1, -39 },
  { 2525, 30, 41, 32, 2, -40 },
  { 2679, 33, 39, 32, 1, -39 },
  { 2840, 30, 41, 32, 1, -40 },
  { 2994, 28, 41, 32, 3, -40 },
  { 3138, 17, 32, 17, 0, -31 },
  { 3206, 20, 38, 17, -3, -31 },
  { 3301, 28, 30, 32, 2, -35 },
  { 3406, 28, 19, 32, 2, -29 },
  { 3473, 28, 30, 32, 2, -35 },
  { 3578, 24, 41, 27, 4, -40 },
  { 3701, 46, 45, 49, 2, -40 },
  { 3960, 37, 39, 37, -3, -39 },
  { 4141, 33, 39, 35, 1, -39 },
  { 4302, 34, 41, 35, 3, -40 },
  { 4477, 35, 39, 38, 1, -39 },
  { 4648, 32, 39, 31, 1, -39 },
  { 4804, 31, 39, 31, 1, -39 },
  { 4956, 35, 41, 38, 3, -40 },
  { 5136, 39, 39, 39, 1, -39 },
  { 5327, 28, 39, 23, -2, -39 },
  { 5464, 30, 51, 21, -9, -39 },
  { 5656, 40, 39, 37, 1, -39 },
  { 5851, 25, 39, 29, 1, -39 },
  { 5973, 49, 39, 50, 1, -39 },
  { 6212, 43, 39, 43, 1, -39 },
  { 6422, 36, 41, 41, 3, -40 },
  { 6607, 33, 39, 34, 1, -39 },
  { 6768, 36, 49, 41, 3, -40 },
  { 6989, 33, 39, 36, 1, -39 },
  { 7150, 30, 41, 30, 1, -40 },
  { 7304, 30, 39, 30, 4, -39 },
  { 7451, 36, 40, 39, 3, -39 },
  { 7631, 34, 39, 34, 4, -39 },
  { 7797, 52, 39, 51, 4, -39 },
  { 8051, 44, 39, 36, -3, -39 },
  { 8266, 34, 39, 33, 4, -39 },
  { 8432, 35, 39, 30, -2, -39 },
  { 8603, 24, 49, 20, -1, -40 },
  { 8750, 15, 41, 26, 6, -40 },
  { 8827, 25, 49, 20, -4, -40 },
  { 8981, 29, 26, 29, 0, -39 },
  { 9076, 27, 6, 25, -5, 4 },
  { 9097, 13, 9, 19, 8, -42 },
  { 9112, 31, 32, 33, 2, -31 },
  { 9236, 30, 43, 33, 1, -42 },
  { 9398, 26, 32, 28, 2, -31 },
  { 9502, 33, 43, 33, 2, -42 },
  { 9680, 29, 32, 32, 2, -31 },
  { 9796, 34, 55, 23, -6, -42 },
  { 10030, 32, 44, 33, 1, -31 },
  { 10206, 31, 42, 34, 1, -42 },
  { 10369, 18, 43, 18, 1, -43 },
  { 10466, 27, 56, 18, -7, -43 },
  { 10655, 36, 42, 34, 1, -42 },
  { 10844, 19, 42, 18, 1, -42 },
  { 10944, 47, 31, 51, 1, -31 },
  { 11127, 31, 31, 34, 1, -31 },
  { 11248, 29, 32, 33, 2, -31 },
  { 11364, 33, 44, 33, -2, -31 },
  { 11546, 31, 44, 33, 2, -31 },
  { 11717, 25, 31, 24, 1, -31 },
  { 11814, 26, 32, 28, 1, -31 },
  { 11918, 24, 38, 25, 2, -37 },
  { 12032, 31, 31, 34, 3, -30 },
  { 12153, 31, 30, 30, 2, -30 },
  { 12270, 45, 30, 45, 3, -30 },
  { 12439, 38, 30, 31, -3, -30 },
  { 12582, 36, 43, 30, -3, -30 },
  { 12776, 29, 30, 27, -1, -30 },
  { 12885, 24, 48, 20, 0, -39 },
  { 13029, 7, 54, 31, 12, -42 },
  { 13077, 23, 48, 20, -3, -39 },
  { 13215, 28, 11, 32, 2, -25 },
};

const GFXfont NotoSans_BlackItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_BLACKITALIC55PT7B_H_
