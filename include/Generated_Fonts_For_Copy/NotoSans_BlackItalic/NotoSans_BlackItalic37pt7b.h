#ifndef _NOTOSANS_BLACKITALIC37PT7B_H_
#define _NOTOSANS_BLACKITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x10, 0x03, 0xE0, 0x3F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x7F, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8,
  0xF8, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x8F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE2,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC0, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0xFE, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xBE, 0x3F, 0xB8, 0x23, 0xFB,
  0x80, 0x3F, 0xB8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xEF, 0xC0,
  0x0E, 0xFC, 0xC0, 0xEF, 0xCF, 0xDD, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xF0, 0x1F,
  0xF8, 0x03, 0xE0, 0x3F, 0xF8, 0x07, 0xC0, 0x7F, 0xFC, 0x0F, 0x80, 0x7E,
  0x7C, 0x1F, 0x80, 0x7C, 0x7C, 0x1F, 0x00, 0xFC, 0x7C, 0x3E, 0x00, 0xFC,
  0xFC, 0x7C, 0x00, 0xF8, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF9,
  0xF9, 0xF1, 0xF8, 0xFF, 0xFB, 0xE7, 0xFC, 0x7F, 0xF7, 0xEF, 0xFE, 0x7F,
  0xE7, 0xDF, 0xFE, 0x3F, 0xCF, 0x9F, 0xBE, 0x0F, 0x1F, 0x1F, 0x3F, 0x00,
  0x3F, 0x3F, 0x3F, 0x00, 0x3E, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x3E, 0x00,
  0xF8, 0x3E, 0x3E, 0x01, 0xF8, 0x3E, 0x7E, 0x01, 0xF0, 0x3E, 0x7E, 0x03,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x1F, 0xF8, 0x1F,
  0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xE3, 0xF0, 0x01,
  0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0xFE, 0x1F,
  0xFE, 0x1F, 0x8F, 0xFF, 0xC7, 0xF1, 0xFF, 0xF8, 0xFE, 0x7F, 0xFF, 0xBF,
  0x9F, 0xE7, 0xFF, 0xF3, 0xF8, 0x7F, 0xFC, 0x7F, 0x07, 0xFF, 0x0F, 0xF0,
  0xFF, 0xE1, 0xFF, 0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xF3, 0xFE, 0x00, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x81, 0x83, 0xC0, 0x79, 0xF0, 0x1F,
  0x7C, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0xC1, 0x3F, 0xF8, 0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0x71, 0xF0,
  0x08, 0x7E, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xC7,
  0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x00, 0x7F, 0xF7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xEF, 0xFC, 0x08, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xCF, 0xF3, 0xFC,
  0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F,
  0x07, 0xF7, 0xF0, 0xFF, 0xFF, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF,
  0xE0, 0xFE, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x3F, 0xCF, 0xF7, 0xF8,
  0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xF3,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x7E, 0xFE, 0x1C, 0x7E, 0x08, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0x9F, 0xE0, 0x70, 0x7F, 0x01, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x3F,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x80, 0x1F,
  0xEF, 0x87, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFB, 0xF8, 0x0F, 0x9F, 0xC0,
  0xFC, 0xFC, 0x0F, 0xCF, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x10, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF9, 0x00, 0x3F, 0xCF, 0x87, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF8, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x70,
  0x0F, 0xDF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xF3, 0xFC, 0xFF, 0x0F, 0xE7, 0xF8, 0x7F, 0x3F, 0x83, 0xF8,
  0xFC, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x9F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF1, 0xFE, 0xFF,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x7F, 0xBF, 0xC7, 0xF1, 0xFC, 0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0xFE,
  0x0F, 0xCF, 0xE1, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xC7, 0xF7, 0xF8, 0x7E,
  0xFE, 0x0F, 0xDF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xEF, 0xF3, 0xFD,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xDF, 0xC3, 0xF3, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF1, 0x07, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x01, 0x80,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0xF0, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x07, 0xE0, 0x00, 0x60, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0x03,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80,
  0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x38, 0x7F, 0x20, 0x7F, 0x00, 0x7F,
  0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x80, 0xFE, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x70, 0x3E, 0x1F, 0x07, 0xFF, 0x3E, 0x7C,
  0x3F, 0xFE, 0x7C, 0xF8, 0xFF, 0xF8, 0xFB, 0xE1, 0xF9, 0xF1, 0xF7, 0xC7,
  0xE3, 0xE3, 0xEF, 0x8F, 0x87, 0xC7, 0xDF, 0x3E, 0x1F, 0x0F, 0xBC, 0x7C,
  0x3E, 0x1F, 0xF8, 0xF8, 0x7C, 0x3D, 0xF1, 0xF1, 0xF8, 0xFB, 0xE3, 0xE3,
  0xF3, 0xE3, 0xC7, 0xFF, 0xFF, 0xC7, 0xCF, 0xFF, 0xFF, 0x0F, 0x8F, 0xF7,
  0xFC, 0x1F, 0x0F, 0xC7, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x38, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F,
  0x87, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0x7E,
  0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0x8F, 0xF0,
  0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xE3, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F,
  0xC3, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x07, 0xFC, 0x1E, 0x1F, 0xE0, 0x08, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0C, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFC, 0xFF, 0xC3, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F,
  0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF3,
  0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xC0, 0xFE, 0x3F,
  0x81, 0xFC, 0xFE, 0x07, 0xF9, 0xFC, 0x1F, 0xE3, 0xF8, 0x7F, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x87, 0xFE, 0x0E, 0x1F, 0xF0, 0x04, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0xDF,
  0xC3, 0xFF, 0xBF, 0x87, 0xFF, 0x7F, 0x1F, 0xFC, 0xFE, 0x3F, 0xF9, 0xFC,
  0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF8, 0x1F, 0xCF, 0xF0, 0x7F, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F,
  0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xE0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0xC1,
  0xFC, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x0F, 0xE3, 0xFC,
  0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xDF,
  0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0x9F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8,
  0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xFB, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0x7C,
  0x1F, 0xFC, 0x1F, 0xBE, 0x1F, 0x7E, 0x0F, 0xDF, 0x0F, 0xFF, 0x07, 0xEF,
  0x8F, 0xBF, 0x03, 0xF7, 0xC7, 0xDF, 0x83, 0xFB, 0xE7, 0xEF, 0xC1, 0xF9,
  0xF3, 0xEF, 0xE0, 0xFC, 0xFB, 0xF7, 0xF0, 0x7E, 0x7D, 0xF3, 0xF0, 0x3F,
  0x3E, 0xF9, 0xF8, 0x3F, 0x9F, 0xF8, 0xFC, 0x1F, 0x8F, 0xFC, 0xFE, 0x0F,
  0xC7, 0xFC, 0x7F, 0x07, 0xE3, 0xFE, 0x3F, 0x03, 0xF1, 0xFE, 0x1F, 0x83,
  0xF8, 0xFF, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x3F, 0x87, 0xE0,
  0x7E, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xF0, 0x7F, 0xC0, 0x3F,
  0x07, 0xFC, 0x07, 0xF0, 0xFF, 0xE0, 0x7F, 0x0F, 0xFE, 0x07, 0xE0, 0xFF,
  0xE0, 0x7E, 0x0F, 0xFE, 0x07, 0xE1, 0xFF, 0xF0, 0xFE, 0x1F, 0xBF, 0x0F,
  0xE1, 0xFB, 0xF0, 0xFC, 0x1F, 0xBF, 0x8F, 0xC1, 0xF9, 0xF8, 0xFC, 0x3F,
  0x9F, 0x9F, 0xC3, 0xF1, 0xF9, 0xF8, 0x3F, 0x1F, 0xDF, 0x83, 0xF0, 0xFD,
  0xF8, 0x3F, 0x0F, 0xDF, 0x87, 0xF0, 0xFF, 0xF8, 0x7E, 0x0F, 0xFF, 0x07,
  0xE0, 0x7F, 0xF0, 0x7E, 0x07, 0xFF, 0x07, 0xE0, 0x7F, 0xF0, 0xFE, 0x03,
  0xFF, 0x0F, 0xC0, 0x3F, 0xE0, 0xFC, 0x03, 0xFE, 0x0F, 0xC0, 0x3F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFF, 0x3F, 0xC0, 0xFF,
  0x3F, 0xC0, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC,
  0xFF, 0x07, 0xFC, 0x7F, 0xDF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0x9F, 0xE0, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x7F, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0x7F,
  0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE,
  0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFF, 0x07, 0xFC,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0x81, 0xFC,
  0xFF, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x8F, 0xE0, 0xFF, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x1F, 0xC1, 0xC1, 0xFC, 0x04, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x88,
  0x07, 0xF8, 0xC0, 0x7F, 0x8F, 0xDF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x81,
  0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x81,
  0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0xFF, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x07,
  0xFB, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC1, 0xFE,
  0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F,
  0x9F, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0xC0, 0x7E, 0x7E,
  0x03, 0xF8, 0x1F, 0xCF, 0xC0, 0xFF, 0x03, 0xF9, 0xF8, 0x1F, 0xE0, 0xFE,
  0x3F, 0x07, 0xFC, 0x1F, 0xC7, 0xE0, 0xFF, 0x83, 0xF0, 0xFC, 0x3F, 0xF0,
  0xFE, 0x1F, 0x87, 0xFE, 0x1F, 0x83, 0xF0, 0xFF, 0xC7, 0xF0, 0x7E, 0x3E,
  0xF8, 0xFE, 0x0F, 0xC7, 0xDF, 0x1F, 0x81, 0xF9, 0xFB, 0xE7, 0xF0, 0x3F,
  0x3E, 0x7C, 0xFC, 0x07, 0xEF, 0xCF, 0x9F, 0x80, 0xFD, 0xF9, 0xF7, 0xE0,
  0x1F, 0xBE, 0x3E, 0xFC, 0x03, 0xFF, 0xC7, 0xDF, 0x80, 0x7F, 0xF0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80,
  0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0x7F,
  0x3F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0x1F,
  0xC3, 0xFC, 0x7F, 0x0F, 0xE0, 0xFC, 0x7F, 0x03, 0xF1, 0xFC, 0x0F, 0xEF,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE2, 0x03, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFC, 0x3F, 0x0F, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0,
  0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C,
  0x78, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0x3E, 0x7E,
  0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0x8F, 0xC3, 0xF0,
  0xF8, 0x3C, 0x01, 0xC0, 0x00, 0x7F, 0x3F, 0x1F, 0xFB, 0xF1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x9F, 0xE7, 0xF0, 0xFE, 0xFF, 0x0F,
  0xCF, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE7, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0xF0, 0x07, 0xEF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xF3, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8,
  0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0xCF, 0xE1, 0xFE, 0x7F, 0x0F, 0xE3,
  0xF8, 0x7F, 0x1F, 0xC7, 0xF8, 0xFE, 0x7F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xBF, 0xE1, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x03,
  0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF1, 0xFE, 0x09,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x11, 0xFE, 0x78, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0xF1, 0xFC, 0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFE, 0x7F, 0x87, 0xF0, 0xFE, 0x3F,
  0xC3, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0x83, 0xF8, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x00,
  0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF,
  0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7E, 0xFE, 0x3F, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x30, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xC4,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x7F, 0xEF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFE, 0x7F, 0x87, 0xF0, 0xFE, 0x3F, 0xC3,
  0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0x83, 0xF8, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xDF, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x30, 0x0F, 0xE0, 0xFD, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x78, 0x07, 0xEF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xF1, 0xFC,
  0x7F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xCF,
  0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF9, 0xFE, 0x1F,
  0xC0, 0x00, 0xE0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x01, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0xFF, 0x03, 0xF8,
  0xFF, 0x01, 0xFC, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFC, 0xFE, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF8,
  0x1F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x03, 0xE7, 0xF8,
  0xFF, 0x03, 0xF7, 0xFC, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0x8F, 0xF9, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x07, 0xF1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F,
  0x07, 0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x3E,
  0x7F, 0x83, 0xF7, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7,
  0xF0, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xCF, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0xDF, 0xE3, 0xFB, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFD, 0xFC,
  0x3F, 0xBF, 0x8F, 0xF7, 0xF3, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xBF, 0xC0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F,
  0xC7, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x87,
  0xFB, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xDF,
  0xE0, 0x7F, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x3F, 0x1F, 0xFB,
  0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x9F, 0xE7, 0xF0,
  0xFE, 0xFF, 0x0F, 0xCF, 0xE0, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE,
  0x1F, 0xCF, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE7, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xC1, 0xF3,
  0xE0, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0,
  0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFF,
  0x87, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFC, 0x70, 0xFE, 0x08, 0x7F,
  0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF9, 0x01, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF,
  0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x98, 0x7F, 0xF8, 0x7F,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x3F, 0x87, 0xF9, 0xFC, 0x3F,
  0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x87, 0xF1, 0xFC,
  0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE7, 0xF0, 0xFF, 0x3F, 0x87, 0xF1,
  0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x1F, 0xE3, 0xF9, 0xFE, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xF7, 0xE0, 0x7F, 0x3E, 0x00,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0xFE, 0x1F, 0xEF, 0xE1, 0xFC, 0xFE, 0x1F,
  0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x87, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xEF,
  0xE0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0xFC, 0x1F, 0xE1, 0xFF, 0xF8, 0x3F, 0xC3, 0xFB, 0xF0, 0xFF,
  0x8F, 0xE7, 0xE1, 0xFF, 0x1F, 0xCF, 0xC7, 0xFC, 0x7F, 0x1F, 0x8F, 0xF8,
  0xFE, 0x3F, 0x1E, 0xF1, 0xF8, 0x7E, 0x7D, 0xE7, 0xF0, 0xFC, 0xFB, 0xCF,
  0xC1, 0xF9, 0xE7, 0xBF, 0x83, 0xF7, 0xDF, 0x7E, 0x03, 0xEF, 0xBE, 0xFC,
  0x07, 0xDE, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0x80,
  0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x01,
  0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x83,
  0xFC, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x1F, 0xBF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF,
  0xF0, 0x1F, 0xE3, 0xF8, 0x1F, 0xE1, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F,
  0xE1, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF8, 0x07, 0xE7, 0xF0, 0x07,
  0xE7, 0xF0, 0x07, 0xEF, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xEF, 0xC0, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x7E, 0x01, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x08,
  0x00, 0x5F, 0xE0, 0x1F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xF8, 0x07, 0xF8,
};

const GFXglyph NotoSans_BlackItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 26, 11, 0, -26 },
  { 44, 16, 9, 17, 3, -26 },
  { 62, 25, 26, 24, 0, -26 },
  { 144, 20, 30, 21, 1, -28 },
  { 219, 32, 27, 34, 2, -27 },
  { 327, 27, 27, 27, 0, -27 },
  { 419, 8, 9, 9, 3, -26 },
  { 428, 15, 33, 14, 1, -27 },
  { 490, 15, 33, 14, -2, -27 },
  { 552, 18, 18, 20, 3, -28 },
  { 593, 18, 18, 22, 2, -22 },
  { 634, 10, 9, 11, -2, -4 },
  { 646, 12, 6, 12, 0, -13 },
  { 655, 8, 7, 11, 0, -7 },
  { 662, 22, 27, 17, -2, -27 },
  { 737, 20, 27, 21, 1, -27 },
  { 805, 17, 26, 21, 3, -26 },
  { 861, 21, 27, 21, -1, -27 },
  { 932, 20, 27, 21, 0, -27 },
  { 1000, 21, 26, 21, 0, -26 },
  { 1069, 21, 26, 21, 0, -26 },
  { 1138, 21, 27, 21, 1, -27 },
  { 1209, 22, 26, 21, 1, -26 },
  { 1281, 20, 27, 21, 1, -27 },
  { 1349, 19, 27, 21, 2, -27 },
  { 1414, 11, 21, 11, 0, -21 },
  { 1443, 13, 26, 11, -2, -21 },
  { 1486, 18, 21, 22, 2, -24 },
  { 1534, 18, 14, 22, 2, -20 },
  { 1566, 18, 21, 22, 2, -24 },
  { 1614, 16, 27, 18, 3, -27 },
  { 1668, 31, 30, 33, 1, -27 },
  { 1785, 25, 26, 25, -2, -26 },
  { 1867, 22, 26, 23, 1, -26 },
  { 1939, 23, 27, 23, 2, -27 },
  { 2017, 23, 26, 25, 1, -26 },
  { 2092, 21, 26, 21, 1, -26 },
  { 2161, 21, 26, 21, 1, -26 },
  { 2230, 23, 27, 26, 2, -27 },
  { 2308, 26, 26, 26, 1, -26 },
  { 2393, 19, 26, 16, -1, -26 },
  { 2455, 20, 34, 14, -6, -26 },
  { 2540, 26, 26, 25, 1, -26 },
  { 2625, 17, 26, 20, 1, -26 },
  { 2681, 33, 26, 34, 1, -26 },
  { 2789, 28, 26, 29, 1, -26 },
  { 2880, 24, 27, 27, 2, -27 },
  { 2961, 22, 26, 23, 1, -26 },
  { 3033, 24, 33, 27, 2, -27 },
  { 3132, 22, 26, 24, 1, -26 },
  { 3204, 20, 27, 20, 1, -27 },
  { 3272, 20, 26, 20, 3, -26 },
  { 3337, 24, 26, 26, 2, -26 },
  { 3415, 23, 26, 23, 3, -26 },
  { 3490, 35, 26, 35, 3, -26 },
  { 3604, 29, 26, 25, -2, -26 },
  { 3699, 22, 26, 22, 3, -26 },
  { 3771, 24, 26, 20, -2, -26 },
  { 3849, 17, 33, 13, -1, -27 },
  { 3920, 10, 27, 17, 4, -27 },
  { 3954, 16, 33, 13, -2, -27 },
  { 4020, 20, 17, 20, 0, -26 },
  { 4063, 18, 5, 17, -3, 2 },
  { 4075, 9, 6, 13, 5, -28 },
  { 4082, 20, 21, 22, 2, -21 },
  { 4135, 21, 28, 22, 0, -28 },
  { 4209, 17, 21, 19, 2, -21 },
  { 4254, 22, 28, 22, 2, -28 },
  { 4331, 19, 21, 21, 2, -21 },
  { 4381, 23, 37, 15, -4, -28 },
  { 4488, 22, 30, 22, 0, -21 },
  { 4571, 21, 28, 23, 0, -28 },
  { 4645, 13, 29, 12, 0, -29 },
  { 4693, 18, 38, 12, -5, -29 },
  { 4779, 25, 28, 23, 0, -28 },
  { 4867, 13, 28, 12, 0, -28 },
  { 4913, 33, 21, 34, 0, -21 },
  { 5000, 21, 21, 23, 0, -21 },
  { 5056, 19, 21, 22, 2, -21 },
  { 5106, 22, 30, 22, -1, -21 },
  { 5189, 20, 30, 22, 2, -21 },
  { 5264, 18, 21, 16, 0, -21 },
  { 5312, 17, 21, 19, 1, -21 },
  { 5357, 16, 25, 17, 1, -25 },
  { 5407, 21, 20, 23, 2, -20 },
  { 5460, 20, 20, 20, 2, -20 },
  { 5510, 31, 20, 30, 2, -20 },
  { 5588, 25, 20, 21, -2, -20 },
  { 5651, 24, 29, 20, -2, -20 },
  { 5738, 20, 20, 18, -1, -20 },
  { 5788, 16, 32, 13, 0, -26 },
  { 5852, 5, 36, 21, 8, -28 },
  { 5875, 16, 32, 13, -2, -26 },
  { 5939, 18, 7, 22, 2, -17 },
};

const GFXfont NotoSans_BlackItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_BLACKITALIC37PT7B_H_
