#ifndef _NOTOSANS_BLACKITALIC61PT7B_H_
#define _NOTOSANS_BLACKITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0xFF, 0xCF, 0xFC, 0x3F, 0xF3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC3, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7,
  0xCF, 0xE0, 0x7F, 0xF3, 0xE0, 0x60, 0x3F, 0xF3, 0xE0, 0x00, 0x1F, 0xF9,
  0xF0, 0x00, 0x0F, 0xFC, 0xF8, 0x00, 0x07, 0xFF, 0x7C, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3E, 0xFF, 0xE0,
  0x00, 0x1F, 0x3F, 0xF0, 0x00, 0x0F, 0x9F, 0xF8, 0x80, 0x07, 0xCF, 0xFC,
  0x70, 0x07, 0xC7, 0xFE, 0x3F, 0x03, 0xE7, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x1F,
  0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x7F, 0xC7, 0xFC, 0x0F, 0x80, 0xFF, 0x8F, 0xFC, 0x7F,
  0x87, 0xFF, 0x07, 0xFC, 0xFF, 0x8F, 0xF8, 0xFF, 0xF8, 0x7F, 0xFF, 0xF9,
  0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE3, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xCF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xCF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xF1, 0xFF, 0x1F, 0xF8, 0xFF,
  0x03, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF1,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xF0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xBF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0x00, 0xFF, 0x80,
  0x0F, 0x03, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFC,
  0x1E, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFC, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xF8, 0x00,
  0x7C, 0x1F, 0xE0, 0x00, 0xE0, 0x7F, 0xC0, 0x00, 0x81, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x03,
  0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF7, 0xFF, 0x1F, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x9F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x1F, 0xFE, 0x07, 0xFF, 0x1F, 0xFE,
  0x07, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x3F, 0xFC,
  0x07, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0x7F, 0xF8,
  0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0,
  0x1F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0,
  0x7F, 0xFC, 0xFF, 0xF0, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xF1,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xDF, 0xF8, 0x3F, 0xFB, 0xFF, 0x81, 0xFE,
  0x3F, 0xF8, 0x1F, 0xC3, 0xFF, 0x80, 0xF0, 0x7F, 0xF8, 0x0C, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0x80, 0xFF, 0xF0, 0x01, 0xC0, 0x0F,
  0xFE, 0x00, 0x10, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x83, 0xFF, 0xF0,
  0x07, 0x80, 0x3F, 0xFC, 0x00, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x80, 0x00, 0x1F,
  0xFE, 0x38, 0x00, 0x0F, 0xFF, 0x8F, 0x80, 0x07, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0xC0,
  0x01, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x1F, 0xF9, 0xFF,
  0xC0, 0x03, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0xE1, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFD,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x00,
  0x3F, 0xFC, 0x30, 0x00, 0x1F, 0xFF, 0x0F, 0x80, 0x0F, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x40, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF1,
  0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xFC, 0x03, 0xFF,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0x81, 0xFF,
  0xE3, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x07,
  0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xE7, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x8F, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x9F, 0xFF, 0x07, 0xFF, 0x87,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0,
  0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xF0,
  0x07, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFC, 0x7F, 0xF9, 0xFF, 0xF0, 0x7F, 0xF3, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF,
  0x81, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xBF, 0xF8, 0x7F, 0xFE, 0x7F, 0xE0, 0x7F, 0xF9, 0xFF,
  0xC0, 0x7F, 0xE3, 0xFF, 0x80, 0x0E, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC2,
  0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xE0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFE, 0x0F, 0xFF, 0x0F, 0x00, 0xFF, 0xF0, 0xC0, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x1F, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFF, 0xF8, 0x7F, 0x83,
  0xFC, 0x07, 0xFF, 0xFF, 0x8F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF,
  0x1F, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xFF, 0xFF, 0x83,
  0xFC, 0xFF, 0x03, 0xFF, 0x0F, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x83, 0xFC,
  0x0F, 0xF7, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xDF, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xFB, 0xFC, 0x3F, 0xE0,
  0x7F, 0x80, 0xFE, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x3F, 0xCF, 0xE0, 0xFF,
  0x01, 0xFE, 0x07, 0xFB, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x7F, 0x87,
  0xFC, 0x0F, 0xF0, 0x3F, 0xCF, 0xF0, 0xFF, 0x81, 0xFE, 0x07, 0xF9, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xF8, 0x7F, 0xC3,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x87, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xFF, 0xDF, 0xFF,
  0xC0, 0x3F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF8, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF,
  0x81, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x00,
  0x03, 0xFF, 0x87, 0xFE, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF,
  0xC1, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x01, 0xFF,
  0xDF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFB, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x7C, 0x03, 0xFF, 0xF0, 0x00, 0x70, 0x1F, 0xFF, 0x80, 0x00,
  0x80, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x04, 0x01,
  0xFF, 0xF0, 0x00, 0xE0, 0x07, 0xFF, 0xF0, 0x1F, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0x83, 0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x07,
  0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFF, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x7F, 0xE0, 0x1F,
  0xFF, 0xC0, 0x07, 0x80, 0x7F, 0xFF, 0x00, 0x03, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xFF, 0xC7,
  0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFC, 0x0F,
  0xFF, 0xFC, 0x7F, 0xF8, 0x1F, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xFF, 0xF1,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x01, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE1,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC7, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x80,
  0x00, 0x3F, 0xFD, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x00,
  0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFB, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0xE0, 0x07,
  0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x07, 0xF9, 0xFF,
  0x80, 0x3F, 0xF7, 0xFC, 0x1F, 0xF7, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x3F,
  0xCF, 0xFC, 0x00, 0xFF, 0xDF, 0xF0, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xBF,
  0xE1, 0xFE, 0x3F, 0xF0, 0x07, 0xFF, 0x7F, 0xC7, 0xFC, 0xFF, 0xE0, 0x0F,
  0xFC, 0xFF, 0x8F, 0xF9, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x1F, 0xE3, 0xFF,
  0x00, 0x3F, 0xF3, 0xFE, 0x7F, 0xC7, 0xFE, 0x00, 0xFF, 0xE7, 0xFC, 0xFF,
  0x1F, 0xFC, 0x01, 0xFF, 0xCF, 0xFB, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x1F,
  0xF7, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xFF, 0x87, 0xFF,
  0x00, 0x7F, 0xF1, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0xFC,
  0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x0F,
  0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F,
  0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xF0,
  0x1F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x03,
  0xFF, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF0, 0x03,
  0xFE, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xF0, 0x07,
  0xFE, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0x07,
  0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F,
  0xFE, 0x1F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0xFF, 0xC0, 0x0F,
  0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFD, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xF8,
  0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xC3,
  0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F,
  0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0x80,
  0x7F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFE, 0xFF,
  0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0x00, 0xFF, 0xF0, 0x01, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC1, 0x00, 0x01, 0xFF, 0xE0, 0xC0, 0x00, 0xFF, 0xF0,
  0x7C, 0x00, 0x7F, 0xF8, 0x3F, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x07,
  0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x01, 0xFF, 0xF7,
  0xFF, 0x00, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xFE, 0x7F, 0xF0, 0x00,
  0xFF, 0xF1, 0xFF, 0xC0, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFE, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F,
  0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0xFF,
  0x8F, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0xC0,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xEF,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF3, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x7F,
  0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0x83, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x3F, 0xEF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xF8,
  0x07, 0xFE, 0x1F, 0xF3, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xF9, 0xFE,
  0x1F, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC7,
  0xFC, 0x7F, 0x8F, 0xFE, 0x00, 0x7F, 0xE3, 0xFE, 0x3F, 0xC7, 0xFE, 0x00,
  0x3F, 0xF3, 0xFE, 0x1F, 0xE3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x0F, 0xF3,
  0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x87, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0x83, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xBF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xBF, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0xC7, 0xFF, 0x80,
  0x3F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x01, 0xFF,
  0xC7, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x80,
  0x01, 0xFF, 0xBF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xEF, 0xF0, 0x00,
  0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x87, 0xF0, 0x01,
  0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x1F,
  0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x7F,
  0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0,
  0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xFB, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xE3,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC,
  0x07, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xE1, 0xFF,
  0xE0, 0x3F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x87,
  0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x3F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xCF, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x3F, 0xFB, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xE0, 0x7F, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF,
  0x80, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE, 0x1F,
  0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF8,
  0x7F, 0xF0, 0x1F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFE, 0x03, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFD,
  0xFF, 0xFE, 0x03, 0xFF, 0x3F, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0x80, 0x3F,
  0xE0, 0xFF, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0x0E, 0x07, 0xFF, 0x80, 0x10,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x20, 0x7F,
  0xF8, 0x0F, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0xE7, 0xFF,
  0x00, 0x3F, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xFC, 0x3F,
  0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x7F, 0xE0, 0x00, 0xFF, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xDF,
  0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x1F, 0xFE, 0x07, 0xFF, 0x1F, 0xFE, 0x07,
  0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x3F, 0xF8, 0x3F,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x20, 0x7F, 0xF8, 0x00, 0xE0, 0x7F, 0xFC, 0x03,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC2, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0xF9,
  0xFF, 0x80, 0x7F, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x07,
  0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x07, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xF8,
  0x00, 0x3F, 0x8F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x01, 0x00, 0x01, 0xFF, 0xC0, 0x38, 0x00,
  0x7F, 0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC7, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x3F,
  0xFB, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC0,
  0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE,
  0x03, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F,
  0xF0, 0x1F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xC3,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF,
  0x1F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F,
  0xF8, 0x7F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x01,
  0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x07,
  0xFF, 0x87, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00,
  0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0xF8,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0xF8, 0x07,
  0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0xF9, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8,
  0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x87,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xC3, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC7, 0xFF, 0x80, 0x3F, 0xF3,
  0xFF, 0xF0, 0x0F, 0xFD, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x03,
  0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF0,
  0x1F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0x1F,
  0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF8,
  0x7F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x01, 0xFF,
  0xC3, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0x9F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC7,
  0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xE0, 0x3F, 0xFD,
  0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFF,
  0x3F, 0xFC, 0x07, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0xCF, 0xFE, 0x01, 0xFF,
  0xEF, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xC0, 0x7F,
  0xF8, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x7F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xF8,
  0x00, 0x1F, 0xFB, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x87,
  0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF7,
  0xFF, 0xF0, 0x03, 0xFF, 0xBF, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00,
  0xFF, 0xE1, 0xFE, 0x00, 0x07, 0xFF, 0x03, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xFE, 0x1F, 0xF0, 0x0F,
  0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xFB, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x01,
  0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF8,
  0x0F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x0F,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF,
  0x3F, 0xF8, 0x00, 0x06, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xF0, 0x1F,
  0xF1, 0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F,
  0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE,
  0x07, 0xC1, 0xFF, 0xE0, 0x18, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC8, 0x00, 0x3F, 0xF8, 0xC0, 0x03, 0xFF, 0x8F, 0x80, 0x7F,
  0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x40, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xE0, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0x87,
  0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFE,
  0x1F, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F,
  0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFE, 0x03,
  0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8,
  0x1F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC3, 0xFF,
  0xC0, 0x7F, 0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFB,
  0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xE0, 0x03, 0xFF,
  0x0F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xFB, 0xFF, 0x80, 0x3F, 0xFC,
  0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x8F, 0xFE, 0x01, 0xFF,
  0xC1, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0xFF,
  0xCF, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0xC0, 0x03,
  0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xCF, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0x81,
  0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0xFE, 0xFF, 0x0F, 0xFC,
  0x07, 0xFE, 0x3F, 0xDF, 0xE3, 0xFF, 0x80, 0xFF, 0xC7, 0xFB, 0xF8, 0x7F,
  0xE0, 0x1F, 0xF8, 0xFE, 0x7F, 0x1F, 0xFC, 0x03, 0xFF, 0x3F, 0xCF, 0xE3,
  0xFF, 0x00, 0x7F, 0xE7, 0xF9, 0xFC, 0xFF, 0xE0, 0x0F, 0xFC, 0xFE, 0x3F,
  0x9F, 0xF8, 0x01, 0xFF, 0xBF, 0xC7, 0xF3, 0xFF, 0x00, 0x3F, 0xF7, 0xF9,
  0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFE, 0x3F, 0xDF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC7, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC1, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x7F,
  0xFB, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF9, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x87, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00,
  0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x0F, 0xFE,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xFE,
  0x00, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00,
  0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x0F, 0xFD,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x04, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFB, 0x00, 0x0F, 0xFF, 0xC8, 0x00, 0x07, 0xFC, 0x00,
};

const GFXglyph NotoSans_BlackItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 21, 45, 19, 0, -44 },
  { 120, 26, 16, 28, 5, -44 },
  { 172, 40, 44, 39, 0, -44 },
  { 392, 33, 50, 35, 2, -46 },
  { 599, 52, 45, 57, 3, -44 },
  { 892, 44, 45, 45, 0, -44 },
  { 1140, 13, 16, 15, 5, -44 },
  { 1166, 25, 55, 23, 2, -45 },
  { 1338, 25, 55, 23, -4, -45 },
  { 1510, 30, 31, 33, 5, -47 },
  { 1627, 30, 29, 36, 3, -36 },
  { 1736, 16, 15, 19, -3, -7 },
  { 1766, 18, 9, 20, 1, -21 },
  { 1787, 13, 12, 19, 0, -11 },
  { 1807, 36, 45, 28, -3, -44 },
  { 2010, 32, 45, 35, 2, -44 },
  { 2190, 28, 44, 35, 4, -44 },
  { 2344, 35, 44, 35, -2, -44 },
  { 2537, 34, 45, 35, 0, -44 },
  { 2729, 35, 44, 35, 0, -44 },
  { 2922, 34, 45, 35, 1, -44 },
  { 3114, 34, 45, 35, 2, -44 },
  { 3306, 37, 44, 35, 1, -44 },
  { 3510, 33, 45, 35, 1, -44 },
  { 3696, 31, 45, 35, 3, -44 },
  { 3871, 18, 35, 19, 0, -34 },
  { 3950, 21, 42, 19, -3, -34 },
  { 4061, 30, 34, 36, 3, -39 },
  { 4189, 30, 21, 36, 3, -32 },
  { 4268, 30, 34, 36, 3, -39 },
  { 4396, 28, 45, 30, 4, -44 },
  { 4554, 51, 50, 55, 2, -44 },
  { 4873, 41, 44, 41, -4, -44 },
  { 5099, 37, 44, 39, 1, -44 },
  { 5303, 38, 45, 38, 3, -44 },
  { 5517, 39, 44, 42, 1, -44 },
  { 5732, 35, 44, 34, 1, -44 },
  { 5925, 35, 44, 35, 1, -44 },
  { 6118, 39, 45, 43, 3, -44 },
  { 6338, 43, 44, 44, 1, -44 },
  { 6575, 31, 44, 26, -2, -44 },
  { 6746, 33, 58, 23, -10, -44 },
  { 6986, 44, 44, 41, 1, -44 },
  { 7228, 28, 44, 32, 1, -44 },
  { 7382, 55, 44, 55, 1, -44 },
  { 7685, 48, 44, 48, 1, -44 },
  { 7949, 40, 45, 45, 3, -44 },
  { 8174, 36, 44, 38, 1, -44 },
  { 8372, 40, 54, 45, 3, -44 },
  { 8642, 36, 44, 40, 1, -44 },
  { 8840, 33, 45, 33, 1, -44 },
  { 9026, 32, 44, 34, 5, -44 },
  { 9202, 39, 45, 43, 4, -44 },
  { 9422, 38, 44, 38, 4, -44 },
  { 9631, 57, 44, 57, 5, -44 },
  { 9945, 49, 44, 40, -4, -44 },
  { 10215, 37, 44, 37, 5, -44 },
  { 10419, 39, 44, 33, -3, -44 },
  { 10634, 28, 55, 22, -2, -45 },
  { 10827, 16, 45, 28, 7, -44 },
  { 10917, 27, 55, 22, -4, -45 },
  { 11103, 32, 29, 33, 0, -44 },
  { 11219, 29, 7, 27, -5, 4 },
  { 11245, 14, 10, 22, 9, -47 },
  { 11263, 34, 35, 37, 2, -34 },
  { 11412, 34, 47, 37, 1, -46 },
  { 11612, 29, 35, 31, 2, -34 },
  { 11739, 37, 47, 37, 2, -46 },
  { 11957, 32, 35, 35, 2, -34 },
  { 12097, 37, 62, 25, -6, -47 },
  { 12384, 35, 49, 37, 1, -34 },
  { 12599, 34, 46, 38, 1, -46 },
  { 12795, 21, 47, 20, 1, -47 },
  { 12919, 30, 62, 20, -8, -47 },
  { 13152, 40, 46, 38, 1, -46 },
  { 13382, 21, 46, 20, 1, -46 },
  { 13503, 53, 34, 56, 1, -34 },
  { 13729, 34, 34, 38, 1, -34 },
  { 13874, 33, 35, 37, 2, -34 },
  { 14019, 37, 49, 37, -2, -34 },
  { 14246, 34, 49, 37, 2, -34 },
  { 14455, 28, 34, 27, 1, -34 },
  { 14574, 28, 35, 31, 1, -34 },
  { 14697, 26, 42, 28, 2, -41 },
  { 14834, 34, 35, 38, 3, -34 },
  { 14983, 34, 34, 33, 3, -34 },
  { 15128, 51, 34, 50, 3, -34 },
  { 15345, 42, 34, 35, -4, -34 },
  { 15524, 41, 49, 33, -4, -34 },
  { 15776, 32, 34, 30, -1, -34 },
  { 15912, 26, 54, 22, 0, -44 },
  { 16088, 8, 60, 35, 13, -46 },
  { 16148, 26, 54, 22, -4, -44 },
  { 16324, 30, 11, 36, 3, -27 },
};

const GFXfont NotoSans_BlackItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_BLACKITALIC61PT7B_H_
