#ifndef _NOTOSANS_BLACKITALIC23PT7B_H_
#define _NOTOSANS_BLACKITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x00,
  0x00, 0x70, 0xF8, 0xF8, 0xF0, 0x7B, 0xDC, 0xEF, 0x7B, 0xDC, 0xE7, 0x39,
  0xC0, 0x03, 0x9C, 0x07, 0x70, 0x1C, 0xE0, 0x39, 0xC3, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0x87, 0x38, 0x1E, 0xE1, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE3,
  0x9C, 0x07, 0x38, 0x0E, 0x70, 0x3D, 0xC0, 0x01, 0x80, 0xFE, 0x3F, 0xF3,
  0xFF, 0x7F, 0x27, 0xB0, 0x7F, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0,
  0x5E, 0xCD, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0x08, 0x01, 0x80, 0x0E, 0x00,
  0x43, 0xF0, 0x38, 0x7F, 0x87, 0x07, 0x38, 0xF0, 0x73, 0x8E, 0x0F, 0x79,
  0xC0, 0xF7, 0xB8, 0x0F, 0x77, 0xBC, 0x7F, 0x77, 0xE7, 0xEE, 0xFF, 0x19,
  0xCE, 0x70, 0x3C, 0xE7, 0x03, 0x9E, 0xF0, 0x71, 0xEE, 0x0E, 0x1F, 0xE1,
  0xE0, 0xFC, 0x3C, 0x07, 0x80, 0x01, 0xC0, 0x03, 0xF8, 0x03, 0xFE, 0x03,
  0xEF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x1F, 0xCF,
  0xBF, 0xE7, 0x9F, 0xFF, 0xDF, 0x3F, 0xCF, 0x9F, 0xC7, 0xC7, 0xE3, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xBE, 0x00, 0x7B, 0xBD, 0xEE, 0x70, 0x07, 0x87,
  0x87, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x80, 0x07, 0x01,
  0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x00, 0x04, 0x00, 0xE2, 0x1C, 0x77, 0x0F, 0xE3, 0xFF, 0xC7, 0xF9, 0xF7,
  0x7F, 0x1E, 0xE0, 0x9E, 0x01, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0xF7,
  0x9E, 0xF3, 0x80, 0x7E, 0xFF, 0xFF, 0xE0, 0x77, 0xFF, 0xE0, 0x00, 0x78,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0xFC, 0x1F, 0xE3, 0xFF, 0x7D, 0xF7, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF1, 0xFF, 0x1F, 0xF1, 0xEF, 0x1E, 0xF3, 0xEF, 0x7C, 0xFF,
  0xC7, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xF3, 0xFF, 0xFE, 0xFF, 0x99, 0xE4,
  0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8,
  0x01, 0xC0, 0x1F, 0xC1, 0xFF, 0x87, 0xFE, 0x0E, 0x7C, 0x11, 0xE0, 0x07,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF,
  0xC7, 0xFF, 0x1F, 0xFC, 0xFF, 0xF0, 0x03, 0x80, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0x8F, 0x80, 0x78, 0x07, 0xC1, 0xFC, 0x0F, 0x80, 0xFF, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x61, 0xFB, 0xFF, 0x9F, 0xF8, 0xFF, 0x80, 0x00, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7F, 0x07, 0xF8, 0x7B, 0xC7, 0xBC, 0x39,
  0xE3, 0x8F, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x3C, 0x01, 0xE0, 0x1F, 0xC0, 0xFF, 0x87,
  0xFC, 0x3F, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xEC, 0x3F, 0x7F, 0xF3, 0xFF,
  0x0F, 0xF0, 0x01, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xE3, 0xC0, 0x3C, 0x01,
  0xEF, 0x1E, 0xFC, 0xFF, 0xE7, 0xFF, 0x3E, 0x79, 0xE3, 0xCF, 0x1E, 0x7D,
  0xF1, 0xFF, 0x0F, 0xF8, 0x3F, 0x00, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0,
  0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0x81,
  0xFE, 0x3F, 0xF3, 0xFF, 0x3C, 0xF3, 0xCF, 0x3D, 0xE3, 0xFC, 0x1F, 0x87,
  0xFC, 0xFB, 0xEF, 0x1E, 0xF1, 0xEF, 0x3E, 0xFF, 0xCF, 0xFC, 0x3F, 0x80,
  0x07, 0x01, 0xFC, 0x3F, 0xE7, 0xFE, 0x79, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F,
  0xFF, 0xF7, 0xFE, 0x7F, 0xE1, 0x9E, 0x03, 0xC8, 0xFC, 0xFF, 0x8F, 0xF0,
  0xFC, 0x00, 0x1C, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xE7,
  0xCF, 0x00, 0x0E, 0x1F, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0x00, 0x20, 0x0C, 0x07, 0x83, 0xF1,
  0xFC, 0xFC, 0x3E, 0x07, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0x80, 0x70, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x18, 0x03, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x3F, 0x1F, 0xDF,
  0xE3, 0xF0, 0x70, 0x08, 0x00, 0x1E, 0x3F, 0xEF, 0xFD, 0xFF, 0x43, 0xC1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x0F, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x03,
  0xE3, 0xC0, 0x1C, 0xF1, 0xF9, 0xDC, 0xFF, 0x3F, 0x9C, 0xE7, 0xE7, 0x1C,
  0xFC, 0xE7, 0x1F, 0xBC, 0xE7, 0x77, 0x9C, 0xEE, 0x7F, 0xF9, 0xCF, 0xBE,
  0x3C, 0xE3, 0x03, 0xC0, 0x20, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF7,
  0x83, 0xEF, 0x07, 0x9E, 0x1F, 0x3C, 0x3F, 0xF8, 0xFF, 0xF9, 0xFF, 0xF7,
  0xFF, 0xEF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0x0F, 0xF8, 0x7F, 0xF1, 0xFF,
  0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xF3, 0xFF, 0x8F, 0xF8, 0x3F, 0xF0, 0xF3,
  0xE3, 0xC7, 0x9F, 0x3E, 0x7D, 0xF9, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0x01,
  0xE0, 0x1F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3E, 0x19, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF3, 0x87,
  0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0xF1,
  0xF1, 0xE3, 0xE3, 0xC3, 0xCF, 0x87, 0x9F, 0x1F, 0x3C, 0x3E, 0x78, 0x7C,
  0xF1, 0xF3, 0xE3, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F,
  0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xFF, 0x0F,
  0xFC, 0x3F, 0xE0, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7F, 0xE1, 0xFF, 0x87,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xE3, 0xF0, 0x8F, 0x80, 0x1F, 0x00, 0x3C, 0xFE, 0xF9, 0xFD,
  0xF3, 0xFB, 0xEF, 0xE7, 0xC3, 0xCF, 0x87, 0x8F, 0x9F, 0x1F, 0xFE, 0x1F,
  0xF8, 0x1F, 0xF0, 0x0F, 0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xC3, 0xC3, 0xE1,
  0xE1, 0xE0, 0xF0, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1E, 0x1E,
  0x0F, 0x0F, 0x0F, 0x87, 0x87, 0xC7, 0xC3, 0xC3, 0xE1, 0xE1, 0xE1, 0xF0,
  0xF0, 0x1F, 0xF1, 0xFF, 0x0F, 0xE0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x07, 0xF8, 0xFF, 0x8F,
  0xF8, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x84, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0xC0, 0x00,
  0x0F, 0x1F, 0x8F, 0x9F, 0x87, 0xCF, 0x83, 0xCF, 0x81, 0xEF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0x7C, 0x0F,
  0x9E, 0x07, 0x8F, 0x83, 0xC7, 0xC1, 0xE1, 0xE1, 0xF0, 0xF8, 0x0F, 0x03,
  0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0xFE, 0xFF, 0xDF, 0xF7, 0xFE, 0x0F, 0xC1, 0xF8, 0xFE,
  0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xDC, 0x7F, 0x0E, 0xE7, 0xF8,
  0xF7, 0x3B, 0xC7, 0xBB, 0xFC, 0x3D, 0xDD, 0xE1, 0xEE, 0xEF, 0x0E, 0x7E,
  0x78, 0xF3, 0xF3, 0x87, 0x9F, 0x3C, 0x3C, 0xF9, 0xE1, 0xE7, 0x8F, 0x1E,
  0x3C, 0x78, 0x0F, 0x83, 0xC7, 0xF0, 0xF1, 0xFC, 0x3C, 0x7F, 0x0E, 0x1F,
  0xC7, 0x87, 0x79, 0xE3, 0xDE, 0x78, 0xF7, 0x9E, 0x3C, 0xF7, 0x0F, 0x3F,
  0xC3, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0x7F, 0x1E, 0x1F, 0x87, 0x87, 0xE3,
  0xC0, 0xF8, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xE3, 0xEF,
  0x83, 0xDF, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xEF, 0x87, 0xCF, 0x9F, 0x1F, 0xFE, 0x1F, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0,
  0x7F, 0xE1, 0xFF, 0xC7, 0x9F, 0x1E, 0x3C, 0x78, 0xF3, 0xE7, 0xCF, 0xFE,
  0x3F, 0xF8, 0xFF, 0x83, 0xF0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE3, 0xEF,
  0x83, 0xDF, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xEF, 0x87, 0xCF, 0xBF, 0x1F, 0xFE, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7,
  0x9F, 0x1E, 0x3C, 0x79, 0xF3, 0xEF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x83,
  0xDE, 0x1F, 0x7C, 0x7C, 0xF1, 0xE3, 0xE7, 0x8F, 0xBE, 0x1F, 0x03, 0xC0,
  0x7F, 0xC7, 0xFC, 0x3F, 0xE3, 0xE2, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC8, 0x1E, 0x79, 0xF3, 0xFF, 0x1F, 0xF8,
  0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x1E, 0x1E, 0x7C, 0x7C, 0xF8, 0xF9, 0xE1, 0xE3, 0xC3, 0xCF,
  0x87, 0x9F, 0x1F, 0x3C, 0x3E, 0x78, 0x78, 0xF0, 0xF3, 0xE1, 0xE7, 0xC7,
  0xC7, 0xDF, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xE0, 0xF0, 0x7F, 0xC3, 0xEF,
  0x0F, 0x3C, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x3C, 0xF0, 0xF7, 0x83,
  0xDE, 0x0F, 0x70, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xF0, 0xF8, 0x7F, 0x87, 0xC7, 0xFC, 0x7E, 0x3D, 0xE3, 0xF1, 0xEF, 0x1F,
  0x9E, 0x79, 0xFC, 0xF3, 0xCF, 0xEF, 0x1E, 0xFF, 0x78, 0xF7, 0x7B, 0xC7,
  0xFB, 0xBC, 0x3F, 0x9D, 0xE1, 0xFC, 0xEE, 0x0F, 0xE7, 0xF0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC3, 0xE3, 0xE0, 0xF9,
  0xF0, 0x1E, 0xF8, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7D, 0xE0, 0x3E, 0x7C, 0x1F,
  0x1F, 0x07, 0xC3, 0xC3, 0xE0, 0xF8, 0xF8, 0xFF, 0xE3, 0xC7, 0x9F, 0x1E,
  0x78, 0x7B, 0xC1, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0xFE,
  0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xFF, 0x1F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF8, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0x80, 0xE0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xF8, 0x3F, 0x0F, 0xC0, 0xF0, 0xE1, 0xC3,
  0x87, 0x8F, 0x1E, 0x1C, 0x38, 0x70, 0xF1, 0xE3, 0xC3, 0x87, 0x0E, 0x1E,
  0x07, 0xE0, 0xFC, 0x3F, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01,
  0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0x03, 0x80, 0x3C, 0x07, 0xC0, 0xFC, 0x0F,
  0xC1, 0xCE, 0x3C, 0xE3, 0x8E, 0x70, 0x7F, 0x07, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0xF9, 0xE3, 0x87, 0x0E, 0x79, 0xFB, 0x8F, 0xFC, 0xFF, 0xE7, 0x9F,
  0x7C, 0x7B, 0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0xDF, 0x3F, 0xF8, 0xFF, 0x87,
  0xDC, 0x00, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xEE, 0x0F, 0xF8,
  0xFF, 0xE7, 0xFF, 0x3C, 0x79, 0xE3, 0xCF, 0x3E, 0xF1, 0xF7, 0x8F, 0x3E,
  0xF9, 0xFF, 0x8F, 0xFC, 0xF7, 0xC0, 0x0F, 0xC3, 0xFC, 0xFF, 0x3F, 0xE7,
  0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x33, 0xFE, 0x3F, 0xC3, 0xF0,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0E, 0xF8, 0xFF, 0xC3, 0xFF,
  0x1F, 0xFC, 0x79, 0xF3, 0xE3, 0xCF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xEF,
  0x8F, 0xFE, 0x1F, 0xF0, 0x7D, 0xC0, 0x07, 0xC1, 0xFE, 0x3F, 0xF7, 0xCF,
  0x78, 0xFF, 0xBE, 0xFF, 0xEF, 0xF8, 0xF0, 0x0F, 0x84, 0xFF, 0xC7, 0xFC,
  0x3F, 0x80, 0x00, 0x70, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xC0, 0x1F,
  0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x10, 0x00, 0x07, 0x3C, 0x7E, 0xE1,
  0xFF, 0x8F, 0xFE, 0x3C, 0xF9, 0xF1, 0xE7, 0xCF, 0x1E, 0x3C, 0x78, 0xF1,
  0xF7, 0xC7, 0xFF, 0x0F, 0xF8, 0x3D, 0xE0, 0x07, 0x88, 0x3E, 0x3F, 0xF0,
  0xFF, 0x83, 0xFC, 0x00, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C,
  0x01, 0xEF, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3E, 0x79, 0xE3, 0xCF, 0x1E,
  0xF9, 0xF7, 0xCF, 0x3C, 0x79, 0xE3, 0xCF, 0x3E, 0xF9, 0xF0, 0x0F, 0x0F,
  0x1F, 0x0E, 0x00, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C,
  0x78, 0x78, 0x78, 0xF8, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x0F, 0xE1, 0xF8, 0x3F, 0x01,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE3, 0xE3, 0xCF,
  0x8F, 0x9E, 0x1F, 0x78, 0x3D, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0x07,
  0xFE, 0x0F, 0x3C, 0x1E, 0x7C, 0x3C, 0x78, 0xF8, 0xF8, 0x0F, 0x0F, 0x1F,
  0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0x78,
  0x78, 0xF8, 0x1C, 0xF1, 0xE1, 0xDF, 0xBF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3E, 0x7C, 0xF3, 0xC7, 0x8F, 0x3C, 0x78, 0xF7, 0xCF, 0x9F, 0x7C, 0xF9,
  0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0xF9, 0xF3, 0xE0, 0x1C,
  0xF0, 0xEF, 0xCF, 0xFE, 0x7F, 0xF3, 0xE7, 0x9E, 0x3C, 0xF1, 0xEF, 0x9F,
  0x7C, 0xF3, 0xC7, 0x9E, 0x3C, 0xF3, 0xEF, 0x9F, 0x00, 0x07, 0xC1, 0xFE,
  0x3F, 0xF7, 0xDF, 0x78, 0xFF, 0x8F, 0xF9, 0xFF, 0x1F, 0xF1, 0xEF, 0xBE,
  0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x0E, 0x70, 0x3B, 0xE1, 0xFF, 0xC7, 0xFF,
  0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0xCF, 0x1F, 0x3C, 0x78, 0xFB, 0xE3, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0x0E, 0x79, 0xFB, 0x8F, 0xFC, 0xFF, 0xE7, 0x9F, 0x7C,
  0x7B, 0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0xDF, 0x3F, 0xF8, 0xFF, 0x87, 0xBC,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1C, 0xE3,
  0xBC, 0xFF, 0x9F, 0xE3, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x80, 0x0F, 0xC7, 0xFC, 0xFF, 0x1E, 0x23, 0xE0, 0x7E,
  0x0F, 0xE0, 0x7E, 0x07, 0xD0, 0x7B, 0xFF, 0x7F, 0xCF, 0xF0, 0x0E, 0x07,
  0x83, 0xFF, 0xFE, 0xFF, 0xBF, 0xE7, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83,
  0xE4, 0xFE, 0x3F, 0x87, 0xE0, 0x3C, 0x79, 0xE7, 0xDF, 0x3E, 0xF1, 0xE7,
  0x8F, 0x3C, 0x7B, 0xE7, 0xDF, 0x3E, 0xF1, 0xE7, 0xDF, 0x3F, 0xF9, 0xFF,
  0xC7, 0xDC, 0x00, 0xF0, 0xFF, 0x87, 0xBC, 0x7D, 0xE3, 0xC7, 0x3E, 0x3D,
  0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xC0,
  0x00, 0xF1, 0xF1, 0xFE, 0x3E, 0x7F, 0xCF, 0xCF, 0x79, 0xF9, 0xEF, 0x3F,
  0x79, 0xEE, 0xEF, 0x1D, 0xDF, 0xC3, 0xBB, 0xF8, 0x7E, 0x6E, 0x0F, 0xCF,
  0xC1, 0xF1, 0xF0, 0x3E, 0x7E, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x3E, 0x7C,
  0x7D, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0xF7, 0xC3, 0xE7, 0x8F, 0x8F, 0x80, 0x3C, 0x3E, 0x78,
  0x78, 0xF1, 0xF1, 0xF3, 0xC1, 0xEF, 0x83, 0xDE, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0x00, 0x00, 0x3F, 0xF3, 0xFE,
  0x3F, 0xE3, 0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0xFF, 0xCF, 0xF8, 0xFF, 0x80, 0x07, 0xC3, 0xE0, 0xF8, 0x38, 0x0E, 0x07,
  0x81, 0xE0, 0xF8, 0xFC, 0x3C, 0x0F, 0x81, 0xE0, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1E,
  0x0F, 0x83, 0xC7, 0xE3, 0xC3, 0xC1, 0xE0, 0xE0, 0x70, 0xF8, 0x7C, 0x3C,
  0x18, 0x00, 0x7C, 0x3F, 0xFF, 0xFF, 0xC1, 0xF0,
};

const GFXglyph NotoSans_BlackItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 16, 7, 0, -16 },
  { 17, 10, 6, 10, 2, -16 },
  { 25, 15, 16, 15, 0, -16 },
  { 55, 12, 18, 13, 1, -17 },
  { 82, 20, 17, 21, 1, -17 },
  { 125, 17, 17, 17, 0, -17 },
  { 162, 5, 6, 5, 2, -16 },
  { 166, 9, 21, 9, 1, -17 },
  { 190, 10, 21, 9, -2, -17 },
  { 217, 11, 12, 12, 2, -18 },
  { 234, 11, 11, 13, 1, -14 },
  { 250, 6, 6, 7, -1, -3 },
  { 255, 7, 4, 8, 0, -8 },
  { 259, 5, 4, 7, 0, -4 },
  { 262, 13, 17, 11, -1, -17 },
  { 290, 12, 17, 13, 1, -17 },
  { 316, 10, 16, 13, 2, -16 },
  { 336, 14, 17, 13, -1, -17 },
  { 366, 13, 17, 13, 0, -17 },
  { 394, 13, 16, 13, 0, -16 },
  { 420, 13, 16, 13, 0, -16 },
  { 446, 13, 17, 13, 1, -17 },
  { 474, 14, 16, 13, 0, -16 },
  { 502, 12, 17, 13, 1, -17 },
  { 528, 12, 17, 13, 1, -17 },
  { 554, 7, 13, 7, 0, -13 },
  { 566, 8, 16, 7, -1, -13 },
  { 582, 11, 13, 13, 1, -15 },
  { 600, 11, 8, 13, 1, -12 },
  { 611, 11, 13, 13, 1, -15 },
  { 629, 10, 17, 11, 2, -17 },
  { 651, 19, 19, 21, 1, -17 },
  { 697, 15, 16, 16, -1, -16 },
  { 727, 14, 16, 15, 0, -16 },
  { 755, 14, 17, 14, 1, -17 },
  { 785, 15, 16, 16, 0, -16 },
  { 815, 14, 16, 13, 0, -16 },
  { 843, 14, 16, 13, 0, -16 },
  { 871, 15, 17, 16, 1, -17 },
  { 903, 17, 16, 16, 0, -16 },
  { 937, 12, 16, 10, -1, -16 },
  { 961, 13, 21, 9, -4, -16 },
  { 996, 17, 16, 15, 0, -16 },
  { 1030, 11, 16, 12, 0, -16 },
  { 1052, 21, 16, 21, 0, -16 },
  { 1094, 18, 16, 18, 0, -16 },
  { 1130, 15, 17, 17, 1, -17 },
  { 1162, 14, 16, 14, 0, -16 },
  { 1190, 15, 21, 17, 1, -17 },
  { 1230, 14, 16, 15, 0, -16 },
  { 1258, 13, 17, 13, 0, -17 },
  { 1286, 12, 16, 13, 2, -16 },
  { 1310, 15, 16, 16, 1, -16 },
  { 1340, 14, 16, 14, 2, -16 },
  { 1368, 21, 16, 22, 2, -16 },
  { 1410, 18, 16, 15, -1, -16 },
  { 1446, 14, 16, 14, 2, -16 },
  { 1474, 15, 16, 12, -1, -16 },
  { 1504, 11, 21, 8, -1, -17 },
  { 1533, 7, 17, 11, 2, -17 },
  { 1548, 11, 21, 8, -2, -17 },
  { 1577, 12, 10, 12, 0, -16 },
  { 1592, 11, 3, 10, -2, 1 },
  { 1597, 6, 4, 8, 3, -18 },
  { 1600, 13, 13, 14, 1, -13 },
  { 1622, 13, 17, 14, 0, -17 },
  { 1650, 11, 13, 12, 1, -13 },
  { 1668, 14, 17, 14, 1, -17 },
  { 1698, 12, 13, 13, 1, -13 },
  { 1718, 14, 24, 9, -2, -18 },
  { 1760, 14, 19, 14, 0, -13 },
  { 1794, 13, 17, 14, 0, -17 },
  { 1822, 8, 18, 7, 0, -18 },
  { 1840, 11, 24, 7, -3, -18 },
  { 1873, 15, 17, 14, 0, -17 },
  { 1905, 8, 17, 7, 0, -17 },
  { 1922, 20, 13, 21, 0, -13 },
  { 1955, 13, 13, 14, 0, -13 },
  { 1977, 12, 13, 14, 1, -13 },
  { 1997, 14, 19, 14, -1, -13 },
  { 2031, 13, 19, 14, 1, -13 },
  { 2062, 11, 13, 10, 0, -13 },
  { 2080, 11, 13, 12, 0, -13 },
  { 2098, 10, 15, 11, 1, -15 },
  { 2117, 13, 13, 14, 1, -13 },
  { 2139, 13, 13, 13, 1, -13 },
  { 2161, 19, 13, 19, 1, -13 },
  { 2192, 15, 13, 13, -1, -13 },
  { 2217, 15, 19, 13, -1, -13 },
  { 2253, 12, 13, 11, 0, -13 },
  { 2273, 10, 20, 8, 0, -16 },
  { 2298, 3, 22, 13, 5, -17 },
  { 2307, 9, 20, 8, -1, -16 },
  { 2330, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_BlackItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_BLACKITALIC23PT7B_H_
