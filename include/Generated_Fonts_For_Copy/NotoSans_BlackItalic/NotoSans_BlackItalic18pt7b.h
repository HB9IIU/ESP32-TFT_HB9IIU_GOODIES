#ifndef _NOTOSANS_BLACKITALIC18PT7B_H_
#define _NOTOSANS_BLACKITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xF3, 0xCE, 0x38, 0xE7, 0x9C, 0x00, 0x07, 0x3C, 0xE0, 0xEF,
  0xDF, 0xB6, 0x6D, 0xC0, 0x06, 0xE0, 0xEE, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7,
  0xFF, 0x19, 0x8F, 0xFE, 0xFF, 0xEF, 0xFE, 0x33, 0x07, 0x70, 0x76, 0x00,
  0x03, 0x00, 0xC1, 0xFC, 0xFF, 0x3E, 0x4F, 0x83, 0xE0, 0x7C, 0x07, 0x83,
  0xEC, 0xF9, 0xFE, 0x7F, 0x02, 0x01, 0x80, 0x3C, 0x1C, 0xF8, 0x73, 0xB9,
  0xC7, 0x73, 0x0E, 0xEC, 0x1D, 0xBB, 0xBF, 0xEF, 0xBD, 0xBB, 0x07, 0x66,
  0x1C, 0xCC, 0x71, 0xB8, 0xC3, 0xE3, 0x87, 0xC0, 0x0F, 0x80, 0xFE, 0x07,
  0x70, 0x7B, 0x81, 0xFC, 0x0F, 0xC0, 0xFD, 0xEF, 0xEE, 0xF7, 0xF7, 0x9F,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xEC, 0x1E, 0x38, 0xE3, 0x87,
  0x1C, 0x38, 0x70, 0xE1, 0x83, 0x07, 0x0E, 0x1C, 0x38, 0x38, 0x1C, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x70,
  0x0C, 0x07, 0x1B, 0x0F, 0x9F, 0xF9, 0xFD, 0xF8, 0xEC, 0x27, 0x00, 0x18,
  0x0C, 0x06, 0x1F, 0xFF, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x00, 0x3B, 0x9D,
  0xC0, 0x7F, 0xEF, 0x80, 0xFF, 0xE0, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0x00,
  0x1E, 0x1F, 0x9F, 0xEE, 0x7F, 0x3F, 0x1F, 0x8F, 0xCF, 0xE7, 0xF3, 0xBF,
  0xDF, 0xC7, 0xC0, 0x07, 0x87, 0x8F, 0xDF, 0xE7, 0xF2, 0x70, 0x38, 0x1C,
  0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC0, 0x07, 0x87, 0xF8, 0x7F, 0x84, 0xF0,
  0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x1E, 0x07, 0x81, 0xFF, 0x3F, 0xEF, 0xF8,
  0x1F, 0x0F, 0xE3, 0xFC, 0x07, 0x03, 0xC7, 0xE1, 0xE0, 0x7E, 0x03, 0x80,
  0xEF, 0xFB, 0xFE, 0xFE, 0x00, 0x01, 0xC0, 0xF0, 0x7C, 0x3F, 0x1F, 0x86,
  0xE3, 0xB9, 0xDE, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x0F, 0x00, 0x1F, 0xC7,
  0xF1, 0xFC, 0xE0, 0x38, 0x0F, 0xC7, 0xF8, 0x9E, 0x03, 0x80, 0xEF, 0xFB,
  0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xE7, 0xF9, 0xC0, 0xF6, 0x3F, 0xCF, 0xFB,
  0xDE, 0xE7, 0xB9, 0xEF, 0xF3, 0xFC, 0x7C, 0x00, 0x3F, 0xE7, 0xFC, 0xFF,
  0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C,
  0x0F, 0x80, 0x0F, 0x87, 0xF3, 0xDC, 0xE7, 0x3B, 0xC7, 0xE1, 0xF1, 0xFE,
  0x73, 0xBC, 0xEF, 0x39, 0xFE, 0x3F, 0x00, 0x3E, 0x3F, 0x9F, 0xFE, 0x7E,
  0x3F, 0x3F, 0xFE, 0xFF, 0x37, 0x07, 0xBF, 0x9F, 0x8F, 0x80, 0x39, 0xCE,
  0x00, 0x00, 0x1E, 0xF7, 0x00, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x79,
  0xC7, 0x38, 0x01, 0x83, 0xC7, 0xCF, 0x8F, 0x07, 0xC0, 0xFC, 0x1F, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x78, 0xFD, 0xF1, 0xE0, 0xC0, 0x00, 0x3E, 0xFF, 0x7F, 0x47,
  0x0F, 0x1E, 0x3C, 0x78, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0x07, 0xE0, 0x3F,
  0xF0, 0xE0, 0xF3, 0x8C, 0x66, 0x7E, 0xDD, 0xDD, 0xF3, 0x33, 0xEE, 0x66,
  0xDD, 0xCD, 0xBF, 0xF3, 0x3F, 0xC7, 0x00, 0x07, 0x9C, 0x07, 0xF8, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C,
  0xE1, 0xCF, 0x3F, 0xF3, 0xFF, 0x7F, 0xF7, 0x07, 0xF0, 0x70, 0x1F, 0xC3,
  0xFC, 0x7F, 0x9E, 0x73, 0xDE, 0x7F, 0x8F, 0xE3, 0xFE, 0x79, 0xCE, 0x39,
  0xFF, 0x3F, 0xCF, 0xF0, 0x0F, 0xC7, 0xFC, 0xFF, 0x3C, 0x27, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xFE, 0x3F, 0xC3, 0xF0, 0x1F, 0x81,
  0xFE, 0x1F, 0xE3, 0xCF, 0x3C, 0xF3, 0x8F, 0x38, 0xF7, 0x8E, 0x78, 0xE7,
  0x1E, 0x7F, 0xC7, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x1E, 0x03,
  0xC0, 0x7F, 0x0F, 0xE3, 0xFC, 0x78, 0x0E, 0x01, 0xFE, 0x3F, 0x8F, 0xF0,
  0x1F, 0xE3, 0xF8, 0x7F, 0x1E, 0x03, 0xC0, 0x7F, 0x0F, 0xE3, 0xFC, 0x78,
  0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0x0F, 0xE3, 0xFC, 0xFF, 0xBC, 0x17,
  0x01, 0xEF, 0xFD, 0xFF, 0x3E, 0xE1, 0xDE, 0x3B, 0xFF, 0x3F, 0xE3, 0xF8,
  0x1C, 0x78, 0xE3, 0xC7, 0x1C, 0x78, 0xE3, 0xC7, 0x1F, 0xF8, 0xFF, 0xCF,
  0xFC, 0x78, 0xE3, 0x87, 0x1C, 0x78, 0xE3, 0xCF, 0x1C, 0x00, 0x1F, 0xC7,
  0xE1, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC1,
  0xF8, 0xFE, 0x00, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70,
  0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x8F, 0xE3, 0xF0, 0xF8,
  0x00, 0x1C, 0x78, 0xE7, 0x87, 0x38, 0x7B, 0xC3, 0xBC, 0x1F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x7B, 0x83, 0x9E, 0x1C, 0xF0, 0xE3, 0x8F, 0x1E, 0x00, 0x1C,
  0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1F, 0xEF,
  0xEF, 0xF0, 0x1F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x3F, 0x3F, 0x37,
  0x3F, 0x7E, 0x3F, 0x6E, 0x77, 0xEE, 0x77, 0xCE, 0x77, 0xDC, 0x77, 0xDC,
  0x77, 0x9C, 0xE7, 0x9C, 0x1E, 0x1C, 0x78, 0x71, 0xF1, 0xCF, 0xC7, 0x3F,
  0x38, 0xFE, 0xE3, 0xBB, 0x9E, 0xEE, 0x73, 0xB9, 0xC7, 0xC7, 0x1F, 0x1C,
  0x7C, 0xE1, 0xF0, 0x0F, 0x81, 0xFE, 0x3F, 0xE7, 0x8F, 0x70, 0xFF, 0x0F,
  0xF0, 0xFE, 0x0E, 0xE1, 0xEF, 0x1E, 0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x1F,
  0x83, 0xF8, 0x7F, 0x9E, 0xF3, 0xCE, 0x73, 0xCF, 0xF3, 0xFC, 0x7E, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0x00, 0x0F, 0x81, 0xFE, 0x3F, 0xE7, 0x8F, 0x70,
  0xFF, 0x0F, 0xF0, 0xFE, 0x0E, 0xE1, 0xEF, 0x1E, 0xFF, 0xC7, 0xF8, 0x3F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x1F, 0x83, 0xF8, 0x7F, 0x9E, 0xF3, 0xDE,
  0x73, 0xCF, 0xF3, 0xFC, 0x7F, 0x8E, 0x71, 0xCF, 0x38, 0xEF, 0x1E, 0x0F,
  0x87, 0xF3, 0xF8, 0xE2, 0x38, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0xA1, 0xEF,
  0xF3, 0xFC, 0x7E, 0x00, 0x7F, 0xDF, 0xFF, 0xF8, 0x70, 0x1C, 0x07, 0x03,
  0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x00, 0x38, 0xF3, 0x8E,
  0x78, 0xE7, 0x8E, 0x71, 0xE7, 0x1E, 0x71, 0xCF, 0x1C, 0xF1, 0xCF, 0x3C,
  0xFF, 0x87, 0xF8, 0x3E, 0x00, 0xF0, 0xFE, 0x3F, 0xC7, 0x39, 0xE7, 0x38,
  0xEF, 0x1D, 0xC3, 0xB8, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF1,
  0xC3, 0xF8, 0xE3, 0xFC, 0xF1, 0xDE, 0x78, 0xEF, 0x3C, 0xE3, 0xBE, 0x71,
  0xDB, 0x78, 0xDD, 0xB8, 0x6C, 0xDC, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x1E,
  0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x79, 0xE0, 0xE7, 0x83, 0xBC, 0x0F, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xF7, 0x83, 0xDE, 0x1E, 0x38,
  0xF0, 0xF0, 0xF1, 0xEE, 0x39, 0xCF, 0x3D, 0xC3, 0xF0, 0x7E, 0x0F, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0x1F, 0xF1, 0xFE, 0x3F,
  0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x7F,
  0xCF, 0xFC, 0xFF, 0x80, 0x1F, 0x1E, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70,
  0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xF8, 0xF0, 0xE7, 0x39, 0xC6, 0x39,
  0xCE, 0x73, 0x8C, 0x73, 0x80, 0x1F, 0x1F, 0x06, 0x0E, 0x0E, 0x0E, 0x0C,
  0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0xF8, 0xF8, 0x06, 0x01, 0x80,
  0xF0, 0x7C, 0x1B, 0x0E, 0xE7, 0x19, 0x86, 0xE1, 0xC0, 0x7F, 0xFF, 0xC0,
  0xEE, 0x70, 0x3D, 0xDF, 0xE7, 0xFB, 0xCE, 0xE3, 0xB9, 0xEE, 0x73, 0xFC,
  0xFF, 0x1D, 0xC0, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3B, 0x8F, 0xF3, 0xFC,
  0xE7, 0x79, 0xDC, 0xF7, 0x3D, 0xFE, 0x7F, 0xBB, 0xC0, 0x1F, 0x7F, 0x7E,
  0xF0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0x7E, 0x01, 0xE0, 0x38, 0x07, 0x01,
  0xE3, 0xFC, 0xFF, 0x1F, 0xE7, 0x9C, 0xE3, 0x9C, 0xF3, 0x9C, 0x7F, 0x8F,
  0xF0, 0xEE, 0x00, 0x1F, 0x3F, 0xDC, 0xFE, 0x7F, 0xF7, 0xF3, 0x81, 0xE4,
  0xFE, 0x3F, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x83, 0x80, 0xFC, 0x3F, 0x87,
  0xF0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x05,
  0xE0, 0xF8, 0x1F, 0x00, 0x1E, 0xE7, 0xF8, 0xFF, 0x3C, 0xE7, 0x1C, 0xE7,
  0x9C, 0xE3, 0xFC, 0x7F, 0x87, 0xF0, 0x1E, 0x67, 0x8F, 0xF1, 0xFC, 0x00,
  0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3B, 0xCF, 0xF3, 0xFC, 0xE7, 0x79, 0xDE,
  0x77, 0x3D, 0xCF, 0x73, 0xBC, 0xE0, 0x1C, 0x71, 0xC0, 0x3C, 0xE3, 0x8E,
  0x79, 0xE7, 0x1C, 0x73, 0xC0, 0x07, 0x07, 0x07, 0x00, 0x0F, 0x0E, 0x0E,
  0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0xF8, 0xF8, 0xF0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0xF3, 0x9E, 0x3B, 0xC3, 0xF8, 0x7F,
  0x07, 0xF0, 0x7F, 0x87, 0x78, 0x73, 0xCF, 0x3C, 0x1E, 0x38, 0x71, 0xE3,
  0xC7, 0x0E, 0x1C, 0x78, 0xF1, 0xC3, 0x87, 0x1E, 0x00, 0x3B, 0xDE, 0x3F,
  0xFF, 0x3F, 0xFF, 0x39, 0xEF, 0x79, 0xCF, 0x79, 0xCE, 0x73, 0xCE, 0x73,
  0xCE, 0x73, 0x9E, 0xF3, 0x9E, 0x3B, 0xCF, 0xF3, 0xFC, 0xE7, 0x79, 0xDE,
  0x77, 0x3D, 0xCF, 0x73, 0xBC, 0xE0, 0x1F, 0x3F, 0xDF, 0xFE, 0x7E, 0x3F,
  0x3F, 0x9F, 0xFE, 0xFF, 0x3E, 0x00, 0x1D, 0xC3, 0xFC, 0x7F, 0x8E, 0x73,
  0x8E, 0x71, 0xCE, 0x79, 0xFE, 0x3F, 0xCF, 0xF1, 0xC0, 0x38, 0x07, 0x01,
  0xE0, 0x00, 0x3D, 0xDF, 0xE7, 0xFB, 0xCE, 0xE3, 0xB9, 0xEE, 0x73, 0xFC,
  0xFF, 0x1F, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x80, 0x3B, 0x9F, 0x8F, 0xC7,
  0x87, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x00, 0x1F, 0x9F, 0x9E, 0x4F,
  0x03, 0xE0, 0xF8, 0x3D, 0x9E, 0xFE, 0x7E, 0x00, 0x18, 0x71, 0xFF, 0xFF,
  0xEE, 0x1C, 0x78, 0xE1, 0xFB, 0xF3, 0xE0, 0x7B, 0xDC, 0xF7, 0x3B, 0xCE,
  0xF3, 0xB9, 0xEE, 0x7B, 0xFC, 0xFF, 0x1F, 0xC0, 0xE3, 0xF8, 0xEE, 0x7B,
  0x9C, 0xEE, 0x3B, 0x87, 0xC1, 0xF0, 0x78, 0x1E, 0x00, 0xE7, 0x9F, 0xCF,
  0x3B, 0x9E, 0xF7, 0x6D, 0xCE, 0xDB, 0x9F, 0xBE, 0x3E, 0xFC, 0x7D, 0xF0,
  0xFB, 0xE1, 0xE7, 0x80, 0x3C, 0xF1, 0xDE, 0x1F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF0, 0x1F, 0x83, 0xF8, 0x7B, 0xCF, 0x3C, 0x38, 0xF3, 0x8E, 0x39, 0xE3,
  0x9C, 0x3B, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x0B,
  0xC0, 0xF8, 0x0F, 0x00, 0x3F, 0x9F, 0xDF, 0xC1, 0xE1, 0xE1, 0xE1, 0xE1,
  0xFE, 0xFE, 0x7F, 0x00, 0x07, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0xF0,
  0xF0, 0x70, 0x70, 0x70, 0x70, 0x78, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x18, 0x1C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1D, 0x0E, 0x1E, 0x3C, 0x38,
  0x38, 0x30, 0xF0, 0xF0, 0xE0, 0xF8, 0xFF, 0xE7, 0xE0,
};

const GFXglyph NotoSans_BlackItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 13, 5, 0, -13 },
  { 11, 7, 5, 8, 2, -13 },
  { 16, 12, 13, 12, 0, -13 },
  { 36, 10, 15, 10, 0, -14 },
  { 55, 15, 13, 17, 1, -13 },
  { 80, 13, 13, 13, 0, -13 },
  { 102, 3, 5, 4, 2, -13 },
  { 104, 7, 16, 7, 1, -13 },
  { 118, 7, 16, 7, -1, -13 },
  { 132, 9, 9, 10, 1, -14 },
  { 143, 9, 9, 11, 1, -11 },
  { 154, 5, 4, 6, -1, -2 },
  { 157, 6, 3, 6, 0, -6 },
  { 160, 4, 3, 6, 0, -3 },
  { 162, 11, 13, 8, -1, -13 },
  { 180, 9, 13, 10, 1, -13 },
  { 195, 9, 13, 10, 1, -13 },
  { 210, 11, 13, 10, -1, -13 },
  { 228, 10, 13, 10, 0, -13 },
  { 245, 10, 13, 10, 0, -13 },
  { 262, 10, 13, 10, 0, -13 },
  { 279, 10, 13, 10, 1, -13 },
  { 296, 11, 13, 10, 0, -13 },
  { 314, 10, 13, 10, 0, -13 },
  { 331, 9, 13, 10, 1, -13 },
  { 346, 5, 10, 6, 0, -10 },
  { 353, 6, 12, 6, -1, -10 },
  { 362, 9, 9, 11, 1, -11 },
  { 373, 9, 7, 11, 1, -10 },
  { 381, 9, 9, 11, 1, -11 },
  { 392, 8, 13, 9, 1, -13 },
  { 405, 15, 15, 16, 1, -13 },
  { 434, 12, 13, 12, -1, -13 },
  { 454, 11, 13, 11, 0, -13 },
  { 472, 11, 13, 11, 1, -13 },
  { 490, 12, 13, 12, 0, -13 },
  { 510, 11, 13, 10, 0, -13 },
  { 528, 11, 13, 10, 0, -13 },
  { 546, 11, 13, 13, 1, -13 },
  { 564, 13, 13, 13, 0, -13 },
  { 586, 10, 13, 8, -1, -13 },
  { 603, 10, 17, 7, -3, -13 },
  { 625, 13, 13, 12, 0, -13 },
  { 647, 9, 13, 9, 0, -13 },
  { 662, 16, 13, 16, 0, -13 },
  { 688, 14, 13, 14, 0, -13 },
  { 711, 12, 13, 13, 1, -13 },
  { 731, 11, 13, 11, 0, -13 },
  { 749, 12, 16, 13, 1, -13 },
  { 773, 11, 13, 12, 0, -13 },
  { 791, 10, 13, 10, 0, -13 },
  { 808, 10, 13, 10, 1, -13 },
  { 825, 12, 13, 13, 1, -13 },
  { 845, 11, 13, 11, 1, -13 },
  { 863, 17, 13, 17, 1, -13 },
  { 891, 14, 13, 12, -1, -13 },
  { 914, 11, 13, 11, 1, -13 },
  { 932, 12, 13, 10, -1, -13 },
  { 952, 8, 16, 6, 0, -13 },
  { 968, 5, 13, 8, 2, -13 },
  { 977, 8, 16, 6, -1, -13 },
  { 993, 10, 9, 10, 0, -13 },
  { 1005, 9, 2, 8, -2, 1 },
  { 1008, 4, 3, 6, 3, -14 },
  { 1010, 10, 10, 11, 1, -10 },
  { 1023, 10, 14, 11, 0, -14 },
  { 1041, 8, 10, 9, 1, -10 },
  { 1051, 11, 14, 11, 1, -14 },
  { 1071, 9, 10, 10, 1, -10 },
  { 1083, 11, 18, 7, -2, -14 },
  { 1108, 11, 14, 11, 0, -10 },
  { 1128, 10, 14, 11, 0, -14 },
  { 1146, 6, 14, 6, 0, -14 },
  { 1157, 8, 18, 6, -2, -14 },
  { 1175, 12, 14, 11, 0, -14 },
  { 1196, 7, 14, 6, 0, -14 },
  { 1209, 16, 10, 17, 0, -10 },
  { 1229, 10, 10, 11, 0, -10 },
  { 1242, 9, 10, 11, 1, -10 },
  { 1254, 11, 14, 11, -1, -10 },
  { 1274, 10, 14, 11, 1, -10 },
  { 1292, 9, 10, 8, 0, -10 },
  { 1304, 9, 10, 9, 0, -10 },
  { 1316, 7, 12, 8, 1, -12 },
  { 1327, 10, 10, 11, 1, -10 },
  { 1340, 10, 10, 10, 1, -10 },
  { 1353, 15, 10, 15, 1, -10 },
  { 1372, 12, 10, 10, -1, -10 },
  { 1387, 12, 14, 10, -1, -10 },
  { 1408, 9, 10, 9, 0, -10 },
  { 1420, 8, 16, 6, 0, -13 },
  { 1436, 2, 18, 10, 4, -14 },
  { 1441, 8, 16, 6, -1, -13 },
  { 1457, 9, 3, 11, 1, -8 },
};

const GFXfont NotoSans_BlackItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_BLACKITALIC18PT7B_H_
