#ifndef _NOTOSANS_BLACKITALIC15PT7B_H_
#define _NOTOSANS_BLACKITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x67, 0x39, 0xC0, 0x67, 0x38, 0x6E, 0xD9, 0xB6, 0x60,
  0x0D, 0x83, 0x61, 0x99, 0xFF, 0x7F, 0xCC, 0xCF, 0xFB, 0xFE, 0x36, 0x19,
  0x86, 0xC0, 0x06, 0x1F, 0xCF, 0xCF, 0x83, 0x81, 0xF0, 0x3C, 0x1E, 0xFF,
  0x7F, 0x04, 0x02, 0x00, 0x30, 0x63, 0xC6, 0x36, 0x71, 0xB3, 0x0D, 0xB2,
  0x7F, 0x79, 0xFF, 0xE1, 0xB7, 0x19, 0xB1, 0x8F, 0x9C, 0x38, 0x0E, 0x03,
  0xE0, 0xEE, 0x1D, 0x83, 0xF0, 0x79, 0xDF, 0xF7, 0x7E, 0xE7, 0x9F, 0xF1,
  0xFF, 0x00, 0x6D, 0xE0, 0x0E, 0x30, 0xE1, 0x87, 0x0C, 0x18, 0x30, 0xE0,
  0xC1, 0x83, 0x07, 0x00, 0x18, 0x71, 0xC3, 0x0C, 0x30, 0xC7, 0x1C, 0x63,
  0x8C, 0xE0, 0x10, 0x1C, 0x58, 0xFF, 0x3E, 0x78, 0xEC, 0x2C, 0x30, 0x60,
  0xC7, 0xFF, 0xE6, 0x0C, 0x00, 0x37, 0x6E, 0xFF, 0x80, 0x7F, 0x80, 0x03,
  0x81, 0x81, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x38, 0x00,
  0x0E, 0x3F, 0x3F, 0x73, 0x73, 0x77, 0x67, 0xE7, 0x6F, 0x7E, 0x3C, 0x0E,
  0x3D, 0xF7, 0x65, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE0, 0x1E, 0x7F, 0x3F,
  0x27, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xFE, 0xFE, 0x1E, 0x7F, 0x37, 0x07,
  0x1F, 0x3C, 0x3E, 0x07, 0x8F, 0xFE, 0xFC, 0x03, 0x83, 0x83, 0xC3, 0xE3,
  0xF1, 0xB1, 0xB9, 0xFE, 0xFF, 0x07, 0x03, 0x00, 0x1F, 0x9F, 0x8F, 0xC6,
  0x07, 0xE3, 0xF0, 0x3C, 0x0E, 0x8F, 0x7F, 0x3F, 0x00, 0x1F, 0x3F, 0x79,
  0xE0, 0xFC, 0xFE, 0xEE, 0xCE, 0xEE, 0xFC, 0x78, 0x3F, 0x9F, 0xDF, 0xE0,
  0xE0, 0xE0, 0x70, 0x70, 0x78, 0x38, 0x38, 0x3C, 0x00, 0x1E, 0x3F, 0x3B,
  0x33, 0x3F, 0x1E, 0x7E, 0x67, 0xE7, 0x7E, 0x7E, 0x3C, 0xFF, 0xBF, 0x3E,
  0xFF, 0xFF, 0x87, 0x1D, 0xF3, 0xC0, 0x3B, 0x80, 0x00, 0x33, 0x9C, 0x1C,
  0xE0, 0x00, 0x00, 0x07, 0x1C, 0x63, 0x80, 0x02, 0x0C, 0x7B, 0xCE, 0x1F,
  0x0F, 0x87, 0x02, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81, 0x83, 0xC1, 0xE0,
  0xE7, 0xFE, 0x60, 0x80, 0x39, 0xFD, 0xB8, 0x73, 0xCF, 0x1C, 0x00, 0x61,
  0xC3, 0x80, 0x0F, 0x83, 0xFE, 0x70, 0x66, 0x7B, 0xDF, 0xBD, 0x9B, 0xDB,
  0x3D, 0xB6, 0xDF, 0xEC, 0x00, 0x73, 0x03, 0xF0, 0x07, 0x81, 0xE0, 0xF8,
  0x3F, 0x1D, 0xC7, 0x73, 0x9C, 0xFF, 0x7F, 0xDC, 0x7E, 0x1C, 0x3F, 0x1F,
  0xCE, 0xE7, 0x73, 0xFB, 0xF1, 0xFC, 0xE7, 0x77, 0x3F, 0xBF, 0x80, 0x1F,
  0x1F, 0xDF, 0xDE, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE2, 0x7F, 0x1F, 0x80,
  0x3E, 0x0F, 0xE3, 0xF8, 0xE7, 0x31, 0xDC, 0x77, 0x1D, 0xCE, 0x77, 0x9F,
  0xCF, 0xC0, 0x3F, 0x9F, 0xCF, 0xC7, 0x03, 0xF3, 0xF9, 0xF8, 0xE0, 0x70,
  0x3F, 0x3F, 0x80, 0x3F, 0x9F, 0xCF, 0xC7, 0x03, 0x03, 0xF9, 0xF8, 0xE0,
  0x70, 0x30, 0x38, 0x00, 0x0F, 0x1F, 0xDF, 0xFE, 0x0E, 0x07, 0x7F, 0xBD,
  0xCE, 0xE7, 0x7F, 0x9F, 0xC0, 0x38, 0xE7, 0x1C, 0xE7, 0x1C, 0xE3, 0xFC,
  0xFF, 0x9F, 0xE3, 0x9C, 0x73, 0x8C, 0x73, 0x8E, 0x00, 0x1F, 0x3F, 0x1E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x7C, 0xFC, 0x07, 0x06, 0x0E, 0x0E,
  0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0xF8, 0xF0, 0x38, 0xE7,
  0x38, 0xEE, 0x1F, 0xC3, 0x70, 0xFC, 0x1F, 0xC3, 0xB8, 0x77, 0x0C, 0xF3,
  0x8E, 0x00, 0x38, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xF8,
  0x3C, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x36, 0x3C, 0xF9, 0xF7, 0xE7, 0xDB,
  0x1F, 0x6C, 0x6F, 0x71, 0xBD, 0xCE, 0xE7, 0x00, 0x3C, 0x73, 0xC7, 0x3C,
  0x63, 0xE6, 0x36, 0xE7, 0x6E, 0x77, 0xE7, 0x7C, 0x63, 0xC6, 0x3C, 0xE3,
  0xC0, 0x0F, 0x0F, 0xE7, 0xFB, 0xC7, 0xE1, 0xF8, 0x7E, 0x3B, 0x8E, 0xE7,
  0x3F, 0xC7, 0xE0, 0x3E, 0x1F, 0xCF, 0xE7, 0x73, 0x3B, 0xFD, 0xFC, 0xE0,
  0x70, 0x30, 0x38, 0x00, 0x0F, 0x0F, 0xE7, 0xF9, 0xC7, 0xE1, 0xF8, 0x7E,
  0x3B, 0x8E, 0xE7, 0x3F, 0xC7, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x3E, 0x1F,
  0xCE, 0xE7, 0x73, 0x3B, 0xF9, 0xF8, 0xEE, 0x77, 0x33, 0xB8, 0xE0, 0x1E,
  0x3F, 0x3B, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0xCE, 0xFE, 0xFC, 0x7F, 0xFF,
  0xFF, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x71, 0xDC, 0xE7,
  0x39, 0xCE, 0x63, 0xB8, 0xEE, 0x73, 0x9C, 0xE7, 0x3F, 0x87, 0xC0, 0xE3,
  0xF1, 0xF9, 0xDC, 0xEE, 0xE7, 0x71, 0xB0, 0xF8, 0x78, 0x3C, 0x1C, 0x00,
  0xE3, 0x1F, 0x9C, 0x7E, 0x71, 0xB9, 0xCE, 0xEF, 0x33, 0xBD, 0xCF, 0xF7,
  0x3E, 0xD8, 0xFB, 0xE3, 0xCF, 0x0F, 0x3C, 0x00, 0x1C, 0x71, 0xCE, 0x1D,
  0xC0, 0xDC, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF8, 0x3B, 0x87, 0x3C, 0xF1,
  0xC0, 0xE3, 0xB3, 0x9D, 0xCF, 0xC7, 0xC1, 0xE0, 0xE0, 0x70, 0x30, 0x38,
  0x1C, 0x00, 0x1F, 0xCF, 0xF3, 0xF8, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0,
  0x78, 0x1F, 0xCF, 0xF0, 0x3C, 0xF3, 0x0C, 0x31, 0xC6, 0x18, 0x63, 0x8E,
  0x30, 0xF3, 0xC0, 0xCC, 0xCC, 0xEE, 0x66, 0x66, 0x70, 0x1E, 0x78, 0x30,
  0x61, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xE1, 0x8F, 0x1E, 0x00, 0x0C, 0x0C,
  0x1C, 0x3E, 0x36, 0x66, 0xE3, 0xFF, 0xFC, 0xE3, 0x7F, 0x7F, 0xE6, 0xE6,
  0xEE, 0xEE, 0xFE, 0xFC, 0x38, 0x38, 0x38, 0x3F, 0x3F, 0x73, 0x73, 0x77,
  0x77, 0xFE, 0xFE, 0x7F, 0xFB, 0x87, 0x0C, 0x1C, 0xBE, 0x3C, 0x03, 0x83,
  0x81, 0xCF, 0xE7, 0xF7, 0x33, 0x99, 0xDC, 0xEE, 0x7F, 0x3F, 0x00, 0x7E,
  0xFF, 0x9F, 0xFF, 0x9C, 0xBF, 0x3E, 0x07, 0xC1, 0xE0, 0xE0, 0x7E, 0x1F,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0xF8, 0x3E, 0x06,
  0x00, 0x3F, 0x9F, 0xDC, 0xCE, 0x67, 0x73, 0xB9, 0xF8, 0xEC, 0x0E, 0x7F,
  0x3F, 0x06, 0x00, 0x38, 0x1C, 0x0E, 0x07, 0xE3, 0xFB, 0x9D, 0xCC, 0xEE,
  0x77, 0x73, 0xB9, 0xC0, 0x19, 0xCE, 0x03, 0x99, 0xCE, 0x73, 0xB9, 0xC0,
  0x06, 0x1C, 0x18, 0x00, 0xE1, 0x87, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x9F,
  0x3C, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xEF, 0x37, 0x1F, 0x87, 0xC1, 0xF8,
  0x7E, 0x39, 0xCE, 0x70, 0x39, 0xCE, 0x73, 0x39, 0xCE, 0x77, 0x38, 0x3F,
  0x79, 0xFF, 0xDC, 0xEE, 0xE6, 0x77, 0x73, 0xBB, 0x9F, 0x9C, 0xDC, 0xEE,
  0x3F, 0x1F, 0xDC, 0xEE, 0x67, 0x73, 0xBB, 0x9D, 0xCE, 0x7E, 0xFF, 0x9F,
  0x3E, 0xFD, 0xFF, 0x3C, 0x1F, 0x8F, 0xCE, 0x67, 0x33, 0xB9, 0xDD, 0xFC,
  0xFE, 0x70, 0x38, 0x18, 0x1C, 0x00, 0x7F, 0x7F, 0xE6, 0xE6, 0xEE, 0xEE,
  0xFC, 0xEC, 0x1C, 0x1C, 0x1C, 0x18, 0x36, 0x7D, 0xE3, 0x87, 0x0E, 0x38,
  0x70, 0x3E, 0xED, 0xC3, 0xE1, 0xD1, 0xFF, 0x7C, 0x18, 0x31, 0xFF, 0xF7,
  0x0E, 0x1C, 0x38, 0x78, 0xF0, 0x77, 0xE7, 0xE7, 0xE6, 0xEE, 0xEE, 0xFE,
  0xFE, 0xC7, 0xEE, 0xEE, 0xFC, 0xF8, 0xF8, 0x70, 0x70, 0xCE, 0x7C, 0xE6,
  0xDE, 0xED, 0xEC, 0xDF, 0xCF, 0x78, 0xF7, 0x8E, 0x70, 0x39, 0xC7, 0xE1,
  0xF0, 0x78, 0x1E, 0x0F, 0xC7, 0x73, 0xDE, 0x39, 0xCE, 0xE3, 0xB8, 0xFC,
  0x3E, 0x0F, 0x81, 0xC0, 0x70, 0x38, 0x3E, 0x0F, 0x03, 0x00, 0x7F, 0x7E,
  0x1C, 0x38, 0x38, 0x70, 0xFC, 0xFC, 0x0C, 0x71, 0x8E, 0x31, 0xCE, 0x38,
  0x71, 0x86, 0x1C, 0x70, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0xE1, 0x86, 0x18,
  0x61, 0xCF, 0x30, 0xC7, 0x3C, 0xE0, 0x63, 0xFE, 0x78,
};

const GFXglyph NotoSans_BlackItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 11, 5, 0, -11 },
  { 8, 7, 4, 7, 1, -11 },
  { 12, 10, 11, 10, 0, -11 },
  { 26, 9, 12, 9, 0, -11 },
  { 40, 13, 11, 14, 1, -11 },
  { 58, 11, 11, 11, 0, -11 },
  { 74, 3, 4, 4, 1, -11 },
  { 76, 7, 13, 6, 0, -11 },
  { 88, 6, 13, 6, -1, -11 },
  { 98, 8, 8, 8, 1, -12 },
  { 106, 7, 7, 9, 1, -9 },
  { 113, 4, 4, 5, -1, -2 },
  { 115, 5, 2, 5, 0, -5 },
  { 117, 3, 3, 5, 0, -3 },
  { 119, 9, 11, 7, -1, -11 },
  { 132, 8, 11, 9, 0, -11 },
  { 143, 7, 11, 9, 1, -11 },
  { 153, 8, 11, 9, 0, -11 },
  { 164, 8, 11, 9, 0, -11 },
  { 175, 9, 11, 9, 0, -11 },
  { 188, 9, 11, 9, 0, -11 },
  { 201, 8, 11, 9, 1, -11 },
  { 212, 9, 11, 9, 0, -11 },
  { 225, 8, 11, 9, 0, -11 },
  { 236, 7, 11, 9, 1, -11 },
  { 246, 5, 8, 5, 0, -8 },
  { 251, 6, 10, 5, -1, -8 },
  { 259, 7, 9, 9, 1, -10 },
  { 267, 7, 5, 9, 1, -8 },
  { 272, 7, 9, 9, 1, -10 },
  { 280, 7, 11, 7, 1, -11 },
  { 290, 12, 12, 13, 1, -11 },
  { 308, 10, 11, 10, -1, -11 },
  { 322, 9, 11, 10, 0, -11 },
  { 335, 9, 11, 9, 1, -11 },
  { 348, 10, 11, 10, 0, -11 },
  { 362, 9, 11, 8, 0, -11 },
  { 375, 9, 11, 9, 0, -11 },
  { 388, 9, 11, 10, 1, -11 },
  { 401, 11, 11, 11, 0, -11 },
  { 417, 8, 11, 6, -1, -11 },
  { 428, 8, 14, 6, -2, -11 },
  { 442, 11, 11, 10, 0, -11 },
  { 458, 7, 11, 8, 0, -11 },
  { 468, 14, 11, 14, 0, -11 },
  { 488, 12, 11, 12, 0, -11 },
  { 505, 10, 11, 11, 1, -11 },
  { 519, 9, 11, 9, 0, -11 },
  { 532, 10, 14, 11, 1, -11 },
  { 550, 9, 11, 10, 0, -11 },
  { 563, 8, 11, 8, 0, -11 },
  { 574, 8, 11, 8, 1, -11 },
  { 585, 10, 11, 11, 1, -11 },
  { 599, 9, 11, 9, 1, -11 },
  { 612, 14, 11, 14, 1, -11 },
  { 632, 12, 11, 10, -1, -11 },
  { 649, 9, 11, 9, 1, -11 },
  { 662, 10, 11, 8, -1, -11 },
  { 676, 6, 14, 5, 0, -11 },
  { 687, 4, 11, 7, 2, -11 },
  { 693, 7, 14, 5, -1, -11 },
  { 706, 8, 7, 8, 0, -11 },
  { 713, 7, 2, 7, -1, 1 },
  { 715, 4, 2, 5, 2, -11 },
  { 716, 8, 8, 9, 1, -8 },
  { 724, 8, 11, 9, 0, -11 },
  { 735, 7, 8, 8, 1, -8 },
  { 742, 9, 11, 9, 1, -11 },
  { 755, 7, 8, 9, 1, -8 },
  { 762, 10, 15, 6, -2, -11 },
  { 781, 9, 12, 9, 0, -8 },
  { 795, 9, 11, 9, 0, -11 },
  { 808, 5, 12, 5, 0, -12 },
  { 816, 7, 16, 5, -2, -12 },
  { 830, 10, 11, 9, 0, -11 },
  { 844, 5, 11, 5, 0, -11 },
  { 851, 13, 8, 14, 0, -8 },
  { 864, 9, 8, 9, 0, -8 },
  { 873, 7, 8, 9, 1, -8 },
  { 880, 9, 12, 9, -1, -8 },
  { 894, 8, 12, 9, 1, -8 },
  { 906, 7, 8, 7, 0, -8 },
  { 913, 7, 8, 8, 0, -8 },
  { 920, 7, 10, 7, 0, -10 },
  { 929, 8, 8, 9, 1, -8 },
  { 937, 8, 8, 8, 1, -8 },
  { 945, 12, 8, 12, 1, -8 },
  { 957, 10, 8, 8, -1, -8 },
  { 967, 10, 12, 8, -1, -8 },
  { 982, 8, 8, 7, 0, -8 },
  { 990, 6, 13, 5, 0, -11 },
  { 1000, 2, 14, 8, 3, -11 },
  { 1004, 6, 13, 5, -1, -11 },
  { 1014, 7, 3, 9, 1, -7 },
};

const GFXfont NotoSans_BlackItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_BLACKITALIC15PT7B_H_
