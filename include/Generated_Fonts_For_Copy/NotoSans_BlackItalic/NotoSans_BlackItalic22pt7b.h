#ifndef _NOTOSANS_BLACKITALIC22PT7B_H_
#define _NOTOSANS_BLACKITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x00,
  0x00, 0x70, 0xF8, 0xF8, 0xF0, 0x77, 0xBB, 0xFD, 0xDC, 0xEE, 0x77, 0x38,
  0x03, 0xB8, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0x83, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0x07, 0x70, 0x1C, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC3, 0x9C,
  0x07, 0x38, 0x0E, 0xE0, 0x39, 0xC0, 0x01, 0x80, 0x10, 0x1F, 0xF3, 0xFE,
  0x7F, 0xE7, 0xA2, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xC0, 0xDE,
  0x8D, 0xCF, 0xFC, 0xFF, 0xCF, 0xF0, 0x18, 0x01, 0x80, 0x1E, 0x03, 0x87,
  0xE0, 0xE1, 0xFC, 0x38, 0x3B, 0x8F, 0x0F, 0x71, 0xC1, 0xCE, 0x70, 0x39,
  0xDC, 0xE7, 0xFF, 0xBE, 0x7E, 0xEF, 0xE7, 0xBB, 0xDC, 0x0E, 0x73, 0x83,
  0xCE, 0x70, 0x71, 0xDE, 0x1C, 0x3B, 0x87, 0x07, 0xF1, 0xE0, 0x7C, 0x03,
  0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1F,
  0xE0, 0x1F, 0xCF, 0x3F, 0x9F, 0x7F, 0xDE, 0xFB, 0xFE, 0xF1, 0xFC, 0xF8,
  0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xBE, 0x77, 0xFE, 0xEE, 0x07, 0x87,
  0x07, 0x87, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x00, 0x0E, 0x0F, 0x0F, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x1E, 0x1C,
  0x3C, 0x78, 0xF0, 0x0C, 0x03, 0xC4, 0xE3, 0xB8, 0xFF, 0xDF, 0xF3, 0xFD,
  0xF8, 0xF7, 0x09, 0xC0, 0x68, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0xE7, 0x9C,
  0xF3, 0x80, 0x7E, 0xFF, 0xF7, 0xE0, 0x77, 0xFD, 0xE0, 0x00, 0x78, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0x07,
  0x83, 0xF8, 0xFF, 0xBE, 0xF7, 0x9E, 0xF3, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xCF, 0xF9, 0xEF, 0x7D, 0xFF, 0x1F, 0xC1, 0xF0, 0x03, 0xC3, 0xE1,
  0xF9, 0xFE, 0xFF, 0xBD, 0xE4, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x1F, 0xF0,
  0xC7, 0x80, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xFF, 0x3F, 0xF9, 0xFF, 0x9F, 0xFC, 0x0F, 0xC3, 0xFE, 0x3F, 0xF1,
  0xDF, 0x00, 0xF0, 0x0F, 0x0F, 0xE0, 0xF8, 0x1F, 0xC1, 0xFE, 0x01, 0xE0,
  0x1E, 0xC3, 0xEF, 0xFE, 0xFF, 0xCF, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x07, 0xE0, 0x7F, 0x07, 0x70, 0x3F, 0x83, 0xBC, 0x39, 0xE3, 0x8F, 0x3F,
  0xFD, 0xFF, 0xEF, 0xFF, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0xF8, 0x7F,
  0x87, 0xFC, 0x3F, 0xE1, 0xE0, 0x1E, 0x00, 0xFF, 0x07, 0xFC, 0x3F, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xCC, 0x3E, 0x7F, 0xF3, 0xFF, 0x0F, 0xE0, 0x03,
  0xF0, 0xFF, 0x1F, 0xE3, 0xF2, 0x7C, 0x07, 0x90, 0xF7, 0xCF, 0xFE, 0xFF,
  0xEF, 0x1E, 0xF1, 0xEF, 0x3E, 0xF3, 0xCF, 0xFC, 0x7F, 0x83, 0xF0, 0x1F,
  0xFC, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0x0F, 0x83, 0xFC, 0xFF, 0x9E, 0xF7, 0x8E, 0x7B, 0xCF,
  0xF0, 0xFC, 0x3F, 0x8F, 0xFB, 0xCF, 0x70, 0xEF, 0x3D, 0xFF, 0xBF, 0xE1,
  0xF8, 0x0F, 0x07, 0xF9, 0xFF, 0xBE, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0xDF,
  0xFF, 0xEF, 0xFC, 0xEF, 0x01, 0xE0, 0xFD, 0xFF, 0x3F, 0xC7, 0xE0, 0x1C,
  0x7C, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0x71, 0xF3, 0xC7, 0x80, 0x0E, 0x1F,
  0x1E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x78, 0x70, 0xF0,
  0xE0, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xE3, 0xF1, 0xF8, 0x3E, 0x03, 0xF0,
  0x1F, 0xC0, 0xFC, 0x07, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x03, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0xF8, 0xFE, 0x7F, 0x1F, 0x83, 0xC0, 0x40, 0x00, 0x3E, 0x7F,
  0xFF, 0xEE, 0xF4, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x00, 0x00, 0x07,
  0x07, 0x83, 0xC1, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xF0,
  0x0E, 0x38, 0xF1, 0xDC, 0xFF, 0x76, 0x3F, 0x9F, 0x9C, 0xE7, 0xE7, 0x39,
  0xFB, 0x8E, 0x7E, 0xE7, 0x3B, 0xBF, 0xFE, 0xE7, 0xFF, 0x3C, 0xE7, 0x07,
  0x00, 0x01, 0xFB, 0xC0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xB8, 0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x0E,
  0x3C, 0x78, 0xF3, 0xFF, 0xCF, 0xFF, 0x7F, 0xFD, 0xE0, 0xFF, 0x83, 0xFC,
  0x0F, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x1E, 0x7C, 0x79, 0xE3,
  0xFF, 0x8F, 0xF8, 0x3F, 0xF0, 0xF7, 0xC3, 0xCF, 0x9F, 0x3C, 0x79, 0xF1,
  0xFF, 0xC7, 0xFE, 0x3F, 0xE0, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE,
  0x7C, 0x11, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0xFC, 0x61, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x87, 0xFF, 0x1E, 0x3C, 0x78, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C,
  0x3C, 0xF0, 0xF3, 0xC7, 0xDF, 0x3E, 0x7B, 0xF9, 0xFF, 0xC7, 0xFE, 0x3F,
  0xE0, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1, 0xE0, 0x0F, 0x00, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xE1,
  0xFF, 0x1F, 0xF8, 0x0F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE,
  0x7E, 0x09, 0xF0, 0x07, 0x80, 0x3E, 0x7E, 0xF3, 0xFB, 0xCF, 0xEF, 0x07,
  0xBE, 0x3C, 0xFC, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0x0F, 0x1F,
  0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3F, 0xFE, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0xF8, 0xF8, 0x1F, 0xF1, 0xFE, 0x1F, 0xE0, 0xF8, 0x07,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x07, 0xF0, 0x7F, 0x8F, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x8F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC,
  0x00, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x1E, 0x7C, 0x1E, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3D, 0xE0, 0x79,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF8, 0xF8, 0xF8, 0x0F, 0x07, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0,
  0x78, 0x1F, 0xF7, 0xFF, 0xFF, 0x0F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x87,
  0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF9,
  0xDE, 0x3F, 0x9D, 0xC3, 0xBB, 0xBC, 0x3B, 0xBB, 0xC7, 0xBF, 0x3C, 0x7B,
  0xF3, 0x87, 0xBE, 0x38, 0x73, 0xE7, 0x8F, 0x3E, 0x78, 0x0F, 0x83, 0x8F,
  0xC3, 0xC7, 0xE1, 0xE3, 0xF0, 0xF1, 0xFC, 0x78, 0xFE, 0x38, 0xF7, 0x3C,
  0x7B, 0xDE, 0x3D, 0xEF, 0x1C, 0xF7, 0x8E, 0x3F, 0x8F, 0x1F, 0xC7, 0x8F,
  0xE3, 0xC3, 0xF1, 0xC1, 0xF1, 0xE0, 0xF8, 0x03, 0xE0, 0x1F, 0xF0, 0x7F,
  0xF1, 0xFF, 0xE7, 0xC3, 0xCF, 0x87, 0xDE, 0x0F, 0xFC, 0x1E, 0xF8, 0x3D,
  0xE0, 0x7B, 0xC1, 0xF7, 0xC3, 0xCF, 0x8F, 0x8F, 0xFE, 0x0F, 0xF8, 0x0F,
  0xE0, 0x0F, 0xC0, 0xFF, 0x87, 0xFE, 0x3F, 0xF1, 0xE7, 0x8F, 0x3C, 0xF9,
  0xE7, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE7, 0xC3,
  0xCF, 0x87, 0xDE, 0x0F, 0xFC, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xF7,
  0xC3, 0xCF, 0x9F, 0x8F, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0x87, 0xFE, 0x3F, 0xF1,
  0xE7, 0x8F, 0x3C, 0xF9, 0xE7, 0xFF, 0x3F, 0xF1, 0xFE, 0x0F, 0x78, 0xFB,
  0xC7, 0x9F, 0x3C, 0x79, 0xE3, 0xFF, 0x1F, 0x07, 0xE0, 0xFF, 0x1F, 0xF3,
  0xEE, 0x3C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xC8,
  0x3E, 0xE3, 0xCF, 0xFC, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x1E, 0x3E, 0x7C, 0x78, 0xF0, 0xF1, 0xE1,
  0xE3, 0xC7, 0xCF, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xF3,
  0xE3, 0xC7, 0xC7, 0x8F, 0x9F, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xC0, 0xF0,
  0x7F, 0x87, 0xFC, 0x3D, 0xE3, 0xEF, 0x1E, 0x79, 0xF3, 0xCF, 0x1E, 0x78,
  0xF7, 0x87, 0xBC, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF1, 0xF1, 0xEF, 0x1F, 0x1E, 0xF3,
  0xF1, 0xEF, 0x3F, 0x3C, 0xF3, 0xF3, 0xCF, 0x77, 0x78, 0xE7, 0x77, 0x8E,
  0xF7, 0x70, 0xEE, 0x7F, 0x0E, 0xE7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0,
  0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0xC1,
  0xF7, 0xC0, 0x7B, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0xDF, 0x03, 0xE7, 0x83, 0xE3, 0xC1, 0xE1,
  0xF1, 0xF0, 0xF8, 0xF0, 0xFF, 0x87, 0xBC, 0x7C, 0xF3, 0xC7, 0xBC, 0x3F,
  0xE1, 0xFE, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xCF, 0xFE, 0x3F, 0xF8, 0x07, 0xC3, 0xF0,
  0xFC, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1F, 0x87, 0xC3, 0xF0, 0xF1, 0xC7,
  0x1C, 0x71, 0xE7, 0x8E, 0x38, 0xE3, 0x8F, 0x3C, 0xF1, 0xC7, 0x0F, 0x8F,
  0xC7, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1,
  0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x7E, 0x3E, 0x1F, 0x00, 0x01, 0x80, 0x38,
  0x07, 0x80, 0x7C, 0x0F, 0xC1, 0xDC, 0x1C, 0xC3, 0x8E, 0x70, 0xE7, 0x0E,
  0xE0, 0x70, 0x7F, 0xFF, 0xFB, 0xFF, 0x00, 0xF3, 0xCE, 0x30, 0x1F, 0x73,
  0xFF, 0x7F, 0xF7, 0x9E, 0xF9, 0xEF, 0x1E, 0xF1, 0xEF, 0x1C, 0xF3, 0xCF,
  0xFC, 0xFF, 0xC7, 0xBC, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xFE, 0x3F, 0xF3, 0xFF, 0x3C, 0xF3, 0xCF, 0x38, 0xF7, 0x8F, 0x78, 0xF7,
  0x9F, 0x7F, 0xE7, 0xFC, 0xF7, 0x80, 0x1F, 0xCF, 0xF7, 0xF9, 0xE2, 0xF8,
  0x3C, 0x0F, 0x03, 0xC0, 0xF1, 0x3F, 0xC7, 0xF0, 0xFC, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x0F, 0x78, 0xFF, 0xCF, 0xFE, 0x79, 0xE7,
  0xCF, 0x3C, 0x79, 0xE3, 0xCF, 0x1C, 0x79, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xC7, 0xFD, 0xF7, 0xBC, 0xFF, 0x9F, 0xFF, 0xBF, 0xE7, 0x80,
  0xF0, 0x5F, 0xF1, 0xFE, 0x1F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x07,
  0x90, 0x3C, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xB8, 0xFF, 0xCF, 0xFE, 0x79,
  0xE7, 0xCF, 0x3C, 0x79, 0xE3, 0xCF, 0x1C, 0x79, 0xE3, 0xFF, 0x1F, 0xF8,
  0x7B, 0xC0, 0x3C, 0x41, 0xE3, 0xFF, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF8, 0xFF, 0xC7, 0xFF, 0x3E,
  0xF9, 0xE7, 0xCF, 0x3C, 0xF9, 0xE7, 0x8F, 0x3C, 0x79, 0xE7, 0xCF, 0x3C,
  0xF9, 0xE0, 0x0E, 0x1F, 0x1F, 0x0C, 0x00, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0x01, 0xE0, 0x7C, 0x0F, 0x80,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x7F, 0x0F, 0xC1,
  0xF0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x23,
  0xCF, 0x8F, 0x9E, 0x1E, 0x78, 0x3D, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0x7C, 0x1E, 0x78, 0x3C, 0xF8, 0xF8, 0xF0, 0x0F, 0x0F,
  0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78,
  0x78, 0x78, 0xF8, 0x1D, 0xF3, 0xE7, 0xFE, 0xFC, 0xFF, 0xFF, 0x9F, 0x7C,
  0xF3, 0xCF, 0x9E, 0x79, 0xE3, 0xDF, 0x3C, 0x7B, 0xC7, 0x8F, 0x78, 0xF3,
  0xCF, 0x3E, 0x79, 0xE7, 0x8F, 0x7C, 0xF1, 0xE0, 0x1D, 0xF1, 0xFF, 0x8F,
  0xFE, 0x7D, 0xF3, 0xCF, 0x9E, 0x79, 0xF3, 0xCF, 0x1E, 0x78, 0xF3, 0xCF,
  0x9E, 0x79, 0xF3, 0xC0, 0x1F, 0xC7, 0xFD, 0xFF, 0xBC, 0xFF, 0x9F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF3, 0xFF, 0xF9, 0xFE, 0x1F, 0x80, 0x0E, 0xF0, 0xFF,
  0xC7, 0xFE, 0x3C, 0xF1, 0xE7, 0x8E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3E, 0xF9,
  0xFF, 0x8F, 0xF8, 0xF7, 0x87, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x00, 0x1F, 0x73, 0xFF, 0x7F, 0xF7, 0x9E, 0xF9, 0xEF, 0x1E, 0xF1, 0xEF,
  0x1C, 0xF3, 0xCF, 0xFC, 0xFF, 0xC7, 0xBC, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0x1D, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xC0, 0x78, 0x1F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x00, 0x1F, 0xE7, 0xF8, 0xF7,
  0x3E, 0x03, 0xE0, 0x7F, 0x07, 0xE0, 0x3E, 0x87, 0xDF, 0xF3, 0xFE, 0x7F,
  0x80, 0x0E, 0x0E, 0x07, 0x0F, 0xFF, 0xFF, 0xFD, 0xE0, 0xF0, 0x78, 0x3C,
  0x3C, 0x1E, 0x4F, 0xE7, 0xF1, 0xF8, 0x3C, 0xF7, 0x8F, 0x78, 0xF7, 0x8F,
  0x79, 0xEF, 0x9E, 0xF1, 0xEF, 0x3E, 0xF3, 0xEF, 0xFC, 0xFD, 0xC7, 0xDC,
  0xF1, 0xFF, 0x1E, 0xF1, 0xEF, 0x3C, 0x73, 0xC7, 0x78, 0x77, 0x87, 0xF0,
  0x7F, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF1, 0xE3, 0xFC, 0xF8, 0xFF, 0x3E,
  0x7B, 0xCF, 0x9E, 0xF7, 0xEF, 0x3D, 0xFB, 0xCF, 0xEF, 0xE1, 0xFB, 0xF8,
  0x7E, 0xFC, 0x1F, 0x3F, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x1E, 0x3E, 0x3E,
  0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x7B, 0xC1, 0xF7, 0xC7, 0xC7, 0x80, 0x3C, 0x7C, 0xF1, 0xE3,
  0xC7, 0x8F, 0x3C, 0x1C, 0xF0, 0x77, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x81,
  0xE0, 0x78, 0x1F, 0xF3, 0xFE, 0x7F, 0xC0, 0x03, 0x83, 0xC3, 0xE1, 0xE0,
  0xE0, 0xF0, 0x78, 0x38, 0xFC, 0x7C, 0x3C, 0x0F, 0x03, 0x81, 0xC1, 0xE0,
  0xF0, 0x7C, 0x3E, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1C, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x0F,
  0x83, 0xC7, 0xE3, 0xE3, 0xC1, 0xE0, 0xE0, 0x70, 0xF8, 0x78, 0x3C, 0x00,
  0x78, 0x3F, 0xFF, 0xFF, 0xC3, 0xF0,
};

const GFXglyph NotoSans_BlackItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 16, 7, 0, -16 },
  { 17, 9, 6, 10, 2, -16 },
  { 24, 15, 16, 14, 0, -16 },
  { 54, 12, 18, 13, 1, -17 },
  { 81, 19, 16, 20, 1, -16 },
  { 119, 16, 16, 16, 0, -16 },
  { 151, 4, 6, 5, 2, -16 },
  { 154, 9, 19, 8, 1, -16 },
  { 176, 8, 19, 8, -1, -16 },
  { 195, 10, 11, 12, 2, -17 },
  { 209, 11, 11, 13, 1, -13 },
  { 225, 6, 6, 7, -1, -3 },
  { 230, 7, 4, 7, 0, -8 },
  { 234, 5, 4, 7, 0, -4 },
  { 237, 13, 16, 10, -1, -16 },
  { 263, 11, 16, 13, 1, -16 },
  { 285, 10, 16, 13, 2, -16 },
  { 305, 13, 16, 13, -1, -16 },
  { 331, 12, 16, 13, 0, -16 },
  { 355, 13, 16, 13, 0, -16 },
  { 381, 13, 16, 13, 0, -16 },
  { 407, 12, 16, 13, 1, -16 },
  { 431, 14, 16, 13, 0, -16 },
  { 459, 11, 16, 13, 1, -16 },
  { 481, 11, 16, 13, 1, -16 },
  { 503, 7, 12, 7, 0, -12 },
  { 514, 8, 15, 7, -1, -12 },
  { 529, 11, 12, 13, 1, -14 },
  { 546, 11, 8, 13, 1, -12 },
  { 557, 11, 12, 13, 1, -14 },
  { 574, 9, 16, 11, 2, -16 },
  { 592, 18, 18, 20, 1, -16 },
  { 633, 14, 16, 15, -1, -16 },
  { 661, 14, 16, 14, 0, -16 },
  { 689, 14, 16, 14, 1, -16 },
  { 717, 14, 16, 15, 0, -16 },
  { 745, 13, 16, 12, 0, -16 },
  { 771, 13, 16, 13, 0, -16 },
  { 797, 14, 16, 15, 1, -16 },
  { 825, 16, 16, 16, 0, -16 },
  { 857, 12, 16, 9, -1, -16 },
  { 881, 12, 21, 8, -4, -16 },
  { 913, 16, 16, 15, 0, -16 },
  { 945, 10, 16, 12, 0, -16 },
  { 965, 20, 16, 20, 0, -16 },
  { 1005, 17, 16, 17, 0, -16 },
  { 1039, 15, 16, 16, 1, -16 },
  { 1069, 13, 16, 14, 0, -16 },
  { 1095, 15, 20, 16, 1, -16 },
  { 1133, 13, 16, 14, 0, -16 },
  { 1159, 12, 16, 12, 0, -16 },
  { 1183, 11, 16, 12, 2, -16 },
  { 1205, 15, 16, 15, 1, -16 },
  { 1235, 13, 16, 14, 2, -16 },
  { 1261, 20, 16, 21, 2, -16 },
  { 1301, 17, 16, 15, -1, -16 },
  { 1335, 13, 16, 13, 2, -16 },
  { 1361, 14, 16, 12, -1, -16 },
  { 1389, 10, 20, 8, -1, -16 },
  { 1414, 6, 16, 10, 2, -16 },
  { 1426, 9, 20, 8, -1, -16 },
  { 1449, 12, 11, 12, 0, -16 },
  { 1466, 11, 3, 10, -2, 1 },
  { 1471, 5, 4, 8, 3, -17 },
  { 1474, 12, 12, 13, 1, -12 },
  { 1492, 12, 17, 13, 0, -17 },
  { 1518, 10, 12, 11, 1, -12 },
  { 1533, 13, 17, 13, 1, -17 },
  { 1561, 11, 12, 13, 1, -12 },
  { 1578, 13, 22, 9, -2, -17 },
  { 1614, 13, 17, 13, 0, -12 },
  { 1642, 13, 17, 14, 0, -17 },
  { 1670, 8, 17, 7, 0, -17 },
  { 1687, 11, 22, 7, -3, -17 },
  { 1718, 15, 17, 14, 0, -17 },
  { 1750, 8, 17, 7, 0, -17 },
  { 1767, 19, 12, 20, 0, -12 },
  { 1796, 13, 12, 14, 0, -12 },
  { 1816, 11, 12, 13, 1, -12 },
  { 1833, 13, 17, 13, -1, -12 },
  { 1861, 12, 17, 13, 1, -12 },
  { 1887, 11, 12, 10, 0, -12 },
  { 1904, 11, 12, 11, 0, -12 },
  { 1921, 9, 15, 10, 1, -15 },
  { 1938, 12, 12, 14, 1, -12 },
  { 1956, 12, 12, 12, 1, -12 },
  { 1974, 18, 12, 18, 1, -12 },
  { 2001, 15, 12, 12, -1, -12 },
  { 2024, 14, 17, 12, -1, -12 },
  { 2054, 11, 12, 11, 0, -12 },
  { 2071, 9, 19, 8, 0, -16 },
  { 2093, 3, 22, 12, 5, -17 },
  { 2102, 9, 19, 8, -1, -16 },
  { 2124, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_BlackItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_BLACKITALIC22PT7B_H_
