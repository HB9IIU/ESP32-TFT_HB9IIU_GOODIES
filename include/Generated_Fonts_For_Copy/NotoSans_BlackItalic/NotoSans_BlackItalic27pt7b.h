#ifndef _NOTOSANS_BLACKITALIC27PT7B_H_
#define _NOTOSANS_BLACKITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0xE0, 0xF8, 0xFC, 0x7E, 0x1E, 0x00, 0x7D,
  0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xC7, 0x3C, 0xF3, 0xC0, 0x01, 0xE7,
  0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x03, 0x8E, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0x8B, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC1, 0xC7, 0x00, 0x73, 0xC0, 0x3C, 0xF0,
  0x0F, 0x38, 0x03, 0x9E, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x0F, 0xC0, 0x7F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x8F, 0x62, 0x3E, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xDE, 0x43, 0xBC, 0xFF,
  0xF9, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0xFC, 0x03, 0xC7, 0xF8, 0x1E, 0x1F, 0xE0, 0xF0,
  0xF3, 0xC7, 0x83, 0xCF, 0x1E, 0x0F, 0x38, 0xF0, 0x39, 0xE7, 0x80, 0xE7,
  0xBC, 0x73, 0xFE, 0xF7, 0xFF, 0xF7, 0xBF, 0xDF, 0xBD, 0xFF, 0x11, 0xE7,
  0x9C, 0x07, 0x9E, 0x70, 0x3C, 0x73, 0xC1, 0xE3, 0xCF, 0x0F, 0x0F, 0x3C,
  0x3C, 0x1F, 0xE1, 0xE0, 0x7F, 0x8F, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x3F,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0x9F, 0x00, 0xF1, 0xE0, 0x0F,
  0xBE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xBF, 0x3F, 0xE3, 0xE7,
  0xFF, 0x3E, 0x7D, 0xFF, 0xCF, 0x8F, 0xFC, 0xF8, 0xFF, 0x8F, 0xC7, 0xF0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFE, 0xFC, 0x7D, 0xE7,
  0x9E, 0x71, 0xCF, 0x00, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x3C,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03,
  0xE0, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07,
  0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x07, 0xC0, 0x02, 0x00,
  0x1E, 0x00, 0xF0, 0xC7, 0x07, 0xB8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0x1F,
  0xF9, 0xFC, 0x1F, 0xF0, 0x73, 0x81, 0x1E, 0x00, 0x80, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0xF9, 0xF3, 0xCF,
  0x9E, 0x00, 0x7F, 0x7F, 0x7F, 0xFF, 0x3B, 0xEF, 0xFE, 0xF8, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x00, 0x80, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xF9, 0xF7, 0xC7,
  0xDF, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3,
  0xEF, 0x8F, 0xBE, 0x7E, 0xFF, 0xF1, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x01,
  0xF0, 0x7F, 0x0F, 0xF3, 0xFE, 0xFF, 0xEF, 0xFE, 0x7B, 0xE2, 0x3E, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x81, 0xF8, 0x1F, 0x00, 0x00, 0x20, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE,
  0x0F, 0xFF, 0x06, 0x3F, 0x04, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0x00, 0xC0, 0x1F, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE1, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x60, 0x7E, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFF, 0x07,
  0xBE, 0x1F, 0x78, 0x3D, 0xF0, 0xF3, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xC0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x19, 0xFC, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0xC0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0,
  0x00, 0x30, 0x07, 0xFC, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xC7, 0xC0, 0x1F,
  0x00, 0x3E, 0xF0, 0x7B, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xE7, 0xEF, 0xCF,
  0xDF, 0x1F, 0xBE, 0x3E, 0x7C, 0x7C, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0xFE, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xC0, 0x3F, 0xE1, 0xFF,
  0xC7, 0xFF, 0x3E, 0x7C, 0xF8, 0xF3, 0xE7, 0xCF, 0xFE, 0x1F, 0xF8, 0x7F,
  0x81, 0xFE, 0x1F, 0xFC, 0xFD, 0xFB, 0xE3, 0xEF, 0x0F, 0xBE, 0x3E, 0xFF,
  0xFB, 0xFF, 0xC7, 0xFE, 0x0F, 0xF0, 0x01, 0x80, 0x3F, 0xC3, 0xFF, 0x8F,
  0xFE, 0x7F, 0xFD, 0xF1, 0xF7, 0xC7, 0xFF, 0x1F, 0xFC, 0xFD, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0x3F, 0xF8, 0x73, 0xE0, 0x1F, 0x80, 0xFC, 0xFF, 0xE3,
  0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0xF8, 0xFC, 0xF8, 0xF8, 0x03, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x0F, 0x83, 0xE0, 0xF0, 0x78, 0x3E, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F,
  0xC0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x3F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x03, 0xFC, 0x7F, 0xC7, 0xFC, 0x3F, 0x80, 0xF8,
  0x03, 0x80, 0x08, 0x00, 0x00, 0x06, 0x03, 0xFC, 0xFF, 0xE7, 0xFF, 0x7F,
  0xF2, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x00,
  0x1C, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x1F, 0x00,
  0x78, 0xF8, 0x00, 0xF3, 0xC7, 0xFB, 0xDE, 0x3F, 0xE7, 0x71, 0xFF, 0x9F,
  0xCF, 0x1C, 0x7F, 0x3C, 0x71, 0xFC, 0xE3, 0xC7, 0xF7, 0x8F, 0x3F, 0xDE,
  0x38, 0xEF, 0x3F, 0xFF, 0xBC, 0xFF, 0xFC, 0xF1, 0xF7, 0xC1, 0xE0, 0x00,
  0x07, 0xC0, 0x10, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xF7, 0x80,
  0x7D, 0xE0, 0x1F, 0x78, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0xF8, 0x1F,
  0x3E, 0x07, 0xDF, 0x01, 0xFF, 0xC0, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x3F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1,
  0xF1, 0xF9, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x00,
  0x00, 0x20, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF1, 0xF8,
  0x10, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x30, 0x7F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0x9F, 0x87, 0xC3, 0xF1, 0xF0, 0xFC, 0x7C,
  0x3F, 0x1F, 0x0F, 0xCF, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F,
  0x8F, 0x8F, 0xC7, 0xE7, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xE0, 0x43, 0xF0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x3F, 0xEF, 0xCF, 0xF3, 0xF3, 0xFC, 0xFC, 0xFF, 0x3F,
  0x07, 0xC7, 0xC3, 0xE1, 0xF8, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x3F, 0xE0, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC3,
  0xF1, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3F,
  0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xE3, 0xF0, 0xF8,
  0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x81, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x9F, 0xC3,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0xF8, 0x7E,
  0x0F, 0x8F, 0xC0, 0xF9, 0xF8, 0x1F, 0xBF, 0x01, 0xF3, 0xE0, 0x1F, 0x7E,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xC3, 0xE0, 0x7C,
  0x3F, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xFF, 0x7F, 0xF3, 0xFF,
  0xBF, 0xFC, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0xC1,
  0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7B, 0x87, 0x78,
  0x3D, 0xC7, 0xFC, 0x1E, 0xE3, 0xBE, 0x1F, 0x73, 0xDF, 0x0F, 0xB9, 0xEF,
  0x07, 0xDD, 0xE7, 0x83, 0xCE, 0xF7, 0xC1, 0xE7, 0xF3, 0xE1, 0xF3, 0xF9,
  0xF0, 0xF9, 0xF8, 0xF0, 0x7C, 0xFC, 0xF8, 0x3C, 0x7C, 0x7C, 0x3E, 0x3E,
  0x3E, 0x00, 0x0F, 0xE0, 0x78, 0x7F, 0x07, 0xC3, 0xF8, 0x3E, 0x1F, 0xE1,
  0xF1, 0xFF, 0x0F, 0x0F, 0x78, 0x78, 0x7B, 0xC7, 0xC3, 0xDF, 0x3E, 0x1E,
  0xF9, 0xF1, 0xF3, 0xCF, 0x0F, 0x9F, 0x78, 0x7C, 0xFB, 0xC3, 0xC3, 0xFE,
  0x1E, 0x1F, 0xF1, 0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x7C, 0x1F, 0xC3, 0xC0,
  0xFE, 0x3E, 0x07, 0xF0, 0x00, 0x30, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFE, 0x1F, 0xFF, 0x8F, 0xC3, 0xF3, 0xE0, 0x7D, 0xF8, 0x1F, 0x7C, 0x07,
  0xDF, 0x01, 0xF7, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF, 0x03, 0xEF,
  0xC1, 0xF9, 0xF8, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xF9, 0xF0,
  0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF,
  0x87, 0xFF, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xC3, 0xF3, 0xE0, 0x7D, 0xF8, 0x1F,
  0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF,
  0x07, 0xEF, 0xC1, 0xF9, 0xF8, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F,
  0x9F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F,
  0xFC, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7E, 0x7C,
  0x3E, 0x7C, 0x3F, 0xFC, 0x3F, 0x00, 0xC0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFE,
  0x3F, 0xF8, 0xF8, 0x23, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFF, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC8, 0x1F, 0x30, 0xFC, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFC, 0x3F, 0xE0, 0x7F, 0xFE, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xE7, 0xC3,
  0xE7, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0xFC, 0xF8, 0x7C, 0x7C, 0x3E, 0x7E,
  0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xF1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xF8, 0x1F, 0xFC,
  0x1F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xE0,
  0xF1, 0xF0, 0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xBC,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x00, 0xF8, 0x3E, 0x0F, 0xFE, 0x0F, 0x83, 0xEF, 0x87, 0xE1, 0xF3,
  0xE1, 0xF8, 0x7C, 0xF8, 0x7E, 0x1E, 0x3E, 0x3F, 0x8F, 0x8F, 0x8F, 0xE3,
  0xE3, 0xE7, 0xF9, 0xF0, 0xF9, 0xFE, 0x7C, 0x3E, 0xF7, 0x9E, 0x0F, 0xBD,
  0xEF, 0x83, 0xFF, 0x7B, 0xC0, 0xFF, 0x9E, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F,
  0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xF0,
  0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x3E, 0x3F,
  0x00, 0xF8, 0xF8, 0x03, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xE3, 0xE0,
  0x3F, 0x0F, 0x81, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0xBE,
  0x1F, 0x1F, 0x1F, 0x8F, 0x8F, 0x87, 0xCF, 0x81, 0xEF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xF8,
  0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x00, 0xF1, 0xE3, 0xC7,
  0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3E,
  0x3C, 0x78, 0xF0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x07, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xFC,
  0x07, 0xF0, 0x3D, 0xC0, 0xF7, 0x87, 0x9E, 0x3C, 0x38, 0xF0, 0xE7, 0x83,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0xFB, 0xE7, 0xCF, 0x1C, 0x0F,
  0x9E, 0x3F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE7, 0xE7, 0xCF, 0x8F, 0x9F, 0x1F,
  0x7E, 0x3E, 0xF8, 0x79, 0xF1, 0xF3, 0xF3, 0xE7, 0xFF, 0xCF, 0xFF, 0x0F,
  0xFE, 0x0F, 0xBC, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xDE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0x7C,
  0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0xBE, 0x3F, 0x7E, 0x7C,
  0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x8F, 0xBE, 0x00, 0x07, 0xF0, 0xFF, 0xCF,
  0xFC, 0x7F, 0xE7, 0xE1, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0x09, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x0F, 0xBE, 0x1F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC,
  0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xFC, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F,
  0xF0, 0x3E, 0xF0, 0x07, 0xF0, 0x7F, 0xE3, 0xFF, 0xCF, 0xDF, 0x7C, 0x7D,
  0xF1, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xE3, 0xE0, 0x0F, 0x81, 0x3F, 0xBC,
  0x7F, 0xF1, 0xFF, 0xC1, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0x90, 0x0F, 0xC0, 0x07, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x00, 0x07, 0xCF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE,
  0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C,
  0x7E, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF8, 0x1E, 0xF8, 0x00, 0xF8,
  0x81, 0xF8, 0xF3, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x7C,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0xFC, 0xFC, 0x07, 0x83, 0xF0, 0xFC, 0x3E, 0x03, 0x00, 0x01,
  0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x1F, 0xE0, 0xFE, 0x07,
  0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0xFC, 0x7C, 0x7E, 0x1F, 0x3F, 0x07,
  0xDF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0x7C, 0xF8, 0x1F, 0x3F, 0x07, 0xC7, 0xC1, 0xF1, 0xF8,
  0xFC, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x00, 0x1F, 0x7C, 0x7C, 0x1E, 0xFE, 0xFE,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0x3F, 0x1F, 0x3F, 0x3F, 0x1F,
  0x3E, 0x3E, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x3E,
  0x7C, 0x7E, 0x3E, 0x7C, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0xFC, 0xFC, 0x7C, 0x1F, 0x7C, 0x1E, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F,
  0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0x07, 0xF0, 0x7F,
  0xE3, 0xFF, 0xCF, 0xFF, 0x7E, 0x7D, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8,
  0x7F, 0xE3, 0xFF, 0x8F, 0xBF, 0xFE, 0x7F, 0xF1, 0xFF, 0x81, 0xF8, 0x00,
  0x0F, 0xBC, 0x0F, 0x7E, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0x9F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x3F, 0x3F, 0x3E, 0x3F, 0xFE,
  0x3F, 0xFC, 0x3D, 0xF8, 0x7D, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x9E, 0x3F, 0xFC, 0xFF, 0xF9,
  0xFF, 0xE7, 0xE7, 0xCF, 0x8F, 0x9F, 0x1F, 0x7E, 0x3E, 0xF8, 0x79, 0xF1,
  0xF3, 0xF3, 0xE7, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x0F, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x78,
  0xF7, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x00, 0x0F,
  0xF0, 0xFF, 0xCF, 0xFC, 0x7C, 0xE3, 0xE1, 0x1F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xA0, 0x7D, 0xFF, 0xEF, 0xFE, 0x7F, 0xE1, 0xFE, 0x00,
  0x07, 0x00, 0xF0, 0x0F, 0x01, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xE3, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFF, 0x8F, 0xF8,
  0x7F, 0x83, 0xF8, 0x3E, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C,
  0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0x7C, 0xF8, 0xFC, 0xF8,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3E, 0xF0, 0xF8, 0x3F, 0xF0,
  0xFB, 0xE1, 0xF3, 0xC7, 0xC7, 0x8F, 0x8F, 0x3E, 0x1E, 0x7C, 0x3D, 0xF0,
  0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0xF8, 0x7C, 0x7F, 0xF1, 0xF8, 0xFB, 0xE3, 0xF1, 0xF3, 0xCF,
  0xE7, 0xC7, 0x9D, 0xCF, 0x8F, 0x3F, 0xBE, 0x1E, 0xFF, 0x7C, 0x3D, 0xDE,
  0xF0, 0x7B, 0xBF, 0xE0, 0xFF, 0x7F, 0x81, 0xFC, 0xFF, 0x03, 0xF9, 0xFC,
  0x07, 0xF3, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7,
  0xE1, 0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFE, 0x03, 0xF3, 0xE0, 0x7C, 0x7C, 0x3F, 0x8F, 0xC0, 0x1F, 0x07,
  0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x7C, 0x0F, 0x9F, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x0F, 0xFE,
  0x3F, 0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x0F, 0xE0, 0xFE, 0x0F, 0x00, 0xFC, 0x07, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xE0,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x07, 0xE0, 0xFE, 0x0F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0x7E,
  0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x81, 0xF0,
};

const GFXglyph NotoSans_BlackItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 19, 8, 0, -19 },
  { 23, 12, 7, 12, 2, -19 },
  { 34, 18, 19, 17, 0, -19 },
  { 77, 15, 23, 16, 1, -21 },
  { 121, 22, 20, 25, 2, -20 },
  { 176, 20, 20, 20, 0, -20 },
  { 226, 6, 7, 6, 2, -19 },
  { 232, 11, 24, 10, 1, -20 },
  { 265, 11, 24, 10, -2, -20 },
  { 298, 13, 14, 15, 2, -21 },
  { 321, 14, 13, 16, 1, -16 },
  { 344, 7, 6, 8, -1, -3 },
  { 350, 8, 4, 9, 0, -9 },
  { 354, 6, 5, 8, 0, -5 },
  { 358, 15, 20, 13, -1, -20 },
  { 396, 14, 20, 16, 1, -20 },
  { 431, 12, 19, 16, 2, -19 },
  { 460, 16, 20, 16, -1, -20 },
  { 500, 15, 20, 16, 0, -20 },
  { 538, 15, 19, 16, 0, -19 },
  { 574, 16, 19, 16, 0, -19 },
  { 612, 15, 20, 16, 1, -20 },
  { 650, 17, 19, 16, 0, -19 },
  { 691, 14, 20, 16, 1, -20 },
  { 726, 14, 20, 16, 1, -20 },
  { 761, 8, 15, 8, 0, -15 },
  { 776, 10, 18, 8, -2, -15 },
  { 799, 14, 15, 16, 1, -17 },
  { 826, 14, 9, 16, 1, -14 },
  { 842, 14, 15, 16, 1, -17 },
  { 869, 12, 20, 13, 2, -20 },
  { 899, 22, 22, 24, 1, -20 },
  { 960, 18, 19, 18, -2, -19 },
  { 1003, 17, 19, 17, 0, -19 },
  { 1044, 17, 20, 17, 1, -20 },
  { 1087, 18, 19, 18, 0, -19 },
  { 1130, 16, 19, 15, 0, -19 },
  { 1168, 16, 19, 15, 0, -19 },
  { 1206, 18, 20, 19, 1, -20 },
  { 1251, 19, 19, 19, 0, -19 },
  { 1297, 14, 19, 12, -1, -19 },
  { 1331, 14, 25, 10, -4, -19 },
  { 1375, 20, 19, 18, 0, -19 },
  { 1423, 13, 19, 14, 0, -19 },
  { 1454, 25, 19, 25, 0, -19 },
  { 1514, 21, 19, 21, 0, -19 },
  { 1564, 18, 20, 20, 1, -20 },
  { 1609, 17, 19, 17, 0, -19 },
  { 1650, 18, 25, 20, 1, -20 },
  { 1707, 16, 19, 18, 0, -19 },
  { 1745, 14, 20, 15, 1, -20 },
  { 1780, 15, 19, 15, 2, -19 },
  { 1816, 17, 19, 19, 2, -19 },
  { 1857, 17, 19, 17, 2, -19 },
  { 1898, 26, 19, 25, 2, -19 },
  { 1960, 22, 19, 18, -2, -19 },
  { 2013, 17, 19, 16, 2, -19 },
  { 2054, 17, 19, 15, -1, -19 },
  { 2095, 12, 25, 10, -1, -20 },
  { 2133, 7, 20, 13, 3, -20 },
  { 2151, 12, 25, 10, -2, -20 },
  { 2189, 14, 12, 14, 0, -19 },
  { 2210, 13, 3, 12, -2, 2 },
  { 2215, 6, 5, 10, 4, -21 },
  { 2219, 15, 15, 16, 1, -15 },
  { 2248, 15, 21, 16, 0, -21 },
  { 2288, 13, 15, 14, 1, -15 },
  { 2313, 16, 21, 16, 1, -21 },
  { 2355, 14, 15, 16, 1, -15 },
  { 2382, 17, 27, 11, -3, -21 },
  { 2440, 16, 21, 16, 0, -15 },
  { 2482, 16, 21, 17, 0, -21 },
  { 2524, 10, 21, 9, 0, -21 },
  { 2551, 13, 27, 9, -3, -21 },
  { 2595, 18, 21, 17, 0, -21 },
  { 2643, 10, 21, 9, 0, -21 },
  { 2670, 24, 15, 25, 0, -15 },
  { 2715, 16, 15, 17, 0, -15 },
  { 2745, 14, 15, 16, 1, -15 },
  { 2772, 16, 21, 16, -1, -15 },
  { 2814, 15, 21, 16, 1, -15 },
  { 2854, 13, 15, 12, 0, -15 },
  { 2879, 13, 15, 14, 0, -15 },
  { 2904, 12, 18, 12, 1, -18 },
  { 2931, 16, 15, 17, 1, -15 },
  { 2961, 15, 15, 15, 1, -15 },
  { 2990, 23, 15, 22, 1, -15 },
  { 3034, 19, 15, 15, -2, -15 },
  { 3070, 18, 21, 15, -2, -15 },
  { 3118, 15, 15, 13, -1, -15 },
  { 3147, 12, 23, 10, 0, -19 },
  { 3182, 3, 26, 15, 6, -20 },
  { 3192, 12, 23, 10, -2, -19 },
  { 3227, 14, 5, 16, 1, -12 },
};

const GFXfont NotoSans_BlackItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_BLACKITALIC27PT7B_H_
