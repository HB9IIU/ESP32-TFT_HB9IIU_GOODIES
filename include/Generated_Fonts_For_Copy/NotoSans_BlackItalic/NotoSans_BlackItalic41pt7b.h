#ifndef _NOTOSANS_BLACKITALIC41PT7B_H_
#define _NOTOSANS_BLACKITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC0, 0x7E, 0x00, 0x7F, 0x3F, 0xBF, 0x1F, 0x9F, 0x8F, 0xCF, 0xCF,
  0xEF, 0xE7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C,
  0x7E, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xE3, 0xF0, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF2, 0x1F, 0x8F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x1F, 0xEE, 0x78, 0x3F, 0xBC, 0x10, 0x7F, 0x78, 0x00,
  0xFE, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0x3F, 0x00, 0x0E, 0x7F, 0x30, 0x1C, 0xFC, 0x7E, 0x7B,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x3F, 0xF0, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0xE0, 0x1F,
  0x80, 0x7E, 0xFC, 0x07, 0xE0, 0x1F, 0x8F, 0x81, 0xF8, 0x03, 0xF1, 0xF8,
  0x3E, 0x00, 0x7E, 0x3E, 0x0F, 0xC0, 0x1F, 0x87, 0xC3, 0xF0, 0x03, 0xF1,
  0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE7, 0xE3, 0xF1,
  0xF9, 0xF9, 0xF9, 0xFF, 0x1F, 0xFF, 0x7E, 0x7F, 0xF3, 0xFF, 0xCF, 0xDF,
  0xFF, 0x3F, 0xF3, 0xF3, 0xFF, 0xE3, 0xFC, 0xFC, 0xFC, 0xFC, 0x0E, 0x3F,
  0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x7E, 0x00,
  0x7E, 0x1F, 0x8F, 0xC0, 0x1F, 0x83, 0xF1, 0xF8, 0x03, 0xF0, 0x7E, 0x3F,
  0x00, 0xFC, 0x0F, 0xCF, 0xC0, 0x3F, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x3F,
  0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0xF0, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0xFE,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x3F, 0xC3,
  0xFF, 0xE1, 0xFE, 0x3F, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0x3F, 0xC7, 0xFD,
  0xFE, 0xFF, 0x1F, 0xE7, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xE3, 0xFC, 0x1F,
  0xFF, 0x0F, 0xF0, 0x7F, 0xF8, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0x80, 0x7F, 0x7E, 0x7E, 0x7E,
  0xFE, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x02,
  0x07, 0xC0, 0x30, 0x7C, 0x07, 0xC7, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFC,
  0x71, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xF3, 0xE0, 0x1F, 0x3F, 0x00, 0xE3,
  0xF0, 0x04, 0x3F, 0x80, 0x01, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xE3,
  0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0x80, 0x3F, 0xFB, 0xFF, 0x9F,
  0xFC, 0xFF, 0xE7, 0xFF, 0x7F, 0xF8, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC,
  0x3F, 0xDF, 0xF0, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F,
  0xDF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF,
  0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC7,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF,
  0xFC, 0x7F, 0xFF, 0x8F, 0xEF, 0xF0, 0xF1, 0xFC, 0x1C, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xF0, 0xFF, 0x01, 0xC1, 0xFE, 0x01, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x01, 0x81, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x20, 0x01, 0xFE,
  0x70, 0x0F, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0x7F, 0x80, 0xFC,
  0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0xF8, 0x3F, 0x8F, 0xF0, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x04, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x80, 0x07, 0xF8, 0xE0, 0x1F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x40, 0x1F, 0xCF, 0xE0, 0x7F, 0xFF, 0xC3,
  0xFB, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFC,
  0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F,
  0xCF, 0xE0, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFC, 0xFF, 0x1F, 0xC3,
  0xFC, 0xFF, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0xC1, 0xFC,
  0xFF, 0x9F, 0xF3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xF0, 0xFE, 0x7F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xBF, 0x8F, 0xFF, 0xFC, 0x3F, 0x9F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x00, 0x00,
  0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xE0, 0x7F, 0x20, 0x1F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0xF8, 0x1F, 0x8F, 0xC1, 0xFF, 0xE7, 0xE3, 0xE0, 0xFF, 0xF8, 0xF9, 0xF8,
  0x7F, 0xFE, 0x3E, 0x7C, 0x3F, 0xFF, 0x8F, 0xBF, 0x1F, 0xC7, 0xC3, 0xFF,
  0xC7, 0xE1, 0xF0, 0xFB, 0xE3, 0xF0, 0x7C, 0x3E, 0xF8, 0xFC, 0x3F, 0x0F,
  0xBE, 0x3F, 0x0F, 0x83, 0xEF, 0x8F, 0x83, 0xE1, 0xFB, 0xE3, 0xE1, 0xF8,
  0x7C, 0xF8, 0xF8, 0x7E, 0x3F, 0x3E, 0x3F, 0xFF, 0xFF, 0x8F, 0x8F, 0xFF,
  0xFF, 0xC3, 0xE1, 0xFF, 0x7F, 0xE0, 0xFC, 0x7F, 0x9F, 0xF0, 0x1F, 0x87,
  0xC1, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x08, 0x00, 0x3F,
  0xC0, 0x1E, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF7,
  0xE0, 0x01, 0xFE, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xF3, 0xF0, 0x01,
  0xFC, 0x7E, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0,
  0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x8F, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xF0, 0x3C, 0x3F, 0xF0, 0x06, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x40, 0xFF, 0x81, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x0F,
  0xF0, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8,
  0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F,
  0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFF,
  0x1F, 0xE0, 0xFF, 0x87, 0xFB, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xF0, 0x1C, 0x1F, 0xF0, 0x01, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFF,
  0xEF, 0xF8, 0xFF, 0xFB, 0xFC, 0x3F, 0xFC, 0xFF, 0x0F, 0xFF, 0x3F, 0xC3,
  0xFF, 0xCF, 0xF1, 0xFF, 0xF3, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F,
  0xC0, 0x7F, 0x8F, 0xF8, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x7F,
  0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x31, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xF8, 0x7F, 0xC0, 0x3F,
  0xC7, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xBF,
  0xC0, 0x03, 0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x1F,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xF0,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFD, 0xF0,
  0x7E, 0xFC, 0x0F, 0xDF, 0x07, 0xFF, 0xC1, 0xFD, 0xF0, 0x7D, 0xFC, 0x1F,
  0xDF, 0x0F, 0xDF, 0xC1, 0xFD, 0xF0, 0xF9, 0xFC, 0x1F, 0xDF, 0x1F, 0xBF,
  0x83, 0xF9, 0xF1, 0xF3, 0xF8, 0x3F, 0x9F, 0x3F, 0x3F, 0x83, 0xF9, 0xF3,
  0xE3, 0xF8, 0x3F, 0x9F, 0x7E, 0x7F, 0x03, 0xF9, 0xF7, 0xE7, 0xF0, 0x7F,
  0x1F, 0xFC, 0x7F, 0x07, 0xF1, 0xFF, 0xC7, 0xF0, 0x7F, 0x1F, 0xF8, 0x7F,
  0x07, 0xF1, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0xF0, 0xFE, 0x0F, 0xE1, 0xFF,
  0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0xFE,
  0x07, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0xFE,
  0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0x81, 0xFC,
  0x0F, 0xDF, 0xC1, 0xFC, 0x0F, 0xDF, 0xC1, 0xFC, 0x0F, 0xDF, 0xC3, 0xF8,
  0x1F, 0xDF, 0xC3, 0xF8, 0x1F, 0xCF, 0xE3, 0xF8, 0x1F, 0xCF, 0xE3, 0xF8,
  0x1F, 0xCF, 0xE3, 0xF0, 0x3F, 0x87, 0xF7, 0xF0, 0x3F, 0x87, 0xF7, 0xF0,
  0x3F, 0x87, 0xF7, 0xF0, 0x3F, 0x87, 0xF7, 0xF0, 0x3F, 0x83, 0xFF, 0xE0,
  0x7F, 0x03, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xE0,
  0x7F, 0x01, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xC0,
  0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC1, 0xFE, 0x1F, 0xF0, 0x3F, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x00,
  0x7F, 0xBF, 0xE0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07,
  0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE,
  0x01, 0xFF, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x0F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFF, 0x1F, 0xE3, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xC1, 0xFE,
  0x1F, 0xF0, 0x3F, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0xE0,
  0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00,
  0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE, 0x01, 0xFF, 0x3F,
  0xE0, 0x7F, 0xC3, 0xFE, 0x3F, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F,
  0xE1, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F,
  0xCF, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F,
  0x87, 0xF8, 0x7F, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x07, 0xF8, 0x1C, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE2, 0x00, 0x7F, 0x8C, 0x03, 0xFC, 0x3E, 0x0F, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xF8,
  0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0,
  0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0xFF, 0x01,
  0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x07, 0xF8, 0x1F, 0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF,
  0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xE3, 0xFC, 0x0F, 0xF0,
  0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xFC,
  0x0F, 0xE1, 0xFE, 0x07, 0xF1, 0xFE, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0xFB, 0xF8, 0x07, 0xF8, 0x0F, 0xF7,
  0xF0, 0x1F, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0xE0, 0x7F, 0x9F, 0xC0, 0x7F,
  0xC0, 0xFE, 0x3F, 0x81, 0xFF, 0x83, 0xFC, 0x7F, 0x03, 0xFF, 0x07, 0xF0,
  0xFE, 0x0F, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F,
  0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0xF1, 0xFE, 0x0F, 0xE1, 0xFF, 0xE3, 0xF8,
  0x1F, 0xC7, 0xEF, 0xC7, 0xF0, 0x1F, 0x8F, 0xDF, 0x9F, 0xC0, 0x3F, 0x3F,
  0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x7E, 0xFF, 0x00, 0xFD, 0xFC, 0xFD, 0xFC,
  0x01, 0xFB, 0xF1, 0xFB, 0xF8, 0x03, 0xF7, 0xE3, 0xFF, 0xE0, 0x07, 0xFF,
  0x87, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xF3,
  0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xBF, 0xC0,
  0xFF, 0x9F, 0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0xC3, 0xF8, 0x3F, 0xC1, 0xFC,
  0x3F, 0xC0, 0xFE, 0x3F, 0xE0, 0x7F, 0x9F, 0xE0, 0x1F, 0xDF, 0xE0, 0x0F,
  0xEF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xF7, 0xE0, 0x0F, 0xCF, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x0F,
  0xC3, 0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x1F, 0x0F, 0xC0, 0x7E, 0x7E, 0x01,
  0xF9, 0xF8, 0x03, 0xEF, 0xC0, 0x0F, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xFF, 0x1F, 0xC3, 0xF8,
  0xFE, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0xFC, 0x1F, 0xF3, 0xF0, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFE, 0xFF, 0x9F,
  0xF1, 0xFE, 0x7F, 0x87, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0x3F, 0xC1,
  0xFC, 0xFF, 0x07, 0xF3, 0xFC, 0x3F, 0xCF, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xBF, 0x01, 0xFD, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFB, 0xE0, 0x0F, 0xEF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFE, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0x07, 0xF8, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xCF,
  0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC7, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xCF, 0xF8, 0x3F, 0x8F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xF8, 0x63, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x08, 0xFF, 0x07, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xF1, 0xFC,
  0x07, 0xF9, 0xFC, 0x0F, 0xFD, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xEF, 0xF8, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xEF, 0xC0, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x01,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x9F, 0xF3, 0xFD, 0xFF, 0x1F,
  0xEF, 0xF0, 0xFF, 0x7F, 0x87, 0xFF, 0xF9, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x87, 0xFC, 0x3C, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xB0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x27, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x7E, 0x07, 0xFC, 0xFC, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF,
  0x1F, 0xF1, 0xFE, 0x3F, 0xC3, 0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xE3,
  0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F,
  0xC3, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFD, 0xFC, 0x03, 0xF7, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC1, 0x00, 0x7F, 0x83, 0x81, 0xFF, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF9, 0xF0, 0x07, 0xF7, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xF9, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFC,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0x83, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x07, 0xF8,
  0x00, 0x78, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x09, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x80,
  0x7F, 0x0F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF7,
  0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xCF, 0xF0,
  0x03, 0xF8, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x7F,
  0x87, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xE1, 0xF8,
  0x1F, 0x80, 0x7E, 0x7F, 0xC3, 0xFC, 0x07, 0xEF, 0xFE, 0x7F, 0xE0, 0x7E,
  0xFF, 0xEF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xF9, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x0F, 0xF1, 0xFE,
  0x1F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE,
  0x3F, 0xC1, 0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xC7, 0xF8,
  0x3F, 0x83, 0xFC, 0x7F, 0x87, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0x83, 0xF8,
  0xFF, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xE1, 0xF0, 0x07, 0xE7, 0xFC, 0x07,
  0xEF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F,
  0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F,
  0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC1, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xFC, 0x7F,
  0x83, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0xFF,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0x1F, 0xEF, 0xF0, 0xFF, 0x7F,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0x1F, 0xE7, 0xFD,
  0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0xFD, 0xFF, 0x00, 0x7E, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xF1,
  0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC,
  0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F,
  0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF1, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFE, 0xFF, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0xFC, 0x1F, 0xF3, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFE, 0xFF, 0x9F, 0xF1, 0xFE, 0x7F, 0x87, 0xFB,
  0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0xFF, 0x07, 0xF3, 0xFC,
  0x3F, 0xCF, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0x7F, 0x01,
  0xFB, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xE1, 0xF0, 0x7E, 0x7E, 0x07,
  0xEF, 0xE0, 0x7E, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xC4, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0x8F, 0x0F, 0xF0, 0x61, 0xFE, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x80, 0x7F, 0x9E, 0x1F, 0xF3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xFF, 0xC7, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xE1, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x84, 0x1F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xE1, 0xFE, 0x3F, 0x83, 0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xE3,
  0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F,
  0x83, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0xCF, 0xF0,
  0x7F, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF8, 0xFF, 0x1F,
  0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFD, 0xFC, 0x0F, 0xF3, 0xF0, 0x00, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xCF, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE,
  0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x7F, 0x81,
  0xFC, 0xFE, 0x03, 0xFB, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0x83, 0xFE, 0x0F, 0xEF, 0xE0,
  0xFF, 0x87, 0xFB, 0xF8, 0x3F, 0xE1, 0xFE, 0xFE, 0x1F, 0xF8, 0x7F, 0x3F,
  0x87, 0xFE, 0x3F, 0xCF, 0xE3, 0xFF, 0x8F, 0xE3, 0xF8, 0xFF, 0xE7, 0xF8,
  0x7E, 0x3F, 0xF9, 0xFC, 0x1F, 0x9F, 0xFC, 0x7F, 0x07, 0xE7, 0xDF, 0x3F,
  0x81, 0xF9, 0xF7, 0xCF, 0xE0, 0x7E, 0xFD, 0xF7, 0xF0, 0x1F, 0xBE, 0x7D,
  0xFC, 0x07, 0xEF, 0x9F, 0x7E, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xF1,
  0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x03,
  0xFC, 0x7F, 0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xEF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x03, 0xFE,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x83, 0xFE,
  0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xC0,
  0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x1F,
  0xBF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x8F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x01,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x80,
  0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0x80, 0x3F, 0xE0,
};

const GFXglyph NotoSans_BlackItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 29, 12, 0, -29 },
  { 52, 17, 10, 19, 4, -29 },
  { 74, 27, 29, 26, 0, -29 },
  { 172, 23, 33, 24, 1, -31 },
  { 267, 35, 30, 38, 2, -30 },
  { 399, 30, 30, 30, 0, -30 },
  { 512, 8, 10, 10, 4, -29 },
  { 522, 17, 36, 15, 1, -30 },
  { 599, 17, 36, 15, -3, -30 },
  { 676, 20, 20, 22, 3, -31 },
  { 726, 20, 19, 24, 2, -24 },
  { 774, 11, 10, 13, -2, -5 },
  { 788, 13, 6, 13, 0, -14 },
  { 798, 8, 7, 13, 0, -7 },
  { 805, 24, 30, 19, -2, -30 },
  { 895, 22, 30, 24, 1, -30 },
  { 978, 19, 29, 24, 3, -29 },
  { 1047, 23, 30, 24, -1, -30 },
  { 1134, 23, 30, 24, 0, -30 },
  { 1221, 23, 29, 24, 0, -29 },
  { 1305, 24, 29, 24, 0, -29 },
  { 1392, 22, 30, 24, 2, -30 },
  { 1475, 25, 29, 24, 1, -29 },
  { 1566, 22, 30, 24, 1, -30 },
  { 1649, 21, 30, 24, 2, -30 },
  { 1728, 12, 23, 13, 0, -23 },
  { 1763, 14, 28, 13, -2, -23 },
  { 1812, 20, 22, 24, 2, -26 },
  { 1867, 20, 15, 24, 2, -22 },
  { 1905, 20, 22, 24, 2, -26 },
  { 1960, 18, 30, 20, 3, -30 },
  { 2028, 34, 34, 37, 2, -30 },
  { 2173, 27, 29, 28, -2, -29 },
  { 2271, 24, 29, 26, 1, -29 },
  { 2358, 25, 30, 26, 2, -30 },
  { 2452, 26, 29, 28, 1, -29 },
  { 2547, 23, 29, 23, 1, -29 },
  { 2631, 23, 29, 23, 1, -29 },
  { 2715, 26, 30, 29, 2, -30 },
  { 2813, 28, 29, 29, 1, -29 },
  { 2915, 21, 29, 17, -1, -29 },
  { 2992, 22, 38, 15, -7, -29 },
  { 3097, 29, 29, 27, 1, -29 },
  { 3203, 18, 29, 22, 1, -29 },
  { 3269, 36, 29, 37, 1, -29 },
  { 3400, 32, 29, 32, 1, -29 },
  { 3516, 27, 30, 30, 2, -30 },
  { 3618, 24, 29, 26, 1, -29 },
  { 3705, 27, 37, 30, 2, -30 },
  { 3830, 24, 29, 27, 1, -29 },
  { 3917, 22, 30, 22, 1, -30 },
  { 4000, 22, 29, 23, 3, -29 },
  { 4080, 27, 29, 29, 2, -29 },
  { 4178, 25, 29, 25, 3, -29 },
  { 4269, 39, 29, 38, 3, -29 },
  { 4411, 33, 29, 27, -3, -29 },
  { 4531, 25, 29, 25, 3, -29 },
  { 4622, 26, 29, 22, -2, -29 },
  { 4717, 18, 37, 15, -1, -30 },
  { 4801, 12, 30, 19, 4, -30 },
  { 4846, 19, 37, 15, -3, -30 },
  { 4934, 22, 19, 22, 0, -29 },
  { 4987, 20, 5, 18, -4, 3 },
  { 5000, 10, 6, 14, 6, -31 },
  { 5008, 22, 23, 25, 2, -23 },
  { 5072, 23, 31, 25, 0, -31 },
  { 5162, 19, 23, 21, 2, -23 },
  { 5217, 24, 31, 25, 2, -31 },
  { 5310, 21, 23, 24, 2, -23 },
  { 5371, 25, 41, 17, -4, -31 },
  { 5500, 23, 33, 25, 1, -23 },
  { 5595, 24, 31, 26, 0, -31 },
  { 5688, 15, 32, 13, 0, -32 },
  { 5748, 20, 42, 13, -5, -32 },
  { 5853, 28, 31, 25, 0, -31 },
  { 5962, 15, 31, 13, 0, -31 },
  { 6021, 36, 23, 38, 0, -23 },
  { 6125, 24, 23, 26, 0, -23 },
  { 6194, 21, 23, 25, 2, -23 },
  { 6255, 25, 33, 25, -2, -23 },
  { 6359, 22, 33, 25, 2, -23 },
  { 6450, 20, 23, 18, 0, -23 },
  { 6508, 19, 23, 21, 1, -23 },
  { 6563, 18, 27, 19, 1, -27 },
  { 6624, 23, 23, 26, 2, -23 },
  { 6691, 23, 23, 22, 2, -23 },
  { 6758, 34, 23, 34, 2, -23 },
  { 6856, 28, 23, 23, -2, -23 },
  { 6937, 28, 33, 22, -3, -23 },
  { 7053, 22, 23, 20, -1, -23 },
  { 7117, 18, 35, 15, 0, -29 },
  { 7196, 5, 40, 23, 9, -31 },
  { 7221, 17, 35, 15, -2, -29 },
  { 7296, 20, 7, 24, 2, -18 },
};

const GFXfont NotoSans_BlackItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_BLACKITALIC41PT7B_H_
