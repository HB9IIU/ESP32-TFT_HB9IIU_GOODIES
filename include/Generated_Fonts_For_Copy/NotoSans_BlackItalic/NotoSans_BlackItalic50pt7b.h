#ifndef _NOTOSANS_BLACKITALIC50PT7B_H_
#define _NOTOSANS_BLACKITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x80, 0x00, 0x3F, 0xE7, 0xF9, 0xFE,
  0x3F, 0xCF, 0xF1, 0xFE, 0x7F, 0x8F, 0xE3, 0xF8, 0xFF, 0x3F, 0xC7, 0xF9,
  0xFE, 0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xEF, 0xC0, 0xFF, 0xBC, 0x08, 0x0F, 0xF3, 0xC0, 0x00, 0xFF, 0x3C,
  0x00, 0x0F, 0xFB, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xE7, 0xF8, 0x00, 0x1E, 0x7F, 0x8E, 0x01,
  0xE7, 0xF8, 0xFC, 0x1E, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xC0,
  0x0F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xF9, 0xFC, 0x03, 0xF8,
  0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x7F, 0x00, 0x3F,
  0xC7, 0xF0, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F,
  0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x8F, 0xF1, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0xFE, 0x0F, 0xC3, 0xF9, 0xFE, 0x7F, 0x9F, 0xFC,
  0xFF, 0xFF, 0x9F, 0xCF, 0xFF, 0xBF, 0xFF, 0xCF, 0xE7, 0xFF, 0xE7, 0xFF,
  0xE7, 0xF3, 0xFF, 0xFD, 0xFF, 0xF3, 0xFC, 0xFF, 0xFF, 0x3F, 0xF8, 0xFE,
  0x7F, 0x9F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x87, 0xF1,
  0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x0F, 0xE1, 0xFC, 0x00, 0xFF,
  0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x1F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0x80, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFF, 0xF8, 0x3F, 0xF1, 0xFF, 0xFF, 0x83, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xE7, 0xFF, 0xFF, 0xE7, 0xFC, 0x7F, 0xE7, 0xFE, 0xFF, 0xC7, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x3F, 0xF8, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0xFF, 0x1F, 0xE3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x20, 0x3F, 0x80, 0x38, 0x3F, 0x80,
  0x7E, 0x3F, 0x00, 0x7F, 0xBF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0x87, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x7F, 0xDF, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0x0F, 0xE0,
  0x02, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xFE, 0xFF,
  0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFE, 0x00, 0x0F,
  0x0F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x82, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0xCF, 0xFC, 0x1F, 0xF3,
  0xFF, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x7F, 0xE0, 0x7F, 0xDF, 0xF8, 0x1F,
  0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xBF,
  0xE0, 0x7F, 0xEF, 0xF8, 0x1F, 0xFB, 0xFE, 0x07, 0xFE, 0xFF, 0x83, 0xFF,
  0x3F, 0xE0, 0xFF, 0xCF, 0xF8, 0x3F, 0xF3, 0xFE, 0x1F, 0xF8, 0xFF, 0xCF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x87,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xF7,
  0xFC, 0x7F, 0x9F, 0xF0, 0xF8, 0xFF, 0xC1, 0x83, 0xFE, 0x04, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFC, 0x3F, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0x60, 0x1F, 0xF0, 0x04, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xCF, 0xFE, 0x00, 0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x80, 0x00, 0xFF, 0xCC,
  0x00, 0x1F, 0xFC, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF7, 0xFC,
  0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x7F,
  0x8F, 0xF8, 0x07, 0xF0, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE1, 0xFF,
  0x03, 0xFC, 0x1F, 0xF1, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x30, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF1, 0xC0, 0x03, 0xFF, 0x0F, 0xC0,
  0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x0E, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x3E, 0x00, 0x7F, 0x9F, 0xF8, 0x1F, 0xF7, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFE, 0x1F, 0xF9, 0xFF, 0x83, 0xFF, 0x3F, 0xF0,
  0x7F, 0xE7, 0xFE, 0x0F, 0xFC, 0xFF, 0x81, 0xFF, 0x9F, 0xF0, 0x3F, 0xF3,
  0xFE, 0x07, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFF,
  0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x7F, 0xF7, 0xFE, 0x0F, 0xF8, 0x7F, 0xE3, 0xFE, 0x0F,
  0xFC, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F,
  0xC0, 0x7F, 0xCF, 0xFC, 0x1F, 0xF9, 0xFF, 0xEF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xE7, 0xFE, 0x7F, 0xE1,
  0xFF, 0x7F, 0xE0, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xEF, 0xF8, 0x7F, 0xEF, 0xF8, 0x1F, 0xC7, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x08, 0x0F, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x00, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFF,
  0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xCF, 0xE7, 0xFF, 0x3C, 0x07, 0xFC, 0x40, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xCF, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0x80, 0x3F, 0x87, 0xF8, 0x0F, 0xFF, 0x0F, 0xE3, 0xF8, 0x1F,
  0xFF, 0xC7, 0xF3, 0xF8, 0x1F, 0xFF, 0xE3, 0xF9, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFD, 0xFC, 0x1F, 0xFF, 0xF8, 0x7E, 0xFE, 0x1F, 0xE1, 0xF8, 0x3F, 0x7E,
  0x0F, 0xE0, 0xFC, 0x1F, 0xBF, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0x87, 0xF0,
  0x7F, 0x07, 0xFF, 0xC7, 0xF0, 0x3F, 0x03, 0xFF, 0xE3, 0xF8, 0x1F, 0x83,
  0xFF, 0xE1, 0xFC, 0x1F, 0xC1, 0xFB, 0xF0, 0xFE, 0x0F, 0xE0, 0xFD, 0xF8,
  0x7F, 0x0F, 0xE0, 0xFE, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x7F, 0x1F, 0xEF,
  0xFD, 0xFE, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF,
  0x0F, 0xE1, 0xFF, 0xDF, 0xFF, 0x03, 0xF8, 0x7F, 0xC7, 0xFE, 0x01, 0xFC,
  0x0F, 0x80, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE,
  0x3F, 0xF0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x0F,
  0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC3, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x0F, 0xF8,
  0x3F, 0xF8, 0x7F, 0xE7, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xF0, 0x7F, 0xF0, 0x01, 0x83, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x10, 0x3F, 0xF8, 0x01, 0xC0, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x0F,
  0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F,
  0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F,
  0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xF8, 0x3F, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x70, 0x3F, 0xFC, 0x00, 0x20, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xFE, 0xFF, 0xC1,
  0xFF, 0xF9, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xE7, 0xFC, 0x1F,
  0xFF, 0xCF, 0xF8, 0x3F, 0xFF, 0x9F, 0xF0, 0xFF, 0xFE, 0x3F, 0xE1, 0xFF,
  0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x80, 0x7F,
  0xE3, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x0F, 0xFF, 0xCF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x7F,
  0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x03, 0xFE,
  0x1F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xF0, 0x00,
  0x7F, 0xCF, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F,
  0xF8, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFB,
  0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC1, 0xFD, 0xFF,
  0x01, 0xFE, 0xFE, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF0, 0xFE, 0x7F, 0x80,
  0x7F, 0xBF, 0x87, 0xF7, 0xFC, 0x07, 0xFD, 0xFC, 0x7F, 0x3F, 0xE0, 0x3F,
  0xEF, 0xE3, 0xF9, 0xFF, 0x01, 0xFF, 0x7F, 0x1F, 0xCF, 0xF0, 0x0F, 0xF3,
  0xF9, 0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xCF, 0xE7, 0xFC, 0x07, 0xFC, 0xFE,
  0xFE, 0x3F, 0xE0, 0x3F, 0xE7, 0xF7, 0xF1, 0xFF, 0x01, 0xFF, 0x3F, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF1, 0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xFF, 0x87,
  0xFC, 0x07, 0xFC, 0x7F, 0xFC, 0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0xC1, 0xFE,
  0x01, 0xFE, 0x1F, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF, 0x80,
  0x7F, 0x87, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F,
  0xE1, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x80,
  0x0F, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xFF,
  0xC0, 0xFF, 0x00, 0xFF, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0xFF, 0x87, 0xFC,
  0x07, 0xF9, 0xFF, 0x0F, 0xF8, 0x0F, 0xF1, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3,
  0xFC, 0x3F, 0xC0, 0x7F, 0xC7, 0xFC, 0xFF, 0x80, 0xFF, 0x8F, 0xF9, 0xFF,
  0x01, 0xFF, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0x1F, 0xF7, 0xF8, 0x07, 0xF8,
  0x3F, 0xEF, 0xF0, 0x1F, 0xF0, 0x3F, 0xDF, 0xE0, 0x3F, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFE,
  0x01, 0xFF, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xF8, 0x07, 0xFF,
  0xF0, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x7F,
  0x80, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x3F,
  0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0x7F,
  0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF,
  0xF9, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE,
  0x07, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0,
  0x03, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80,
  0x0F, 0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0,
  0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF,
  0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00,
  0xFF, 0xC7, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x03,
  0xFF, 0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0x01,
  0xFF, 0x00, 0x20, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC3, 0x00, 0x1F, 0xF8,
  0x78, 0x03, 0xFF, 0x0F, 0xF1, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFF,
  0x07, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFE,
  0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFB,
  0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0x1F,
  0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF,
  0x80, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0xFF, 0x8F,
  0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0xFF,
  0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFE, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFB,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xEF,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x3F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xF8, 0x0F, 0xF8, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xC3, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1,
  0xFD, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0xF8, 0x7F, 0x80, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0xDF, 0xE3, 0xFE, 0x03, 0xFC, 0x7F,
  0xBF, 0xCF, 0xF8, 0x07, 0xF8, 0xFE, 0x7F, 0x9F, 0xF0, 0x0F, 0xF1, 0xFC,
  0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF9, 0xFE, 0xFF, 0x80, 0x3F, 0xCF, 0xE3,
  0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC7, 0xF3, 0xFC, 0x00, 0x7F, 0x7F, 0x0F,
  0xEF, 0xF8, 0x00, 0xFE, 0xFE, 0x1F, 0xDF, 0xE0, 0x01, 0xFF, 0xFC, 0x3F,
  0xBF, 0xC0, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x0F,
  0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x03,
  0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xE7, 0xFC, 0x03, 0xFF, 0x9F, 0xF0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x3F,
  0xE0, 0x07, 0xFD, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0,
  0x03, 0xFB, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x87,
  0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xE1, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x9F, 0xE0, 0x07, 0xF7,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF0, 0xFF, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF0,
  0x3F, 0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xF8, 0xFF, 0x03, 0xFF, 0xDF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xDF, 0xFC, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC,
  0x7F, 0xE0, 0x7F, 0xC7, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC,
  0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xE7, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xDF, 0xC0, 0x1F, 0xF9, 0xFC, 0x00,
  0xFF, 0x3F, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFB, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xDF, 0xFC, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F,
  0xF8, 0xFF, 0x03, 0xFF, 0x3F, 0xE0, 0x7F, 0xE7, 0xFC, 0x0F, 0xFC, 0xFF,
  0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0xE3, 0xFE, 0x0F, 0xFC, 0xFF, 0xC3, 0xFF,
  0x1F, 0xFC, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xBF, 0xFE, 0x0F, 0xF3, 0xFF, 0x81,
  0xFC, 0x3F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFC, 0xF8, 0x3F, 0xF8, 0x08, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x30, 0xFF, 0xE1, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x07, 0xE3, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0xBF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0x03, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F,
  0xFC, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F,
  0x00, 0x1F, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0xCF, 0xFC,
  0xFF, 0xC1, 0xFF, 0x3F, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xF7, 0xFE, 0x0F,
  0xF9, 0xFF, 0x8F, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x10, 0xFF, 0xC0, 0x1C, 0x1F, 0xFC, 0x3F,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x04, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x02, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x07, 0xFE, 0x3F, 0xC0, 0x7F, 0xFB,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xDF, 0xFC, 0x1F, 0xFC, 0x7F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0x83, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8,
  0x7F, 0xE0, 0x7F, 0x83, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x07, 0xFF, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0xF0,
  0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x10, 0x01, 0xFF, 0x80, 0xF8, 0x3F,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x7F, 0x00, 0x7F, 0xDF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xF7, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x83,
  0xFF, 0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1,
  0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xFE, 0x3F, 0xE0,
  0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC7, 0xFE, 0x0F, 0xFC,
  0x7F, 0xE0, 0xFF, 0xC7, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x8F, 0xFC,
  0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0,
  0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC,
  0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF,
  0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE, 0x07, 0xFC, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0xFE, 0x00, 0xFF, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xEF, 0xFF,
  0x1F, 0xFF, 0x03, 0xFD, 0xFF, 0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFB, 0xFF, 0xF7, 0xFF, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE3, 0xFF,
  0x87, 0xFF, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF1, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x8F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC7, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC7, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC7, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE3, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x9F, 0xF8,
  0x07, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF7, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF1, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0x83, 0xFE, 0x1F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x07,
  0xFE, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC7,
  0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x8F, 0xFC, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8,
  0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xE3, 0xFF, 0x3F, 0xF0, 0xFF,
  0xCF, 0xFC, 0x1F, 0xF7, 0xFE, 0x07, 0xFD, 0xFF, 0x81, 0xFF, 0x7F, 0xC0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xEF, 0xFC, 0x1F, 0xFB, 0xFF, 0x0F, 0xFC,
  0xFF, 0xC3, 0xFF, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0x80, 0x03, 0xFD,
  0xFF, 0x80, 0x0F, 0xF7, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF,
  0x01, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x7F,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xFE, 0x01, 0xFF, 0x7F, 0xF0, 0x07,
  0xFC, 0x7F, 0x00, 0x3F, 0xF0, 0x40, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xF8, 0xFF, 0x03, 0xFF, 0xDF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xDF, 0xFC, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F,
  0xE0, 0x7F, 0xC7, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F,
  0xF8, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE7,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0xC0, 0x1F, 0xF7, 0xFC, 0x00, 0xFE,
  0x7F, 0xC0, 0x01, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x7E, 0x0F,
  0xF3, 0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFE,
  0x7E, 0x1F, 0xF8, 0x1C, 0x3F, 0xF0, 0x08, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE4,
  0x00, 0xFF, 0xCC, 0x01, 0xFF, 0x9F, 0xDF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x18, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x3F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xEF, 0xF0, 0x0F, 0xFE, 0x7F,
  0x80, 0x1F, 0xE3, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xE7, 0xFC, 0x07, 0xFC, 0x7F,
  0xC0, 0xFF, 0xC7, 0xFC, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC7, 0xFE, 0x03,
  0xFC, 0x7F, 0xC0, 0x3F, 0xCF, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xCF,
  0xF0, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xDF, 0xE0, 0x3F, 0xF0, 0x3F, 0xE7, 0xF8, 0x1F,
  0xFC, 0x0F, 0xF9, 0xFE, 0x07, 0xFF, 0x07, 0xFC, 0x7F, 0x83, 0xFF, 0xC1,
  0xFF, 0x1F, 0xE0, 0xFF, 0xF0, 0xFF, 0xC7, 0xF8, 0x3F, 0xFC, 0x3F, 0xE1,
  0xFE, 0x1F, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xFF, 0xC7, 0xFC, 0x1F, 0xE1,
  0xFF, 0xF1, 0xFF, 0x07, 0xF8, 0xFF, 0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0x7E,
  0x3F, 0xE0, 0x7F, 0x9F, 0xDF, 0x8F, 0xF0, 0x1F, 0xE7, 0xF7, 0xE7, 0xFC,
  0x07, 0xF9, 0xF9, 0xF9, 0xFE, 0x01, 0xFE, 0xFE, 0x7E, 0xFF, 0x80, 0x7F,
  0xBF, 0x1F, 0xBF, 0xC0, 0x1F, 0xEF, 0xC7, 0xEF, 0xF0, 0x03, 0xFF, 0xF1,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xE0,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFC,
  0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0,
  0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC,
  0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0x8F, 0xFC, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xBF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x80, 0x03, 0xFC, 0x00,
};

const GFXglyph NotoSans_BlackItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 17, 37, 15, 0, -36 },
  { 80, 21, 13, 23, 4, -36 },
  { 115, 33, 36, 32, 0, -36 },
  { 264, 28, 41, 29, 1, -38 },
  { 408, 42, 37, 47, 3, -36 },
  { 603, 36, 37, 37, 0, -36 },
  { 770, 11, 13, 12, 4, -36 },
  { 788, 20, 45, 19, 2, -37 },
  { 901, 20, 45, 19, -3, -37 },
  { 1014, 24, 25, 27, 4, -38 },
  { 1089, 25, 24, 29, 2, -30 },
  { 1164, 14, 12, 15, -3, -6 },
  { 1185, 15, 7, 16, 1, -17 },
  { 1199, 10, 10, 15, 0, -9 },
  { 1212, 29, 37, 23, -2, -36 },
  { 1347, 26, 37, 29, 2, -36 },
  { 1468, 22, 36, 29, 4, -36 },
  { 1567, 28, 36, 29, -1, -36 },
  { 1693, 28, 37, 29, 0, -36 },
  { 1823, 28, 36, 29, 0, -36 },
  { 1949, 29, 37, 29, 0, -36 },
  { 2084, 27, 37, 29, 2, -36 },
  { 2209, 30, 36, 29, 1, -36 },
  { 2344, 27, 37, 29, 1, -36 },
  { 2469, 25, 37, 29, 3, -36 },
  { 2585, 15, 29, 15, 0, -28 },
  { 2640, 18, 34, 15, -3, -28 },
  { 2717, 25, 28, 29, 2, -32 },
  { 2805, 25, 17, 29, 2, -26 },
  { 2859, 25, 28, 29, 2, -32 },
  { 2947, 22, 37, 24, 4, -36 },
  { 3049, 41, 41, 45, 2, -36 },
  { 3260, 34, 36, 34, -3, -36 },
  { 3413, 30, 36, 32, 1, -36 },
  { 3548, 30, 37, 32, 3, -36 },
  { 3687, 32, 36, 34, 1, -36 },
  { 3831, 29, 36, 28, 1, -36 },
  { 3962, 28, 36, 28, 1, -36 },
  { 4088, 31, 37, 35, 3, -36 },
  { 4232, 35, 36, 36, 1, -36 },
  { 4390, 26, 36, 21, -2, -36 },
  { 4507, 27, 47, 19, -8, -36 },
  { 4666, 36, 36, 33, 1, -36 },
  { 4828, 23, 36, 26, 1, -36 },
  { 4932, 45, 36, 45, 1, -36 },
  { 5135, 39, 36, 40, 1, -36 },
  { 5311, 32, 37, 37, 3, -36 },
  { 5459, 30, 36, 31, 1, -36 },
  { 5594, 32, 45, 37, 3, -36 },
  { 5774, 30, 36, 33, 1, -36 },
  { 5909, 27, 37, 27, 1, -36 },
  { 6034, 27, 36, 28, 4, -36 },
  { 6156, 32, 37, 35, 3, -36 },
  { 6304, 31, 36, 31, 4, -36 },
  { 6444, 47, 36, 47, 4, -36 },
  { 6656, 40, 36, 33, -3, -36 },
  { 6836, 30, 36, 30, 4, -36 },
  { 6971, 32, 36, 27, -2, -36 },
  { 7115, 22, 45, 18, -1, -37 },
  { 7239, 14, 37, 23, 5, -36 },
  { 7304, 22, 45, 18, -3, -37 },
  { 7428, 26, 24, 27, 0, -36 },
  { 7506, 25, 6, 23, -5, 3 },
  { 7525, 12, 8, 18, 7, -38 },
  { 7537, 28, 29, 30, 2, -28 },
  { 7639, 27, 39, 30, 1, -38 },
  { 7771, 24, 29, 25, 2, -28 },
  { 7858, 30, 39, 30, 2, -38 },
  { 8005, 26, 29, 29, 2, -28 },
  { 8100, 31, 50, 21, -5, -38 },
  { 8294, 29, 40, 30, 1, -28 },
  { 8439, 28, 38, 31, 1, -38 },
  { 8572, 17, 39, 16, 1, -39 },
  { 8655, 24, 51, 16, -6, -39 },
  { 8808, 33, 38, 31, 1, -38 },
  { 8965, 17, 38, 16, 1, -38 },
  { 9046, 43, 28, 46, 1, -28 },
  { 9197, 28, 28, 31, 1, -28 },
  { 9295, 26, 29, 30, 2, -28 },
  { 9390, 30, 40, 30, -2, -28 },
  { 9540, 28, 40, 30, 2, -28 },
  { 9680, 23, 28, 22, 1, -28 },
  { 9761, 23, 29, 25, 1, -28 },
  { 9845, 21, 34, 23, 2, -33 },
  { 9935, 29, 29, 31, 2, -28 },
  { 10041, 28, 28, 27, 2, -28 },
  { 10139, 42, 28, 41, 2, -28 },
  { 10286, 35, 28, 28, -3, -28 },
  { 10409, 33, 40, 27, -3, -28 },
  { 10574, 26, 28, 24, -1, -28 },
  { 10665, 22, 44, 18, 0, -36 },
  { 10786, 6, 49, 28, 11, -38 },
  { 10823, 21, 44, 18, -3, -36 },
  { 10939, 25, 9, 29, 2, -22 },
};

const GFXfont NotoSans_BlackItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_BLACKITALIC50PT7B_H_
