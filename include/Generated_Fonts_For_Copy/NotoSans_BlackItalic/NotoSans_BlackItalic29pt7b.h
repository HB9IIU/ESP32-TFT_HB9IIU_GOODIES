#ifndef _NOTOSANS_BLACKITALIC29PT7B_H_
#define _NOTOSANS_BLACKITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F,
  0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x0F,
  0xC3, 0xF0, 0x78, 0x00, 0x79, 0xFF, 0x9E, 0xF9, 0xEF, 0x3E, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCE, 0x3C, 0x00, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00,
  0xF3, 0xC0, 0x3C, 0x70, 0x07, 0x9E, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x8E, 0x0F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF0, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF1,
  0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x00, 0x70, 0x00, 0x60, 0x03, 0xFC,
  0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E, 0xC4, 0x3E, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x83, 0x3C, 0xE3, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0xC0,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x7C, 0x3F, 0x80, 0x78,
  0x7F, 0xC0, 0xF0, 0x7B, 0xC1, 0xE0, 0xFB, 0xC3, 0xE0, 0xF3, 0xC3, 0xC0,
  0xF3, 0xC7, 0x80, 0xF3, 0xCF, 0x00, 0xF3, 0xDF, 0x38, 0xF7, 0x9E, 0xFE,
  0xFF, 0xBD, 0xFF, 0x7F, 0x79, 0xFF, 0x3E, 0xFB, 0xEF, 0x00, 0xF3, 0xCF,
  0x01, 0xE3, 0xCF, 0x03, 0xC3, 0xCF, 0x07, 0xC3, 0xCF, 0x07, 0x83, 0xDE,
  0x0F, 0x03, 0xFE, 0x1E, 0x03, 0xFC, 0x3E, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xF8, 0xF8, 0x07, 0xC7,
  0xC0, 0x3E, 0x7C, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE7, 0xC7,
  0xFC, 0x7E, 0x7F, 0xE3, 0xE7, 0xFF, 0xBF, 0x7E, 0x7F, 0xF3, 0xF1, 0xFF,
  0x9F, 0x8F, 0xF8, 0xFC, 0x3F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x81, 0xFF, 0x7E, 0x00, 0x7F, 0xFF, 0xEF, 0x7B, 0xDC, 0x03, 0xF0,
  0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03,
  0xC0, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0x03, 0xC0, 0x0F, 0x84, 0x3C, 0x1C, 0xF0, 0x7F,
  0xC3, 0xFF, 0xF7, 0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0xFF, 0x07, 0xDE, 0x0F,
  0x78, 0x19, 0xF0, 0x03, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x3E, 0xFD, 0xF3, 0xEF,
  0x9E, 0x3C, 0x00, 0x7F, 0xBF, 0xDF, 0xFF, 0xE0, 0x7B, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xF3, 0xFF, 0xE7, 0xC7, 0xDF, 0x8F, 0xBF, 0x1F, 0x7C, 0x3F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x3F, 0x7C, 0x7E,
  0xFD, 0xF9, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0x78,
  0x0F, 0xC1, 0xFE, 0x1F, 0xF3, 0xFF, 0x7F, 0xF9, 0xF7, 0xCF, 0x7E, 0x33,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x38, 0xFC, 0x08, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE,
  0x1F, 0xFF, 0x0F, 0x7F, 0x08, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x07, 0xFE,
  0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x80, 0x7E, 0xE0, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE,
  0x03, 0xFE, 0x07, 0xFE, 0x07, 0xBE, 0x0F, 0x7E, 0x1E, 0x7C, 0x3E, 0x7C,
  0x7C, 0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F,
  0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0xE0, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F,
  0xE2, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0xF0, 0x7D, 0xF8, 0x7F, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7C, 0xFC,
  0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0xF8, 0x7F, 0xF8, 0xFF, 0xF3, 0xF3, 0xE7, 0xC7, 0xCF, 0xCF, 0x9F, 0xBF,
  0x1F, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xC7, 0xFF, 0xDF, 0x9F, 0xBE,
  0x1F, 0x7C, 0x3E, 0xF8, 0xFD, 0xFF, 0xFB, 0xFF, 0xE3, 0xFF, 0x81, 0xFE,
  0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xFE, 0xFF, 0xF1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8,
  0xFB, 0xE0, 0x1F, 0x80, 0x7C, 0x87, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0,
  0xFE, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF0, 0x03, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x00,
  0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xE0, 0x07, 0xC0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0x01, 0xFE, 0x0F, 0xF8, 0xFF, 0xC7, 0xFC, 0x0F, 0xE0,
  0x1F, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xC3, 0xFF, 0xBF, 0xFC, 0xFF, 0xF7,
  0xDF, 0x90, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x7E,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x0F, 0xF0, 0xFC, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x3C, 0x3F,
  0xCF, 0x78, 0x7F, 0xCF, 0x78, 0xFF, 0xCF, 0x71, 0xE3, 0xCF, 0xF3, 0xE3,
  0x8F, 0xF3, 0xC7, 0x8F, 0xF3, 0xC7, 0x8F, 0xF3, 0xC7, 0x9E, 0xF3, 0xCF,
  0xBE, 0xF3, 0xFF, 0xFC, 0xF1, 0xFB, 0xF8, 0x78, 0xF1, 0xE0, 0x7C, 0x00,
  0x00, 0x3E, 0x01, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xBC, 0x00, 0xFB, 0xC0, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xF0,
  0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x3F, 0xFC, 0x03, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xE3, 0xF0, 0xF8,
  0xFC, 0x7E, 0x3E, 0x1F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFC,
  0x3F, 0x7F, 0x0F, 0xC7, 0xC3, 0xE1, 0xF8, 0xF8, 0x7C, 0x7E, 0x7F, 0x1F,
  0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE0, 0x63, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x08, 0x7F, 0x1C, 0x1F,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x1F, 0xC3,
  0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x9F,
  0x83, 0xF3, 0xF0, 0x7C, 0x7E, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0xC1, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x83, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x01, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xCF, 0xF9, 0xF1, 0xFF, 0x3E, 0x3F, 0xCF, 0xCF, 0xF9,
  0xF8, 0x1F, 0x1F, 0x07, 0xE3, 0xF0, 0xFC, 0x7F, 0x1F, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xC1, 0xF8, 0x3E, 0x0F,
  0xC3, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x3E,
  0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x07, 0xC1,
  0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0xFF,
  0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x00, 0x18, 0x00, 0x07, 0xC1, 0xFC, 0x1F, 0x0F, 0xE0, 0xFC, 0x7F, 0x03,
  0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0x3E, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xEF,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E,
  0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F,
  0xC0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0x9F, 0xFE,
  0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xEF, 0x83, 0xFE, 0x3D, 0xF0,
  0x7F, 0xCF, 0x7C, 0x1F, 0x79, 0xEF, 0x83, 0xEF, 0x79, 0xF0, 0x7D, 0xEF,
  0x3E, 0x0F, 0xBD, 0xEF, 0x81, 0xF7, 0xF9, 0xF0, 0x7C, 0xFF, 0x3E, 0x0F,
  0x9F, 0xC7, 0xC1, 0xF3, 0xF8, 0xF8, 0x3E, 0x7E, 0x3E, 0x0F, 0xCF, 0xC7,
  0xC0, 0x07, 0xE0, 0x3E, 0x0F, 0xE0, 0x7C, 0x3F, 0xC0, 0xF8, 0x7F, 0x83,
  0xE0, 0xFF, 0x87, 0xC1, 0xFF, 0x0F, 0x83, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E,
  0x1F, 0x7C, 0xF8, 0x3E, 0xF9, 0xF0, 0x7D, 0xF3, 0xE1, 0xF1, 0xF7, 0xC3,
  0xE3, 0xEF, 0x07, 0xC7, 0xDE, 0x0F, 0x8F, 0xFC, 0x1F, 0x0F, 0xF8, 0x7C,
  0x1F, 0xF0, 0xF8, 0x3F, 0xC1, 0xF0, 0x3F, 0x83, 0xE0, 0x7F, 0x0F, 0xC0,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1,
  0xFF, 0xFE, 0x7F, 0x0F, 0xCF, 0xC0, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xEF,
  0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xDF,
  0x03, 0xF3, 0xF0, 0xFE, 0x7F, 0x3F, 0x8F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xCF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07,
  0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0x0F, 0xCF, 0xC0, 0xFB, 0xF0, 0x1F, 0x7E,
  0x03, 0xEF, 0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xDF, 0x03, 0xF3, 0xF0, 0xFE, 0x7F, 0x7F, 0x8F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x9F, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xDF, 0x03, 0xE7, 0xE0, 0xF9, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF0, 0x7E, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF9,
  0xFF, 0xE3, 0xFF, 0xC7, 0xC0, 0x8F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x40, 0xFC,
  0xE3, 0xF9, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xFF,
  0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x1F, 0x07, 0xE7, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F,
  0x87, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xF0, 0xFC, 0x7E,
  0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1, 0xF8,
  0x7E, 0x3E, 0x0F, 0x87, 0xC3, 0xF0, 0xFE, 0xFE, 0x1F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xEF, 0xC1,
  0xFB, 0xF0, 0x7C, 0xFC, 0x3F, 0x3F, 0x0F, 0x87, 0xC7, 0xE1, 0xF1, 0xF0,
  0x7C, 0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F,
  0x7C, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xFF, 0x81, 0xF0,
  0x3E, 0xF8, 0x1F, 0x07, 0xEF, 0x83, 0xF0, 0x7C, 0xF8, 0x3F, 0x0F, 0xCF,
  0x87, 0xF0, 0xF8, 0xF8, 0x7F, 0x0F, 0x8F, 0x8F, 0xF1, 0xF0, 0xF8, 0xFF,
  0x1F, 0x0F, 0x8F, 0xF3, 0xF0, 0xF9, 0xEF, 0x3E, 0x07, 0x9E, 0xF3, 0xE0,
  0x7B, 0xEF, 0x7C, 0x07, 0xBC, 0xF7, 0xC0, 0x7F, 0xCF, 0x78, 0x07, 0xF8,
  0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x0F,
  0xC1, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x3E,
  0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80,
  0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xDF,
  0x07, 0xE7, 0xC3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E, 0x0F, 0x9F, 0x03, 0xEF,
  0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xFE, 0x0F, 0xE0,
  0x7F, 0x07, 0xF8, 0x00, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F,
  0x1F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x60, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0x9C, 0x1F,
  0x3C, 0x3C, 0x78, 0xF0, 0xF3, 0xE0, 0xF7, 0x81, 0xFE, 0x03, 0xC0, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0xF8, 0xF0, 0xF0, 0x07, 0xCF, 0x1F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0x7E, 0x7E, 0x3E, 0x7C, 0x3E, 0xFC,
  0x3E, 0xFC, 0x7C, 0xFC, 0x7C, 0xFC, 0x7C, 0xFC, 0xFC, 0xFF, 0xFC, 0x7F,
  0xF8, 0x7F, 0x78, 0x3E, 0x78, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xBE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xBF, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F, 0x3E,
  0x3F, 0x7E, 0x3F, 0x7E, 0x7E, 0x7F, 0xFE, 0x7F, 0xFC, 0x7B, 0xF8, 0xF9,
  0xF0, 0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x7F, 0x11, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x08, 0x7F, 0xE1,
  0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0xFD, 0xF0, 0x7F, 0x7C, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC7, 0xF7, 0xE1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3F, 0x0F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x3F, 0x0F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0x78, 0x0F, 0x9E, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x7F,
  0xF9, 0xFB, 0xF7, 0xE3, 0xEF, 0xC7, 0xDF, 0x7F, 0xFF, 0xFE, 0xFF, 0xF9,
  0xFF, 0xC3, 0xF0, 0x07, 0xE0, 0xC7, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xBF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0x87, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xF3, 0xFB, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0xFC, 0x3E,
  0x7E, 0x3E, 0x3F, 0x1F, 0x1F, 0x8F, 0x8F, 0xCF, 0xC7, 0xFF, 0xE1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3E, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x38, 0x7E, 0x1F,
  0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0xF8, 0x3F,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xE7, 0xE3, 0xE3, 0xF3, 0xF1, 0xF1,
  0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F,
  0x8F, 0x87, 0xC7, 0xC7, 0xE7, 0xE3, 0xF0, 0x01, 0x01, 0xF0, 0xFC, 0x3F,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F,
  0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC0,
  0x00, 0x10, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC2, 0xFE, 0x0F, 0xF8, 0x3F,
  0xC0, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0xFC, 0x7E,
  0x1F, 0x9F, 0x83, 0xE7, 0xE0, 0x7D, 0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xCF, 0x81,
  0xF9, 0xF8, 0x3E, 0x3F, 0x07, 0xC3, 0xF1, 0xF8, 0x7E, 0x00, 0x07, 0xC1,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0,
  0x7C, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C,
  0x3F, 0x00, 0x0F, 0x3E, 0x1F, 0x0F, 0xBF, 0xBF, 0xC7, 0xFF, 0xDF, 0xE3,
  0xFF, 0xFF, 0xF1, 0xF9, 0xFC, 0xF8, 0xF8, 0xFC, 0x7C, 0xFC, 0x7E, 0x3E,
  0x7E, 0x3E, 0x1F, 0x3E, 0x1F, 0x1F, 0x9F, 0x1F, 0x8F, 0xDF, 0x8F, 0xC7,
  0xEF, 0xC7, 0xE3, 0xE7, 0xE3, 0xE1, 0xF3, 0xE1, 0xF1, 0xF9, 0xF1, 0xF8,
  0xFD, 0xF8, 0xFC, 0x7E, 0x0F, 0x7E, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xF1, 0xF9, 0xF8, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E, 0x3E, 0x3E, 0x1F, 0x1F,
  0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF9,
  0xF8, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xF9, 0xFF, 0xF7, 0xE3, 0xEF,
  0xC7, 0xDF, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE7,
  0xEF, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x07, 0xBE, 0x07, 0xFF,
  0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xFD, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E,
  0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE7, 0xE3, 0xFF, 0xF1,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFD, 0xF0, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0xCF, 0x1F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0x7E, 0x7E, 0x3E, 0x7C, 0x3E, 0xFC,
  0x3E, 0xFC, 0x7C, 0xFC, 0x7C, 0xFC, 0x7C, 0xFC, 0xFC, 0xFF, 0xFC, 0x7F,
  0xF8, 0x7F, 0xF8, 0x3E, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x3C, 0x7D, 0xF1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x0F,
  0xF8, 0x7F, 0xF3, 0xFF, 0x8F, 0xDE, 0x3F, 0x08, 0xFE, 0x03, 0xFC, 0x07,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xA0, 0x7E, 0xFF, 0xF3, 0xFF, 0xCF,
  0xFE, 0x1F, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFB, 0xFF, 0xC7, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF1, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xE0, 0x3F, 0x1F,
  0x9F, 0x8F, 0x8F, 0x87, 0xC7, 0xC7, 0xE3, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8,
  0xF8, 0xF8, 0x7C, 0x7C, 0x7E, 0x3E, 0x3F, 0x3F, 0x1F, 0x9F, 0x9F, 0x8F,
  0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x7E, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F,
  0x7C, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x7D, 0xF0,
  0x7D, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0xFC, 0x7E, 0x1F, 0x7C, 0x7E, 0x3F, 0x7C, 0xFE,
  0x3E, 0x7C, 0xFE, 0x3E, 0x7C, 0xFE, 0x7C, 0x7D, 0xFE, 0x7C, 0x7D, 0xFE,
  0xF8, 0x7D, 0xDE, 0xF8, 0x7F, 0xDE, 0xF0, 0x7F, 0xDF, 0xF0, 0x7B, 0x9F,
  0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x7C, 0x7E, 0x07, 0xEF, 0xC0,
  0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xBE,
  0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x0F, 0xE1, 0xF8, 0x1F, 0x87, 0xE3, 0xF0,
  0xFC, 0x3E, 0x3F, 0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x3F, 0x03, 0xE7,
  0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x02, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0x00,
  0x78, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x0F, 0xC1, 0xFE, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x3E,
  0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0xC1, 0xF8, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80,
  0xF8, 0x06, 0x00, 0x00, 0x3E, 0x03, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xD0, 0x06, 0x00,
};

const GFXglyph NotoSans_BlackItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 21, 9, 0, -21 },
  { 28, 12, 8, 13, 3, -21 },
  { 40, 19, 21, 19, 0, -21 },
  { 90, 16, 24, 17, 1, -22 },
  { 138, 24, 21, 27, 2, -21 },
  { 201, 21, 21, 21, 0, -21 },
  { 257, 5, 8, 7, 3, -21 },
  { 262, 12, 26, 11, 1, -21 },
  { 301, 12, 26, 11, -2, -21 },
  { 340, 14, 14, 16, 2, -22 },
  { 365, 15, 14, 17, 1, -17 },
  { 392, 7, 7, 9, -1, -3 },
  { 399, 9, 4, 10, 0, -10 },
  { 404, 6, 5, 9, 0, -5 },
  { 408, 16, 21, 14, -1, -21 },
  { 450, 15, 21, 17, 1, -21 },
  { 490, 13, 21, 17, 2, -21 },
  { 525, 17, 21, 17, -1, -21 },
  { 570, 16, 21, 17, 0, -21 },
  { 612, 16, 21, 17, 0, -21 },
  { 654, 17, 21, 17, 0, -21 },
  { 699, 16, 21, 17, 1, -21 },
  { 741, 18, 21, 17, 0, -21 },
  { 789, 15, 21, 17, 1, -21 },
  { 829, 14, 21, 17, 2, -21 },
  { 866, 9, 16, 9, 0, -16 },
  { 884, 11, 20, 9, -2, -16 },
  { 912, 15, 15, 17, 1, -18 },
  { 941, 15, 10, 17, 1, -15 },
  { 960, 15, 15, 17, 1, -18 },
  { 989, 13, 21, 14, 2, -21 },
  { 1024, 24, 24, 26, 1, -21 },
  { 1096, 20, 21, 20, -2, -21 },
  { 1149, 18, 21, 18, 0, -21 },
  { 1197, 18, 21, 18, 1, -21 },
  { 1245, 19, 21, 20, 0, -21 },
  { 1295, 17, 21, 16, 0, -21 },
  { 1340, 17, 21, 17, 0, -21 },
  { 1385, 19, 21, 20, 1, -21 },
  { 1435, 21, 21, 21, 0, -21 },
  { 1491, 15, 21, 12, -1, -21 },
  { 1531, 16, 28, 11, -5, -21 },
  { 1587, 22, 21, 19, 0, -21 },
  { 1645, 14, 21, 15, 0, -21 },
  { 1682, 27, 21, 26, 0, -21 },
  { 1753, 23, 21, 23, 0, -21 },
  { 1814, 19, 21, 21, 1, -21 },
  { 1864, 18, 21, 18, 0, -21 },
  { 1912, 19, 26, 21, 1, -21 },
  { 1974, 18, 21, 19, 0, -21 },
  { 2022, 15, 21, 16, 1, -21 },
  { 2062, 16, 21, 16, 2, -21 },
  { 2104, 19, 21, 20, 2, -21 },
  { 2154, 18, 21, 18, 2, -21 },
  { 2202, 28, 21, 27, 2, -21 },
  { 2276, 23, 21, 19, -2, -21 },
  { 2337, 18, 21, 18, 2, -21 },
  { 2385, 18, 21, 16, -1, -21 },
  { 2433, 13, 26, 10, -1, -21 },
  { 2476, 8, 21, 14, 3, -21 },
  { 2497, 13, 26, 10, -2, -21 },
  { 2540, 15, 14, 16, 0, -21 },
  { 2567, 14, 3, 13, -3, 2 },
  { 2573, 7, 4, 10, 4, -22 },
  { 2577, 16, 16, 18, 1, -16 },
  { 2609, 16, 22, 18, 0, -22 },
  { 2653, 14, 16, 15, 1, -16 },
  { 2681, 18, 22, 18, 1, -22 },
  { 2731, 15, 16, 17, 1, -16 },
  { 2761, 18, 29, 12, -3, -22 },
  { 2827, 17, 23, 18, 0, -16 },
  { 2876, 17, 22, 18, 0, -22 },
  { 2923, 10, 23, 9, 0, -23 },
  { 2952, 14, 30, 9, -4, -23 },
  { 3005, 19, 22, 18, 0, -22 },
  { 3058, 10, 22, 9, 0, -22 },
  { 3086, 25, 16, 27, 0, -16 },
  { 3136, 17, 16, 18, 0, -16 },
  { 3170, 15, 16, 18, 1, -16 },
  { 3200, 17, 23, 18, -1, -16 },
  { 3249, 16, 23, 18, 1, -16 },
  { 3295, 14, 16, 13, 0, -16 },
  { 3323, 14, 16, 15, 0, -16 },
  { 3351, 13, 19, 13, 1, -19 },
  { 3382, 17, 16, 18, 1, -16 },
  { 3416, 16, 16, 16, 1, -16 },
  { 3448, 24, 16, 24, 1, -16 },
  { 3496, 20, 16, 16, -2, -16 },
  { 3536, 19, 23, 16, -2, -16 },
  { 3591, 16, 16, 14, -1, -16 },
  { 3623, 13, 26, 10, 0, -21 },
  { 3666, 4, 29, 16, 6, -22 },
  { 3681, 13, 26, 10, -2, -21 },
  { 3724, 15, 6, 17, 1, -13 },
};

const GFXfont NotoSans_BlackItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_BLACKITALIC29PT7B_H_
