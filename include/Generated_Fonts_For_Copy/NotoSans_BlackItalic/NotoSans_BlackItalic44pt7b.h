#ifndef _NOTOSANS_BLACKITALIC44PT7B_H_
#define _NOTOSANS_BLACKITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3F, 0x80,
  0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x04,
  0x00, 0x7F, 0x9F, 0xDF, 0xC7, 0xF7, 0xF1, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F,
  0x9F, 0x8F, 0xE7, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0x8F,
  0xC7, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x80, 0x7C, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0x80,
  0x01, 0xF8, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xEF,
  0x0C, 0x1F, 0xEF, 0x00, 0x1F, 0xEF, 0x00, 0x1F, 0xEE, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x39,
  0xFC, 0x00, 0x39, 0xFC, 0x80, 0x79, 0xFC, 0xF0, 0x7B, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x40,
  0x1F, 0xF0, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x07, 0xFF, 0xC0,
  0x0F, 0xC0, 0x3F, 0xFF, 0x00, 0x7E, 0x00, 0xFE, 0xFE, 0x03, 0xF0, 0x07,
  0xF1, 0xF8, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0, 0x7E, 0x00, 0x7E, 0x1F, 0x83,
  0xF0, 0x01, 0xF8, 0xFE, 0x1F, 0x80, 0x07, 0xE3, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x1F, 0x80, 0x03, 0xF9, 0xFC, 0xFC,
  0x7F, 0x87, 0xFF, 0xE7, 0xF3, 0xFF, 0x1F, 0xFF, 0x9F, 0x9F, 0xFE, 0x7F,
  0xFC, 0xFC, 0xFF, 0xF8, 0xFF, 0xE7, 0xE7, 0xFF, 0xF1, 0xFF, 0x3F, 0x9F,
  0xCF, 0xC1, 0xF0, 0xFC, 0xFE, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0xFC, 0x00,
  0x3F, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x7F, 0x00, 0x3F, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x0F,
  0xE0, 0x3F, 0x3F, 0x80, 0x3F, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xFF,
  0xF0, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03,
  0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0x0F, 0xFF, 0xC1, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFE, 0x3F, 0xFF, 0xF3, 0xFC, 0x7F, 0xFF, 0xF7, 0xFC, 0x7F,
  0x8F, 0xFF, 0xF8, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x9F, 0xF8, 0x7F,
  0xBF, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x20, 0x3F, 0x00, 0xE1, 0xF8,
  0x03, 0xE7, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0xE0, 0x47, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFE, 0x7E, 0x01, 0xF1, 0xF8,
  0x01, 0xC7, 0xF0, 0x02, 0x1F, 0x80, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x7F, 0x1F,
  0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0x00, 0x3F,
  0xFC, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xEF, 0xFF, 0x00,
  0x1E, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x18, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xF9, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFF,
  0x3F, 0xC1, 0xFF, 0x3F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF,
  0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE,
  0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFC, 0xFF, 0x87, 0xFC,
  0xFF, 0x87, 0xFC, 0x7F, 0x8F, 0xF8, 0x7F, 0xDF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F,
  0xDF, 0xC7, 0xFB, 0xFC, 0x3F, 0x3F, 0xC3, 0xC3, 0xFC, 0x18, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xF1, 0xFF, 0x01, 0xE0,
  0xFF, 0x80, 0x60, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xC1,
  0xFF, 0x01, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0xC0, 0x07, 0xFE, 0xFC, 0x1F, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xBF, 0x80, 0x1F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x1F, 0xCF, 0xF0,
  0x1F, 0xC7, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF9, 0x80, 0x0F, 0xF8, 0xFC, 0x1F, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x8F, 0xC0, 0x7F, 0xBF, 0xE0, 0x7F, 0x7F, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x87, 0xFC,
  0xFF, 0x87, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFC,
  0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x9F, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x0F, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xFB, 0xFE, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xEF, 0xF8, 0x7F, 0x87, 0xFC, 0x7F,
  0x83, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF,
  0x87, 0xFC, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xDF, 0xF0, 0xFF, 0x7F, 0xC3, 0xFD, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xBF,
  0xCF, 0xFE, 0xFE, 0x1F, 0xF7, 0xF8, 0x0E, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xE3, 0x07, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x00, 0xC0, 0x1F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0,
  0xFE, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1F, 0xE0, 0x7F, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x7F, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xC1, 0xFF, 0x10,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x1F, 0xFC, 0x7E, 0x3F,
  0x03, 0xFF, 0xE3, 0xF3, 0xF0, 0xFF, 0xFE, 0x3F, 0x7E, 0x1F, 0xFF, 0xE3,
  0xF7, 0xE1, 0xFE, 0x7E, 0x3F, 0x7C, 0x3F, 0x87, 0xC3, 0xFF, 0xC3, 0xF0,
  0xFC, 0x3F, 0xFC, 0x7E, 0x0F, 0xC3, 0xFF, 0xC7, 0xE0, 0xFC, 0x3F, 0xF8,
  0x7E, 0x0F, 0x83, 0xFF, 0x8F, 0xC1, 0xF8, 0x3E, 0xF8, 0xFC, 0x1F, 0x87,
  0xEF, 0x8F, 0xE3, 0xF8, 0xFC, 0xF8, 0x7E, 0x7F, 0x9F, 0xCF, 0xC7, 0xFF,
  0xFF, 0xF8, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xC3, 0xFE, 0xFF, 0xE0, 0xFE,
  0x1F, 0xC7, 0xF8, 0x07, 0xE0, 0x20, 0x08, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x08, 0x00, 0x3F, 0xE0, 0x0F, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFE,
  0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFE, 0x1F,
  0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8,
  0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFD, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xCF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xFC, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0,
  0x7C, 0x1F, 0xF8, 0x03, 0x83, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x18, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xF9, 0xFF, 0xE0, 0x7F,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x1F,
  0xF0, 0x1F, 0xF1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x03,
  0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xC3,
  0xFC, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x87, 0xFC, 0x3F, 0xF8, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7C, 0x1F, 0xFC, 0x00, 0x81, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC7, 0xFF, 0xE7, 0xF8, 0x7F, 0xFC, 0xFF, 0x87, 0xFF,
  0xCF, 0xF8, 0x7F, 0xFC, 0xFF, 0x87, 0xFF, 0xCF, 0xF8, 0xFF, 0xFC, 0xFF,
  0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x0F,
  0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x83, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x03, 0xFC, 0x0F, 0xFC, 0x03,
  0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x07,
  0xF8, 0x7F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x0F,
  0xF9, 0xFF, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xEF, 0x80, 0xFF, 0xF8, 0x1F, 0xDF, 0x03,
  0xF7, 0xF0, 0x3F, 0xBE, 0x07, 0xEF, 0xE0, 0x7F, 0x7C, 0x1F, 0xFF, 0xC0,
  0xFE, 0xF8, 0x3F, 0x7F, 0x03, 0xFD, 0xF0, 0xFE, 0xFE, 0x07, 0xFB, 0xE1,
  0xF9, 0xFC, 0x0F, 0xE7, 0xC3, 0xF7, 0xF8, 0x1F, 0xCF, 0x8F, 0xCF, 0xF0,
  0x3F, 0x9F, 0x1F, 0x9F, 0xC0, 0xFF, 0x3E, 0x7E, 0x3F, 0x81, 0xFE, 0x7C,
  0xFC, 0xFF, 0x03, 0xF8, 0xFB, 0xF1, 0xFE, 0x07, 0xF1, 0xF7, 0xE3, 0xFC,
  0x1F, 0xE3, 0xFF, 0xC7, 0xF0, 0x3F, 0xC7, 0xFF, 0x0F, 0xE0, 0x7F, 0x8F,
  0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0xF0, 0xFE,
  0x07, 0xF8, 0x7F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x0F, 0xFE,
  0x00, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F,
  0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0x01, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x03,
  0xFB, 0xF8, 0x3F, 0xC0, 0xFE, 0xFE, 0x0F, 0xF0, 0x3F, 0xBF, 0xC3, 0xF8,
  0x0F, 0xEF, 0xF0, 0xFE, 0x07, 0xF9, 0xFC, 0x3F, 0x81, 0xFE, 0x7F, 0x1F,
  0xE0, 0x7F, 0x1F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF9, 0xFC, 0x07, 0xF0, 0xFE,
  0x7F, 0x03, 0xFC, 0x3F, 0xDF, 0xC0, 0xFF, 0x0F, 0xF7, 0xF0, 0x3F, 0x81,
  0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xF8, 0x1F, 0xC0, 0x3F, 0xFE, 0x07,
  0xF0, 0x0F, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xC0, 0x1F, 0xFC, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xC7, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x03,
  0xFE, 0x7F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFD,
  0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01,
  0xFF, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8,
  0x7F, 0xC0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0x9F, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0xFF, 0x87,
  0xFC, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xCF, 0xF8,
  0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x03,
  0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8,
  0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x0F,
  0xF8, 0x7F, 0xC1, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x8F, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xCF, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xFC, 0x7F, 0xC1, 0xFF,
  0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x1F, 0xF3,
  0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xF0,
  0x78, 0x1F, 0xF0, 0x08, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x80, 0x1F,
  0xF0, 0xE0, 0x1F, 0xF0, 0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFE,
  0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE,
  0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xC3, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F,
  0xC3, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFB, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x3F,
  0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC,
  0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3,
  0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00,
  0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF8, 0x0F, 0xFB,
  0xFC, 0x03, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x3F, 0xC0,
  0x7F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xFE,
  0x0F, 0xF0, 0x7F, 0x03, 0xFF, 0x83, 0xFC, 0x1F, 0xC1, 0xFF, 0xE0, 0xFF,
  0x07, 0xF0, 0x7F, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0xFE, 0x1F, 0xE0, 0x7F,
  0x0F, 0xDF, 0x8F, 0xF0, 0x1F, 0xC7, 0xFF, 0xE3, 0xFC, 0x07, 0xF1, 0xFB,
  0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0xBF, 0x9F,
  0xE0, 0x1F, 0xCF, 0xCF, 0xE7, 0xF0, 0x07, 0xF7, 0xF3, 0xFB, 0xFC, 0x01,
  0xFD, 0xFC, 0xFE, 0xFE, 0x00, 0x7F, 0x7E, 0x3F, 0xBF, 0x80, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xEF, 0xF8, 0x1F, 0xF1, 0xFE, 0x07, 0xFC, 0x7F, 0x83, 0xFE, 0x1F,
  0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x3F, 0xE0, 0x3F, 0xCF, 0xF0,
  0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x07, 0xE0, 0x7F, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xC7,
  0xC0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x00, 0xF9, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFC,
  0x1F, 0x81, 0xF8, 0x00, 0x70, 0x00, 0x03, 0xFE, 0x7F, 0x07, 0xFE, 0x7F,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC,
  0xFF, 0x83, 0xFC, 0xFF, 0x83, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xF7, 0xF0,
  0x3F, 0xF7, 0xE0, 0x1F, 0xCF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0xF0, 0x03, 0xFD,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x87,
  0xF8, 0x7F, 0xC3, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xF8,
  0xFF, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x7F, 0x83, 0xFE, 0x3F, 0xC1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x0F, 0xF9, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFE, 0xFF, 0xC0, 0xFE, 0x1F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFC, 0x18, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x04, 0x3F, 0xF1, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xF0,
  0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0xEF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x8F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F,
  0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF9, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0x7F,
  0x00, 0xFF, 0xDF, 0x80, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x8F, 0xF8, 0xFF, 0x1F, 0xE0, 0xFF, 0x7F, 0xC3, 0xFC, 0xFF, 0x07,
  0xFB, 0xFE, 0x3F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x43,
  0xFE, 0x03, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x01, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0xFF,
  0xCF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xE3, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x8F, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1,
  0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xE3, 0xFE,
  0x1F, 0xF3, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xCF, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x10, 0x03, 0xFC, 0x0C, 0x03, 0xFE, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x78, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0x0F,
  0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xF1,
  0xFE, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0xC1, 0xFE,
  0x3F, 0xE1, 0xFF, 0x1F, 0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F,
  0xC7, 0xFC, 0x1F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0x07,
  0xF8, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x02, 0x3F, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x04, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0x01, 0xFE,
  0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x9F,
  0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xF1,
  0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x1F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0xE3, 0xFC, 0x1F,
  0xF0, 0x1F, 0xCF, 0xFC, 0x7F, 0xE0, 0x3F, 0xBF, 0xFD, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xFE, 0x3F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFC,
  0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFF,
  0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8,
  0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xF9, 0xFF, 0x01,
  0xFD, 0xFF, 0xC0, 0xFE, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F,
  0xC3, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0x07,
  0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xE0,
  0xFF, 0x8F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE3, 0xFE,
  0x1F, 0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0x9F, 0xF1, 0xFF, 0x7F,
  0xC3, 0xFE, 0xFF, 0x87, 0xFD, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x7F, 0x83, 0xFE, 0xFF, 0x07,
  0xFD, 0xFE, 0x1F, 0xF3, 0xFE, 0x3F, 0xE7, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF7, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xE0,
  0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1,
  0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x1F,
  0xF0, 0x3F, 0xE7, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xE7, 0xF0,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x07, 0xFE, 0x7F, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xE3, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0xFF,
  0x83, 0xFC, 0xFF, 0x83, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xDF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x78, 0x3F, 0x8F, 0xC1, 0xFC, 0xFE, 0x0F, 0xEF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFE, 0x10, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xE1, 0xC3, 0xFC, 0x04, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xC8, 0x03, 0xFC, 0xC0, 0x7F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x10,
  0x7F, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC6, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0x8F, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F,
  0xE3, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x83,
  0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xE0, 0xFF, 0x8F, 0xF0,
  0x7F, 0x87, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFE,
  0x0F, 0xF8, 0xFF, 0x8F, 0xF8, 0x7F, 0xCF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xC0,
  0x3F, 0x8F, 0xE0, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE,
  0xFF, 0x03, 0xFC, 0x7F, 0x07, 0xFC, 0x7F, 0x07, 0xF8, 0x7F, 0x0F, 0xF8,
  0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x9F, 0xE0, 0x7F, 0x9F, 0xE0,
  0x7F, 0xBF, 0xC0, 0x3F, 0xBF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F,
  0xBF, 0xC1, 0xFF, 0x87, 0xF9, 0xFE, 0x1F, 0xF8, 0x3F, 0xCF, 0xF0, 0xFF,
  0xC3, 0xFC, 0x3F, 0x87, 0xFE, 0x1F, 0xE1, 0xFC, 0x7F, 0xF0, 0xFE, 0x0F,
  0xE3, 0xEF, 0x8F, 0xF0, 0x7F, 0x1F, 0x7C, 0x7F, 0x03, 0xF9, 0xFB, 0xE7,
  0xF8, 0x1F, 0xCF, 0x9F, 0x3F, 0xC0, 0xFE, 0xFD, 0xF9, 0xFC, 0x07, 0xF7,
  0xEF, 0xDF, 0xE0, 0x3F, 0xBE, 0x7E, 0xFE, 0x01, 0xFF, 0xF3, 0xFF, 0xF0,
  0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0xC7,
  0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xFE, 0x03, 0xFE,
  0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF3,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0xCF, 0xF8, 0x01,
  0xFF, 0x0F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE,
  0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80,
  0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x20, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x05, 0xFF, 0x80, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x07, 0xFC, 0x80, 0x01, 0xC0,
};

const GFXglyph NotoSans_BlackItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 32, 13, 0, -31 },
  { 61, 18, 11, 20, 4, -31 },
  { 86, 29, 31, 28, 0, -31 },
  { 199, 24, 36, 26, 1, -33 },
  { 307, 38, 32, 41, 2, -32 },
  { 459, 32, 32, 32, 0, -32 },
  { 587, 9, 11, 10, 4, -31 },
  { 600, 18, 39, 16, 1, -32 },
  { 688, 18, 39, 16, -3, -32 },
  { 776, 22, 22, 24, 3, -34 },
  { 837, 22, 21, 26, 2, -26 },
  { 895, 11, 11, 13, -2, -5 },
  { 911, 14, 7, 14, 0, -15 },
  { 924, 9, 9, 13, 0, -8 },
  { 935, 25, 32, 21, -2, -32 },
  { 1035, 24, 32, 26, 1, -32 },
  { 1131, 20, 31, 26, 3, -31 },
  { 1209, 25, 32, 26, -1, -32 },
  { 1309, 24, 32, 26, 0, -32 },
  { 1405, 25, 31, 26, 0, -31 },
  { 1502, 25, 31, 26, 0, -31 },
  { 1599, 24, 32, 26, 2, -32 },
  { 1695, 26, 31, 26, 1, -31 },
  { 1796, 24, 32, 26, 1, -32 },
  { 1892, 22, 32, 26, 2, -32 },
  { 1980, 13, 26, 13, 0, -25 },
  { 2023, 16, 31, 13, -3, -25 },
  { 2085, 22, 24, 26, 2, -28 },
  { 2151, 22, 15, 26, 2, -23 },
  { 2193, 22, 24, 26, 2, -28 },
  { 2259, 20, 33, 21, 3, -32 },
  { 2342, 36, 36, 39, 2, -32 },
  { 2504, 30, 31, 30, -3, -31 },
  { 2621, 26, 31, 28, 1, -31 },
  { 2722, 27, 32, 28, 2, -32 },
  { 2830, 28, 31, 30, 1, -31 },
  { 2939, 25, 31, 25, 1, -31 },
  { 3036, 25, 31, 25, 1, -31 },
  { 3133, 28, 32, 31, 2, -32 },
  { 3245, 31, 31, 31, 1, -31 },
  { 3366, 23, 31, 19, -2, -31 },
  { 3456, 24, 41, 16, -7, -31 },
  { 3579, 32, 31, 29, 1, -31 },
  { 3703, 20, 31, 23, 1, -31 },
  { 3781, 39, 31, 40, 1, -31 },
  { 3933, 34, 31, 35, 1, -31 },
  { 4065, 29, 32, 32, 2, -32 },
  { 4181, 26, 31, 27, 1, -31 },
  { 4282, 29, 39, 32, 2, -32 },
  { 4424, 26, 31, 29, 1, -31 },
  { 4525, 24, 32, 24, 1, -32 },
  { 4621, 24, 31, 24, 3, -31 },
  { 4714, 28, 31, 31, 3, -31 },
  { 4823, 27, 31, 27, 3, -31 },
  { 4928, 42, 31, 41, 3, -31 },
  { 5091, 35, 31, 29, -3, -31 },
  { 5227, 26, 31, 27, 4, -31 },
  { 5328, 28, 31, 24, -2, -31 },
  { 5437, 20, 39, 16, -1, -32 },
  { 5535, 12, 32, 21, 5, -32 },
  { 5583, 20, 39, 16, -3, -32 },
  { 5681, 23, 20, 24, 0, -31 },
  { 5739, 21, 5, 20, -4, 3 },
  { 5753, 11, 7, 16, 6, -34 },
  { 5763, 24, 25, 27, 2, -25 },
  { 5838, 25, 33, 27, 0, -33 },
  { 5942, 21, 25, 22, 2, -25 },
  { 6008, 26, 33, 27, 2, -33 },
  { 6116, 23, 25, 25, 2, -25 },
  { 6188, 27, 45, 18, -4, -34 },
  { 6340, 25, 36, 27, 1, -25 },
  { 6453, 25, 33, 27, 0, -33 },
  { 6557, 16, 34, 14, 0, -34 },
  { 6625, 22, 45, 14, -6, -34 },
  { 6749, 30, 33, 27, 0, -33 },
  { 6873, 16, 33, 14, 0, -33 },
  { 6939, 39, 25, 41, 0, -25 },
  { 7061, 25, 25, 27, 0, -25 },
  { 7140, 23, 25, 27, 2, -25 },
  { 7212, 27, 36, 27, -2, -25 },
  { 7334, 24, 36, 27, 2, -25 },
  { 7442, 21, 25, 19, 0, -25 },
  { 7508, 20, 25, 22, 1, -25 },
  { 7571, 20, 29, 20, 1, -29 },
  { 7644, 25, 24, 27, 2, -24 },
  { 7719, 24, 24, 24, 2, -24 },
  { 7791, 37, 24, 36, 2, -24 },
  { 7902, 31, 24, 25, -3, -24 },
  { 7995, 29, 35, 24, -3, -24 },
  { 8122, 23, 24, 21, -1, -24 },
  { 8191, 19, 38, 16, 0, -31 },
  { 8282, 6, 43, 25, 9, -33 },
  { 8315, 19, 38, 16, -3, -31 },
  { 8406, 22, 9, 26, 2, -20 },
};

const GFXfont NotoSans_BlackItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_BLACKITALIC44PT7B_H_
