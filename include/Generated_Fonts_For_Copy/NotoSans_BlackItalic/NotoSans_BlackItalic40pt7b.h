#ifndef _NOTOSANS_BLACKITALIC40PT7B_H_
#define _NOTOSANS_BLACKITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7E, 0x00, 0x7F, 0x3F, 0x7E, 0x7F, 0x7E, 0x7F, 0x7E, 0x7E,
  0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7C, 0xFC, 0x7C, 0xF8, 0xFC, 0xF8, 0xFC,
  0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0xFC,
  0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x1F, 0x80, 0x03, 0xE3, 0xE0, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x03, 0xE3,
  0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE3, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0x1F, 0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0xDE, 0x30, 0x7F, 0x70, 0x01, 0xFD, 0xC0, 0x07, 0xF7,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1D, 0xFC, 0x00,
  0x73, 0xF3, 0x03, 0xDF, 0xCF, 0x8F, 0x7F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x03, 0xFE, 0x00, 0x3F, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0xF8, 0x07,
  0xC0, 0x3F, 0xFE, 0x03, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0x07, 0xE7, 0xE0,
  0xFC, 0x01, 0xF9, 0xF8, 0x3E, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x3F, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE7, 0xE0, 0x03, 0xF1, 0xF1, 0xF0, 0x20, 0xFC,
  0xFC, 0xFC, 0xFF, 0x3F, 0xFF, 0x7E, 0x7F, 0xE7, 0xFF, 0x9F, 0x3F, 0xFD,
  0xFF, 0xCF, 0xDF, 0xFF, 0x3F, 0xE7, 0xE7, 0xEF, 0xC3, 0xE3, 0xF3, 0xF1,
  0xF0, 0x00, 0xF8, 0xFC, 0x7C, 0x00, 0x7E, 0x3F, 0x1F, 0x00, 0x3F, 0x0F,
  0x8F, 0xC0, 0x1F, 0x87, 0xE3, 0xF0, 0x07, 0xC1, 0xF8, 0xFC, 0x03, 0xF0,
  0x7E, 0x7E, 0x01, 0xF8, 0x0F, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xC0, 0x3E,
  0x00, 0xFF, 0xF0, 0x1F, 0x80, 0x1F, 0xF8, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF3, 0xFC, 0x3F, 0xFE, 0x1F, 0xE3, 0xFF, 0xF0, 0xFE, 0x3F, 0xFF,
  0xCF, 0xF3, 0xFF, 0xFE, 0x7F, 0x1F, 0xE7, 0xFF, 0xF9, 0xFE, 0x3F, 0xFF,
  0x8F, 0xF0, 0xFF, 0xFC, 0x7F, 0x83, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x00, 0x7F, 0x7E,
  0x7E, 0x7E, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0x00, 0x7F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x20, 0xFC, 0x07, 0x8F, 0x80, 0x7E, 0xF8, 0x07, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xF7, 0xE0, 0x3E, 0x3E, 0x00, 0xE3, 0xF0,
  0x04, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0x80, 0x3F, 0xF7, 0xFF,
  0x7F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFE, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0x7F, 0x87, 0xF8, 0xFE, 0x3F,
  0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83,
  0xFD, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC1, 0xFE, 0xFF, 0x07, 0xFB,
  0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF,
  0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0x1F, 0xDF, 0xC7, 0xE7, 0xF0, 0xE3, 0xFC,
  0x10, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xE0, 0xFF, 0x01, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3C, 0x3F, 0xC0, 0x80,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFA, 0x00, 0x1F, 0xEE, 0x00, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x7F,
  0x00, 0xFC, 0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xE7, 0xF8, 0x3F, 0x8F, 0xE0,
  0x7E, 0x1F, 0xC1, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x06, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x90,
  0x01, 0xFE, 0x38, 0x07, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0x80, 0x8F, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x1F, 0xDF, 0xF0, 0xFE, 0xFF, 0xC3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0x9F, 0xF3, 0xFC, 0x3F,
  0xCF, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F,
  0xE1, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F,
  0x8F, 0xE0, 0xFF, 0x7F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0x7F, 0x87,
  0xF0, 0xFE, 0x3F, 0xC3, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0,
  0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xCF, 0xF7,
  0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFE, 0xFE, 0x1F, 0xCF, 0xE0, 0x31, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xC3, 0xFC, 0xC0, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xF0,
  0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x03, 0xFE, 0x3F,
  0x1F, 0x07, 0xFF, 0xCF, 0x9F, 0x87, 0xFF, 0xC7, 0xCF, 0x87, 0xFF, 0xE3,
  0xF7, 0xC7, 0xF1, 0xF1, 0xFF, 0xC3, 0xF1, 0xF8, 0xFF, 0xE3, 0xF0, 0xF8,
  0x7F, 0xF1, 0xF8, 0x7C, 0x3E, 0xF8, 0xF8, 0x3E, 0x1F, 0x7C, 0x7C, 0x3F,
  0x0F, 0xBE, 0x7E, 0x1F, 0x0F, 0xDF, 0x3F, 0x1F, 0x87, 0xCF, 0x8F, 0xDF,
  0xEF, 0xC7, 0xC7, 0xFF, 0xFF, 0xE3, 0xE3, 0xFF, 0xFF, 0xE1, 0xF8, 0xFF,
  0x3F, 0xC0, 0xFC, 0x3E, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x80, 0x07, 0xF8, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF,
  0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F,
  0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x81,
  0xFE, 0x07, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0,
  0x1F, 0xDF, 0xE0, 0x07, 0xF7, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC,
  0x3F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0x8F, 0xF8,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xF1, 0xF8, 0x3F, 0xE0, 0x18, 0x3F, 0xE0, 0x04, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x01, 0x01, 0xFF, 0x03, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xE3,
  0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x01, 0xFE,
  0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xC7, 0xF0, 0x3F, 0xE7, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xF1, 0xFE, 0x7F,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xF3, 0xE0, 0x7F, 0xE0, 0x18, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x8F, 0xFF, 0x3F, 0xC3, 0xFF, 0xCF, 0xF0, 0xFF, 0xF3, 0xFC, 0x3F, 0xFC,
  0xFF, 0x1F, 0xFE, 0x3F, 0xC7, 0xFF, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07,
  0xF8, 0xFF, 0x01, 0xFC, 0x3F, 0xE0, 0x7F, 0x07, 0xFC, 0x3F, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x7F,
  0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F,
  0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xF0,
  0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x80, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x11,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0,
  0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x07, 0xF8,
  0x03, 0xF8, 0x7F, 0xC0, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x0F,
  0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xFB, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F,
  0xE0, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x07, 0xDF, 0x81,
  0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0x0F, 0xBF, 0x81, 0xFF, 0xF1, 0xFB,
  0xF8, 0x1F, 0xBF, 0x1F, 0x3F, 0x83, 0xFB, 0xF3, 0xF7, 0xF0, 0x3F, 0xBF,
  0x3E, 0x7F, 0x03, 0xFB, 0xF7, 0xE7, 0xF0, 0x3F, 0xBF, 0x7E, 0x7F, 0x03,
  0xF3, 0xFF, 0xC7, 0xE0, 0x7F, 0x3F, 0xFC, 0xFE, 0x07, 0xF3, 0xFF, 0x8F,
  0xE0, 0x7F, 0x3F, 0xF8, 0xFE, 0x07, 0xF3, 0xFF, 0x0F, 0xE0, 0x7E, 0x3F,
  0xF0, 0xFC, 0x0F, 0xE3, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xE1, 0xFC, 0x0F,
  0xE3, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0xFE, 0x0F, 0xFC, 0x01, 0xFC, 0x1F, 0xF8, 0x03, 0xF0, 0x3F, 0xF0, 0x0F,
  0xE0, 0x7F, 0xF0, 0x1F, 0xC0, 0xFF, 0xE0, 0x3F, 0x83, 0xFF, 0xC0, 0x7F,
  0x07, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0x83, 0xF8, 0x1F, 0xFF, 0x07, 0xF0,
  0x3F, 0x7E, 0x0F, 0xE0, 0xFE, 0xFE, 0x1F, 0x81, 0xFD, 0xFC, 0x7F, 0x03,
  0xF9, 0xF8, 0xFE, 0x07, 0xE3, 0xF9, 0xFC, 0x1F, 0xC7, 0xF3, 0xF8, 0x3F,
  0x8F, 0xE7, 0xE0, 0x7F, 0x0F, 0xEF, 0xC0, 0xFE, 0x1F, 0xFF, 0x81, 0xF8,
  0x3F, 0xFF, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0xC0,
  0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xE0, 0x7E, 0x01, 0xFF, 0xC1, 0xFC, 0x03,
  0xFF, 0x83, 0xF8, 0x07, 0xFE, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xE0, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xCF,
  0xFC, 0x7F, 0xC0, 0xFF, 0x3F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF7, 0xFC,
  0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0,
  0x7F, 0xC7, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF8, 0xFF,
  0x0F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0xFF, 0x0F, 0xF1,
  0xFE, 0x3F, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x7F, 0xC0, 0xFF, 0x3F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF7, 0xFC, 0x03,
  0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xEF,
  0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x7F,
  0xC7, 0xFC, 0x7F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0x87, 0xF8, 0xFF, 0x0F, 0xF0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x7F, 0xE3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFC, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xF1,
  0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF9, 0xFE, 0x0F,
  0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xE0, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0x87, 0x83, 0xFC, 0x04, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x40, 0x1F, 0xE3, 0xC0, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC3,
  0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F,
  0x87, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0,
  0x7F, 0x87, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF8,
  0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x7F, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8,
  0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F,
  0x83, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF1, 0xFE, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xEF,
  0xE0, 0x1F, 0xC0, 0x7F, 0xBF, 0x80, 0xFF, 0x01, 0xFC, 0xFE, 0x03, 0xFC,
  0x07, 0xF3, 0xF8, 0x1F, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0xC0, 0xFE, 0x3F,
  0x81, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xF0,
  0x7F, 0x0F, 0xE1, 0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xFF, 0x0F, 0xE0, 0xFE,
  0x3F, 0x7C, 0x7F, 0x83, 0xF8, 0xFF, 0xF1, 0xFC, 0x0F, 0xE3, 0xEF, 0xC7,
  0xF0, 0x3F, 0x9F, 0xBF, 0x3F, 0x80, 0xFE, 0x7E, 0xFC, 0xFE, 0x01, 0xFB,
  0xF3, 0xF3, 0xF0, 0x07, 0xEF, 0xCF, 0xDF, 0xC0, 0x1F, 0xFE, 0x3F, 0x7F,
  0x00, 0x7F, 0xF8, 0xFD, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x07, 0xFF,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x01, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0,
  0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0x01,
  0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0x87, 0xF8, 0x3F, 0x8F,
  0xF0, 0x3F, 0x8F, 0xF0, 0x3F, 0x9F, 0xE0, 0x1F, 0xDF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF8, 0x0F, 0xC7, 0xC0,
  0xFC, 0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0xC7, 0xE0, 0x3E, 0x3E, 0x01,
  0xF3, 0xF0, 0x0F, 0xFF, 0x00, 0x3E, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x7F, 0x9F, 0xC7, 0xE3, 0xF8, 0xFC, 0x3E,
  0x00, 0x40, 0x00, 0x0F, 0xE3, 0xF0, 0xFF, 0xDF, 0xC7, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xF1, 0xFC, 0x7F, 0x87,
  0xF3, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0xFF, 0x0F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF8, 0xFF, 0x1F, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0x7E,
  0x01, 0xF9, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x40, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0x8F,
  0xF0, 0xFF, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF0, 0xFE,
  0x0F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F, 0xE3,
  0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x07, 0xEF, 0xFC, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xF0,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3,
  0xFC, 0x04, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x06, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x43, 0xFC, 0x03, 0xFB, 0xFC, 0x0F, 0xFB, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xC7, 0xF0, 0x7F,
  0x87, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF,
  0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xDF, 0x80, 0x1F, 0x9F, 0x80, 0x00, 0x08, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F,
  0xC7, 0xF7, 0xF8, 0x7F, 0x7F, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x8F, 0xF0, 0x78, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xE2, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x03, 0xF8, 0xFC, 0x1F, 0xFB, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xF1, 0xFC, 0x3F, 0xC3, 0xF8, 0xFF,
  0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xC7, 0xF8, 0x7F, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x03, 0xE7, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0x00, 0x7F, 0x03,
  0x83, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x20, 0x07, 0xF7, 0xF8, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F,
  0xF0, 0xFF, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE,
  0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x1F, 0xE1, 0xFE, 0x00, 0x00,
  0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0xFE, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0xFF,
  0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFF,
  0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFF, 0x01,
  0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x07,
  0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x04, 0x00,
  0xFC, 0xFF, 0x07, 0xF0, 0x1F, 0xBF, 0xF3, 0xFF, 0x03, 0xF7, 0xFE, 0x7F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0x8F, 0xF8, 0xFF, 0x1F, 0xE1, 0xFF, 0x1F, 0xE3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xE0, 0xFF, 0x0F, 0xF1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0x3F, 0x8F, 0xF0, 0xFF, 0x0F,
  0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F,
  0x07, 0xF1, 0xFE, 0x0F, 0xE0, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0xF8,
  0x7F, 0x87, 0xF8, 0xFE, 0x0F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0,
  0x00, 0x00, 0x40, 0x0F, 0xCF, 0xF0, 0x1F, 0xBF, 0xF0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x1F,
  0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC,
  0x1F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0x83,
  0xF8, 0x7F, 0x07, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F,
  0x8F, 0xE0, 0xFE, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0x3F, 0xCF, 0xF0, 0xFF, 0x7F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xEF, 0xF0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8, 0x3F, 0xDF, 0xC1,
  0xFC, 0xFF, 0x1F, 0xE7, 0xF9, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0xFC, 0xFE, 0x00, 0x7E, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x7F,
  0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1,
  0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0xFE, 0xFF, 0x80, 0x7F, 0x3F, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xE3, 0xF0, 0xFF, 0xDF,
  0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F,
  0xF1, 0xFC, 0x7F, 0x87, 0xF3, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0x3F, 0xC1,
  0xFC, 0xFF, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x40, 0xFC, 0x7C, 0x1F, 0xBF, 0x83, 0xF7, 0xF0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x30, 0x01, 0xFF, 0xC0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xF8, 0x30, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x80, 0x7F, 0x38, 0x3F, 0xCF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF0, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x84, 0x1F, 0xFF, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F,
  0xC1, 0xFC, 0xFF, 0x07, 0xF3, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0x83,
  0xF8, 0xFE, 0x0F, 0xE7, 0xF8, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F, 0x87, 0xF9,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC,
  0x3F, 0xCF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x1F, 0xFB, 0xF0, 0x7F, 0xEF, 0xC0, 0xFE, 0x3F, 0x00,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0xBF, 0x83, 0xFC, 0xFE,
  0x0F, 0xF3, 0xF8, 0x7F, 0x87, 0xE1, 0xFE, 0x1F, 0xCF, 0xF0, 0x7F, 0x3F,
  0x81, 0xFC, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0x07, 0xF8, 0x3F, 0xBF, 0x87, 0xFC,
  0x1F, 0xDF, 0xC3, 0xFE, 0x1F, 0xCF, 0xE1, 0xFF, 0x0F, 0xE7, 0xF1, 0xFF,
  0x8F, 0xE3, 0xF8, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0xE7, 0xF8, 0xFE, 0x7D,
  0xF3, 0xF8, 0x3F, 0x3E, 0xF9, 0xFC, 0x1F, 0xBF, 0x7D, 0xFC, 0x0F, 0xDF,
  0x3E, 0xFE, 0x07, 0xEF, 0x9F, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x01, 0xFF,
  0xC7, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xE0,
  0xFF, 0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xDF,
  0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xF7, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0,
  0x1F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x3F,
  0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F,
  0xC7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x1B,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0x80, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x17, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x7F, 0xE8, 0x00, 0x70,
};

const GFXglyph NotoSans_BlackItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 29, 12, 0, -29 },
  { 52, 16, 11, 18, 4, -29 },
  { 74, 27, 29, 26, 0, -29 },
  { 172, 22, 32, 23, 1, -30 },
  { 260, 34, 29, 37, 2, -29 },
  { 384, 29, 29, 29, 0, -29 },
  { 490, 8, 11, 10, 4, -29 },
  { 501, 17, 35, 15, 1, -29 },
  { 576, 17, 35, 15, -3, -29 },
  { 651, 20, 20, 22, 3, -31 },
  { 701, 20, 20, 23, 2, -24 },
  { 751, 11, 10, 12, -2, -5 },
  { 765, 12, 6, 13, 0, -14 },
  { 774, 8, 7, 12, 0, -7 },
  { 781, 23, 29, 19, -2, -29 },
  { 865, 22, 29, 23, 1, -29 },
  { 945, 18, 29, 23, 3, -29 },
  { 1011, 23, 29, 23, -1, -29 },
  { 1095, 22, 29, 23, 0, -29 },
  { 1175, 23, 29, 23, 0, -29 },
  { 1259, 23, 29, 23, 0, -29 },
  { 1343, 22, 29, 23, 2, -29 },
  { 1423, 24, 29, 23, 1, -29 },
  { 1510, 22, 29, 23, 1, -29 },
  { 1590, 20, 29, 23, 2, -29 },
  { 1663, 12, 22, 12, 0, -22 },
  { 1696, 14, 27, 12, -2, -22 },
  { 1744, 20, 22, 23, 2, -25 },
  { 1799, 20, 14, 23, 2, -21 },
  { 1834, 20, 22, 23, 2, -25 },
  { 1889, 18, 29, 20, 3, -29 },
  { 1955, 33, 33, 36, 2, -29 },
  { 2092, 26, 29, 27, -2, -29 },
  { 2187, 24, 29, 25, 1, -29 },
  { 2274, 25, 29, 25, 2, -29 },
  { 2365, 25, 29, 27, 1, -29 },
  { 2456, 23, 29, 22, 1, -29 },
  { 2540, 23, 29, 23, 1, -29 },
  { 2624, 26, 29, 28, 2, -29 },
  { 2719, 28, 29, 29, 1, -29 },
  { 2821, 20, 29, 17, -1, -29 },
  { 2894, 21, 38, 15, -6, -29 },
  { 2994, 29, 29, 27, 1, -29 },
  { 3100, 18, 29, 21, 1, -29 },
  { 3166, 36, 29, 36, 1, -29 },
  { 3297, 31, 29, 32, 1, -29 },
  { 3410, 26, 29, 29, 2, -29 },
  { 3505, 23, 29, 25, 1, -29 },
  { 3589, 26, 36, 29, 2, -29 },
  { 3706, 23, 29, 26, 1, -29 },
  { 3790, 21, 29, 22, 1, -29 },
  { 3867, 21, 29, 22, 3, -29 },
  { 3944, 26, 29, 28, 2, -29 },
  { 4039, 25, 29, 25, 3, -29 },
  { 4130, 38, 29, 37, 3, -29 },
  { 4268, 32, 29, 27, -2, -29 },
  { 4384, 24, 29, 24, 3, -29 },
  { 4471, 26, 29, 22, -2, -29 },
  { 4566, 18, 36, 14, -1, -29 },
  { 4647, 11, 29, 19, 4, -29 },
  { 4687, 18, 36, 14, -3, -29 },
  { 4768, 21, 19, 21, 0, -29 },
  { 4818, 20, 4, 18, -4, 3 },
  { 4828, 9, 7, 14, 6, -31 },
  { 4836, 22, 23, 24, 2, -23 },
  { 4900, 23, 30, 24, 0, -30 },
  { 4987, 19, 23, 20, 2, -23 },
  { 5042, 24, 30, 24, 2, -30 },
  { 5132, 20, 23, 23, 2, -23 },
  { 5190, 24, 41, 16, -4, -31 },
  { 5313, 23, 33, 24, 1, -23 },
  { 5408, 23, 30, 25, 0, -30 },
  { 5495, 14, 31, 13, 0, -31 },
  { 5550, 19, 41, 13, -5, -31 },
  { 5648, 27, 30, 25, 0, -30 },
  { 5750, 14, 30, 13, 0, -30 },
  { 5803, 35, 23, 37, 0, -23 },
  { 5904, 23, 23, 25, 0, -23 },
  { 5971, 21, 23, 24, 2, -23 },
  { 6032, 25, 33, 24, -2, -23 },
  { 6136, 22, 33, 24, 2, -23 },
  { 6227, 19, 23, 17, 0, -23 },
  { 6282, 18, 23, 20, 1, -23 },
  { 6334, 18, 27, 18, 1, -27 },
  { 6395, 22, 22, 25, 2, -22 },
  { 6456, 22, 22, 22, 2, -22 },
  { 6517, 33, 22, 33, 2, -22 },
  { 6608, 27, 22, 23, -2, -22 },
  { 6683, 27, 32, 22, -3, -22 },
  { 6791, 21, 22, 19, -1, -22 },
  { 6849, 17, 35, 14, 0, -29 },
  { 6924, 5, 39, 23, 9, -30 },
  { 6949, 17, 35, 14, -2, -29 },
  { 7024, 20, 8, 23, 2, -18 },
};

const GFXfont NotoSans_BlackItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_BLACKITALIC40PT7B_H_
