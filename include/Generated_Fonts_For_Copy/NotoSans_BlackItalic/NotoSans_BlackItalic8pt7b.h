#ifndef _NOTOSANS_BLACKITALIC8PT7B_H_
#define _NOTOSANS_BLACKITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x61, 0x80, 0xBC, 0x29, 0xFE, 0xAF, 0xF0, 0x3B, 0x98, 0x6B,
  0x70, 0x66, 0xDB, 0xAB, 0xB2, 0xAD, 0xC0, 0x31, 0xE7, 0x3F, 0xDB, 0xE0,
  0xC0, 0x34, 0x4C, 0xCC, 0x40, 0x23, 0x33, 0x22, 0xC0, 0x6F, 0xCA, 0x22,
  0xF2, 0xE0, 0xE0, 0xC0, 0x13, 0x24, 0x48, 0x33, 0xB7, 0xAF, 0x30, 0x3F,
  0xB5, 0x80, 0x77, 0x12, 0x4F, 0x75, 0x77, 0x9F, 0x19, 0x9D, 0xEF, 0x10,
  0x7B, 0x98, 0xEB, 0x78, 0x3B, 0x5D, 0xAD, 0x38, 0x7B, 0xCC, 0x46, 0x60,
  0x32, 0xDC, 0xED, 0x78, 0x75, 0xD7, 0x3E, 0x43, 0x43, 0x80, 0x16, 0xE1,
  0xF0, 0xF0, 0xC7, 0x3C, 0xF5, 0xE1, 0x00, 0x3C, 0xCD, 0xED, 0x5B, 0xC9,
  0x0E, 0x00, 0x31, 0xDE, 0xBF, 0xCC, 0x73, 0xDE, 0xED, 0xF8, 0x3B, 0x51,
  0x8C, 0xB8, 0x73, 0xD2, 0x9D, 0xF8, 0x7B, 0x9C, 0xEC, 0x78, 0x7B, 0x90,
  0xEC, 0x60, 0x3D, 0xA4, 0x36, 0xD9, 0xE0, 0x6D, 0xA7, 0x9E, 0xDB, 0x60,
  0x76, 0x64, 0x4E, 0x33, 0x32, 0x26, 0xEC, 0x6D, 0xE5, 0x1C, 0xD3, 0x60,
  0x66, 0x44, 0xCF, 0x66, 0xCD, 0xBB, 0x7F, 0x5E, 0x80, 0x65, 0x97, 0x57,
  0xDB, 0x60, 0x39, 0xB4, 0xF3, 0xD9, 0xC0, 0x73, 0xD6, 0xEC, 0x60, 0x39,
  0xF4, 0xF3, 0xD9, 0xC1, 0x80, 0x73, 0xD6, 0xED, 0x6C, 0x35, 0x63, 0xBE,
  0xFF, 0x4C, 0xCC, 0x6D, 0xA4, 0x96, 0xD9, 0xC0, 0x9D, 0xA9, 0x4C, 0x60,
  0x93, 0x6E, 0xD7, 0xED, 0x9B, 0x00, 0x6D, 0xE3, 0x1C, 0x53, 0x60, 0x9B,
  0xEC, 0xCC, 0x7B, 0x8C, 0xCC, 0x78, 0x69, 0x2D, 0x30, 0xAB, 0x50, 0x31,
  0x32, 0x22, 0xE0, 0x22, 0x59, 0xF0, 0xC0, 0x23, 0xF5, 0xA7, 0x00, 0x63,
  0x1C, 0xBD, 0x78, 0x27, 0xCC, 0x60, 0x19, 0xDF, 0xAD, 0x38, 0x27, 0xFC,
  0x70, 0x19, 0xDC, 0x42, 0x31, 0x98, 0x23, 0xF5, 0xA7, 0x5B, 0x80, 0x63,
  0x1E, 0xBD, 0x78, 0x65, 0x2D, 0x80, 0x31, 0x22, 0x66, 0x6C, 0x63, 0x16,
  0xEF, 0x6C, 0x6D, 0x2D, 0x80, 0x14, 0xFD, 0x7E, 0xBD, 0x60, 0x13, 0xD7,
  0xAF, 0x00, 0x23, 0xB7, 0xA7, 0x00, 0x13, 0x97, 0xAF, 0x42, 0x00, 0x23,
  0xF5, 0xA7, 0x18, 0xC0, 0x17, 0x4C, 0xC0, 0x27, 0x62, 0xE0, 0x6F, 0x4C,
  0xE0, 0x5A, 0xB4, 0xE0, 0xDB, 0x98, 0xC0, 0xD6, 0xE9, 0xF2, 0xC0, 0x5B,
  0x19, 0xE0, 0x6C, 0xE3, 0x0C, 0x23, 0x00, 0x76, 0x4E, 0x2D, 0x65, 0xB0,
  0xFF, 0x49, 0x35, 0xA0, 0x5B,
};

const GFXglyph NotoSans_BlackItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 5, 6, 5, 0, -6 },
  { 13, 7, 6, 7, 0, -6 },
  { 19, 6, 6, 6, 0, -6 },
  { 24, 1, 2, 2, 1, -6 },
  { 25, 4, 7, 3, 0, -6 },
  { 29, 4, 7, 3, -1, -6 },
  { 33, 4, 4, 4, 1, -6 },
  { 35, 4, 4, 5, 0, -5 },
  { 37, 2, 2, 2, 0, -1 },
  { 38, 3, 1, 3, 0, -3 },
  { 39, 2, 1, 2, 0, -1 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 5, 6, 5, 0, -6 },
  { 47, 3, 6, 5, 1, -6 },
  { 50, 4, 6, 5, 0, -6 },
  { 53, 4, 6, 5, 0, -6 },
  { 56, 5, 6, 5, 0, -6 },
  { 60, 5, 6, 5, 0, -6 },
  { 64, 5, 6, 5, 0, -6 },
  { 68, 5, 6, 5, 0, -6 },
  { 72, 5, 6, 5, 0, -6 },
  { 76, 4, 6, 5, 0, -6 },
  { 79, 2, 4, 2, 0, -4 },
  { 80, 2, 5, 2, 0, -4 },
  { 82, 4, 4, 5, 0, -5 },
  { 84, 4, 3, 5, 0, -4 },
  { 86, 4, 4, 5, 0, -5 },
  { 88, 3, 6, 4, 1, -6 },
  { 91, 7, 7, 7, 0, -6 },
  { 98, 5, 6, 5, 0, -6 },
  { 102, 5, 6, 5, 0, -6 },
  { 106, 5, 6, 5, 0, -6 },
  { 110, 5, 6, 5, 0, -6 },
  { 114, 5, 6, 5, 0, -6 },
  { 118, 5, 6, 5, 0, -6 },
  { 122, 6, 6, 6, 0, -6 },
  { 127, 6, 6, 6, 0, -6 },
  { 132, 4, 6, 3, 0, -6 },
  { 135, 4, 8, 3, -1, -6 },
  { 139, 6, 6, 5, 0, -6 },
  { 144, 4, 6, 4, 0, -6 },
  { 147, 7, 6, 7, 0, -6 },
  { 153, 6, 6, 6, 0, -6 },
  { 158, 6, 6, 6, 0, -6 },
  { 163, 5, 6, 5, 0, -6 },
  { 167, 6, 7, 6, 0, -6 },
  { 173, 5, 6, 5, 0, -6 },
  { 177, 4, 6, 4, 0, -6 },
  { 180, 4, 6, 4, 1, -6 },
  { 183, 6, 6, 6, 0, -6 },
  { 188, 5, 6, 5, 1, -6 },
  { 192, 7, 6, 7, 1, -6 },
  { 198, 6, 6, 5, 0, -6 },
  { 203, 4, 6, 5, 1, -6 },
  { 206, 5, 6, 4, 0, -6 },
  { 210, 3, 7, 3, 0, -6 },
  { 213, 2, 6, 4, 1, -6 },
  { 215, 4, 7, 3, -1, -6 },
  { 219, 4, 4, 4, 0, -6 },
  { 221, 4, 1, 4, -1, 0 },
  { 222, 2, 1, 3, 1, -6 },
  { 223, 5, 5, 5, 0, -5 },
  { 227, 5, 6, 5, 0, -6 },
  { 231, 4, 5, 4, 0, -5 },
  { 234, 5, 6, 5, 0, -6 },
  { 238, 4, 5, 5, 0, -5 },
  { 241, 5, 8, 3, -1, -6 },
  { 246, 5, 7, 5, 0, -5 },
  { 251, 5, 6, 5, 0, -6 },
  { 255, 3, 6, 3, 0, -6 },
  { 258, 4, 8, 3, -1, -6 },
  { 262, 5, 6, 5, 0, -6 },
  { 266, 3, 6, 3, 0, -6 },
  { 269, 7, 5, 7, 0, -5 },
  { 274, 5, 5, 5, 0, -5 },
  { 278, 5, 5, 5, 0, -5 },
  { 282, 5, 7, 5, 0, -5 },
  { 287, 5, 7, 5, 0, -5 },
  { 292, 4, 5, 4, 0, -5 },
  { 295, 4, 5, 4, 0, -5 },
  { 298, 4, 5, 4, 0, -5 },
  { 301, 5, 4, 5, 0, -4 },
  { 304, 5, 4, 4, 0, -4 },
  { 307, 7, 4, 7, 0, -4 },
  { 311, 5, 4, 5, 0, -4 },
  { 314, 6, 6, 4, -1, -4 },
  { 319, 4, 4, 4, 0, -4 },
  { 321, 3, 7, 3, 0, -6 },
  { 324, 1, 8, 5, 2, -6 },
  { 325, 3, 7, 3, 0, -6 },
  { 328, 4, 2, 5, 0, -4 },
};

const GFXfont NotoSans_BlackItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_BLACKITALIC8PT7B_H_
