#ifndef _NOTOSANS_BLACKITALIC60PT7B_H_
#define _NOTOSANS_BLACKITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xF1, 0xFF,
  0x9F, 0xF8, 0xFF, 0xCF, 0xFC, 0x7F, 0xE7, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F,
  0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xFC, 0xFF, 0x87, 0xFC, 0x7F, 0xC3,
  0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8,
  0x3F, 0xC3, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFE, 0xF8, 0x3C, 0x0F, 0xFC, 0xF8, 0x04, 0x0F, 0xFC,
  0xF8, 0x00, 0x0F, 0xFC, 0xF8, 0x00, 0x0F, 0xFC, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xDF, 0xF8, 0x00, 0x07, 0x8F, 0xFC, 0x80, 0x0F, 0x8F, 0xF8, 0xC0, 0x0F,
  0x8F, 0xF8, 0xFC, 0x0F, 0x9F, 0xF8, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xE3, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0x00,
  0xFF, 0x87, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F,
  0x83, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0x9F,
  0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF9, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F,
  0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xE0, 0xFF, 0xC3,
  0xFC, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x7F, 0x80, 0x00,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x00,
  0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF1,
  0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0xCF, 0xFF, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xBF, 0xFE, 0x00, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3,
  0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87,
  0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xE8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x40, 0x1F, 0xE0, 0x01,
  0xC0, 0x7F, 0x80, 0x07, 0xC1, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFF,
  0x9F, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x3F,
  0x81, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xBF, 0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F,
  0x87, 0xFC, 0x00, 0x1C, 0x1F, 0xF0, 0x00, 0x30, 0x3F, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xFF,
  0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x01, 0x01, 0xFE, 0x3F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC1,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x8F, 0xFE, 0x0F, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0x3F, 0xFC,
  0x0F, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x7F, 0xF8,
  0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0,
  0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0,
  0x0F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xE0,
  0x1F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0,
  0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xE0,
  0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xBF, 0xF8, 0x3F, 0xF3, 0xFF, 0x81, 0xFC, 0x7F, 0xF0, 0x1F, 0x87,
  0xFF, 0x00, 0xE0, 0x7F, 0xF0, 0x08, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFC, 0x7F, 0xFC, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0x00,
  0xFF, 0xF0, 0x00, 0xC0, 0x1F, 0xFE, 0x00, 0x10, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x03, 0xFF, 0xC0,
  0x08, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0xC0, 0x00, 0x3F, 0xFE, 0x7C, 0x00,
  0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xFE, 0x00, 0x1F, 0xF3, 0xFF,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0x1F,
  0xFC, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x80, 0x3F, 0xF0,
  0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x80, 0x00, 0x7F, 0xFC, 0x3C, 0x00, 0x3F, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x78, 0x00, 0x7F, 0xF1, 0xFF, 0x80,
  0x3F, 0xFB, 0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFC, 0x7F, 0xFC, 0x0F, 0xFE, 0x3F, 0xFC, 0x07, 0xFF, 0x1F, 0xFE, 0x03,
  0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xC0,
  0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFF, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC,
  0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xDF,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xE0,
  0x0F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE,
  0x07, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xF0, 0xFF, 0xF7, 0xFF, 0x81, 0xFF, 0xDF, 0xFE, 0x07,
  0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xDF, 0xF8, 0x7F, 0xFE, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0x81, 0xFF, 0x8F,
  0xFC, 0x01, 0xF8, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x0F,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1F, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE3, 0xF0, 0x1F, 0xFC, 0x38, 0x03, 0xFF, 0x84, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x03,
  0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0x83, 0xFC, 0x03,
  0xFF, 0xFF, 0x1F, 0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x81,
  0xFF, 0xFF, 0xF0, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xCF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xF8, 0x7F, 0x83, 0xFD, 0xFE,
  0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xDF,
  0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF7, 0xF8, 0x7F, 0x80, 0xFF, 0x03, 0xFD,
  0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0xFE, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0xBF, 0xC3, 0xFE, 0x07, 0xF8, 0x1F, 0xEF, 0xF0, 0xFF, 0x01, 0xFE, 0x07,
  0xFB, 0xFC, 0x3F, 0xC0, 0xFF, 0x83, 0xFC, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1,
  0xFF, 0x3F, 0xC3, 0xFE, 0x1F, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x87, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0xFE,
  0x7F, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x7E,
  0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x1F, 0xFD,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x01, 0xFF, 0xC1,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F,
  0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x0F,
  0xFE, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xBF,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF,
  0x80, 0x0F, 0x00, 0xFF, 0xF8, 0x00, 0x18, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x08, 0x03, 0xFF, 0xE0, 0x01, 0xC0, 0x1F, 0xFF, 0x80, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x03,
  0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F,
  0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x3F,
  0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0xC1, 0xFF,
  0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7E, 0x03,
  0xFF, 0xF8, 0x00, 0x38, 0x0F, 0xFF, 0xC0, 0x00, 0x40, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF,
  0xC0, 0xFF, 0xFF, 0xCF, 0xFF, 0x03, 0xFF, 0xFF, 0x3F, 0xFC, 0x1F, 0xFF,
  0xF8, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF,
  0x07, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xFF,
  0xC3, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x02,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xFC,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x00,
  0x1F, 0xFC, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x9F, 0xFF, 0x00, 0x00, 0x3F, 0xF9, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xBF,
  0xFC, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F,
  0xF7, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x7F, 0xDF, 0xF8, 0x03, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFC, 0x0F, 0xFB, 0xFF, 0x00, 0x7F,
  0xEF, 0xF0, 0x3F, 0xCF, 0xFC, 0x01, 0xFF, 0xBF, 0xC0, 0xFF, 0x3F, 0xF0,
  0x07, 0xFE, 0xFF, 0x07, 0xF9, 0xFF, 0x80, 0x3F, 0xFB, 0xFC, 0x1F, 0xE7,
  0xFE, 0x00, 0xFF, 0xCF, 0xF0, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x3F, 0xC3,
  0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0x1F, 0xF3, 0xFF, 0x80, 0x3F, 0xF3,
  0xFC, 0x7F, 0x8F, 0xFC, 0x01, 0xFF, 0xCF, 0xF3, 0xFE, 0x3F, 0xF0, 0x07,
  0xFE, 0x3F, 0xCF, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0x7F, 0xC7, 0xFF,
  0x00, 0x7F, 0xE3, 0xFD, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x8F, 0xFF, 0xF8,
  0x7F, 0xE0, 0x0F, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xF8, 0x03, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0x00,
  0x7F, 0xF0, 0xFF, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xF0, 0x3F,
  0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xBF, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFE,
  0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF9,
  0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE3,
  0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x07,
  0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F,
  0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xFB, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xF7, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0,
  0xFF, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0x80,
  0x07, 0xFF, 0x9F, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x0F, 0xFE,
  0x7F, 0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0xC0,
  0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0xFF,
  0xF7, 0xFF, 0x80, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x07, 0xFF, 0x9F, 0xFE,
  0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xE3, 0xFF,
  0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFF, 0x00, 0x07,
  0xFF, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFD, 0xFF,
  0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x01, 0xFF, 0xEF,
  0xFF, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00,
  0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x9F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE7, 0xFF,
  0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC,
  0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF0,
  0x07, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xCF,
  0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0xF8, 0x07, 0xFF, 0x00, 0x18, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0xC0, 0x00, 0xFF, 0xF0, 0xF0, 0x00, 0xFF, 0xE0, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x07,
  0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF,
  0x80, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x01, 0xFF,
  0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xE0,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE1,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xDF,
  0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x1F,
  0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFC,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x9F,
  0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xDF,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x1F, 0xEF, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xF7, 0xFC,
  0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFB, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0x8F,
  0xF9, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xC7, 0xFC, 0xFF, 0x8F, 0xFC, 0x00,
  0x7F, 0xE7, 0xFC, 0x7F, 0xCF, 0xFE, 0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xE7,
  0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x1F, 0xF3, 0xFF, 0x00, 0x0F, 0xFD, 0xFF,
  0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x87, 0xFD, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x87, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xE7,
  0xFF, 0x00, 0x7F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF,
  0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xF8, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xCF, 0xFE,
  0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x40, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0,
  0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC,
  0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE,
  0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFE,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x07, 0xFF, 0x8F, 0xF8, 0x07, 0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xEF, 0xFF, 0xC1, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xF8,
  0x7F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x07,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8,
  0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xE0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x7C, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFE, 0xFF, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF,
  0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x01, 0xFF,
  0xE1, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xE0, 0x3F,
  0xFC, 0x7F, 0xE0, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFE, 0x1F, 0xF8, 0x0F,
  0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFB, 0xFF, 0xF8, 0x0F, 0xF8,
  0xFF, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x3E, 0x07,
  0xFF, 0xC0, 0x30, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x20, 0x7F, 0xF8, 0x0F, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0x81, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xFB,
  0xFF, 0x80, 0x1F, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFB, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFB, 0xFE, 0x00,
  0x0F, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFE, 0x3F, 0xFC, 0x0F, 0xFC, 0x7F, 0xF0, 0x1F, 0xF9, 0xFF, 0xE0, 0x7F,
  0xF3, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0xDF, 0xFE, 0x7F, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0xC0, 0xFF, 0xF0, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x82, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xF1, 0xFF, 0x00, 0x7F, 0xFF,
  0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFB, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0x8F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x01, 0x00, 0x03, 0xFF, 0xC0, 0x38, 0x00, 0xFF, 0xF0, 0x07, 0xF0,
  0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC1, 0xE0, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF9, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F,
  0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xC0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xE1,
  0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF,
  0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFF, 0x07,
  0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x01, 0xFF, 0xCF,
  0xFF, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00,
  0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x3F,
  0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0xF1, 0xFF, 0xFC, 0x03, 0xFE,
  0x7F, 0xFF, 0x3F, 0xFF, 0xE0, 0x3F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x7F, 0xFF, 0x9F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE1, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE1,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC7, 0xFF, 0x00, 0x3F, 0xF3,
  0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF9, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0x80, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0x3F, 0xFC,
  0x0F, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8,
  0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0,
  0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0,
  0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xF0,
  0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xEF, 0xFF, 0x00,
  0x07, 0xFD, 0xFF, 0xF8, 0x00, 0x7F, 0xDF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF,
  0x87, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xDF, 0xFF, 0x80, 0x1F, 0xFC,
  0xFF, 0xF0, 0x01, 0xFF, 0xC7, 0xFC, 0x00, 0x1F, 0xFC, 0x0C, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFF, 0x8F, 0xF8, 0x07,
  0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xEF, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x80,
  0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFD,
  0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0x3F, 0xF8, 0x00, 0x06,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0x03, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFE,
  0x03, 0xFE, 0x7F, 0xE0, 0x3F, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFE, 0x04, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFE, 0x0F, 0x81, 0xFF, 0xE0, 0x38, 0x1F, 0xFE, 0x00, 0x81,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0xC0, 0x03, 0xFF,
  0x8F, 0x00, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x81, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xFB, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xEF, 0xF8, 0x03, 0xFF, 0xF3,
  0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xBF,
  0xF8, 0x03, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xE7,
  0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8,
  0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFE,
  0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xC7, 0xFF, 0x00, 0x3F, 0xE7, 0xFF,
  0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F,
  0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0x8F, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x7F, 0x7F, 0x0F, 0xFE, 0x07, 0xFE,
  0x1F, 0xDF, 0xC3, 0xFF, 0x81, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F,
  0xE3, 0xFB, 0xFC, 0x7F, 0xF0, 0x1F, 0xF8, 0xFE, 0xFF, 0x1F, 0xF8, 0x07,
  0xFE, 0x7F, 0xBF, 0xCF, 0xFE, 0x01, 0xFF, 0x9F, 0xEF, 0xF3, 0xFF, 0x00,
  0x7F, 0xEF, 0xF3, 0xFC, 0xFF, 0xC0, 0x1F, 0xFB, 0xFC, 0xFF, 0x7F, 0xE0,
  0x07, 0xFE, 0xFE, 0x3F, 0xDF, 0xF8, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x00, 0x7F, 0xDF, 0xE3, 0xFF, 0xFF, 0x00, 0x1F, 0xF7, 0xF0, 0xFE, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x87, 0xFF,
  0x80, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00,
  0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00,
  0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x09, 0xFF, 0xE0, 0x00,
  0x5F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xA0, 0x00, 0x3F, 0xF1, 0x00, 0x00, 0x1C,
  0x00,
};

const GFXglyph NotoSans_BlackItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 21, 44, 18, 0, -43 },
  { 117, 25, 16, 27, 5, -43 },
  { 167, 40, 43, 39, 0, -43 },
  { 382, 32, 50, 35, 2, -46 },
  { 582, 51, 44, 56, 3, -43 },
  { 863, 44, 45, 44, 0, -44 },
  { 1111, 12, 16, 14, 5, -43 },
  { 1135, 24, 53, 22, 2, -44 },
  { 1294, 24, 53, 22, -4, -44 },
  { 1453, 30, 30, 33, 4, -46 },
  { 1566, 29, 29, 35, 3, -36 },
  { 1672, 16, 15, 18, -3, -7 },
  { 1702, 18, 9, 20, 1, -21 },
  { 1723, 12, 12, 18, 0, -11 },
  { 1741, 35, 44, 28, -3, -43 },
  { 1934, 32, 45, 35, 2, -44 },
  { 2114, 28, 43, 35, 4, -43 },
  { 2265, 35, 43, 35, -2, -43 },
  { 2454, 33, 44, 35, 0, -43 },
  { 2636, 34, 43, 35, 0, -43 },
  { 2819, 34, 44, 35, 1, -43 },
  { 3006, 33, 44, 35, 2, -43 },
  { 3188, 36, 43, 35, 1, -43 },
  { 3382, 33, 45, 35, 1, -44 },
  { 3568, 30, 44, 35, 3, -43 },
  { 3733, 18, 35, 18, 0, -34 },
  { 3812, 21, 42, 18, -3, -34 },
  { 3923, 29, 33, 35, 3, -38 },
  { 4043, 29, 22, 35, 3, -32 },
  { 4123, 29, 33, 35, 3, -38 },
  { 4243, 27, 44, 29, 4, -43 },
  { 4392, 50, 48, 54, 2, -43 },
  { 4692, 41, 43, 41, -4, -43 },
  { 4913, 36, 43, 38, 1, -43 },
  { 5107, 37, 45, 38, 3, -44 },
  { 5316, 38, 43, 41, 1, -43 },
  { 5521, 34, 43, 34, 1, -43 },
  { 5704, 34, 43, 34, 1, -43 },
  { 5887, 38, 45, 42, 3, -44 },
  { 6101, 42, 43, 43, 1, -43 },
  { 6327, 31, 43, 26, -2, -43 },
  { 6494, 33, 57, 22, -10, -43 },
  { 6730, 44, 43, 40, 1, -43 },
  { 6967, 27, 43, 32, 1, -43 },
  { 7113, 54, 43, 55, 1, -43 },
  { 7404, 47, 43, 47, 1, -43 },
  { 7657, 39, 45, 44, 3, -44 },
  { 7877, 36, 43, 37, 1, -43 },
  { 8071, 39, 54, 44, 3, -44 },
  { 8335, 36, 43, 39, 1, -43 },
  { 8529, 32, 44, 33, 1, -43 },
  { 8705, 32, 43, 33, 5, -43 },
  { 8877, 38, 44, 42, 4, -43 },
  { 9086, 37, 43, 37, 4, -43 },
  { 9285, 57, 43, 56, 4, -43 },
  { 9592, 48, 43, 40, -4, -43 },
  { 9850, 36, 43, 36, 5, -43 },
  { 10044, 39, 43, 32, -3, -43 },
  { 10254, 28, 54, 22, -2, -44 },
  { 10443, 17, 44, 28, 6, -43 },
  { 10537, 27, 54, 22, -4, -44 },
  { 10720, 32, 28, 32, 0, -43 },
  { 10832, 29, 7, 27, -5, 4 },
  { 10858, 14, 10, 21, 9, -46 },
  { 10876, 34, 35, 36, 2, -34 },
  { 11025, 33, 47, 36, 1, -46 },
  { 11219, 29, 35, 30, 2, -34 },
  { 11346, 36, 47, 36, 2, -46 },
  { 11558, 31, 35, 35, 2, -34 },
  { 11694, 37, 60, 25, -6, -46 },
  { 11972, 35, 48, 36, 1, -34 },
  { 12182, 34, 46, 37, 1, -46 },
  { 12378, 20, 47, 20, 1, -47 },
  { 12496, 29, 61, 20, -8, -47 },
  { 12718, 39, 46, 37, 1, -46 },
  { 12943, 21, 46, 20, 1, -46 },
  { 13064, 52, 34, 56, 1, -34 },
  { 13285, 34, 34, 37, 1, -34 },
  { 13430, 32, 35, 36, 2, -34 },
  { 13570, 36, 48, 36, -2, -34 },
  { 13786, 34, 48, 36, 2, -34 },
  { 13990, 28, 34, 26, 1, -34 },
  { 14109, 28, 35, 30, 1, -34 },
  { 14232, 26, 41, 27, 2, -40 },
  { 14366, 34, 34, 37, 3, -33 },
  { 14511, 33, 33, 33, 3, -33 },
  { 14648, 50, 33, 49, 3, -33 },
  { 14855, 41, 33, 34, -3, -33 },
  { 15025, 40, 47, 33, -4, -33 },
  { 15260, 31, 33, 29, -1, -33 },
  { 15388, 26, 52, 22, 0, -43 },
  { 15557, 8, 59, 34, 13, -45 },
  { 15616, 26, 52, 22, -4, -43 },
  { 15785, 29, 12, 35, 3, -27 },
};

const GFXfont NotoSans_BlackItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_BLACKITALIC60PT7B_H_
