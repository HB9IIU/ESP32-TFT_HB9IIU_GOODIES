#ifndef _NOTOSANS_BLACKITALIC10PT7B_H_
#define _NOTOSANS_BLACKITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xA1, 0xB0, 0xFB, 0x34, 0x59, 0xF9, 0x4F, 0xCA, 0x14, 0x00,
  0x10, 0xF7, 0x9C, 0x38, 0xAF, 0x9C, 0x20, 0xE6, 0xA4, 0xA8, 0xF7, 0x3D,
  0x2F, 0xC6, 0x3C, 0xD8, 0xE3, 0xBD, 0xFB, 0x9F, 0x80, 0xE0, 0x36, 0x64,
  0xCC, 0xC4, 0x60, 0x31, 0x11, 0x13, 0x26, 0xC0, 0x25, 0x3E, 0xDF, 0x00,
  0x31, 0xBE, 0x63, 0x00, 0x78, 0xE0, 0xF0, 0x18, 0x8C, 0x46, 0x63, 0x00,
  0x39, 0xB6, 0xF3, 0xDB, 0x67, 0x00, 0x3F, 0xB3, 0x66, 0x60, 0x7B, 0xC6,
  0x77, 0x7F, 0xE0, 0x79, 0x31, 0x8C, 0x5A, 0x6F, 0x00, 0x1C, 0x63, 0x96,
  0xFF, 0xE3, 0x00, 0x3D, 0x87, 0x1E, 0x1A, 0x6F, 0x00, 0x3D, 0x85, 0xBE,
  0xD9, 0x67, 0x00, 0x7C, 0x31, 0x8C, 0x31, 0x8E, 0x00, 0x39, 0xB7, 0x9E,
  0xDB, 0x67, 0x80, 0xF6, 0xA7, 0xEF, 0x7B, 0x80, 0x2C, 0x0D, 0x80, 0x13,
  0x00, 0x06, 0xC0, 0x09, 0xB0, 0x70, 0x80, 0xF8, 0x3E, 0xC3, 0x86, 0xEC,
  0x00, 0xFB, 0x76, 0x8C, 0xC0, 0x3F, 0x30, 0x97, 0xFA, 0xBF, 0x52, 0xF9,
  0x90, 0x78, 0x0E, 0x3C, 0x59, 0xB3, 0xEF, 0xF9, 0x80, 0x3D, 0xB6, 0xDE,
  0x6F, 0x7F, 0x80, 0x7F, 0xAC, 0x20, 0x83, 0x4F, 0x00, 0x3C, 0xD9, 0x9B,
  0x26, 0xDF, 0xBE, 0x00, 0x3D, 0x86, 0x1E, 0x63, 0xEF, 0x80, 0x3D, 0x86,
  0x1E, 0x63, 0x0C, 0x00, 0x7F, 0xAC, 0x7E, 0x9B, 0x6F, 0x80, 0x36, 0xCD,
  0x9B, 0xE6, 0xD9, 0xB3, 0x00, 0x79, 0x98, 0xC6, 0x3B, 0x80, 0x0C, 0x21,
  0x86, 0x18, 0x63, 0x0C, 0xF0, 0x36, 0xD9, 0xE3, 0xC7, 0x9B, 0xB3, 0x00,
  0x33, 0x18, 0xC6, 0x7F, 0xE0, 0x33, 0xB9, 0xDD, 0xEE, 0xA5, 0xF6, 0xDB,
  0x6C, 0x33, 0x73, 0x7A, 0x7E, 0x4E, 0xCE, 0xCE, 0x7B, 0xBC, 0xF3, 0x8F,
  0x6F, 0x00, 0x3D, 0xB6, 0xDF, 0x73, 0x0C, 0x00, 0x7B, 0xBC, 0xF3, 0x8F,
  0xEF, 0x0C, 0x18, 0x3D, 0xB6, 0xDE, 0x7B, 0x6C, 0xC0, 0x3D, 0xA6, 0x0C,
  0x1B, 0xEF, 0x00, 0xFB, 0x18, 0xC6, 0x63, 0x00, 0x6F, 0x3C, 0xF6, 0xDB,
  0xEF, 0x00, 0xCF, 0x6D, 0xBC, 0xF3, 0x8E, 0x00, 0xD9, 0xEC, 0xB6, 0xD7,
  0x6A, 0xA7, 0x73, 0x30, 0x33, 0x1E, 0x1C, 0x1C, 0x3C, 0x7C, 0xE6, 0xDF,
  0x6F, 0x18, 0x61, 0x8C, 0x00, 0x7C, 0x63, 0x8C, 0x63, 0xEF, 0x80, 0x76,
  0x64, 0x4C, 0xCE, 0xC0, 0xD9, 0x24, 0xD8, 0x38, 0x84, 0x63, 0x18, 0x8C,
  0xE0, 0x11, 0x9E, 0x98, 0x80, 0xF8, 0xCC, 0x2D, 0xF6, 0xF2, 0xF9, 0xE0,
  0x31, 0x87, 0x9F, 0x6D, 0x3F, 0xBE, 0x33, 0xD9, 0x8F, 0x38, 0x0C, 0x32,
  0xDF, 0x6F, 0x2F, 0x9E, 0x11, 0xF6, 0xBE, 0xC9, 0xE0, 0x0C, 0x71, 0xDE,
  0x30, 0xC3, 0x08, 0x63, 0x80, 0x3D, 0xF6, 0xF2, 0xF9, 0xE1, 0xBC, 0x31,
  0x86, 0x9F, 0x6D, 0xBD, 0xB6, 0x32, 0x66, 0x66, 0xCC, 0x18, 0x8C, 0x63,
  0x19, 0x8C, 0x67, 0x00, 0x30, 0xC1, 0x9B, 0x67, 0x8F, 0x36, 0x6E, 0x36,
  0x66, 0x66, 0xCC, 0x69, 0x3F, 0xDB, 0x6D, 0xBD, 0xB6, 0xD8, 0x69, 0xF6,
  0xDB, 0xDB, 0x60, 0x11, 0xE6, 0xF3, 0xD9, 0xC0, 0x79, 0xF6, 0xD3, 0xFB,
  0xEC, 0x30, 0x3D, 0xF6, 0xF2, 0xF9, 0xE1, 0x8C, 0x6B, 0xD8, 0xCC, 0x60,
  0x33, 0xD8, 0xEB, 0x78, 0x31, 0xFC, 0xC6, 0x39, 0xC0, 0x6D, 0xB6, 0xD2,
  0xF9, 0xE0, 0xCD, 0x25, 0x94, 0x71, 0x80, 0xCD, 0xAF, 0x96, 0xCF, 0x46,
  0xE3, 0x60, 0x36, 0x78, 0xF1, 0xC3, 0xDD, 0x80, 0x66, 0x48, 0xB1, 0xC3,
  0x86, 0x0C, 0x70, 0x7B, 0xCC, 0xCC, 0x78, 0x32, 0x6E, 0xC4, 0x4E, 0x60,
  0xFF, 0xC0, 0x31, 0x8C, 0x73, 0x11, 0x9C, 0xC0, 0xF8,
};

const GFXglyph NotoSans_BlackItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 4, 2, 5, 1, -7 },
  { 5, 7, 7, 6, 0, -7 },
  { 12, 6, 9, 6, 0, -8 },
  { 19, 8, 7, 9, 1, -7 },
  { 26, 7, 7, 7, 0, -7 },
  { 33, 2, 2, 2, 1, -7 },
  { 34, 4, 9, 4, 0, -7 },
  { 39, 4, 9, 4, -1, -7 },
  { 44, 5, 5, 5, 1, -8 },
  { 48, 5, 5, 6, 0, -6 },
  { 52, 3, 2, 3, -1, -1 },
  { 53, 3, 1, 3, 0, -3 },
  { 54, 2, 2, 3, 0, -2 },
  { 55, 5, 7, 5, 0, -7 },
  { 60, 6, 7, 6, 0, -7 },
  { 66, 4, 7, 6, 1, -7 },
  { 70, 5, 7, 6, 0, -7 },
  { 75, 6, 7, 6, 0, -7 },
  { 81, 6, 7, 6, 0, -7 },
  { 87, 6, 7, 6, 0, -7 },
  { 93, 6, 7, 6, 0, -7 },
  { 99, 6, 7, 6, 0, -7 },
  { 105, 6, 7, 6, 0, -7 },
  { 111, 5, 7, 6, 1, -7 },
  { 116, 3, 6, 3, 0, -6 },
  { 119, 4, 7, 3, -1, -6 },
  { 123, 5, 5, 6, 0, -6 },
  { 127, 5, 3, 6, 0, -5 },
  { 129, 5, 5, 6, 0, -6 },
  { 133, 4, 7, 5, 1, -7 },
  { 137, 9, 8, 9, 0, -7 },
  { 146, 7, 7, 7, -1, -7 },
  { 153, 6, 7, 6, 0, -7 },
  { 159, 6, 7, 6, 1, -7 },
  { 165, 7, 7, 7, 0, -7 },
  { 172, 6, 7, 6, 0, -7 },
  { 178, 6, 7, 6, 0, -7 },
  { 184, 6, 7, 7, 1, -7 },
  { 190, 7, 7, 7, 0, -7 },
  { 197, 5, 7, 4, 0, -7 },
  { 202, 6, 9, 4, -2, -7 },
  { 209, 7, 7, 7, 0, -7 },
  { 216, 5, 7, 5, 0, -7 },
  { 221, 9, 7, 9, 0, -7 },
  { 229, 8, 7, 8, 0, -7 },
  { 236, 6, 7, 7, 1, -7 },
  { 242, 6, 7, 6, 0, -7 },
  { 248, 6, 9, 7, 1, -7 },
  { 255, 6, 7, 7, 0, -7 },
  { 261, 6, 7, 5, 0, -7 },
  { 267, 5, 7, 6, 1, -7 },
  { 272, 6, 7, 7, 1, -7 },
  { 278, 6, 7, 6, 1, -7 },
  { 284, 9, 7, 9, 1, -7 },
  { 292, 8, 7, 7, -1, -7 },
  { 299, 6, 7, 6, 1, -7 },
  { 305, 6, 7, 5, 0, -7 },
  { 311, 4, 9, 4, 0, -7 },
  { 316, 3, 7, 5, 1, -7 },
  { 319, 5, 9, 4, -1, -7 },
  { 325, 5, 5, 5, 0, -7 },
  { 329, 5, 1, 5, -1, 1 },
  { 330, 3, 2, 4, 1, -8 },
  { 331, 6, 6, 6, 0, -6 },
  { 336, 6, 8, 6, 0, -8 },
  { 342, 5, 6, 5, 0, -6 },
  { 346, 6, 8, 6, 0, -8 },
  { 352, 6, 6, 6, 0, -6 },
  { 357, 6, 10, 4, -1, -8 },
  { 365, 6, 8, 6, 0, -6 },
  { 371, 6, 8, 6, 0, -8 },
  { 377, 4, 8, 3, 0, -8 },
  { 381, 5, 10, 3, -1, -8 },
  { 388, 7, 8, 6, 0, -8 },
  { 395, 4, 8, 3, 0, -8 },
  { 399, 9, 6, 9, 0, -6 },
  { 406, 6, 6, 6, 0, -6 },
  { 411, 6, 6, 6, 0, -6 },
  { 416, 6, 8, 6, 0, -6 },
  { 422, 6, 8, 6, 0, -6 },
  { 428, 5, 6, 4, 0, -6 },
  { 432, 5, 6, 5, 0, -6 },
  { 436, 5, 7, 5, 0, -7 },
  { 441, 6, 6, 6, 0, -6 },
  { 446, 6, 6, 5, 0, -6 },
  { 451, 9, 6, 8, 0, -6 },
  { 458, 7, 6, 6, -1, -6 },
  { 464, 7, 8, 5, -1, -6 },
  { 471, 5, 6, 5, 0, -6 },
  { 475, 4, 9, 4, 0, -7 },
  { 480, 1, 10, 6, 2, -8 },
  { 482, 5, 9, 4, -1, -7 },
  { 488, 5, 1, 6, 0, -4 },
};

const GFXfont NotoSans_BlackItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_BLACKITALIC10PT7B_H_
