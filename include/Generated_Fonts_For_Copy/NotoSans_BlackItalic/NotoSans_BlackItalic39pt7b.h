#ifndef _NOTOSANS_BLACKITALIC39PT7B_H_
#define _NOTOSANS_BLACKITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x01, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFC, 0x00, 0x3F,
  0x3F, 0x9F, 0x9F, 0x8F, 0xCF, 0xCF, 0xC7, 0xE7, 0xE3, 0xE3, 0xF3, 0xF1,
  0xF1, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x7E, 0x3E, 0x00, 0x00, 0x3E, 0x3F,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x01, 0xF1, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F,
  0x80, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0xFC, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFD, 0xF0, 0xFC, 0xE0, 0x87, 0xE7, 0x00, 0x3F, 0x78, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0x7E, 0x40,
  0x73, 0xF3, 0xC3, 0x9F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xFC, 0x00, 0xFC,
  0x07, 0xFF, 0x00, 0x7C, 0x07, 0xFF, 0x80, 0x7C, 0x07, 0xFF, 0xC0, 0x7E,
  0x03, 0xF3, 0xF0, 0x7E, 0x01, 0xF1, 0xF8, 0x3E, 0x00, 0xF8, 0xFC, 0x3E,
  0x00, 0xFC, 0x7C, 0x3F, 0x00, 0x7E, 0x3E, 0x3F, 0x00, 0x3F, 0x3F, 0x1F,
  0x00, 0x1F, 0x9F, 0x9F, 0x1F, 0x8F, 0xDF, 0x9F, 0x9F, 0xF3, 0xFF, 0xDF,
  0x9F, 0xF9, 0xFF, 0xCF, 0x9F, 0xFE, 0x7F, 0xCF, 0x9F, 0xFF, 0x1F, 0xCF,
  0xCF, 0xCF, 0x80, 0x0F, 0xC7, 0xC7, 0xC0, 0x07, 0xC7, 0xE3, 0xE0, 0x07,
  0xE3, 0xF1, 0xF0, 0x07, 0xE1, 0xF8, 0xF8, 0x07, 0xE0, 0xF8, 0xFC, 0x03,
  0xE0, 0x7C, 0x7E, 0x03, 0xF0, 0x3F, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0x03,
  0xF0, 0x07, 0xFF, 0x01, 0xF0, 0x03, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF0, 0xFC,
  0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE7, 0xF0, 0x7F, 0xF8,
  0x7F, 0x1F, 0xFF, 0x0F, 0xF3, 0xFF, 0xF8, 0xFE, 0x7F, 0xFF, 0xDF, 0xE7,
  0xFB, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xCF, 0xF0, 0xFF, 0xF8, 0xFF, 0x0F,
  0xFF, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xE7, 0xFC, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0x0F, 0x80, 0xF9, 0xF0, 0x1F, 0xBC,
  0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x0F, 0xFF, 0x87, 0xFF,
  0xF1, 0xFF, 0x86, 0x7F, 0xF8, 0x1F, 0xDF, 0x01, 0xF3, 0xE0, 0x1E, 0x7E,
  0x01, 0x87, 0xE0, 0x00, 0xF0, 0x00, 0x10, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC7, 0xF1, 0xFC, 0xFE, 0x3F,
  0x8F, 0xC7, 0xF1, 0xF8, 0x7C, 0x3F, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFE, 0x7F, 0xEF, 0xFE, 0x1E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x7F, 0x9F, 0xE7, 0xF8, 0xFF, 0x3F, 0xC3, 0xF9, 0xFC, 0x1F, 0xDF, 0xE0,
  0xFE, 0xFF, 0x0F, 0xF7, 0xF0, 0x7F, 0xBF, 0x83, 0xFD, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x7F, 0xBF, 0xC3, 0xFD, 0xFE, 0x1F,
  0xCF, 0xF1, 0xFE, 0x7F, 0x8F, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0x7F, 0x1F, 0x9F, 0xC3, 0xCF, 0xE0, 0xC3,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3E, 0x3F, 0xC0, 0x60, 0x7F, 0x01,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0C, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x60, 0x0F, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFD, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x81, 0xFC,
  0xFE, 0x07, 0xE3, 0xF8, 0x3F, 0x0F, 0xE1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF3, 0x00,
  0x7F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0xC0, 0x1F, 0xDF, 0xE1, 0xFD,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xF3, 0xFC,
  0xFF, 0x1F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x3F, 0xCF, 0xE1,
  0xFE, 0x7F, 0x0F, 0xE3, 0xFD, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x88, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xF3, 0xFC, 0x7F, 0x0F, 0xE3,
  0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFF, 0x3F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE3, 0xFC, 0xFF, 0x3F, 0xC3, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE,
  0x7F, 0x07, 0xF3, 0xFC, 0x7F, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x8F,
  0xEF, 0xF0, 0xFE, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F,
  0xEF, 0xE3, 0xFC, 0xFE, 0x0F, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF8, 0xEF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x07, 0xE0, 0x00, 0x70, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xFE,
  0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03,
  0xF8, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x1F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0xE0,
  0xFE, 0x40, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x7E, 0x3F, 0x81, 0xF0, 0x7E, 0x3F, 0x07, 0xFF, 0x3E, 0x7E, 0x1F,
  0xFF, 0x3F, 0x7C, 0x3F, 0xFF, 0x1F, 0x7C, 0x7F, 0xBE, 0x1F, 0xF8, 0x7E,
  0x3E, 0x1F, 0xF8, 0xFC, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8,
  0x7C, 0x3E, 0xF9, 0xF8, 0x7C, 0x3E, 0xF9, 0xF8, 0x7C, 0x3E, 0xF9, 0xF8,
  0xFC, 0x7C, 0xF9, 0xF9, 0xFC, 0xFC, 0xF8, 0xFF, 0xFF, 0xF8, 0xF8, 0xFF,
  0xFF, 0xF0, 0xF8, 0x7F, 0xBF, 0xE0, 0xFC, 0x3E, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x04, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x3F, 0x00,
  0x1F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F,
  0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0xFE,
  0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0xFF,
  0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xCF, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xC7, 0xF8,
  0x7F, 0x8F, 0xE1, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xF0, 0x3C, 0x3F, 0xE0, 0x08, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF3, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0,
  0xFF, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x3F, 0x80, 0xFF, 0x3F, 0x81, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x87,
  0xFC, 0x7F, 0x0F, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xE0, 0x78, 0x7F, 0xC0, 0x08, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x2F, 0xF0, 0xFF,
  0xE7, 0xF8, 0x7F, 0xF3, 0xFC, 0x7F, 0xF9, 0xFE, 0x3F, 0xFC, 0xFF, 0x1F,
  0xFE, 0x7F, 0x8F, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0,
  0x3F, 0xC7, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0,
  0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xF0, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFE,
  0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x03, 0x3F, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x07, 0xF0, 0x7F, 0xC0, 0x7F, 0x07,
  0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF3, 0xFE, 0x00,
  0xFE, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFD,
  0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0,
  0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x1F,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3E,
  0xFC, 0x0F, 0xDF, 0x0F, 0xDF, 0x81, 0xFB, 0xE1, 0xF7, 0xF0, 0x3F, 0x7C,
  0x7E, 0xFE, 0x0F, 0xEF, 0x8F, 0x9F, 0xC1, 0xFD, 0xF1, 0xF3, 0xF0, 0x3F,
  0xBE, 0x7E, 0xFE, 0x07, 0xE7, 0xCF, 0x9F, 0xC0, 0xFC, 0xFB, 0xF3, 0xF8,
  0x3F, 0x9F, 0x7C, 0x7F, 0x07, 0xF3, 0xFF, 0x8F, 0xC0, 0xFE, 0x7F, 0xE3,
  0xF8, 0x1F, 0x8F, 0xFC, 0x7F, 0x03, 0xF1, 0xFF, 0x0F, 0xE0, 0xFE, 0x3F,
  0xE1, 0xF8, 0x1F, 0xC7, 0xF8, 0x3F, 0x03, 0xF8, 0xFF, 0x0F, 0xE0, 0x7E,
  0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFC, 0x1F, 0xF8, 0x07, 0xF0,
  0x7F, 0xE0, 0x1F, 0xC1, 0xFF, 0x80, 0x7E, 0x07, 0xFE, 0x03, 0xF8, 0x3F,
  0xFC, 0x0F, 0xE0, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF,
  0x83, 0xF0, 0x3F, 0xFE, 0x1F, 0xC1, 0xFD, 0xF8, 0x7F, 0x07, 0xE7, 0xE1,
  0xFC, 0x1F, 0x9F, 0xC7, 0xE0, 0x7E, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0xFE,
  0x0F, 0xE3, 0xFB, 0xF8, 0x3F, 0x8F, 0xEF, 0xE0, 0xFC, 0x3F, 0xBF, 0x03,
  0xF0, 0x7F, 0xFC, 0x1F, 0xC1, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xC1, 0xFC,
  0x0F, 0xFE, 0x07, 0xE0, 0x3F, 0xF8, 0x1F, 0x80, 0xFF, 0xE0, 0xFE, 0x03,
  0xFF, 0x83, 0xF8, 0x07, 0xFE, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0x0F, 0xF8,
  0xFF, 0x81, 0xFE, 0x3F, 0xC0, 0x3F, 0x9F, 0xF0, 0x0F, 0xE7, 0xF8, 0x03,
  0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF0,
  0x03, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xCF,
  0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0xFF,
  0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFC, 0xFF, 0x87, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3,
  0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x1F, 0xE1, 0xFC, 0x7F, 0xC3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE1, 0xFF, 0x0F, 0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0xC0, 0x3F, 0x9F, 0xE0,
  0x0F, 0xE7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF,
  0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F,
  0xBF, 0xC0, 0x1F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x07, 0xFC, 0xFF, 0x01,
  0xFE, 0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xE1,
  0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x1F, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0xFE, 0x7F, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0xFE, 0x0F,
  0xE1, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xFC, 0xFF, 0x07, 0xF9, 0xFE,
  0x0F, 0xF3, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F,
  0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x7F, 0x83, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x88, 0x03, 0xFC, 0x70, 0x1F, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x81,
  0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F,
  0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03,
  0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0x7E, 0x0F,
  0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0x03, 0xFD, 0xFC, 0x07, 0xF8,
  0x1F, 0xCF, 0xE0, 0x7F, 0xC0, 0xFE, 0x7F, 0x03, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0xF0, 0x7F, 0x1F, 0xC1, 0xFF, 0x87, 0xF8, 0xFE, 0x0F, 0xFC, 0x3F,
  0x87, 0xF0, 0xFF, 0xE1, 0xFC, 0x3F, 0x87, 0xFF, 0x1F, 0xC1, 0xFC, 0x7F,
  0xF8, 0xFE, 0x0F, 0xE3, 0xEF, 0xC7, 0xE0, 0x7F, 0x3F, 0x7E, 0x7F, 0x03,
  0xF9, 0xFB, 0xF3, 0xF8, 0x1F, 0xCF, 0x9F, 0xBF, 0x80, 0xFE, 0xFC, 0xFD,
  0xFC, 0x07, 0xF7, 0xE7, 0xEF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0xFF,
  0xF1, 0xF7, 0xE0, 0x07, 0xDF, 0x0F, 0xBF, 0x00, 0x3F, 0xF8, 0x7F, 0xF8,
  0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xF8, 0x0F,
  0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xE1, 0xFF,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F,
  0x9F, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE,
  0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x8F, 0xF0,
  0x3F, 0x8F, 0xE0, 0x3F, 0x9F, 0xE0, 0x3F, 0x9F, 0xC0, 0x1F, 0xBF, 0x80,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xF7, 0xC0, 0x1F, 0x3E, 0x01, 0xF9, 0xF0,
  0x1F, 0x8F, 0xC0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0xFC, 0x0F, 0x87, 0xC0,
  0x3E, 0x7E, 0x01, 0xF7, 0xE0, 0x0F, 0xC0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x7F, 0x1F, 0xC7, 0xE1, 0xF0, 0x7C,
  0x01, 0xF1, 0xF8, 0x3F, 0xCF, 0xC3, 0xFF, 0x7E, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0x3F, 0xCF, 0xF1, 0xFE, 0xFF, 0x0F, 0xF7,
  0xF8, 0x7F, 0x3F, 0xC3, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07,
  0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF3, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC1, 0xFC, 0x7F, 0x0F, 0xF1,
  0xFC, 0x3F, 0xC7, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8,
  0x7F, 0x8F, 0xF3, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7E, 0xFF, 0x83, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFC,
  0x31, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x18, 0xFF, 0xFE, 0x3F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x01, 0xE3,
  0xF8, 0x0F, 0xF7, 0xF0, 0x3F, 0xEF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x1F, 0xF3, 0xFC, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xF1,
  0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFD, 0xF8, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF3, 0xFC, 0xFF, 0x7F, 0x87, 0xF7, 0xF0, 0xFF, 0xFF, 0x0F,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x08, 0xFF, 0x07, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x7E, 0x03, 0xFC, 0xFC,
  0x0F, 0xFD, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xFC, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0xFF,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFE, 0xFE, 0x00, 0xF9, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x80, 0x3F, 0xC1, 0xF0, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF3,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0x1F, 0xC7, 0xF8, 0x7F, 0x1F, 0xE1, 0xFC, 0x7F,
  0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF9, 0xFE, 0x1F, 0xC7,
  0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x0F, 0xF3, 0xFC, 0x3F, 0xC0, 0x01,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE3, 0xFC, 0x03, 0xF9, 0xFE, 0x00, 0xFE,
  0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F,
  0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x3E,
  0x01, 0xF9, 0xFE, 0x3F, 0xE0, 0x7E, 0xFF, 0xDF, 0xF8, 0x3F, 0xFF, 0xF7,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x1F,
  0xF1, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x1F, 0xE1, 0xFE, 0x1F, 0xC7, 0xF8,
  0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xF0, 0xFF, 0x3F,
  0xC3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x83, 0xF8,
  0xFE, 0x0F, 0xE1, 0xFE, 0x3F, 0x87, 0xF8, 0x7F, 0x9F, 0xE1, 0xFE, 0x1F,
  0xC7, 0xF8, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF0,
  0xFF, 0x3F, 0xC3, 0xFC, 0x3F, 0xC0, 0x07, 0xE3, 0xE0, 0x1F, 0xBF, 0xE0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0x1F, 0xC7, 0xF8, 0x7F, 0x1F, 0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x1F,
  0xC7, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F,
  0xE0, 0xFE, 0x3F, 0x87, 0xF9, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC1,
  0xFC, 0x7F, 0x0F, 0xF3, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF8,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFF, 0x7F, 0x8F,
  0xF7, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0xFE, 0x1F, 0xEF, 0xE1, 0xFE, 0xFF,
  0x3F, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0xFF, 0x80, 0x01, 0xF9, 0xF0, 0x01, 0xFB, 0xFC, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x07,
  0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F,
  0xF1, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xDF, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xF1, 0xF8, 0x3F, 0xCF, 0xC3, 0xFF, 0x7E, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF9, 0xFF, 0x3F, 0xCF, 0xF1, 0xFE, 0x7F, 0x0F, 0xF7, 0xF8,
  0x7F, 0x3F, 0xC3, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xE3,
  0xF8, 0x7F, 0x1F, 0xC7, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xDF, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE3, 0xE0,
  0xFC, 0xF8, 0x1F, 0xBF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFF, 0x8F, 0xE1, 0xC3, 0xF8, 0x10, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF2,
  0x03, 0xFC, 0xC0, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0xF8, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0x87, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00,
  0x1F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F,
  0x83, 0xF8, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x9F, 0xE1, 0xFC, 0x7F, 0x07,
  0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xE3,
  0xF8, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0x8F, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFB, 0xF0, 0x7F, 0xDF, 0xC0, 0xFE, 0x7E,
  0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFD, 0xFC, 0x1F, 0xEF,
  0xE0, 0xFE, 0x7F, 0x0F, 0xF3, 0xF8, 0x7F, 0x0F, 0xC7, 0xF8, 0x7E, 0x3F,
  0x83, 0xF3, 0xFC, 0x1F, 0x9F, 0xC0, 0xFC, 0xFE, 0x07, 0xEF, 0xE0, 0x3F,
  0x7E, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0xFF, 0xFE, 0x1F, 0xF0, 0xFE, 0xFE,
  0x1F, 0xF0, 0xFE, 0xFE, 0x1F, 0xF1, 0xFC, 0xFE, 0x3F, 0xF1, 0xFC, 0xFE,
  0x3F, 0xF3, 0xF8, 0xFE, 0x7D, 0xE3, 0xF8, 0xFE, 0x7D, 0xE3, 0xF0, 0xFE,
  0x7F, 0xE7, 0xF0, 0x7E, 0xFB, 0xE7, 0xF0, 0x7E, 0xFB, 0xEF, 0xE0, 0x7E,
  0xFB, 0xEF, 0xE0, 0x7F, 0xF3, 0xEF, 0xC0, 0x7F, 0xF3, 0xFF, 0xC0, 0x7F,
  0xE3, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x0F, 0xE1,
  0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF7, 0xF0,
  0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8,
  0x3F, 0x81, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F,
  0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F,
  0xF0, 0x3F, 0x87, 0xF0, 0x0F, 0xC7, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF9,
  0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xC0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xA0, 0x07, 0xE0,
};

const GFXglyph NotoSans_BlackItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 28, 12, 0, -28 },
  { 47, 17, 10, 18, 3, -28 },
  { 69, 26, 28, 25, 0, -28 },
  { 160, 21, 32, 23, 1, -30 },
  { 244, 33, 28, 36, 2, -28 },
  { 360, 28, 28, 29, 0, -28 },
  { 458, 8, 10, 9, 3, -28 },
  { 468, 16, 35, 15, 1, -29 },
  { 538, 16, 35, 15, -3, -29 },
  { 608, 19, 20, 21, 3, -30 },
  { 656, 19, 19, 23, 2, -23 },
  { 702, 10, 10, 12, -2, -5 },
  { 715, 12, 6, 13, 0, -13 },
  { 724, 8, 7, 12, 0, -7 },
  { 731, 23, 28, 18, -2, -28 },
  { 812, 21, 28, 23, 1, -28 },
  { 886, 18, 28, 23, 3, -28 },
  { 949, 22, 28, 23, -1, -28 },
  { 1026, 21, 28, 23, 0, -28 },
  { 1100, 22, 28, 23, 0, -28 },
  { 1177, 22, 28, 23, 0, -28 },
  { 1254, 21, 28, 23, 2, -28 },
  { 1328, 23, 28, 23, 1, -28 },
  { 1409, 21, 28, 23, 1, -28 },
  { 1483, 20, 28, 23, 2, -28 },
  { 1553, 12, 22, 12, 0, -22 },
  { 1586, 14, 27, 12, -2, -22 },
  { 1634, 19, 22, 23, 2, -25 },
  { 1687, 19, 14, 23, 2, -21 },
  { 1721, 19, 22, 23, 2, -25 },
  { 1774, 17, 28, 19, 3, -28 },
  { 1834, 32, 32, 35, 2, -28 },
  { 1962, 26, 28, 26, -2, -28 },
  { 2053, 23, 28, 25, 1, -28 },
  { 2134, 24, 28, 25, 2, -28 },
  { 2218, 24, 28, 27, 1, -28 },
  { 2302, 22, 28, 22, 1, -28 },
  { 2379, 22, 28, 22, 1, -28 },
  { 2456, 25, 28, 27, 2, -28 },
  { 2544, 27, 28, 28, 1, -28 },
  { 2639, 20, 28, 17, -1, -28 },
  { 2709, 21, 37, 15, -6, -28 },
  { 2807, 28, 28, 26, 1, -28 },
  { 2905, 17, 28, 21, 1, -28 },
  { 2965, 35, 28, 35, 1, -28 },
  { 3088, 30, 28, 31, 1, -28 },
  { 3193, 26, 28, 29, 2, -28 },
  { 3284, 23, 28, 24, 1, -28 },
  { 3365, 26, 35, 29, 2, -28 },
  { 3479, 23, 28, 25, 1, -28 },
  { 3560, 21, 28, 21, 1, -28 },
  { 3634, 21, 28, 22, 3, -28 },
  { 3708, 26, 28, 27, 2, -28 },
  { 3799, 24, 28, 24, 3, -28 },
  { 3883, 37, 28, 36, 3, -28 },
  { 4013, 31, 28, 26, -2, -28 },
  { 4122, 24, 28, 24, 3, -28 },
  { 4206, 25, 28, 21, -2, -28 },
  { 4294, 18, 36, 14, -1, -29 },
  { 4375, 11, 28, 18, 4, -28 },
  { 4414, 18, 36, 14, -3, -29 },
  { 4495, 21, 18, 21, 0, -28 },
  { 4543, 19, 4, 18, -4, 3 },
  { 4553, 9, 6, 14, 6, -30 },
  { 4560, 21, 22, 24, 2, -22 },
  { 4618, 22, 30, 24, 0, -30 },
  { 4701, 18, 22, 20, 2, -22 },
  { 4751, 23, 30, 24, 2, -30 },
  { 4838, 20, 22, 23, 2, -22 },
  { 4893, 24, 39, 16, -4, -30 },
  { 5010, 23, 31, 24, 0, -22 },
  { 5100, 22, 30, 24, 0, -30 },
  { 5183, 14, 30, 13, 0, -30 },
  { 5236, 19, 39, 13, -5, -30 },
  { 5329, 26, 30, 24, 0, -30 },
  { 5427, 14, 30, 13, 0, -30 },
  { 5480, 34, 22, 36, 0, -22 },
  { 5574, 22, 22, 24, 0, -22 },
  { 5635, 20, 22, 24, 2, -22 },
  { 5690, 24, 31, 24, -2, -22 },
  { 5783, 21, 31, 24, 2, -22 },
  { 5865, 19, 22, 17, 0, -22 },
  { 5918, 18, 22, 20, 1, -22 },
  { 5968, 17, 26, 18, 1, -26 },
  { 6024, 22, 22, 24, 2, -22 },
  { 6085, 21, 22, 21, 2, -22 },
  { 6143, 32, 22, 32, 2, -22 },
  { 6231, 27, 22, 22, -2, -22 },
  { 6306, 25, 31, 21, -2, -22 },
  { 6403, 21, 22, 19, -1, -22 },
  { 6461, 17, 34, 14, 0, -28 },
  { 6534, 6, 38, 22, 8, -29 },
  { 6563, 16, 34, 14, -2, -28 },
  { 6631, 19, 7, 23, 2, -17 },
};

const GFXfont NotoSans_BlackItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_BLACKITALIC39PT7B_H_
