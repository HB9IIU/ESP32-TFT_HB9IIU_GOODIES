#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_BlackItalic
// Headers: 67

#include "NotoSans_BlackItalic6pt7b.h"
#include "NotoSans_BlackItalic7pt7b.h"
#include "NotoSans_BlackItalic8pt7b.h"
#include "NotoSans_BlackItalic9pt7b.h"
#include "NotoSans_BlackItalic10pt7b.h"
#include "NotoSans_BlackItalic11pt7b.h"
#include "NotoSans_BlackItalic12pt7b.h"
#include "NotoSans_BlackItalic13pt7b.h"
#include "NotoSans_BlackItalic14pt7b.h"
#include "NotoSans_BlackItalic15pt7b.h"
#include "NotoSans_BlackItalic16pt7b.h"
#include "NotoSans_BlackItalic17pt7b.h"
#include "NotoSans_BlackItalic18pt7b.h"
#include "NotoSans_BlackItalic19pt7b.h"
#include "NotoSans_BlackItalic20pt7b.h"
#include "NotoSans_BlackItalic21pt7b.h"
#include "NotoSans_BlackItalic22pt7b.h"
#include "NotoSans_BlackItalic23pt7b.h"
#include "NotoSans_BlackItalic24pt7b.h"
#include "NotoSans_BlackItalic25pt7b.h"
#include "NotoSans_BlackItalic26pt7b.h"
#include "NotoSans_BlackItalic27pt7b.h"
#include "NotoSans_BlackItalic28pt7b.h"
#include "NotoSans_BlackItalic29pt7b.h"
#include "NotoSans_BlackItalic30pt7b.h"
#include "NotoSans_BlackItalic31pt7b.h"
#include "NotoSans_BlackItalic32pt7b.h"
#include "NotoSans_BlackItalic33pt7b.h"
#include "NotoSans_BlackItalic34pt7b.h"
#include "NotoSans_BlackItalic35pt7b.h"
#include "NotoSans_BlackItalic36pt7b.h"
#include "NotoSans_BlackItalic37pt7b.h"
#include "NotoSans_BlackItalic38pt7b.h"
#include "NotoSans_BlackItalic39pt7b.h"
#include "NotoSans_BlackItalic40pt7b.h"
#include "NotoSans_BlackItalic41pt7b.h"
#include "NotoSans_BlackItalic42pt7b.h"
#include "NotoSans_BlackItalic43pt7b.h"
#include "NotoSans_BlackItalic44pt7b.h"
#include "NotoSans_BlackItalic45pt7b.h"
#include "NotoSans_BlackItalic46pt7b.h"
#include "NotoSans_BlackItalic47pt7b.h"
#include "NotoSans_BlackItalic48pt7b.h"
#include "NotoSans_BlackItalic49pt7b.h"
#include "NotoSans_BlackItalic50pt7b.h"
#include "NotoSans_BlackItalic51pt7b.h"
#include "NotoSans_BlackItalic52pt7b.h"
#include "NotoSans_BlackItalic53pt7b.h"
#include "NotoSans_BlackItalic54pt7b.h"
#include "NotoSans_BlackItalic55pt7b.h"
#include "NotoSans_BlackItalic56pt7b.h"
#include "NotoSans_BlackItalic57pt7b.h"
#include "NotoSans_BlackItalic58pt7b.h"
#include "NotoSans_BlackItalic59pt7b.h"
#include "NotoSans_BlackItalic60pt7b.h"
#include "NotoSans_BlackItalic61pt7b.h"
#include "NotoSans_BlackItalic62pt7b.h"
#include "NotoSans_BlackItalic63pt7b.h"
#include "NotoSans_BlackItalic64pt7b.h"
#include "NotoSans_BlackItalic65pt7b.h"
#include "NotoSans_BlackItalic66pt7b.h"
#include "NotoSans_BlackItalic67pt7b.h"
#include "NotoSans_BlackItalic68pt7b.h"
#include "NotoSans_BlackItalic69pt7b.h"
#include "NotoSans_BlackItalic70pt7b.h"
#include "NotoSans_BlackItalic71pt7b.h"
#include "NotoSans_BlackItalic72pt7b.h"
