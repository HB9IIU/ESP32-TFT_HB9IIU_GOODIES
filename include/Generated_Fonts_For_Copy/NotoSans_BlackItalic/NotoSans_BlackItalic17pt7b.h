#ifndef _NOTOSANS_BLACKITALIC17PT7B_H_
#define _NOTOSANS_BLACKITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xE3, 0x8E, 0x39, 0xC7, 0x1C, 0x01, 0x8F, 0x38, 0xEF, 0x9B,
  0x76, 0xE0, 0x0E, 0xC1, 0x98, 0x37, 0x3F, 0xF7, 0xFE, 0x37, 0x06, 0xC7,
  0xFE, 0xFF, 0xC6, 0xE1, 0xD8, 0x33, 0x00, 0x02, 0x03, 0xE3, 0xFC, 0xFE,
  0x34, 0x0F, 0x03, 0xE0, 0x3E, 0x0F, 0xA2, 0xEF, 0xF9, 0xFC, 0x18, 0x06,
  0x00, 0x7C, 0x39, 0xF1, 0xCE, 0xC6, 0x33, 0x30, 0xCD, 0x83, 0xFF, 0xF7,
  0xB7, 0xC1, 0xBB, 0x0C, 0xEC, 0x73, 0xB1, 0x8F, 0xDC, 0x1E, 0x1F, 0x81,
  0xFC, 0x39, 0xC3, 0x9C, 0x1F, 0x83, 0xF7, 0x7E, 0x7F, 0x7E, 0xE7, 0xEF,
  0x3C, 0xFF, 0xC3, 0xFE, 0xFB, 0x60, 0x1E, 0x71, 0xC3, 0x8E, 0x1C, 0x38,
  0x60, 0xC1, 0x83, 0x06, 0x0E, 0x1C, 0x18, 0x00, 0x1C, 0x18, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x71, 0xC3, 0x0E, 0x38, 0x00, 0x0E, 0x26,
  0x1B, 0x1F, 0xF1, 0xF9, 0xE1, 0xF8, 0x4C, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0x3B, 0x9D, 0xC0, 0x7F, 0xFE, 0x6F, 0xE0, 0x01, 0xC0,
  0xE0, 0x30, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x03,
  0x80, 0x3E, 0x3F, 0x9D, 0xDE, 0xFE, 0x7F, 0x3F, 0x9D, 0xCE, 0xEF, 0x77,
  0x3F, 0x8F, 0x80, 0x0F, 0x1F, 0x7E, 0xFE, 0x6E, 0x0E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x3C, 0x1F, 0x3F, 0xCE, 0xE4, 0x70, 0x38, 0x38, 0x38, 0x38,
  0x78, 0x7F, 0xBF, 0xDF, 0xE0, 0x3F, 0x1F, 0xC4, 0xE0, 0x70, 0x78, 0xF0,
  0x7C, 0x0F, 0x07, 0xE7, 0xFF, 0xDF, 0xC0, 0x03, 0xC1, 0xE0, 0xF8, 0x3E,
  0x1B, 0x8F, 0xC7, 0x73, 0xFE, 0xFF, 0xBF, 0xE0, 0xE0, 0x38, 0x1F, 0xC7,
  0xE3, 0xF8, 0xE0, 0x3E, 0x1F, 0xC3, 0xF8, 0x1E, 0x07, 0xB3, 0xEF, 0xF3,
  0xF8, 0x1F, 0x9F, 0xDE, 0x0E, 0x0E, 0xE7, 0xFB, 0xDD, 0xCE, 0xE7, 0x77,
  0xBF, 0x8F, 0x80, 0x3F, 0xE7, 0xF9, 0xFF, 0x01, 0xC0, 0x78, 0x1E, 0x03,
  0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x00, 0x1F, 0x8F, 0xE3, 0x9C,
  0xEE, 0x3F, 0x87, 0x83, 0xF1, 0xDE, 0xE3, 0xBD, 0xE7, 0xF0, 0xF8, 0x3E,
  0x7F, 0xF7, 0xE7, 0xE7, 0xFF, 0xFF, 0x77, 0x0F, 0x9E, 0xFC, 0xF8, 0x11,
  0xCE, 0x60, 0x00, 0x0C, 0xF7, 0x00, 0x08, 0x71, 0xC6, 0x00, 0x00, 0x00,
  0x79, 0xC6, 0x38, 0x01, 0x03, 0x0F, 0x3C, 0xF0, 0xF0, 0x7E, 0x0F, 0x03,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x3C, 0x0F,
  0x0F, 0x7E, 0xF0, 0xC0, 0x80, 0xFE, 0x7F, 0x67, 0x0F, 0x1E, 0x3C, 0x78,
  0x70, 0x00, 0x70, 0xF0, 0xE0, 0x0F, 0xE0, 0xFF, 0xC7, 0x03, 0x99, 0xF7,
  0xEF, 0xDF, 0x33, 0x3D, 0xDD, 0xF6, 0x66, 0xDF, 0xFB, 0x3B, 0xCE, 0x00,
  0x1C, 0x60, 0x3F, 0x80, 0x10, 0x00, 0x03, 0xC0, 0xF8, 0x1F, 0x87, 0x70,
  0xEE, 0x39, 0xC7, 0x39, 0xFF, 0x3F, 0xEF, 0xFD, 0xC3, 0xF8, 0x70, 0x1F,
  0xC7, 0xF8, 0xF7, 0x9C, 0xE3, 0xBC, 0x7E, 0x1F, 0xE3, 0x9E, 0x73, 0xCF,
  0xF1, 0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xF7, 0xD9, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3F, 0xC7, 0xF0, 0xFC, 0x1F, 0x87, 0xF8, 0xFF, 0x9C,
  0x73, 0x8E, 0x71, 0xDE, 0x3B, 0x8F, 0x71, 0xCF, 0xF9, 0xFE, 0x7F, 0x00,
  0x1F, 0xCF, 0xF3, 0xFC, 0xE0, 0x3F, 0x8F, 0xE7, 0xF1, 0xC0, 0x70, 0x1F,
  0xC7, 0xF3, 0xFC, 0x1F, 0xCF, 0xF3, 0xF8, 0xE0, 0x38, 0x0F, 0xE7, 0xF1,
  0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0x1F, 0xE7, 0xF9, 0xF3, 0x38, 0x0F,
  0x01, 0xCF, 0xB9, 0xF7, 0x1E, 0xE3, 0x9F, 0xF1, 0xFE, 0x1F, 0xC0, 0x1C,
  0x73, 0xC7, 0x3C, 0xF3, 0x8E, 0x3F, 0xE3, 0xFE, 0x7F, 0xE7, 0x1E, 0x71,
  0xC7, 0x1C, 0x71, 0xCF, 0x3C, 0x1F, 0x8F, 0xC3, 0x81, 0xC1, 0xE0, 0xE0,
  0x70, 0x38, 0x1C, 0x1E, 0x1F, 0x9F, 0xC0, 0x03, 0x81, 0xC0, 0xE0, 0xF0,
  0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE7, 0xE3, 0xF1,
  0xE0, 0x1C, 0xF9, 0xE7, 0x0F, 0x70, 0x77, 0x83, 0xF8, 0x1F, 0x81, 0xFC,
  0x0F, 0xF0, 0x73, 0x83, 0x9C, 0x1C, 0xF1, 0xE3, 0x80, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x7F, 0x7F, 0xFF, 0x1E, 0x1F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x6E, 0x36, 0x7C, 0x76, 0xDC, 0x76,
  0xDC, 0x77, 0xDC, 0x77, 0x98, 0x67, 0xB8, 0xE7, 0x38, 0x1E, 0x3C, 0xF8,
  0xE3, 0xE3, 0x8F, 0xCE, 0x3F, 0x38, 0xDD, 0xC7, 0x3F, 0x1C, 0xFC, 0x73,
  0xF1, 0xCF, 0x86, 0x1E, 0x38, 0x78, 0x1F, 0x87, 0xF9, 0xE7, 0xB8, 0x7F,
  0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xE1, 0xDF, 0xF9, 0xFE, 0x1F, 0x00, 0x1F,
  0x8F, 0xF3, 0xFC, 0xE7, 0x39, 0xCF, 0xF7, 0xF9, 0xFC, 0x70, 0x1C, 0x07,
  0x03, 0xC0, 0x1F, 0x87, 0xF9, 0xF7, 0xB8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7F,
  0x0E, 0xE3, 0xDF, 0xF9, 0xFE, 0x1F, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1F,
  0x8F, 0xF3, 0xDC, 0xE7, 0x39, 0xCF, 0xF7, 0xF9, 0xFC, 0x77, 0x9C, 0xE7,
  0x3F, 0xC7, 0x1F, 0x9F, 0xCE, 0x67, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x87,
  0x7F, 0xBF, 0x8F, 0x80, 0x7F, 0xBF, 0xFF, 0xE3, 0x81, 0xC1, 0xE0, 0xE0,
  0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x00, 0x38, 0xEF, 0x3D, 0xC7, 0x38, 0xE7,
  0x1C, 0xE3, 0xBC, 0xF7, 0x1C, 0xE3, 0x9F, 0xF1, 0xFC, 0x1F, 0x00, 0xE1,
  0xFC, 0x3B, 0xCE, 0x79, 0xC7, 0x70, 0xEE, 0x1F, 0x83, 0xF0, 0x7C, 0x0F,
  0x81, 0xE0, 0x3C, 0x00, 0xE1, 0xC7, 0xE3, 0xCF, 0xE3, 0xCE, 0xE7, 0xCE,
  0xE7, 0xDC, 0xEF, 0xDC, 0xEF, 0xD8, 0x6D, 0xF8, 0x7D, 0xF8, 0x79, 0xF0,
  0x79, 0xF0, 0x71, 0xE0, 0x1C, 0x7C, 0x79, 0xC0, 0xEF, 0x03, 0xF8, 0x0F,
  0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xF0, 0x1D, 0xC0, 0xE7, 0x07, 0x9E, 0x3C,
  0x38, 0xF1, 0xEE, 0x79, 0xCE, 0x3B, 0x83, 0xE0, 0x7C, 0x0F, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x3C, 0x00, 0x1F, 0xE3, 0xFC, 0xFF, 0x01, 0xC0,
  0x78, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0xF1, 0xFE, 0x7F, 0xC0, 0x1E,
  0x7C, 0xE1, 0xC3, 0x06, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1E, 0x3C,
  0x00, 0xEE, 0xEE, 0x66, 0x77, 0x77, 0x33, 0x1F, 0x1E, 0x0E, 0x0E, 0x0C,
  0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0xF8, 0xF0, 0x06, 0x07,
  0x07, 0x83, 0x63, 0xB3, 0x99, 0x8F, 0xC3, 0x7F, 0xFF, 0x80, 0xF3, 0x8E,
  0x18, 0x1F, 0xDF, 0xFE, 0xFE, 0x77, 0x3B, 0x9D, 0xDE, 0xFE, 0x3B, 0x00,
  0x1C, 0x07, 0x03, 0xC0, 0xEC, 0x3F, 0x8F, 0xE3, 0xBD, 0xCF, 0x73, 0x9C,
  0xE7, 0x79, 0xFC, 0xEE, 0x00, 0x0C, 0x3F, 0x7E, 0xF0, 0xE0, 0xE0, 0xE0,
  0xF4, 0xFC, 0x7C, 0x01, 0xC0, 0xF0, 0x38, 0x4E, 0x3F, 0x9F, 0xEF, 0x7B,
  0x9C, 0xE7, 0x39, 0xCE, 0xF3, 0xF8, 0x76, 0x00, 0x0C, 0x3F, 0x7F, 0xF7,
  0xFF, 0xFE, 0xE0, 0xE2, 0xFE, 0x7E, 0x03, 0xE0, 0xF8, 0x1D, 0x03, 0xA1,
  0xF8, 0x3F, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x3F, 0x07, 0xC0, 0xF0, 0x00, 0x0C, 0x07, 0xF3, 0xFD, 0xEF, 0x73,
  0x9C, 0xE7, 0x39, 0xDE, 0x7F, 0x0F, 0xC0, 0x73, 0x3C, 0xFE, 0x3F, 0x00,
  0x1C, 0x07, 0x03, 0xC0, 0xE4, 0x3F, 0x8F, 0xF3, 0x9D, 0xEF, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0xF7, 0x80, 0x1C, 0x71, 0x80, 0x38, 0xE3, 0x9E, 0x71,
  0xC7, 0x1C, 0xF0, 0x07, 0x07, 0x06, 0x00, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C,
  0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0xF8, 0xF8, 0xF0, 0x1C, 0x03, 0x80, 0xF0,
  0x1C, 0x03, 0x9E, 0x77, 0x8F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xDE, 0x3B,
  0xCF, 0x3C, 0x1C, 0x73, 0xCE, 0x38, 0xE3, 0x9E, 0x71, 0xC7, 0x1C, 0xF0,
  0x01, 0x08, 0x7F, 0x7C, 0xFF, 0xF9, 0xCE, 0x77, 0xBC, 0xEE, 0x73, 0xDC,
  0xE7, 0x39, 0xCE, 0x73, 0x9D, 0xEF, 0x78, 0x01, 0x0F, 0xE3, 0xFC, 0xE7,
  0x7B, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0xBD, 0xE0, 0x0C, 0x1F, 0x9F, 0xDE,
  0xFE, 0x7F, 0x3B, 0x9D, 0xDE, 0xFE, 0x3E, 0x00, 0x01, 0x83, 0xF8, 0x7F,
  0x0E, 0xF3, 0x9E, 0x73, 0x8E, 0x71, 0xDE, 0x7F, 0x8E, 0xE1, 0xC0, 0x38,
  0x07, 0x01, 0xE0, 0x00, 0x18, 0x1F, 0xDF, 0xFE, 0xFE, 0x77, 0x3B, 0x9D,
  0xDE, 0xFE, 0x3F, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x01, 0x3F, 0x3F, 0x3D,
  0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0x0C, 0x3F, 0x7F, 0x78, 0x7C, 0x3E,
  0x0E, 0x8E, 0xFE, 0xFC, 0x38, 0x73, 0xFF, 0xF7, 0x1E, 0x38, 0x70, 0xE9,
  0xF3, 0xE0, 0x73, 0xB9, 0xFC, 0xFC, 0xFE, 0x77, 0x3B, 0xBD, 0xFE, 0xF6,
  0x00, 0xE7, 0xF3, 0xBB, 0xDD, 0xCE, 0xE7, 0xE1, 0xF0, 0xF0, 0x70, 0x00,
  0xE7, 0xBF, 0xBC, 0xEE, 0xF3, 0xBB, 0xDC, 0xFB, 0x73, 0xEF, 0x8F, 0xBE,
  0x3C, 0xF0, 0xF3, 0xC0, 0x3D, 0xF1, 0xDC, 0x1F, 0x80, 0xF8, 0x0F, 0x01,
  0xF0, 0x3B, 0x87, 0xB8, 0xF3, 0xC0, 0x39, 0xE7, 0x38, 0xEF, 0x1D, 0xC3,
  0xB8, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0x83, 0xE0, 0x7C, 0x0F, 0x00,
  0x3F, 0xBF, 0x83, 0x83, 0xC3, 0xC3, 0xC1, 0xC1, 0xFC, 0xFE, 0x00, 0x0E,
  0x3C, 0x70, 0xC3, 0x87, 0x3C, 0x70, 0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x78, 0x70, 0xE1, 0xC3, 0x87,
  0x8F, 0x3E, 0x70, 0xC1, 0x8F, 0x1C, 0x30, 0x00, 0x61, 0xFF, 0xFF, 0x86,
};

const GFXglyph NotoSans_BlackItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 12, 5, 0, -12 },
  { 10, 7, 4, 8, 2, -12 },
  { 14, 11, 12, 11, 0, -12 },
  { 31, 10, 14, 10, 0, -13 },
  { 49, 14, 12, 16, 1, -12 },
  { 70, 12, 12, 12, 0, -12 },
  { 88, 3, 4, 4, 2, -12 },
  { 90, 7, 15, 6, 1, -12 },
  { 104, 7, 15, 6, -1, -12 },
  { 118, 9, 8, 9, 1, -13 },
  { 127, 8, 8, 10, 1, -10 },
  { 135, 5, 4, 5, -1, -2 },
  { 138, 5, 3, 6, 0, -6 },
  { 140, 4, 3, 5, 0, -3 },
  { 142, 10, 12, 8, -1, -12 },
  { 157, 9, 12, 10, 1, -12 },
  { 171, 8, 12, 10, 1, -12 },
  { 183, 9, 12, 10, 0, -12 },
  { 197, 9, 12, 10, 0, -12 },
  { 211, 10, 12, 10, 0, -12 },
  { 226, 10, 12, 10, 0, -12 },
  { 241, 9, 12, 10, 1, -12 },
  { 255, 11, 12, 10, 0, -12 },
  { 272, 10, 12, 10, 0, -12 },
  { 287, 8, 12, 10, 1, -12 },
  { 299, 5, 10, 5, 0, -10 },
  { 306, 6, 12, 5, -1, -10 },
  { 315, 8, 10, 10, 1, -11 },
  { 325, 8, 6, 10, 1, -9 },
  { 331, 8, 10, 10, 1, -11 },
  { 341, 8, 12, 8, 1, -12 },
  { 353, 14, 14, 15, 1, -12 },
  { 378, 11, 12, 11, -1, -12 },
  { 395, 11, 12, 11, 0, -12 },
  { 412, 10, 12, 11, 1, -12 },
  { 427, 11, 12, 12, 0, -12 },
  { 444, 10, 12, 10, 0, -12 },
  { 459, 10, 12, 10, 0, -12 },
  { 474, 11, 12, 12, 1, -12 },
  { 491, 12, 12, 12, 0, -12 },
  { 509, 9, 12, 7, -1, -12 },
  { 523, 9, 16, 6, -3, -12 },
  { 541, 13, 12, 11, 0, -12 },
  { 561, 8, 12, 9, 0, -12 },
  { 573, 16, 12, 15, 0, -12 },
  { 597, 14, 12, 13, 0, -12 },
  { 618, 11, 12, 13, 1, -12 },
  { 635, 10, 12, 11, 0, -12 },
  { 650, 11, 15, 13, 1, -12 },
  { 671, 10, 12, 11, 0, -12 },
  { 686, 9, 12, 9, 0, -12 },
  { 700, 9, 12, 9, 1, -12 },
  { 714, 11, 12, 12, 1, -12 },
  { 731, 11, 12, 10, 1, -12 },
  { 748, 16, 12, 16, 1, -12 },
  { 772, 14, 12, 11, -1, -12 },
  { 793, 11, 12, 10, 1, -12 },
  { 810, 11, 12, 9, -1, -12 },
  { 827, 7, 15, 6, 0, -12 },
  { 841, 4, 12, 8, 2, -12 },
  { 847, 8, 15, 6, -1, -12 },
  { 862, 9, 8, 9, 0, -12 },
  { 871, 9, 2, 8, -2, 1 },
  { 874, 5, 3, 6, 2, -13 },
  { 876, 9, 10, 10, 1, -10 },
  { 888, 10, 13, 10, 0, -13 },
  { 905, 8, 10, 9, 1, -10 },
  { 915, 10, 13, 10, 1, -13 },
  { 932, 8, 10, 10, 1, -10 },
  { 942, 11, 17, 7, -2, -13 },
  { 966, 10, 14, 10, 0, -10 },
  { 984, 10, 13, 11, 0, -13 },
  { 1001, 6, 13, 6, 0, -13 },
  { 1011, 8, 17, 6, -2, -13 },
  { 1028, 11, 13, 10, 0, -13 },
  { 1046, 6, 13, 6, 0, -13 },
  { 1056, 15, 10, 16, 0, -10 },
  { 1075, 10, 10, 11, 0, -10 },
  { 1088, 9, 10, 10, 1, -10 },
  { 1100, 11, 14, 10, -1, -10 },
  { 1120, 9, 14, 10, 1, -10 },
  { 1136, 8, 10, 7, 0, -10 },
  { 1146, 8, 10, 9, 0, -10 },
  { 1156, 7, 11, 8, 1, -11 },
  { 1166, 9, 9, 11, 1, -9 },
  { 1177, 9, 9, 9, 1, -9 },
  { 1188, 14, 9, 14, 1, -9 },
  { 1204, 12, 9, 10, -1, -9 },
  { 1218, 11, 13, 9, -1, -9 },
  { 1236, 9, 9, 8, 0, -9 },
  { 1247, 7, 15, 6, 0, -12 },
  { 1261, 2, 17, 10, 4, -13 },
  { 1266, 7, 15, 6, -1, -12 },
  { 1280, 8, 4, 10, 1, -8 },
};

const GFXfont NotoSans_BlackItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_BLACKITALIC17PT7B_H_
