#ifndef _NOTOSANS_BLACKITALIC30PT7B_H_
#define _NOTOSANS_BLACKITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BlackItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BlackItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F,
  0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x0F,
  0xC3, 0xF0, 0x78, 0x00, 0x7D, 0xFF, 0x9F, 0xF9, 0xEF, 0x9E, 0xF3, 0xEF,
  0x3C, 0xF3, 0xC0, 0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1E,
  0x78, 0x03, 0xC7, 0x83, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF0, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF1, 0xE0, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xC1, 0xE3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x70,
  0x01, 0xF8, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0xEE, 0x3E, 0xE0,
  0x3E, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x03, 0xBE, 0x83, 0xBE, 0xF3, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0x3F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0xE0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0xFC, 0x1E, 0x0F, 0x9E,
  0x1F, 0x07, 0xCF, 0x0F, 0x03, 0xC7, 0x8F, 0x01, 0xE7, 0xCF, 0x00, 0xF3,
  0xCF, 0x80, 0x79, 0xE7, 0x9F, 0x3F, 0xF7, 0xBF, 0xDF, 0xF7, 0x9F, 0xF7,
  0xF7, 0xDF, 0xF8, 0xE3, 0xCF, 0x3C, 0x03, 0xCF, 0x9E, 0x03, 0xC7, 0xCF,
  0x03, 0xE3, 0xC7, 0x81, 0xE1, 0xE7, 0xC1, 0xE0, 0xFB, 0xC1, 0xE0, 0x7F,
  0xE1, 0xF0, 0x1F, 0xE1, 0xF0, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xCF, 0xCF, 0xFC, 0x3E, 0x7F, 0xF9, 0xF9, 0xFB, 0xF7, 0xCF, 0xCF, 0xFF,
  0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0xE3, 0xF8, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xDF, 0xC0, 0x7F, 0xEF, 0xBE, 0xF3,
  0xCF, 0x00, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x3E, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x00,
  0x01, 0x80, 0x03, 0xC0, 0x07, 0x83, 0x1E, 0x07, 0xBC, 0x0F, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x3F, 0x8C, 0xFF, 0x83, 0xEF, 0x03, 0xDF,
  0x01, 0x1E, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1F, 0x3F,
  0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0x7F, 0xBF, 0xDF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F,
  0x3F, 0x3E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0xFC, 0xFD,
  0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0xFC, 0x0F,
  0xE0, 0x7F, 0x87, 0xFE, 0x7F, 0xFB, 0xFF, 0xE7, 0xDF, 0x0E, 0x7C, 0x23,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x78,
  0x01, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3C, 0xFC, 0x08,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x01, 0xF0, 0x07,
  0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x20, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x7F, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x80, 0x7E, 0x78, 0x7F, 0x3F,
  0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xBE, 0x07, 0x9F, 0x07, 0x9F, 0x87, 0xCF, 0xC7, 0xC7, 0xCB,
  0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1F, 0xFC,
  0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xBF, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xF9, 0x00, 0xFC, 0xF0, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF,
  0xF1, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7D, 0xF8, 0x3F, 0xFE, 0x1F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xE7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC,
  0xFC, 0x7E, 0x3E, 0x7E, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0xBF, 0x3F,
  0x1F, 0x3F, 0x1F, 0x3F, 0x3E, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7E, 0xFC, 0xFC, 0x7C, 0xF8, 0x7E, 0xF8, 0x7E, 0xFC,
  0x7C, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x1F, 0xE0, 0x03, 0xC0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xDF, 0x8F, 0xBF, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xCF, 0xEF, 0x8F,
  0xBF, 0x00, 0x7C, 0x01, 0xF9, 0x1F, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF8,
  0x1F, 0xC0, 0x00, 0x07, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x00, 0x01,
  0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0x81,
  0xF0, 0x3C, 0x0F, 0x80, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0,
  0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xE0, 0x03, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7E,
  0x03, 0xFC, 0x3F, 0xF1, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0x60,
  0x00, 0x07, 0x80, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x7F, 0xF8, 0xC3, 0xF0,
  0x0F, 0x80, 0x7E, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFC, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0xF8,
  0x7E, 0x3C, 0x78, 0xFF, 0xCF, 0x78, 0xFF, 0xE7, 0xBC, 0x7C, 0xE3, 0xDE,
  0x78, 0xF1, 0xFE, 0x3C, 0x78, 0xFF, 0x3C, 0x3C, 0x7F, 0x9E, 0x3C, 0x3B,
  0xCF, 0x1E, 0x3D, 0xE7, 0xDF, 0x3C, 0xF3, 0xFF, 0xFE, 0x7C, 0xFF, 0xFE,
  0x1E, 0x3C, 0x7C, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x08, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x7E, 0x3F, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF0, 0x1F, 0x7E, 0x01, 0xF7, 0xE0,
  0x1F, 0xFC, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFC, 0xFE, 0x1F, 0x8F, 0x83, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xF1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC, 0x7E, 0x7F, 0x8F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xE1, 0xC7, 0xF0, 0x11, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x04, 0x3F, 0xDF, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0x7E, 0x0F,
  0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x03, 0xE3,
  0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x0F, 0xC3, 0xE1, 0xFC,
  0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x04, 0x1F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0x83, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x8F,
  0xFB, 0xF3, 0xFE, 0x7E, 0x7F, 0xCF, 0x8F, 0xF9, 0xF1, 0xFF, 0x3E, 0x07,
  0xE7, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0xEF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x83, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0xFC, 0x1F, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0x00, 0x7C, 0x00, 0x07, 0xE1, 0xFC, 0x1F, 0x0F, 0xE0, 0xFC, 0x7F,
  0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E, 0x7E, 0x00, 0xFB, 0xF8, 0x07,
  0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFD, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xF0, 0xFC,
  0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0xE0,
  0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83,
  0xDE, 0x1F, 0xF0, 0xFB, 0xC7, 0xBE, 0x1F, 0x78, 0xFF, 0xC3, 0xEF, 0x3D,
  0xF0, 0x7D, 0xE7, 0xBE, 0x1F, 0xBD, 0xE7, 0xC3, 0xE7, 0xBD, 0xF8, 0x7C,
  0xFF, 0xBE, 0x0F, 0x9F, 0xE7, 0xC1, 0xF3, 0xFC, 0xF8, 0x7E, 0x7F, 0x1F,
  0x0F, 0x8F, 0xE7, 0xE1, 0xF1, 0xF8, 0xF8, 0x3E, 0x3F, 0x1F, 0x0F, 0xC7,
  0xC3, 0xE0, 0x07, 0xF0, 0x1F, 0x07, 0xF0, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F,
  0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x7E, 0x0F, 0x7C, 0x7C, 0x1F,
  0x7C, 0x7C, 0x1F, 0x7C, 0x7C, 0x1F, 0x7E, 0x7C, 0x1F, 0x3E, 0xFC, 0x3F,
  0x3E, 0xF8, 0x3E, 0x3E, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E,
  0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C,
  0x0F, 0xF0, 0xFC, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0x1F, 0xDF, 0xC1, 0xFB, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xC0, 0x7E, 0xFC, 0x1F, 0x9F, 0xEF, 0xF3,
  0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0x1F,
  0xDF, 0xC1, 0xFB, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0xFE,
  0xFC, 0x3F, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x0F, 0xCF, 0xC3, 0xF1, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0xC7,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xDF, 0x83, 0xF7,
  0xE0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E,
  0xFC, 0x0F, 0xC0, 0x01, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3F, 0x0C, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x81,
  0xF8, 0xF3, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x87, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F,
  0x9F, 0x83, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E,
  0x7E, 0x0F, 0x8F, 0xC3, 0xF1, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x0F, 0xFF, 0x81, 0xFB,
  0xF0, 0x7E, 0x7E, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0x83,
  0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0xFC, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0x81,
  0xFF, 0xE0, 0xFC, 0x1F, 0xBF, 0x07, 0xE0, 0xF9, 0xF8, 0x7F, 0x0F, 0xCF,
  0xC3, 0xF8, 0x7C, 0x7E, 0x3F, 0xC3, 0xE3, 0xF1, 0xFE, 0x3F, 0x1F, 0x8F,
  0xF1, 0xF0, 0x7C, 0xF7, 0x9F, 0x83, 0xE7, 0xBC, 0xF8, 0x1F, 0x7D, 0xE7,
  0xC0, 0xF3, 0xCF, 0x7C, 0x07, 0xBE, 0x7B, 0xE0, 0x3D, 0xE3, 0xDF, 0x01,
  0xEF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03,
  0xF1, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x0F,
  0xCF, 0xC0, 0x1F, 0xCF, 0xC0, 0x1F, 0x87, 0xE0, 0x3F, 0x07, 0xE0, 0x7F,
  0x07, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x0F, 0xEF, 0xC3, 0xF1, 0xF8, 0xFE,
  0x3F, 0x1F, 0x83, 0xE7, 0xE0, 0x7C, 0xFC, 0x0F, 0xBF, 0x01, 0xFF, 0xC0,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x1F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x03, 0xFC, 0x0F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x00, 0xF8, 0xF8, 0x78,
  0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E,
  0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x0F, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x1F,
  0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xB8, 0x07, 0xBC, 0x0F, 0x3C, 0x1F,
  0x3C, 0x1E, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0x7F,
  0xFE, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xE0, 0xFC, 0xF8, 0xF8, 0xF0, 0xE0,
  0x03, 0xCF, 0x87, 0xF7, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF3, 0xF9,
  0xF9, 0xF8, 0xFC, 0xFC, 0x7C, 0xFC, 0x3E, 0x7E, 0x1F, 0x3F, 0x1F, 0x9F,
  0x8F, 0xCF, 0xEF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0x7C,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x70, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF,
  0xE3, 0xF3, 0xF1, 0xF1, 0xF9, 0xF8, 0xFC, 0xF8, 0x7E, 0x7C, 0x3F, 0x3E,
  0x3F, 0x3F, 0x1F, 0x9F, 0xDF, 0xCF, 0xFF, 0xC7, 0xFF, 0xE3, 0xDF, 0xE3,
  0xE7, 0xC0, 0x01, 0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x3F, 0xF9, 0xFC,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x04, 0xFE,
  0x71, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x39, 0xF8,
  0x3F, 0x7E, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFC, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0x8F, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xEF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xF7, 0x80,
  0x01, 0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0x3F, 0x3F, 0x7E, 0x3F,
  0x7E, 0x3E, 0x7F, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xFC, 0x00,
  0xFC, 0x08, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x0F,
  0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x80, 0x3F, 0x00,
  0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x2F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xC7, 0xC1, 0xFD, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C,
  0x7E, 0x1F, 0x1F, 0x87, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0x7E, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC3, 0x87, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x78, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xF3, 0xF1, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3E, 0x1F,
  0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xE1, 0xF3, 0xF1,
  0xF8, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x38, 0x00, 0x03, 0xF0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x00, 0x00, 0x3C, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC1, 0x3F, 0x83, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x83, 0xF0,
  0xF8, 0x7E, 0x1F, 0x8F, 0xC1, 0xF9, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xE0,
  0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x07, 0xC3,
  0xF0, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x00,
  0x0F, 0x1E, 0x0F, 0x03, 0xDF, 0xCF, 0xE1, 0xF7, 0xFB, 0xFC, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF1, 0xF0, 0xF8, 0x7C, 0xFC,
  0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xF3, 0xE1, 0xF0, 0xFD,
  0xF8, 0x7C, 0x3E, 0x7E, 0x3F, 0x1F, 0x9F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF1,
  0xF9, 0xF0, 0xF8, 0x7E, 0xFC, 0x7E, 0x1F, 0x00, 0x0F, 0x1E, 0x07, 0xBF,
  0x87, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E, 0x7E,
  0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0x87, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3,
  0xF1, 0xF9, 0xF8, 0xFC, 0xF8, 0x7C, 0xFC, 0x7E, 0x00, 0x01, 0xF0, 0x07,
  0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0xFE, 0x7F,
  0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0x9E, 0x01, 0xEF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xF3, 0xF0, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x0F, 0xC7, 0xC3, 0xF1, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0xBF,
  0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x7E, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x03, 0x8F, 0x87, 0xF7, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF3,
  0xF9, 0xF9, 0xF8, 0xFC, 0xFC, 0x7C, 0xFC, 0x3E, 0x7E, 0x1F, 0x3F, 0x1F,
  0x9F, 0x8F, 0xCF, 0xEF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3E,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0x1C, 0x3D, 0xF1, 0xF7, 0xC7, 0xFF, 0x1F,
  0xF8, 0x7F, 0xE1, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x3F, 0x18, 0xFC, 0x03, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0x7E, 0xC1, 0xFB, 0xFF, 0xEF, 0xFF,
  0x3F, 0xF8, 0x7F, 0xC0, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F,
  0x80, 0x1F, 0x0F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xE1, 0xF1,
  0xF0, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3E, 0x1F, 0x1F, 0x1F,
  0x9F, 0x8F, 0xCF, 0xEF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0x7C, 0x00, 0xFC, 0x1F, 0xFE, 0x1F, 0x9F, 0x0F, 0xCF, 0x87, 0xC7, 0xC7,
  0xE3, 0xE3, 0xE1, 0xF3, 0xF0, 0xF9, 0xF0, 0x7D, 0xF8, 0x3E, 0xF8, 0x0F,
  0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x0F, 0xBE, 0x3F, 0x8F, 0xDF, 0x1F, 0xC7,
  0xCF, 0x8F, 0xE7, 0xE7, 0xCF, 0xF3, 0xE3, 0xE7, 0xF9, 0xF1, 0xF3, 0xBD,
  0xF0, 0xFB, 0xDC, 0xF8, 0x7D, 0xEE, 0xFC, 0x3F, 0xE7, 0x7C, 0x1F, 0xF7,
  0xBE, 0x0F, 0xFB, 0xFE, 0x07, 0xF9, 0xFF, 0x03, 0xFC, 0xFF, 0x01, 0xFC,
  0x7F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xC3, 0xF8,
  0x3F, 0x1F, 0x81, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0x7C,
  0x0F, 0xE3, 0xF0, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF1, 0xF8, 0x7E, 0x0F,
  0x87, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F, 0x80,
  0xF9, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x09, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF8, 0xFF, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7C,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F,
  0x80, 0x7E, 0x03, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x80, 0x3E, 0x03, 0xF8, 0x1F, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0x83,
  0xF8, 0x3F, 0xC1, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0x00, 0x00, 0x7F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0,
};

const GFXglyph NotoSans_BlackItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 21, 9, 0, -21 },
  { 28, 12, 7, 14, 3, -21 },
  { 39, 20, 21, 19, 0, -21 },
  { 92, 16, 25, 17, 1, -23 },
  { 142, 25, 22, 28, 2, -22 },
  { 211, 22, 22, 22, 0, -22 },
  { 272, 6, 7, 7, 3, -21 },
  { 278, 12, 27, 11, 1, -22 },
  { 319, 12, 27, 11, -2, -22 },
  { 360, 15, 15, 16, 2, -23 },
  { 389, 15, 15, 18, 1, -18 },
  { 418, 8, 7, 9, -2, -3 },
  { 425, 9, 4, 10, 0, -10 },
  { 430, 6, 5, 9, 0, -5 },
  { 434, 17, 22, 14, -1, -22 },
  { 481, 16, 22, 17, 1, -22 },
  { 525, 14, 21, 17, 2, -21 },
  { 562, 17, 22, 17, -1, -22 },
  { 609, 17, 22, 17, 0, -22 },
  { 656, 17, 21, 17, 0, -21 },
  { 701, 17, 21, 17, 0, -21 },
  { 746, 17, 22, 17, 1, -22 },
  { 793, 18, 21, 17, 1, -21 },
  { 841, 16, 22, 17, 1, -22 },
  { 885, 15, 22, 17, 2, -22 },
  { 927, 9, 17, 9, 0, -17 },
  { 947, 11, 21, 9, -2, -17 },
  { 976, 15, 16, 18, 1, -19 },
  { 1006, 15, 11, 18, 1, -16 },
  { 1027, 15, 16, 18, 1, -19 },
  { 1057, 14, 22, 15, 2, -22 },
  { 1096, 25, 25, 27, 1, -22 },
  { 1175, 20, 21, 20, -2, -21 },
  { 1228, 19, 21, 19, 0, -21 },
  { 1278, 18, 22, 19, 2, -22 },
  { 1328, 20, 21, 21, 0, -21 },
  { 1381, 18, 21, 17, 0, -21 },
  { 1429, 18, 21, 17, 0, -21 },
  { 1477, 19, 22, 21, 2, -22 },
  { 1530, 22, 21, 21, 0, -21 },
  { 1588, 15, 21, 13, -1, -21 },
  { 1628, 16, 28, 11, -5, -21 },
  { 1684, 22, 21, 20, 0, -21 },
  { 1742, 14, 21, 16, 0, -21 },
  { 1779, 27, 21, 27, 0, -21 },
  { 1850, 24, 21, 24, 0, -21 },
  { 1913, 19, 22, 22, 2, -22 },
  { 1966, 18, 21, 19, 0, -21 },
  { 2014, 19, 27, 22, 2, -22 },
  { 2079, 18, 21, 20, 0, -21 },
  { 2127, 16, 22, 16, 1, -22 },
  { 2171, 16, 21, 17, 2, -21 },
  { 2213, 19, 21, 21, 2, -21 },
  { 2263, 19, 21, 19, 2, -21 },
  { 2313, 29, 21, 28, 2, -21 },
  { 2390, 24, 21, 20, -2, -21 },
  { 2453, 19, 21, 18, 2, -21 },
  { 2503, 19, 21, 16, -1, -21 },
  { 2553, 14, 27, 11, -1, -22 },
  { 2601, 8, 22, 14, 3, -22 },
  { 2623, 14, 27, 11, -2, -22 },
  { 2671, 16, 14, 16, 0, -21 },
  { 2699, 15, 4, 14, -3, 2 },
  { 2707, 7, 5, 11, 4, -23 },
  { 2712, 17, 17, 18, 1, -17 },
  { 2749, 17, 23, 18, 0, -23 },
  { 2798, 14, 17, 15, 1, -17 },
  { 2828, 18, 23, 18, 1, -23 },
  { 2880, 16, 17, 17, 1, -17 },
  { 2914, 18, 30, 12, -3, -23 },
  { 2982, 18, 24, 18, 0, -17 },
  { 3036, 17, 23, 19, 0, -23 },
  { 3085, 11, 23, 10, 0, -23 },
  { 3117, 15, 30, 10, -4, -23 },
  { 3174, 20, 23, 19, 0, -23 },
  { 3232, 11, 23, 10, 0, -23 },
  { 3264, 26, 17, 28, 0, -17 },
  { 3320, 17, 17, 19, 0, -17 },
  { 3357, 16, 17, 18, 1, -17 },
  { 3391, 18, 24, 18, -1, -17 },
  { 3445, 17, 24, 18, 1, -17 },
  { 3496, 14, 17, 13, 0, -17 },
  { 3526, 14, 17, 15, 0, -17 },
  { 3556, 13, 20, 14, 1, -20 },
  { 3589, 17, 17, 19, 1, -17 },
  { 3626, 17, 17, 16, 1, -17 },
  { 3663, 25, 17, 25, 1, -17 },
  { 3717, 21, 17, 17, -2, -17 },
  { 3762, 20, 24, 16, -2, -17 },
  { 3822, 16, 17, 15, -1, -17 },
  { 3856, 13, 26, 11, 0, -21 },
  { 3899, 4, 30, 17, 6, -23 },
  { 3914, 13, 26, 11, -2, -21 },
  { 3957, 15, 5, 18, 1, -13 },
};

const GFXfont NotoSans_BlackItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BlackItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_BlackItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_BLACKITALIC30PT7B_H_
