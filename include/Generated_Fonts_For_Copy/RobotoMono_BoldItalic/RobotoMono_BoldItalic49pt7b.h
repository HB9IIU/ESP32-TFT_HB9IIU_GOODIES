#ifndef _ROBOTOMONO_BOLDITALIC49PT7B_H_
#define _ROBOTOMONO_BOLDITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x3F, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x0F,
  0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E,
  0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78,
  0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3,
  0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x3F,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x78, 0x78,
  0x10, 0xF8, 0x78, 0x3C, 0xF8, 0x78, 0x3C, 0xF8, 0x78, 0x78, 0xF0, 0x78,
  0xF0, 0xF8, 0xF9, 0xF0, 0xF8, 0xF9, 0xE0, 0xFF, 0xF3, 0xC0, 0x7F, 0xF7,
  0xC0, 0x3F, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0xE0, 0x01, 0xE7, 0xFC, 0x03, 0xEF, 0xFC, 0x03, 0xDF, 0xFE, 0x07, 0x9F,
  0x3E, 0x0F, 0x1E, 0x1F, 0x0F, 0x3E, 0x1F, 0x1E, 0x3E, 0x1F, 0x3C, 0x3E,
  0x1E, 0x0C, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x1F, 0x8F, 0xFF, 0x83, 0xF3, 0xFF, 0xF8, 0x7E, 0x7F, 0x7F, 0x0F,
  0x9F, 0xC7, 0xF3, 0xF7, 0xF0, 0xFE, 0x7E, 0xFE, 0x0F, 0xFF, 0x9F, 0xC0,
  0xFF, 0xF3, 0xF0, 0x1F, 0xFC, 0x7F, 0x01, 0xFF, 0x8F, 0xE0, 0x3F, 0xE1,
  0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xEF, 0xE0, 0x3F, 0xF0, 0xFE, 0x00, 0x20, 0x00, 0x00,
  0x3E, 0x7C, 0xF9, 0xF7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF, 0x80,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x18,
  0x1E, 0x03, 0x7C, 0x3C, 0x3E, 0xFE, 0x79, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0x9E, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C,
  0x03, 0xF0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x00, 0xF0, 0x04, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8,
  0xFC, 0x3E, 0x07, 0x00, 0x80, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F,
  0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F,
  0x80, 0x7F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x7F, 0x01, 0xFE, 0x7F,
  0x07, 0xFE, 0x7F, 0x0F, 0xFE, 0x7E, 0x3F, 0xFE, 0x7E, 0x7E, 0xFE, 0x7F,
  0xFC, 0xFE, 0x7F, 0xF0, 0xFE, 0xFF, 0xE0, 0xFC, 0xFF, 0x80, 0xFC, 0xFF,
  0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x7F, 0x03,
  0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC,
  0xFE, 0xE0, 0xFE, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x1F, 0xE0, 0x7F,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F,
  0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x20, 0x00, 0x1F, 0xCF, 0xE0, 0x07,
  0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0x7F,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0xFE, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFA, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0x70,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x3F,
  0x8F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x1F, 0xC1,
  0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x07, 0xEF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0x87,
  0xF9, 0xFE, 0x07, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xE7, 0xF0, 0x3F, 0xCF, 0xF0, 0xFF, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80,
  0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x3F, 0x87, 0xF0,
  0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFC,
  0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x00,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7F, 0x01, 0xFE, 0xFE, 0x07, 0xF9,
  0xFF, 0x3F, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x01,
  0xFF, 0x7E, 0x00, 0x71, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F,
  0xC0, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F,
  0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x78, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x18, 0x00,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFE,
  0x1F, 0xEF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x7C,
  0x00, 0x1E, 0x0F, 0x87, 0xF1, 0xE0, 0xF0, 0xFF, 0xCE, 0x1E, 0x1F, 0xF8,
  0xE1, 0xE3, 0xF3, 0x8E, 0x3C, 0x7C, 0x78, 0xE3, 0xC7, 0x87, 0x8E, 0x78,
  0xF0, 0x70, 0xE7, 0x8F, 0x07, 0x1E, 0x79, 0xF0, 0xF1, 0xE7, 0x1E, 0x0F,
  0x1E, 0xF1, 0xE0, 0xE1, 0xCF, 0x1E, 0x1E, 0x1C, 0xF1, 0xE1, 0xE1, 0xCF,
  0x1E, 0x1E, 0x3C, 0xF1, 0xE1, 0xE3, 0x8F, 0x1E, 0x3E, 0x78, 0xF1, 0xFF,
  0xFF, 0x0F, 0x0F, 0xFF, 0xE0, 0xF0, 0xFC, 0xFC, 0x07, 0x83, 0x07, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01,
  0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x3F, 0x80,
  0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0,
  0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x03,
  0xFC, 0x3F, 0x81, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0,
  0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x83, 0xF0, 0x1F, 0xE0, 0xFE, 0x3F,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x1F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xFF, 0xEF, 0xE0, 0x7F, 0xFB, 0xF8,
  0x3F, 0xFE, 0xFE, 0x0F, 0xFF, 0x3F, 0x83, 0xFF, 0xCF, 0xE0, 0x07, 0xF3,
  0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07,
  0xE1, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F,
  0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x07,
  0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x02, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF0,
  0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0x81, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0xFF, 0x80, 0x3F, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0xFF, 0x80, 0x1F, 0xC0,
  0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF0,
  0x7F, 0x80, 0x01, 0xF8, 0x7F, 0x80, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F,
  0xBF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xDF, 0xC0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8,
  0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x3F,
  0xF0, 0x1F, 0xF9, 0xFF, 0xC0, 0x7D, 0xE7, 0xFF, 0x01, 0xF7, 0xBE, 0xFC,
  0x0F, 0xDE, 0xFB, 0xE0, 0x3F, 0x7F, 0xDF, 0x80, 0xFD, 0xFF, 0x7E, 0x03,
  0xF7, 0xF9, 0xF8, 0x0F, 0xDF, 0xE7, 0xE0, 0x7E, 0x3F, 0x1F, 0x81, 0xF8,
  0xFC, 0xFC, 0x07, 0xE3, 0xE3, 0xF0, 0x1F, 0x8F, 0x8F, 0xC0, 0x7E, 0x3C,
  0x3F, 0x01, 0xF8, 0xF0, 0xFC, 0x0F, 0xC3, 0x83, 0xF0, 0x3F, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x00, 0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0x3F, 0x03, 0xFE, 0x03,
  0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0xFF, 0xC0, 0xFE, 0x07, 0xFE, 0x07, 0xE0,
  0x3F, 0xF0, 0x3F, 0x01, 0xFF, 0x81, 0xF8, 0x1F, 0xFE, 0x1F, 0xC0, 0xFF,
  0xF0, 0xFE, 0x07, 0xFF, 0x87, 0xF0, 0x3F, 0xFC, 0x3F, 0x01, 0xF9, 0xF1,
  0xF8, 0x0F, 0xCF, 0x9F, 0xC0, 0xFE, 0x7C, 0xFE, 0x07, 0xF3, 0xE7, 0xF0,
  0x3F, 0x8F, 0xBF, 0x81, 0xF8, 0x7D, 0xF8, 0x0F, 0xC3, 0xEF, 0xC0, 0x7E,
  0x1F, 0xFE, 0x07, 0xF0, 0x7F, 0xF0, 0x3F, 0x83, 0xFF, 0x81, 0xFC, 0x1F,
  0xFC, 0x0F, 0xC0, 0xFF, 0xC0, 0x7E, 0x03, 0xFE, 0x07, 0xF0, 0x1F, 0xF0,
  0x3F, 0x80, 0xFF, 0x81, 0xFC, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E,
  0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x03, 0xFB,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03,
  0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x8F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xE1, 0xFE, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xE0, 0x1F, 0xE0, 0x7E, 0x00, 0xFE, 0x07,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7E,
  0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xF8,
  0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xC0, 0x03,
  0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0,
  0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xE1, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xFC, 0x1F, 0x81, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80,
  0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xC1, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0xFC,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x0F, 0xF0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0,
  0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xE7, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x07,
  0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07,
  0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xFC,
  0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x0F, 0x83, 0xF7, 0xE0, 0xF8, 0x3F, 0x7E, 0x1F, 0x83, 0xF7,
  0xE1, 0xF8, 0x7E, 0x7E, 0x1F, 0x87, 0xE7, 0xE3, 0xF8, 0x7E, 0x7C, 0x3F,
  0x8F, 0xC7, 0xC3, 0xF8, 0xFC, 0x7C, 0x3F, 0x8F, 0xC7, 0xC7, 0xF8, 0xFC,
  0x7C, 0x7F, 0x9F, 0x87, 0xC7, 0xF9, 0xF8, 0x7C, 0xFF, 0x9F, 0x87, 0xCF,
  0xF9, 0xF0, 0xFC, 0xFF, 0xBF, 0x0F, 0xDF, 0xFB, 0xF0, 0xFD, 0xFF, 0x3F,
  0x0F, 0xDE, 0xF7, 0xE0, 0xFD, 0xEF, 0x7E, 0x0F, 0xFE, 0xF7, 0xE0, 0xFF,
  0xCF, 0x7C, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xF8, 0xFF,
  0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x1F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFC, 0x3F,
  0x00, 0x3F, 0x83, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x01, 0xF8, 0x0F,
  0xE0, 0x1F, 0x80, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00,
  0xFC, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xE7, 0x80, 0x7E, 0x7C, 0x07, 0xC7,
  0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC1, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xE0,
  0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x01, 0xF0, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE,
  0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0,
  0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x3F, 0xE0, 0x7E, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00,
  0xFE, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFD, 0xFC, 0x0F, 0xF8,
  0xFC, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01,
  0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8,
  0x03, 0xF1, 0xFC, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0x9F, 0xFC, 0x0F, 0xC7, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC0, 0x7E,
  0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x83, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0x9F, 0xC0, 0x3F, 0xFB, 0xF8, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0,
  0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x3F, 0xE0,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE,
  0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F,
  0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x20, 0x7F, 0x00, 0x70, 0x7F, 0x80, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x7F, 0xFB, 0xF0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0xF1, 0xFE,
  0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3,
  0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F,
  0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0x87, 0xF0, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFE, 0xFC,
  0x00, 0xFF, 0x3F, 0x00, 0x04, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x20, 0x03,
  0xF8, 0x0C, 0x01, 0xFE, 0x07, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0xFC, 0xFF, 0xE0, 0x7E, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE,
  0x7F, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F,
  0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0xFF, 0x00, 0xFC, 0x1F, 0xE0, 0x1F,
  0xC3, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x01, 0xF9, 0xFE,
  0x00, 0x1F, 0xBF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFC, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0x7E, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xFC, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xCF, 0xC7, 0xC0, 0xFD,
  0xFC, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFC, 0x7F, 0x3F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F,
  0x87, 0xE3, 0xF1, 0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFC,
  0x3E, 0x1F, 0x0F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xE3,
  0xF0, 0xF8, 0x7E, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xF8, 0x7E, 0x3E, 0x1F,
  0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC,
  0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7C, 0x3F, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x0F, 0xC3, 0xF8, 0x07, 0xE7, 0xFF, 0x03, 0xF7, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xFC, 0x7F, 0x80, 0xFE,
  0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF3, 0xF8,
  0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFC, 0x7E, 0x01, 0xFC,
  0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x7E, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xF8, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xBF, 0xF8, 0x07, 0xF3, 0xFE,
  0x00, 0xFC, 0x04, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x1F, 0x81, 0xFF, 0xCF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F,
  0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01,
  0xF8, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFD, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0x20, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE1, 0xFF, 0x0F, 0xC7, 0xFF, 0x0F, 0xCF,
  0xFE, 0x0F, 0xDF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFE,
  0x0C, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFB,
  0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFE, 0x01,
  0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F,
  0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x03,
  0xF9, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x00,
  0x7F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xC7, 0xF0,
  0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x7E,
  0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0xFF, 0x87,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFB, 0xE0, 0x3F, 0xFB, 0xF0,
  0x0F, 0xF1, 0xF8, 0x00, 0x40, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x1E, 0x0F, 0xFF, 0x07, 0xC1, 0xFB,
  0xE0, 0xF8, 0x3F, 0x7C, 0x1F, 0x0F, 0xCF, 0x87, 0xE1, 0xF9, 0xF0, 0xFC,
  0x3F, 0x3E, 0x1F, 0x87, 0xC7, 0xC7, 0xF1, 0xF8, 0xF8, 0xFE, 0x3F, 0x1F,
  0x3F, 0xC7, 0xC3, 0xE7, 0xF9, 0xF8, 0x7C, 0xFF, 0x3F, 0x0F, 0xBD, 0xE7,
  0xC1, 0xF7, 0xBD, 0xF8, 0x3E, 0xF3, 0xBF, 0x07, 0xFC, 0x77, 0xC0, 0xFF,
  0x8E, 0xF8, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8,
  0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0x83, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0x0F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x1F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFB,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xA0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x04, 0x00, 0x03, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x0F, 0x9F, 0xFF, 0x01, 0xF7, 0xFF, 0xF0, 0x7E,
  0xFF, 0xFF, 0xFF, 0x9F, 0x07, 0xFF, 0xF7, 0xC0, 0x7F, 0xFC, 0xF8, 0x07,
  0xFF, 0x01, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
};

const GFXglyph RobotoMono_BoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 13, 35, 29, 8, -35 },
  { 58, 16, 13, 29, 8, -37 },
  { 84, 29, 35, 29, 0, -35 },
  { 211, 26, 45, 29, 2, -40 },
  { 358, 24, 36, 29, 3, -35 },
  { 466, 27, 36, 29, 1, -35 },
  { 588, 7, 13, 29, 12, -37 },
  { 600, 16, 50, 29, 8, -39 },
  { 700, 17, 50, 29, 4, -39 },
  { 807, 23, 25, 29, 4, -35 },
  { 879, 24, 26, 29, 2, -29 },
  { 957, 10, 16, 29, 5, -6 },
  { 977, 21, 5, 29, 6, -18 },
  { 991, 9, 9, 29, 8, -8 },
  { 1002, 25, 38, 29, 2, -35 },
  { 1121, 24, 36, 29, 3, -35 },
  { 1229, 16, 35, 29, 6, -35 },
  { 1299, 26, 35, 29, 0, -35 },
  { 1413, 26, 36, 29, 1, -35 },
  { 1530, 26, 35, 29, 0, -35 },
  { 1644, 26, 36, 29, 2, -35 },
  { 1761, 23, 36, 29, 2, -35 },
  { 1865, 26, 35, 29, 3, -35 },
  { 1979, 26, 36, 29, 1, -35 },
  { 2096, 23, 35, 29, 3, -35 },
  { 2197, 13, 29, 29, 8, -28 },
  { 2245, 16, 38, 29, 6, -28 },
  { 2321, 23, 23, 29, 3, -27 },
  { 2388, 25, 16, 29, 2, -23 },
  { 2438, 23, 23, 29, 2, -26 },
  { 2505, 22, 35, 29, 6, -35 },
  { 2602, 28, 35, 29, 1, -35 },
  { 2725, 28, 35, 29, -2, -35 },
  { 2848, 29, 35, 29, 0, -35 },
  { 2975, 26, 36, 29, 2, -35 },
  { 3092, 27, 35, 29, 0, -35 },
  { 3211, 29, 35, 29, 1, -35 },
  { 3338, 29, 35, 29, 1, -35 },
  { 3465, 26, 36, 29, 2, -35 },
  { 3582, 29, 35, 29, 0, -35 },
  { 3709, 26, 35, 29, 2, -35 },
  { 3823, 27, 36, 29, 2, -35 },
  { 3945, 33, 35, 29, 0, -35 },
  { 4090, 23, 35, 29, 1, -35 },
  { 4191, 30, 35, 29, 0, -35 },
  { 4323, 29, 35, 29, 0, -35 },
  { 4450, 26, 36, 29, 2, -35 },
  { 4567, 28, 35, 29, 1, -35 },
  { 4690, 26, 41, 29, 2, -35 },
  { 4824, 28, 35, 29, 1, -35 },
  { 4947, 28, 36, 29, 1, -35 },
  { 5073, 28, 35, 29, 3, -35 },
  { 5196, 27, 36, 29, 2, -35 },
  { 5318, 27, 35, 29, 4, -35 },
  { 5437, 28, 35, 29, 3, -35 },
  { 5560, 34, 35, 29, -2, -35 },
  { 5709, 28, 35, 29, 4, -35 },
  { 5832, 30, 35, 29, 0, -35 },
  { 5964, 18, 48, 29, 6, -40 },
  { 6072, 12, 38, 29, 9, -35 },
  { 6129, 18, 48, 29, 6, -40 },
  { 6237, 20, 19, 29, 5, -35 },
  { 6285, 22, 5, 29, 0, 0 },
  { 6299, 10, 6, 29, 13, -35 },
  { 6307, 24, 27, 29, 1, -26 },
  { 6388, 25, 38, 29, 1, -37 },
  { 6507, 24, 27, 29, 2, -26 },
  { 6588, 27, 38, 29, 2, -37 },
  { 6717, 24, 27, 29, 2, -26 },
  { 6798, 27, 38, 29, 4, -38 },
  { 6927, 26, 36, 29, 1, -26 },
  { 7044, 25, 37, 29, 1, -37 },
  { 7160, 22, 36, 29, 2, -36 },
  { 7259, 23, 47, 29, 1, -36 },
  { 7395, 28, 37, 29, 1, -37 },
  { 7525, 22, 37, 29, 2, -37 },
  { 7627, 28, 26, 29, -1, -26 },
  { 7718, 25, 26, 29, 1, -26 },
  { 7800, 24, 27, 29, 2, -26 },
  { 7881, 27, 36, 29, -1, -26 },
  { 8003, 25, 36, 29, 2, -26 },
  { 8116, 24, 26, 29, 4, -26 },
  { 8194, 24, 27, 29, 2, -26 },
  { 8275, 23, 33, 29, 4, -32 },
  { 8370, 25, 27, 29, 3, -26 },
  { 8455, 25, 26, 29, 4, -26 },
  { 8537, 27, 26, 29, 3, -26 },
  { 8625, 29, 26, 29, 0, -26 },
  { 8720, 31, 37, 29, 0, -26 },
  { 8864, 28, 26, 29, 0, -26 },
  { 8955, 19, 47, 29, 7, -38 },
  { 9067, 11, 45, 29, 9, -35 },
  { 9129, 18, 47, 29, 5, -38 },
  { 9235, 27, 11, 29, 0, -20 },
};

const GFXfont RobotoMono_BoldItalic49pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic49pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _ROBOTOMONO_BOLDITALIC49PT7B_H_
