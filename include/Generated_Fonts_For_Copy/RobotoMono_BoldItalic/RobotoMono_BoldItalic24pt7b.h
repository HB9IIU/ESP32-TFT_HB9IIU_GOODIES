#ifndef _ROBOTOMONO_BOLDITALIC24PT7B_H_
#define _ROBOTOMONO_BOLDITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xCF, 0x38, 0xE3, 0x8E, 0x38, 0xC7, 0x00, 0x00, 0x0F,
  0x3C, 0xE0, 0x63, 0x67, 0x66, 0xE6, 0xC6, 0xC6, 0x01, 0x98, 0x0C, 0x60,
  0x33, 0x00, 0xCC, 0x06, 0x30, 0xFF, 0xF3, 0xFF, 0xC3, 0x18, 0x0C, 0xC0,
  0x33, 0x0F, 0xFF, 0x3F, 0xFC, 0x19, 0x80, 0xC6, 0x03, 0x30, 0x1C, 0xC0,
  0x67, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0F, 0xC1, 0xFF, 0x1F, 0x78,
  0xE1, 0xE7, 0x07, 0x38, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x70, 0x03, 0xDC, 0x1E, 0xF0, 0xE3, 0xDF, 0x1F, 0xF0, 0x7F, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0x3C, 0x07, 0xE0, 0x66, 0x66, 0x66, 0xE6, 0xC7,
  0xD8, 0x7D, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0D, 0xE1, 0xBF, 0x3B, 0x37,
  0x73, 0x27, 0x30, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x80, 0xEF, 0x07,
  0x1C, 0x1C, 0x60, 0x73, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x77,
  0xB9, 0x9C, 0xFE, 0xF1, 0xFB, 0xC7, 0xC7, 0xBE, 0x1F, 0xFC, 0x3F, 0x78,
  0x6D, 0xFD, 0x80, 0x02, 0x07, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x60,
  0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60,
  0x70, 0x38, 0x10, 0x08, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38,
  0x70, 0xE0, 0xC0, 0x07, 0x00, 0xC0, 0x18, 0x23, 0x1F, 0x6F, 0xFF, 0xC3,
  0xC0, 0xF0, 0x3B, 0x0E, 0x73, 0x8E, 0x10, 0x80, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x39, 0xCE, 0x77, 0x3B, 0x88, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0x0F, 0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x38, 0x77,
  0x87, 0x70, 0xF7, 0x3F, 0x77, 0xF7, 0xCE, 0x78, 0xEF, 0x0E, 0xF0, 0xE7,
  0x1C, 0x7B, 0xC7, 0xF8, 0x3F, 0x00, 0x03, 0x1F, 0xFF, 0xFE, 0xEE, 0x8E,
  0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x07,
  0xE0, 0xFF, 0x87, 0xBC, 0x70, 0xF3, 0x83, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0xDF,
  0xFE, 0xFF, 0xE0, 0x0F, 0xC1, 0xFE, 0x3C, 0xF7, 0x87, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0xFC, 0x0F, 0x80, 0xFC, 0x00, 0xE0, 0x0E, 0xE0, 0xEE, 0x1E,
  0xF3, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xE0,
  0x3F, 0x03, 0xB8, 0x3B, 0x83, 0x9C, 0x18, 0xE1, 0xC7, 0x1C, 0x39, 0xFF,
  0xFF, 0xFF, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1F, 0xF8, 0xFF,
  0x87, 0xFC, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFE, 0x0F, 0xF8, 0x79, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xCE, 0x0E, 0x70, 0xF3, 0xEF, 0x0F, 0xF0, 0x3F,
  0x00, 0x03, 0xE0, 0xF8, 0x7F, 0x0E, 0x03, 0x80, 0xF0, 0x1D, 0xF3, 0xFF,
  0xF9, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE3, 0xDE, 0xF3, 0xFC, 0x3F,
  0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x38,
  0x73, 0x8F, 0x38, 0xE3, 0xFC, 0x3F, 0x87, 0xFC, 0xF0, 0xEE, 0x0E, 0xE0,
  0xEE, 0x1E, 0xF3, 0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xF9, 0xEF, 0x78,
  0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xF3, 0xDF, 0xF9, 0xFF, 0x01, 0xE0,
  0x38, 0x0E, 0x1F, 0xC3, 0xE0, 0x78, 0x00, 0x38, 0xF3, 0xCF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x3C, 0xF1, 0xC0, 0x0E, 0x1F, 0x1F, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0xE0,
  0x40, 0x00, 0x20, 0x3C, 0x1F, 0x9F, 0xEF, 0xE1, 0xE0, 0x3E, 0x03, 0xF8,
  0x1F, 0x80, 0xF0, 0x06, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0xFF, 0xEF, 0xFE, 0x20, 0x07, 0x01, 0xF8, 0x1F, 0xC0, 0x7E,
  0x01, 0xC1, 0xF9, 0xFE, 0xFE, 0x1F, 0x03, 0x00, 0x00, 0x3F, 0x8F, 0xFB,
  0xEF, 0x70, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x1F,
  0xC0, 0xC1, 0x86, 0x03, 0x33, 0xEC, 0xDD, 0xB6, 0x66, 0xDB, 0x13, 0x6C,
  0xCD, 0x33, 0x2C, 0xCD, 0xB3, 0x74, 0x6F, 0xF1, 0x80, 0x07, 0x00, 0x0F,
  0xE0, 0x1F, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x77, 0x01, 0xDC, 0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x87, 0xFE,
  0x3F, 0xF8, 0xE0, 0xE7, 0x83, 0x9C, 0x0F, 0xF0, 0x3C, 0x1F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xC7, 0x0F, 0x3C, 0x1C, 0xE0, 0xF3, 0x83, 0x8F, 0xFC, 0x3F,
  0xE0, 0xE3, 0xC7, 0x83, 0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xE7, 0xFF, 0x3F,
  0xF8, 0xFF, 0x80, 0x0F, 0xE0, 0xFF, 0x8F, 0x3C, 0x70, 0xF7, 0x03, 0xB8,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x2E, 0x0E,
  0x70, 0x71, 0xEF, 0x8F, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0xFF, 0x07, 0xFC,
  0x38, 0xF3, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x3B, 0xC1, 0xDE,
  0x0E, 0xE0, 0xF7, 0x07, 0x38, 0x71, 0xFF, 0x9F, 0xF8, 0xFF, 0x00, 0x1F,
  0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F,
  0xF0, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x8F, 0x3C, 0x70, 0xF7, 0x03, 0xB8,
  0x01, 0xC0, 0x1E, 0x00, 0xE3, 0xF7, 0x1F, 0xB8, 0xFD, 0xC1, 0xEE, 0x0F,
  0x78, 0x71, 0xEF, 0x8F, 0xFC, 0x3F, 0x80, 0x1C, 0x1C, 0x70, 0x71, 0xC1,
  0xC7, 0x0F, 0x3C, 0x38, 0xE0, 0xE3, 0x83, 0x8F, 0xFE, 0x3F, 0xF9, 0xFF,
  0xE7, 0x87, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x0F, 0x3C, 0x38, 0xE0,
  0xE0, 0x1F, 0xF8, 0xFF, 0x8F, 0xFC, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x03,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01,
  0xCE, 0x0E, 0x70, 0xF3, 0xEF, 0x0F, 0xF0, 0x3F, 0x00, 0x1C, 0x1F, 0x1C,
  0x3E, 0x1C, 0x3C, 0x1C, 0x78, 0x3C, 0xF0, 0x39, 0xE0, 0x3B, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x7D, 0xC0, 0x79, 0xE0, 0x70, 0xE0, 0x70,
  0xF0, 0x70, 0xF0, 0xF0, 0x70, 0xF0, 0x78, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0x1E, 0x3C, 0x78,
  0xF1, 0xE7, 0xC7, 0x9F, 0x3E, 0xFC, 0xFF, 0x73, 0xFF, 0x8E, 0xEE, 0x3B,
  0xB8, 0xCC, 0xE7, 0x33, 0x9C, 0x0C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x38,
  0x1C, 0xE0, 0x70, 0x1C, 0x1C, 0x78, 0x71, 0xE3, 0xC7, 0x8F, 0x3E, 0x38,
  0xFC, 0xE3, 0xF3, 0x8E, 0xCE, 0x3B, 0x79, 0xEF, 0xC7, 0xBF, 0x1C, 0x7C,
  0x71, 0xF1, 0xC7, 0xC7, 0x1F, 0x3C, 0x38, 0xF0, 0xE0, 0x0F, 0xC0, 0xFF,
  0x0F, 0x7C, 0x70, 0xE7, 0x07, 0x38, 0x3F, 0xC1, 0xFE, 0x0E, 0xE0, 0x77,
  0x03, 0xB8, 0x1D, 0xC1, 0xEE, 0x0E, 0x70, 0xF1, 0xEF, 0x0F, 0xF0, 0x3F,
  0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC7, 0x0F, 0x1C, 0x1C, 0xF0, 0x73,
  0xC3, 0xCE, 0x0E, 0x3F, 0xF8, 0xFF, 0xC3, 0xF8, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0xBC,
  0x70, 0xE7, 0x07, 0xB8, 0x3D, 0xC1, 0xFE, 0x0F, 0xE0, 0x77, 0x03, 0xB8,
  0x1D, 0xC0, 0xEE, 0x0E, 0x78, 0xF1, 0xEF, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0x80, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC7, 0x0F, 0x3C,
  0x1C, 0xE0, 0x73, 0x83, 0xCE, 0x1E, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x1C,
  0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x1C, 0x1C, 0xF0, 0x78, 0x0F, 0xE0,
  0xFF, 0x8F, 0x3E, 0x70, 0x77, 0x83, 0xBC, 0x00, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x3C, 0x00, 0xEE, 0x07, 0x70, 0x7B, 0xE7, 0x8F, 0xF8,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x00, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70,
  0xF7, 0x87, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x87, 0xBC, 0x39,
  0xC1, 0xCE, 0x0E, 0x78, 0xF1, 0xEF, 0x0F, 0xF0, 0x3F, 0x00, 0xE0, 0x7F,
  0x83, 0xFC, 0x1D, 0xE1, 0xE7, 0x0E, 0x38, 0xF1, 0xC7, 0x0E, 0x78, 0x73,
  0x83, 0x9C, 0x1D, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x00, 0x73, 0x9D, 0xCE, 0x77, 0x39, 0xDD, 0xEE, 0x77, 0xB9, 0xDE,
  0xE7, 0xFB, 0x1B, 0xFC, 0x6F, 0xF1, 0xBF, 0xC7, 0xBE, 0x1E, 0xF8, 0x7B,
  0xE1, 0xCF, 0x07, 0x3C, 0x1C, 0xF0, 0xF3, 0xC0, 0x1E, 0x0F, 0x0E, 0x0E,
  0x0F, 0x1E, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x70, 0x1C, 0x70,
  0x3C, 0x78, 0x78, 0x38, 0xF0, 0x3C, 0xF0, 0x3D, 0xC1, 0xE7, 0x07, 0x1C,
  0x38, 0x39, 0xE0, 0xE7, 0x03, 0xBC, 0x0E, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x07, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x1F, 0x8F, 0x87, 0xC3, 0x81, 0xC0,
  0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xC7, 0x39, 0xCE,
  0x71, 0x8E, 0x73, 0x9C, 0xE3, 0x1C, 0xE7, 0x39, 0xC0, 0x1F, 0x8F, 0x87,
  0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x87, 0xC3, 0xE1, 0xF0,
  0x0E, 0x07, 0x07, 0xC3, 0x63, 0xB3, 0x99, 0xCF, 0xC7, 0xC1, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF1, 0xC6, 0x0F, 0x87, 0xF9, 0xFF, 0xB8, 0x70,
  0x0E, 0x1F, 0xDF, 0xFF, 0x87, 0xE1, 0xFC, 0x3B, 0xCF, 0x7F, 0xE7, 0xDC,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0xE0, 0xFF, 0xC7,
  0xFE, 0x3C, 0x71, 0xC3, 0xCE, 0x1E, 0x70, 0xF7, 0x87, 0x38, 0x39, 0xC3,
  0xCF, 0xBC, 0x7F, 0xE7, 0xBE, 0x00, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x8E,
  0x70, 0xFF, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x1E, 0x73, 0xC7, 0xF8,
  0x3F, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x07, 0xB8,
  0xFF, 0xC7, 0xFE, 0x78, 0xF3, 0x87, 0xBC, 0x39, 0xC1, 0xCE, 0x0E, 0x70,
  0x73, 0xC7, 0x9F, 0x7C, 0x7F, 0xC1, 0xEE, 0x00, 0x07, 0x81, 0xFC, 0x3F,
  0xE7, 0x8F, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x04, 0x79,
  0xE7, 0xFC, 0x1F, 0x80, 0x00, 0x20, 0x1F, 0xC1, 0xFE, 0x1E, 0x00, 0xE0,
  0x07, 0x03, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0x07,
  0xB8, 0xFF, 0xC7, 0xFE, 0x78, 0xF3, 0x83, 0xBC, 0x3D, 0xC1, 0xCE, 0x0E,
  0x70, 0x73, 0xC3, 0x8F, 0x7C, 0x7F, 0xE1, 0xFE, 0x00, 0x71, 0x07, 0x9F,
  0xF8, 0x7F, 0x81, 0xF8, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0xF0, 0xEF, 0xC7, 0xFE, 0x3C, 0x79, 0xC1, 0xCE, 0x1E, 0xF0,
  0xE7, 0x87, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xF7, 0x87, 0x80, 0x01,
  0x80, 0x78, 0x0F, 0x00, 0xC0, 0x00, 0x7F, 0x0F, 0xE1, 0xFC, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xC0, 0x38, 0x07, 0x80, 0x60, 0x00, 0x3F, 0x87, 0xF0, 0xFC, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x0F, 0xE1, 0xF8, 0x3E, 0x00, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xF3, 0xC7, 0x8E, 0x3C, 0x39, 0xE0,
  0xEF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xEF, 0x07, 0x1C, 0x1C, 0x78,
  0x70, 0xF3, 0xC3, 0xC0, 0x1F, 0xC3, 0xF8, 0x7F, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x3B, 0x31, 0xFF, 0xDF, 0xFE, 0xE7, 0x77,
  0x3B, 0xB9, 0x9D, 0xDC, 0xEC, 0xE7, 0xE7, 0x3F, 0x39, 0xB9, 0xDD, 0xCC,
  0xEE, 0xE7, 0x00, 0x19, 0xE1, 0xDF, 0x8F, 0xFC, 0x78, 0xF3, 0x87, 0x9C,
  0x3C, 0xE1, 0xCF, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xEF, 0x0E,
  0x00, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x8E, 0x70, 0xFE, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0xEE, 0x1E, 0x7B, 0xC7, 0xF8, 0x3F, 0x00, 0x1D, 0xC1, 0xFF,
  0x8F, 0xFC, 0x78, 0xE3, 0x87, 0x9C, 0x3C, 0xE1, 0xEF, 0x0E, 0x70, 0x73,
  0x87, 0x9E, 0x78, 0xFF, 0xC7, 0x7C, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x0F, 0x73, 0xFF, 0x3F, 0xF7, 0x8F, 0x70, 0xFF, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE0, 0xEF, 0x1E, 0xFB, 0xE7, 0xFC, 0x3F, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x39, 0xF3, 0xBE, 0x3F, 0xE3, 0xE2,
  0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x00, 0x0F, 0x83, 0xFE, 0x7D, 0xF7, 0x07, 0x70, 0x07, 0xE0, 0x3F,
  0x80, 0xFE, 0x01, 0xEE, 0x0E, 0xF1, 0xE7, 0xFC, 0x3F, 0x80, 0x0E, 0x01,
  0xC0, 0x78, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0x00, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x7D, 0x0F, 0xE0, 0xFE, 0x38, 0x77, 0x87, 0x78,
  0x77, 0x07, 0x70, 0x77, 0x0F, 0x70, 0xEF, 0x0E, 0xF0, 0xEF, 0x1E, 0x7B,
  0xE7, 0xEE, 0x3D, 0xC0, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C, 0x71, 0xC7,
  0x38, 0x73, 0x87, 0x70, 0x77, 0x03, 0x60, 0x3E, 0x03, 0xC0, 0x3C, 0x00,
  0xE3, 0x3F, 0x39, 0xF9, 0xCF, 0xCE, 0x6E, 0xF7, 0x77, 0xBB, 0xBD, 0x9F,
  0x7C, 0xFB, 0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8E, 0x38, 0x00, 0x38, 0x1C,
  0x70, 0xE1, 0xE7, 0x83, 0xBC, 0x0F, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xF0,
  0x1F, 0xC0, 0x77, 0x83, 0xCE, 0x1E, 0x3C, 0xF0, 0x70, 0x38, 0x1E, 0x70,
  0x38, 0xE0, 0xF1, 0xE1, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x38, 0x0E, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x80, 0xF0, 0x70, 0x1C, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x07, 0xC1, 0xC0, 0xF0, 0x0E, 0x01,
  0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x80, 0xC0, 0x0C,
  0x61, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x31, 0xC6, 0x18, 0x61,
  0x86, 0x18, 0xC3, 0x00, 0x08, 0x07, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x7C, 0x0E, 0x07, 0x83, 0x81, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x3C, 0x0E, 0x00, 0x18, 0x03, 0xF0,
  0xDF, 0xCF, 0xCF, 0xFC, 0x1F, 0x00, 0x20,
};

const GFXglyph RobotoMono_BoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 17, 14, 4, -17 },
  { 14, 8, 6, 14, 4, -18 },
  { 20, 14, 17, 14, 0, -17 },
  { 50, 13, 23, 14, 1, -20 },
  { 88, 12, 17, 14, 1, -17 },
  { 114, 14, 17, 14, 0, -17 },
  { 144, 3, 6, 14, 6, -18 },
  { 147, 8, 24, 14, 4, -19 },
  { 171, 8, 24, 14, 2, -19 },
  { 195, 11, 12, 14, 2, -17 },
  { 212, 12, 12, 14, 1, -14 },
  { 230, 5, 8, 14, 2, -3 },
  { 235, 10, 3, 14, 3, -9 },
  { 239, 4, 4, 14, 4, -4 },
  { 241, 12, 18, 14, 1, -17 },
  { 268, 12, 17, 14, 1, -17 },
  { 294, 8, 17, 14, 3, -17 },
  { 311, 13, 17, 14, 0, -17 },
  { 339, 12, 17, 14, 1, -17 },
  { 365, 13, 17, 14, 0, -17 },
  { 393, 13, 17, 14, 1, -17 },
  { 421, 11, 17, 14, 1, -17 },
  { 445, 13, 17, 14, 1, -17 },
  { 473, 12, 17, 14, 1, -17 },
  { 499, 11, 17, 14, 2, -17 },
  { 523, 6, 14, 14, 4, -14 },
  { 534, 8, 19, 14, 3, -14 },
  { 553, 11, 11, 14, 2, -13 },
  { 569, 12, 8, 14, 1, -11 },
  { 581, 11, 11, 14, 1, -13 },
  { 597, 11, 17, 14, 3, -17 },
  { 621, 14, 17, 14, 0, -17 },
  { 651, 14, 17, 14, -1, -17 },
  { 681, 14, 17, 14, 0, -17 },
  { 711, 13, 17, 14, 1, -17 },
  { 739, 13, 17, 14, 0, -17 },
  { 767, 15, 17, 14, 0, -17 },
  { 799, 15, 17, 14, 0, -17 },
  { 831, 13, 17, 14, 1, -17 },
  { 859, 14, 17, 14, 0, -17 },
  { 889, 13, 17, 14, 1, -17 },
  { 917, 13, 17, 14, 1, -17 },
  { 945, 16, 17, 14, 0, -17 },
  { 979, 12, 17, 14, 0, -17 },
  { 1005, 14, 17, 14, 0, -17 },
  { 1035, 14, 17, 14, 0, -17 },
  { 1065, 13, 17, 14, 1, -17 },
  { 1093, 14, 17, 14, 0, -17 },
  { 1123, 13, 20, 14, 1, -17 },
  { 1156, 14, 17, 14, 0, -17 },
  { 1186, 13, 17, 14, 1, -17 },
  { 1214, 13, 17, 14, 2, -17 },
  { 1242, 13, 17, 14, 1, -17 },
  { 1270, 13, 17, 14, 2, -17 },
  { 1298, 14, 17, 14, 1, -17 },
  { 1328, 16, 17, 14, -1, -17 },
  { 1362, 14, 17, 14, 2, -17 },
  { 1392, 14, 17, 14, 0, -17 },
  { 1422, 9, 24, 14, 3, -20 },
  { 1449, 5, 18, 14, 5, -17 },
  { 1461, 9, 24, 14, 3, -20 },
  { 1488, 9, 9, 14, 3, -17 },
  { 1499, 11, 3, 14, 0, 0 },
  { 1504, 5, 3, 14, 6, -17 },
  { 1506, 11, 13, 14, 1, -13 },
  { 1524, 13, 18, 14, 0, -18 },
  { 1554, 12, 13, 14, 1, -13 },
  { 1574, 13, 18, 14, 1, -18 },
  { 1604, 12, 13, 14, 1, -13 },
  { 1624, 13, 19, 14, 2, -19 },
  { 1655, 13, 18, 14, 0, -13 },
  { 1685, 13, 18, 14, 0, -18 },
  { 1715, 11, 18, 14, 1, -18 },
  { 1740, 11, 23, 14, 1, -18 },
  { 1772, 14, 18, 14, 0, -18 },
  { 1804, 11, 18, 14, 1, -18 },
  { 1829, 13, 13, 14, 0, -13 },
  { 1851, 13, 13, 14, 0, -13 },
  { 1873, 12, 13, 14, 1, -13 },
  { 1893, 13, 18, 14, 0, -13 },
  { 1923, 12, 18, 14, 1, -13 },
  { 1950, 12, 13, 14, 2, -13 },
  { 1970, 12, 13, 14, 1, -13 },
  { 1990, 11, 16, 14, 2, -16 },
  { 2012, 12, 13, 14, 1, -13 },
  { 2032, 12, 13, 14, 2, -13 },
  { 2052, 13, 13, 14, 1, -13 },
  { 2074, 14, 13, 14, 0, -13 },
  { 2097, 15, 18, 14, 0, -13 },
  { 2131, 14, 13, 14, 0, -13 },
  { 2154, 10, 23, 14, 3, -19 },
  { 2183, 6, 22, 14, 4, -17 },
  { 2200, 10, 23, 14, 2, -19 },
  { 2229, 13, 6, 14, 0, -10 },
};

const GFXfont RobotoMono_BoldItalic24pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic24pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOMONO_BOLDITALIC24PT7B_H_
