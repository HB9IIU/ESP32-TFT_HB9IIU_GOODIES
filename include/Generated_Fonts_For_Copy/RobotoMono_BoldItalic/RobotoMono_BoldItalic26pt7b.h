#ifndef _ROBOTOMONO_BOLDITALIC26PT7B_H_
#define _ROBOTOMONO_BOLDITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x1E, 0x38, 0x70, 0xE1, 0xC0,
  0x00, 0x08, 0x38, 0xF0, 0xE0, 0x73, 0xB9, 0xDC, 0xEC, 0x66, 0x33, 0x1B,
  0x9C, 0x01, 0xCC, 0x03, 0x38, 0x0E, 0x60, 0x18, 0xC0, 0x33, 0x87, 0xFF,
  0xCF, 0xFF, 0x83, 0x38, 0x0E, 0x60, 0x18, 0xC0, 0x33, 0x87, 0xFF, 0xCF,
  0xFF, 0x83, 0x38, 0x0E, 0x60, 0x18, 0xC0, 0x33, 0x80, 0xE6, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x03, 0xFC, 0x1F, 0xF8, 0x78, 0xF3, 0xC3, 0xCF,
  0x0F, 0x3C, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0x3C, 0x1E, 0xF0, 0x7B, 0xC1, 0xC7, 0xFF, 0x1F, 0xF8, 0x1F, 0xC0,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x38, 0x07, 0xC0, 0xEE, 0x0C, 0xE6, 0xCE,
  0xEC, 0xEC, 0xFD, 0x87, 0xB8, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xDC, 0x1B,
  0xF3, 0x77, 0x76, 0x36, 0x63, 0x06, 0x70, 0x7E, 0x03, 0xE0, 0x01, 0xC0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x73, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0xBC, 0x07,
  0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x7E, 0x39, 0xFC, 0x77, 0xBD, 0xCE, 0x3F,
  0xBC, 0x7E, 0x78, 0x7C, 0x7F, 0xF0, 0xFF, 0xF0, 0xFE, 0xF0, 0x77, 0x77,
  0x66, 0xE0, 0x00, 0x81, 0xC1, 0xE1, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70,
  0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x02, 0x00, 0x08, 0x06, 0x03,
  0x80, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0xF0, 0x70,
  0x70, 0x70, 0x20, 0x00, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x86, 0x2F, 0x2F,
  0x7F, 0xFC, 0x3E, 0x01, 0xE0, 0x1B, 0x81, 0xCC, 0x1C, 0x70, 0x43, 0x00,
  0x10, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00,
  0x1C, 0xF3, 0xCE, 0x39, 0xC7, 0x38, 0x7F, 0xEF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFE, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0x07, 0x81, 0xFE, 0x3F, 0xE3, 0xCF, 0x78, 0x77, 0x07, 0x70, 0x7F,
  0x0F, 0xF3, 0xFF, 0x7F, 0xFE, 0xFF, 0x8E, 0xF0, 0xEE, 0x0E, 0xE1, 0xEE,
  0x1C, 0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x03, 0x8F, 0xFF, 0xDF, 0xEE, 0x74,
  0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38,
  0x1C, 0x1E, 0x00, 0x01, 0xC0, 0x1F, 0xC1, 0xFF, 0x87, 0x9F, 0x3C, 0x3C,
  0xE0, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0x00, 0x03, 0x80, 0x7F, 0x87, 0xFE, 0x78, 0xF3, 0x83, 0x80, 0x1C, 0x01,
  0xE0, 0x0F, 0x07, 0xF0, 0x3E, 0x03, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x3B,
  0x83, 0xDE, 0x1E, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x1F, 0xE0, 0x77, 0x03, 0x9C, 0x1C, 0x70,
  0xE3, 0xC7, 0x8F, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xF0, 0x43, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x73, 0x83, 0xCF, 0x0F, 0x1F, 0xF8, 0x7F, 0xC0, 0x7E, 0x00,
  0x00, 0x60, 0x3E, 0x07, 0xE0, 0xF8, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x7C,
  0x7F, 0xE7, 0xFF, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xF7, 0x0F,
  0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x7F, 0x87, 0xFC, 0x78, 0xF3, 0xC7, 0x9C, 0x1C, 0xE1, 0xE7, 0x8E,
  0x1F, 0xE0, 0xFE, 0x0F, 0xF8, 0xF1, 0xEF, 0x0F, 0x70, 0x3B, 0x83, 0xDE,
  0x1E, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0, 0x07, 0x01, 0xFC, 0x3F, 0xE7, 0x9E,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1E, 0xFF, 0xE7, 0xFE,
  0x3F, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x7F, 0x07, 0xE0, 0x78, 0x00, 0x1E,
  0x7C, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE7, 0xCF, 0x8F, 0x00,
  0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x3C, 0x38, 0x38, 0x38, 0x70, 0x70, 0xE0, 0x00, 0x30, 0x0F, 0x07, 0xF1,
  0xFE, 0xFF, 0x0F, 0x80, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFC, 0x03, 0xC0,
  0x04, 0x3F, 0xFB, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF,
  0xDF, 0xFE, 0x20, 0x03, 0x80, 0x3E, 0x07, 0xFC, 0x07, 0xF0, 0x1F, 0x01,
  0xF0, 0xFF, 0x7F, 0xCF, 0xE0, 0xF0, 0x0C, 0x00, 0x0F, 0x03, 0xFC, 0x7F,
  0xE7, 0x9F, 0xF0, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0xF8, 0x0F,
  0x01, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x3C, 0x03, 0xC0, 0x38,
  0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xC1, 0x8E, 0x03, 0x73, 0xED, 0x9D, 0xBE,
  0xE6, 0xF3, 0x33, 0xDC, 0xCF, 0x63, 0x3D, 0x8D, 0xB6, 0x66, 0xDF, 0xF3,
  0x3B, 0x8C, 0x00, 0x38, 0x20, 0x7F, 0x80, 0x7C, 0x00, 0x00, 0x70, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x77, 0x00, 0xEE, 0x03, 0x9C,
  0x07, 0x38, 0x1E, 0x78, 0x38, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x8E,
  0x07, 0x3C, 0x0E, 0x70, 0x1F, 0xE0, 0x3C, 0x1F, 0xF8, 0x3F, 0xF8, 0x70,
  0xF8, 0xE0, 0xF1, 0xC0, 0xE7, 0x83, 0xCF, 0x07, 0x1F, 0xFE, 0x3F, 0xF0,
  0x7F, 0xF0, 0xE0, 0xF3, 0xC0, 0xE7, 0x81, 0xCF, 0x07, 0x9C, 0x1F, 0x3F,
  0xFC, 0x7F, 0xF1, 0xFF, 0x80, 0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E,
  0x38, 0x3D, 0xE0, 0xF7, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x81, 0xEF, 0x07, 0x3C, 0x3C, 0x7F, 0xE1, 0xFF,
  0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x73, 0xE0, 0xE1, 0xE1, 0xC1,
  0xC7, 0x83, 0x8F, 0x07, 0x9E, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xF3,
  0xC1, 0xE7, 0x83, 0x8F, 0x0F, 0x1C, 0x3C, 0x3F, 0xF0, 0xFF, 0xC1, 0xFE,
  0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF,
  0xF8, 0x1F, 0xFE, 0x7F, 0xFC, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E, 0x3C, 0x3D, 0xE0, 0xF7, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x1F, 0xBC, 0xFE, 0xF0, 0x7B, 0xC1, 0xEF,
  0x07, 0x1C, 0x1C, 0x7F, 0xF0, 0xFF, 0x81, 0xFC, 0x00, 0x1E, 0x0E, 0x3C,
  0x1C, 0x70, 0x78, 0xE0, 0xF1, 0xC1, 0xC7, 0x83, 0x8F, 0x07, 0x1F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF9, 0xE0, 0xE3, 0xC1, 0xC7, 0x83, 0x8E, 0x0F, 0x1C,
  0x1E, 0x38, 0x3C, 0xF0, 0x71, 0xE0, 0xE0, 0x1F, 0xFC, 0x7F, 0xE0, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x3F, 0xF8, 0xFF,
  0xE3, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x73, 0x83, 0xCF, 0x0F, 0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x1E,
  0x0F, 0x8F, 0x0F, 0x07, 0x0F, 0x83, 0x8F, 0x81, 0xCF, 0x81, 0xE7, 0x80,
  0xF7, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xBC,
  0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x78,
  0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F,
  0x3E, 0x1F, 0x7E, 0x3B, 0x6E, 0x3B, 0xFC, 0x3B, 0xDC, 0x3B, 0xDC, 0x3B,
  0x9C, 0x3B, 0x9C, 0x7B, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0x70,
  0x38, 0xF0, 0x38, 0xF0, 0x78, 0x1E, 0x0E, 0x3C, 0x3C, 0x7C, 0x78, 0xF8,
  0xF1, 0xF1, 0xC7, 0xE3, 0x8F, 0xE7, 0x1F, 0xDE, 0x3B, 0xBC, 0x73, 0x79,
  0xE7, 0xE3, 0xCF, 0xC7, 0x9F, 0x8E, 0x1F, 0x1C, 0x3E, 0x38, 0x7C, 0xF0,
  0xF1, 0xE0, 0xE0, 0x03, 0x80, 0x3F, 0xC1, 0xFF, 0x0F, 0x1E, 0x38, 0x39,
  0xE0, 0xF7, 0x03, 0xDC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x03, 0xBC, 0x0E,
  0xE0, 0x7B, 0x81, 0xEF, 0x07, 0x3C, 0x3C, 0x7F, 0xE1, 0xFF, 0x01, 0xF8,
  0x00, 0x1F, 0xF0, 0xFF, 0xE3, 0xC7, 0xCE, 0x0F, 0x38, 0x1C, 0xE0, 0x77,
  0x83, 0xDE, 0x0F, 0x7F, 0xF9, 0xFF, 0xC7, 0xFC, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x3F,
  0xC1, 0xFF, 0x8F, 0x9E, 0x38, 0x3D, 0xE0, 0xF7, 0x03, 0xDC, 0x0F, 0x70,
  0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x0E, 0xE0, 0x3B, 0x81, 0xEF, 0x07, 0x3C,
  0x3C, 0x7F, 0xE1, 0xFF, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0x80,
  0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0xF8, 0xE0, 0xF1, 0xC0, 0xE7, 0x83, 0xCF,
  0x07, 0x9E, 0x1E, 0x3F, 0xFC, 0x7F, 0xE0, 0xFF, 0x83, 0xC7, 0x07, 0x8F,
  0x0F, 0x1E, 0x1C, 0x1C, 0x38, 0x3C, 0x70, 0x79, 0xE0, 0x78, 0x03, 0xC0,
  0x3F, 0xC1, 0xFF, 0x8F, 0x8F, 0x38, 0x1C, 0xE0, 0x73, 0x80, 0x0F, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3C, 0x00, 0x7B, 0x81, 0xEE, 0x07,
  0xBC, 0x1E, 0x7F, 0xF1, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x3C, 0x1C, 0xF0, 0x73, 0x83, 0xCE,
  0x0F, 0x38, 0x3D, 0xE0, 0xE7, 0x83, 0x9E, 0x0E, 0x70, 0x79, 0xC1, 0xE7,
  0x07, 0xBC, 0x1C, 0xF0, 0x73, 0xC3, 0xCF, 0x0F, 0x1F, 0xF8, 0x7F, 0xC0,
  0x7E, 0x00, 0xF0, 0x3F, 0xE0, 0x79, 0xC1, 0xE3, 0x83, 0xC7, 0x07, 0x0E,
  0x1E, 0x1E, 0x38, 0x3C, 0xF0, 0x79, 0xC0, 0xF7, 0x80, 0xEF, 0x01, 0xDC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00,
  0xE3, 0x1F, 0xCE, 0x3B, 0x9C, 0x77, 0x39, 0xCE, 0xF3, 0x9D, 0xE7, 0x3B,
  0xDE, 0x77, 0xB8, 0xFF, 0x71, 0xF6, 0xE3, 0xEF, 0x87, 0xDF, 0x0F, 0x3E,
  0x1E, 0x7C, 0x3C, 0xF0, 0x79, 0xE0, 0xE3, 0xC1, 0xC7, 0x00, 0x1F, 0x07,
  0xC3, 0xC3, 0xC0, 0xF0, 0xF0, 0x1C, 0x78, 0x07, 0xBC, 0x00, 0xEE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0x78, 0x07, 0x9E, 0x01, 0xE3, 0x80, 0xF0, 0xF0, 0x78, 0x3C,
  0x3E, 0x07, 0x80, 0xF0, 0x3E, 0xF0, 0x79, 0xE1, 0xE1, 0xC3, 0xC3, 0x8F,
  0x07, 0x1C, 0x0F, 0x78, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0x0F, 0xC3, 0xE0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xF0, 0xFC, 0x00, 0xE3, 0x8E, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x1C, 0x71, 0xC7,
  0x0F, 0xC3, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x07, 0x01, 0xC3, 0xF0, 0xFC, 0x00, 0x07, 0x03, 0xC0, 0xF8,
  0x7E, 0x3B, 0x8E, 0x67, 0x19, 0xC7, 0xE1, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF,
  0xE0, 0xF3, 0x8E, 0x70, 0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0x87, 0x00, 0x70,
  0x07, 0x3F, 0xF7, 0xFF, 0xF0, 0xFE, 0x0E, 0xE1, 0xEF, 0xFE, 0xFF, 0xE7,
  0xEE, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xDE, 0x07, 0xFE, 0x3F, 0xF8, 0xF0, 0xE3, 0xC3, 0xCE, 0x0F, 0x38, 0x3C,
  0xE0, 0xF7, 0x83, 0x9E, 0x0E, 0x78, 0x79, 0xFF, 0xC7, 0xFF, 0x3D, 0xF0,
  0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7, 0x87, 0xB8, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x87, 0x9C, 0x3C, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xF3, 0x87,
  0xFE, 0x3F, 0xF9, 0xE1, 0xE7, 0x07, 0x9C, 0x1C, 0xF0, 0x73, 0xC1, 0xCF,
  0x0F, 0x3C, 0x3C, 0xF0, 0xF1, 0xFF, 0x87, 0xFE, 0x0F, 0xB8, 0x07, 0xC0,
  0xFF, 0x0F, 0xFC, 0xF8, 0xF7, 0x83, 0xB8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x80, 0x1C, 0x18, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x0F,
  0xF0, 0x7F, 0xC1, 0xE0, 0x0F, 0x00, 0x3C, 0x07, 0xFF, 0x3F, 0xFC, 0xFF,
  0xF0, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x07, 0xDE, 0x1F, 0xF8,
  0x7F, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x1C, 0x78,
  0x38, 0xF0, 0xF1, 0xE1, 0xE1, 0xFF, 0xC3, 0xFF, 0x03, 0xEE, 0x00, 0x1C,
  0x10, 0x78, 0x7B, 0xE1, 0xFF, 0x80, 0xFE, 0x00, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xCF, 0x07, 0xFE, 0x3F, 0xF8,
  0xF0, 0xF3, 0xC3, 0xCE, 0x0F, 0x38, 0x3C, 0xE0, 0xE7, 0x83, 0x9E, 0x0E,
  0x70, 0x39, 0xC1, 0xE7, 0x07, 0xBC, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0,
  0x0C, 0x00, 0x01, 0xFC, 0x3F, 0xC3, 0xFC, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x7F, 0xF7, 0xFE, 0xFF, 0xE0,
  0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x04, 0x00, 0x00, 0xFE, 0x0F, 0xC1, 0xFC,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x09, 0xF0, 0xFE, 0x0F, 0xC0,
  0x40, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x07, 0x8E, 0x1E, 0x3C, 0xF8, 0x7B, 0xE0, 0xFF, 0x81, 0xFE,
  0x03, 0xF8, 0x07, 0xF8, 0x1F, 0x70, 0x3C, 0xF0, 0x78, 0xE0, 0xE1, 0xE1,
  0xC1, 0xE7, 0x83, 0xC0, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x3B, 0xB8,
  0xFF, 0xF3, 0xFF, 0xDE, 0xF7, 0x73, 0x9D, 0xCE, 0x77, 0x39, 0xDC, 0xE7,
  0x73, 0x9F, 0xDC, 0xFE, 0x73, 0xB9, 0xCE, 0xE7, 0x3B, 0x9C, 0xE0, 0x1C,
  0xF0, 0x7F, 0xE3, 0xFF, 0x8F, 0x0F, 0x3C, 0x3C, 0xE0, 0xF3, 0x83, 0xCE,
  0x0E, 0x78, 0x39, 0xE0, 0xE7, 0x07, 0x9C, 0x1E, 0x70, 0x7B, 0xC1, 0xC0,
  0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x77, 0x83, 0xBC, 0x3C, 0xFF, 0xC7, 0xFC, 0x0F, 0xC0, 0x1D,
  0xE0, 0x7F, 0xE3, 0xFF, 0x8F, 0x0E, 0x3C, 0x3C, 0xE0, 0xF3, 0x83, 0xCE,
  0x0F, 0x78, 0x39, 0xE1, 0xE7, 0x87, 0x9F, 0xFC, 0x7F, 0xE1, 0xDF, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0x38, 0xFF,
  0xCF, 0xFE, 0xF0, 0xF7, 0x87, 0xB8, 0x3B, 0xC1, 0xDE, 0x0E, 0xF0, 0xF7,
  0x87, 0xBC, 0x3C, 0xFF, 0xC7, 0xFE, 0x1F, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x1C, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xC0,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFE, 0xF0, 0xF7, 0x80, 0x3E,
  0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x03, 0xB8, 0x1D, 0xF3, 0xE7, 0xFE,
  0x1F, 0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3F,
  0xC1, 0xFC, 0x0F, 0xC0, 0x38, 0x3C, 0xE0, 0xE3, 0x83, 0x9E, 0x0E, 0x78,
  0x79, 0xC1, 0xE7, 0x07, 0x9C, 0x1C, 0x70, 0x73, 0xC1, 0xC7, 0x0F, 0x1F,
  0xFC, 0x7F, 0xE0, 0xFB, 0x80, 0xE0, 0x7F, 0x83, 0xFC, 0x1C, 0xE1, 0xE7,
  0x0E, 0x38, 0xF1, 0xC7, 0x0E, 0x70, 0x3B, 0x81, 0xF8, 0x0F, 0xC0, 0x7C,
  0x01, 0xE0, 0x0E, 0x00, 0xF3, 0x9F, 0xC7, 0x3B, 0x8E, 0x77, 0x3D, 0xEE,
  0x7B, 0x9D, 0xF7, 0x3B, 0x6C, 0x76, 0xF8, 0xF9, 0xF1, 0xF3, 0xC3, 0xE7,
  0x87, 0x8F, 0x0F, 0x1C, 0x1E, 0x38, 0x00, 0x3C, 0x1F, 0x1C, 0x1C, 0x1E,
  0x3C, 0x0F, 0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1E, 0xF0, 0x3C, 0xF0, 0x78, 0x78, 0xF0, 0x38, 0x38,
  0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x1C, 0x78, 0x1E,
  0x78, 0x0E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x40, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x00, 0x01, 0xC0, 0xF0, 0x70, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x03, 0xC3, 0xC0, 0xF0, 0x3E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x04, 0x00, 0x18, 0xC6, 0x33, 0x98, 0xC6, 0x31, 0x8C, 0xE6, 0x31, 0x8C,
  0x67, 0x31, 0x8C, 0x63, 0x00, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0F, 0x03, 0xC1, 0xF0, 0xE0,
  0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x0F, 0x81, 0xC0, 0x40,
  0x00, 0x3E, 0x0D, 0xFC, 0x7F, 0x7F, 0xF8, 0xFE, 0x00, 0xF0,
};

const GFXglyph RobotoMono_BoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 18, 15, 4, -18 },
  { 17, 9, 7, 15, 4, -20 },
  { 25, 15, 18, 15, 0, -18 },
  { 59, 14, 24, 15, 1, -21 },
  { 101, 12, 19, 15, 2, -19 },
  { 130, 15, 19, 15, 0, -19 },
  { 166, 4, 7, 15, 6, -20 },
  { 170, 9, 27, 15, 4, -21 },
  { 201, 9, 27, 15, 2, -21 },
  { 232, 13, 13, 15, 2, -18 },
  { 254, 13, 13, 15, 1, -15 },
  { 276, 6, 8, 15, 2, -3 },
  { 282, 11, 3, 15, 3, -10 },
  { 287, 5, 4, 15, 4, -4 },
  { 290, 14, 20, 15, 1, -18 },
  { 325, 12, 19, 15, 2, -19 },
  { 354, 9, 18, 15, 3, -18 },
  { 375, 14, 19, 15, 0, -19 },
  { 409, 13, 19, 15, 1, -19 },
  { 440, 14, 18, 15, 0, -18 },
  { 472, 14, 18, 15, 1, -18 },
  { 504, 12, 19, 15, 1, -19 },
  { 533, 13, 18, 15, 2, -18 },
  { 563, 13, 19, 15, 1, -19 },
  { 594, 12, 19, 15, 2, -19 },
  { 623, 7, 14, 15, 4, -14 },
  { 636, 8, 19, 15, 3, -14 },
  { 655, 12, 12, 15, 2, -14 },
  { 673, 13, 8, 15, 1, -12 },
  { 686, 12, 12, 15, 1, -14 },
  { 704, 12, 19, 15, 3, -19 },
  { 733, 14, 18, 15, 1, -18 },
  { 765, 15, 18, 15, -1, -18 },
  { 799, 15, 18, 15, 0, -18 },
  { 833, 14, 19, 15, 1, -19 },
  { 867, 15, 18, 15, 0, -18 },
  { 901, 16, 18, 15, 0, -18 },
  { 937, 15, 18, 15, 1, -18 },
  { 971, 14, 19, 15, 1, -19 },
  { 1005, 15, 18, 15, 0, -18 },
  { 1039, 14, 18, 15, 1, -18 },
  { 1071, 14, 18, 15, 1, -18 },
  { 1103, 17, 18, 15, 0, -18 },
  { 1142, 12, 18, 15, 1, -18 },
  { 1169, 16, 18, 15, 0, -18 },
  { 1205, 15, 18, 15, 0, -18 },
  { 1239, 14, 19, 15, 1, -19 },
  { 1273, 14, 18, 15, 1, -18 },
  { 1305, 14, 22, 15, 1, -19 },
  { 1344, 15, 18, 15, 0, -18 },
  { 1378, 14, 19, 15, 1, -19 },
  { 1412, 15, 18, 15, 2, -18 },
  { 1446, 14, 18, 15, 1, -18 },
  { 1478, 15, 18, 15, 2, -18 },
  { 1512, 15, 18, 15, 2, -18 },
  { 1546, 18, 18, 15, -1, -18 },
  { 1587, 15, 18, 15, 2, -18 },
  { 1621, 16, 18, 15, 0, -18 },
  { 1657, 10, 25, 15, 3, -21 },
  { 1689, 6, 20, 15, 5, -18 },
  { 1704, 10, 25, 15, 3, -21 },
  { 1736, 10, 9, 15, 3, -18 },
  { 1748, 12, 3, 15, 0, 0 },
  { 1753, 5, 4, 15, 7, -19 },
  { 1756, 12, 14, 15, 1, -14 },
  { 1777, 14, 20, 15, 0, -20 },
  { 1812, 13, 14, 15, 1, -14 },
  { 1835, 14, 20, 15, 1, -20 },
  { 1870, 13, 14, 15, 1, -14 },
  { 1893, 14, 20, 15, 2, -20 },
  { 1928, 15, 19, 15, 0, -14 },
  { 1964, 14, 20, 15, 0, -20 },
  { 1999, 12, 19, 15, 1, -19 },
  { 2028, 12, 25, 15, 1, -19 },
  { 2066, 15, 20, 15, 0, -20 },
  { 2104, 12, 20, 15, 1, -20 },
  { 2134, 14, 14, 15, 0, -14 },
  { 2159, 14, 14, 15, 0, -14 },
  { 2184, 13, 14, 15, 1, -14 },
  { 2207, 14, 19, 15, 0, -14 },
  { 2241, 13, 19, 15, 1, -14 },
  { 2272, 13, 14, 15, 2, -14 },
  { 2295, 13, 14, 15, 1, -14 },
  { 2318, 12, 17, 15, 2, -17 },
  { 2344, 14, 14, 15, 1, -14 },
  { 2369, 13, 14, 15, 2, -14 },
  { 2392, 15, 14, 15, 1, -14 },
  { 2419, 16, 14, 15, 0, -14 },
  { 2447, 16, 20, 15, 0, -14 },
  { 2487, 15, 14, 15, 0, -14 },
  { 2514, 10, 25, 15, 4, -20 },
  { 2546, 5, 23, 15, 5, -18 },
  { 2561, 10, 25, 15, 2, -20 },
  { 2593, 14, 5, 15, 0, -10 },
};

const GFXfont RobotoMono_BoldItalic26pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic26pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOMONO_BOLDITALIC26PT7B_H_
