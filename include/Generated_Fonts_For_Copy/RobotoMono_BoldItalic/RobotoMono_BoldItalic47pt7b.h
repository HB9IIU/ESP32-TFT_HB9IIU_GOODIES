#ifndef _ROBOTOMONO_BOLDITALIC47PT7B_H_
#define _ROBOTOMONO_BOLDITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7C, 0x00, 0x7C, 0x1E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0x83,
  0xCF, 0x07, 0x9E, 0x0F, 0x7C, 0x1E, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0xC0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1E, 0x00,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x3F, 0xC1, 0xFC, 0x07, 0xE0,
  0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC,
  0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0x8F, 0x82, 0x1F, 0x0F, 0x06, 0x3C, 0x1E, 0x1E,
  0x78, 0x7C, 0x78, 0xF0, 0xF9, 0xF1, 0xE1, 0xE3, 0xC3, 0xE7, 0xCF, 0x07,
  0xFF, 0xBC, 0x07, 0xFE, 0x78, 0x07, 0xF9, 0xE0, 0x03, 0x87, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x3F, 0x00, 0x79, 0xFF, 0x00, 0xF7, 0xFF, 0x03, 0xCF,
  0xFE, 0x0F, 0x3E, 0x3C, 0x3E, 0x78, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE1,
  0xE1, 0x83, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x8F, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x7C, 0x7F,
  0xF8, 0x3F, 0x3F, 0xBF, 0x0F, 0x9F, 0xCF, 0xE3, 0xE7, 0xE1, 0xF9, 0xFB,
  0xF8, 0x7F, 0xFE, 0xFC, 0x0F, 0xFF, 0x3F, 0x03, 0xFF, 0x8F, 0xC0, 0x7F,
  0xE3, 0xF0, 0x1F, 0xF0, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x7E, 0x03, 0xFF, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7D, 0xF7, 0xDF, 0x79, 0xEF, 0xBE, 0xFB, 0xCF, 0x3C,
  0x00, 0x02, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x06, 0x03, 0xC0, 0xDE, 0x0E, 0x0F, 0xFE, 0x39, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xF7, 0x80, 0x0F, 0x9E, 0x00, 0x7C, 0x3C, 0x03,
  0xF0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x07, 0xC0, 0x60, 0x1C, 0x00, 0x80,
  0x60, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x7E,
  0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x3F, 0x03, 0x80, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFE, 0x7F, 0x87, 0xF0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xFC, 0xFC, 0x03,
  0xF9, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0x9F, 0x83, 0xFF,
  0x3F, 0x0F, 0xFE, 0x7E, 0x7F, 0xFC, 0xFD, 0xFB, 0xFB, 0xFF, 0xE7, 0xF7,
  0xFF, 0x0F, 0xCF, 0xFC, 0x1F, 0x9F, 0xE0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E,
  0x00, 0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x3F, 0xC0, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xF8, 0xFF, 0xFC, 0x7C, 0x7E, 0x30, 0x3F, 0x20, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xE7, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0,
  0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xC7, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x01, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x11, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x3F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0xDF, 0xC0,
  0x0F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F,
  0x03, 0xE0, 0x1F, 0x83, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF3, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x01,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0xFD, 0xFF, 0x87, 0xEF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF9, 0xFE, 0x0F, 0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0x9F, 0x80, 0xFE, 0x7F, 0x07,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xC7, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFE,
  0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0x03,
  0xF8, 0x1F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F,
  0x87, 0xF0, 0x3F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0x9F, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x7F, 0x00, 0xFD,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x7E, 0x03, 0xF9, 0xFC, 0x1F,
  0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0x7F, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0xFE,
  0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x7F, 0x0F, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0,
  0x7E, 0x00, 0x00, 0x70, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x18, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xC7,
  0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x07, 0xF9, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0x38, 0x3C, 0x1F, 0x8F, 0x1F, 0x1F, 0xF9, 0xC7, 0x8F, 0xFC, 0x73,
  0xC7, 0xE7, 0x1C, 0xF1, 0xE1, 0xC7, 0x38, 0xF0, 0xF1, 0xDE, 0x3C, 0x3C,
  0x77, 0x9E, 0x0E, 0x3D, 0xC7, 0x87, 0x8F, 0xF1, 0xE1, 0xE3, 0xBC, 0x78,
  0x78, 0xEF, 0x3C, 0x1C, 0x3B, 0xCF, 0x0F, 0x1E, 0xF3, 0xC3, 0xC7, 0x3C,
  0xF8, 0xF1, 0xCF, 0x1F, 0xFD, 0xE3, 0xC7, 0xFF, 0xF8, 0xF0, 0xFD, 0xFC,
  0x3C, 0x1C, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01,
  0x00, 0x0F, 0xE3, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3, 0xF0, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x81, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xFB,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00,
  0xFE, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0x80,
  0xFF, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xF8,
  0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0,
  0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x87, 0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xC7, 0xF8, 0x3F, 0x81,
  0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0,
  0x07, 0xEF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x04, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x7F, 0x83, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xF8, 0x1F,
  0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x1F,
  0xC7, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x3F, 0xC1, 0xFC, 0x3F, 0xE0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xCF, 0xF8,
  0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x1F, 0x9F, 0xC0, 0x0F,
  0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x07,
  0xFF, 0xBF, 0x83, 0xFF, 0xDF, 0x81, 0xFF, 0xCF, 0xC1, 0xFF, 0xE7, 0xE0,
  0xFF, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x7E,
  0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x3F, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x3F,
  0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01,
  0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFE,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x07, 0xF0,
  0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x03,
  0xFE, 0x07, 0xE0, 0x0F, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0x80, 0x7F,
  0x80, 0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xF8, 0x1F, 0xE0,
  0x03, 0xF0, 0x7F, 0x80, 0x07, 0xE1, 0xFE, 0x00, 0x0F, 0xC7, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x01,
  0xFB, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x3F,
  0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x7F,
  0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x0F,
  0xDE, 0xF7, 0xC0, 0xFD, 0xFF, 0x7C, 0x0F, 0xDF, 0xE7, 0xC0, 0xF9, 0xFE,
  0xFC, 0x0F, 0x9F, 0xCF, 0xC1, 0xF9, 0xFC, 0xFC, 0x1F, 0x9F, 0x8F, 0x81,
  0xF9, 0xF8, 0xF8, 0x1F, 0x9F, 0x1F, 0x81, 0xF1, 0xF1, 0xF8, 0x1F, 0x0F,
  0x1F, 0x83, 0xF0, 0xE1, 0xF8, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x80, 0x7E, 0x07, 0xFC,
  0x07, 0xE0, 0x7F, 0xC0, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0xC0, 0xFC,
  0x07, 0xFE, 0x0F, 0xC0, 0xFF, 0xE0, 0xFC, 0x0F, 0xFE, 0x1F, 0xC0, 0xFD,
  0xE1, 0xFC, 0x0F, 0xDE, 0x1F, 0x80, 0xFD, 0xF1, 0xF8, 0x0F, 0xDF, 0x1F,
  0x81, 0xFD, 0xF1, 0xF8, 0x1F, 0xCF, 0x3F, 0x81, 0xF8, 0xFB, 0xF8, 0x1F,
  0x8F, 0xBF, 0x01, 0xF8, 0xFB, 0xF0, 0x1F, 0x87, 0xBF, 0x03, 0xF8, 0x7F,
  0xF0, 0x3F, 0x87, 0xFF, 0x03, 0xF0, 0x7F, 0xF0, 0x3F, 0x03, 0xFE, 0x03,
  0xF0, 0x3F, 0xE0, 0x7F, 0x03, 0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0x7E, 0x01,
  0xFE, 0x07, 0xE0, 0x1F, 0xE0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0,
  0xFE, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F,
  0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFD,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F,
  0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03,
  0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xC0, 0x7F, 0x81, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x1F, 0xE0, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x7F, 0xCF, 0xF0, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0x7E, 0x1F,
  0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xF7,
  0xF0, 0x03, 0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F,
  0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x07,
  0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xF9, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0xC0,
  0x7F, 0x07, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0xC1,
  0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x1F,
  0x80, 0x3F, 0x83, 0xF0, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC3,
  0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x0F, 0xF8, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x87, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xF0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x7F,
  0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7F, 0x00,
  0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x7E,
  0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x1F,
  0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x7E,
  0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F,
  0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0x7C,
  0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0x07,
  0xEF, 0x83, 0xE0, 0xF9, 0xF0, 0x7C, 0x3F, 0x3E, 0x1F, 0x87, 0xE7, 0xC3,
  0xF0, 0xFC, 0xF8, 0x7E, 0x1F, 0x1F, 0x1F, 0xC7, 0xE7, 0xE3, 0xF8, 0xFC,
  0xFC, 0x7F, 0x1F, 0x1F, 0x9F, 0xE7, 0xE3, 0xF3, 0xFC, 0xFC, 0x7E, 0x7F,
  0x9F, 0x8F, 0xCF, 0xF3, 0xE1, 0xFB, 0xFE, 0xFC, 0x3F, 0x7B, 0xDF, 0x87,
  0xEF, 0x7B, 0xE0, 0xFF, 0xEF, 0x7C, 0x1F, 0xF9, 0xFF, 0x83, 0xFF, 0x3F,
  0xF0, 0x7F, 0xE7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F,
  0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC,
  0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x1F, 0xEF, 0xC0, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7F,
  0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xBF, 0x80,
  0x01, 0xF7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0,
  0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03,
  0xDE, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x3E,
  0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xE0,
  0x1E, 0xFC, 0x03, 0xE0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F,
  0x81, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xE0, 0x3F, 0x3F, 0x80, 0x7E,
  0x7E, 0x01, 0xFD, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE7, 0xF0, 0x3F, 0xC7,
  0xF9, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFE, 0xFC, 0x0F,
  0xF1, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x0F,
  0xDF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F,
  0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7F, 0x1F,
  0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7E,
  0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFD, 0xFF, 0xF0, 0xFD, 0xFF, 0xC0, 0xFC, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80,
  0x7E, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x79, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF8, 0x3F, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x1F, 0xE3, 0xF0, 0x0F, 0xFD, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0xFE,
  0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC,
  0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xE0,
  0xFE, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFE, 0xFC, 0x00, 0xFF, 0x3F, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC3, 0xFC, 0x3F, 0x8F, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x7F, 0x00,
  0x7E, 0xFC, 0x00, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x01, 0x83, 0xFC, 0x0F, 0x83, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0xFF, 0xEF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0x07, 0xF8, 0x7F,
  0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x8F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7E,
  0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xF9, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x04, 0x00, 0x7E, 0x07, 0x00, 0x7F, 0x03, 0xE0,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC7, 0xF0, 0x0F, 0xCF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xBF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x7F,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC,
  0xFC, 0x01, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00,
  0x00, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x10, 0xFF,
  0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0xFF, 0x87, 0xE0, 0x3F, 0xC0, 0xFC, 0x0F, 0xF0, 0x1F,
  0x83, 0xFC, 0x07, 0xF0, 0xFF, 0x00, 0xFC, 0x3F, 0xC0, 0x1F, 0x8F, 0xF0,
  0x03, 0xF3, 0xFC, 0x00, 0x7E, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFB, 0xF8, 0x01, 0xFE, 0x3F, 0x00, 0x3F, 0x87,
  0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xCF,
  0x8F, 0x81, 0xFB, 0xFB, 0xF8, 0x3E, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x1F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0xC7, 0xC3, 0xE1, 0xF1, 0xF8,
  0x7C, 0x3E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x0F, 0x87, 0xE3, 0xE1, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x00, 0x0F,
  0xC7, 0xF0, 0x0F, 0x9F, 0xFC, 0x0F, 0xBF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7F, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7E,
  0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC,
  0x01, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0x3F, 0x80,
  0x7F, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0x7E,
  0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xE3, 0xF8, 0x3F, 0x87,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x00, 0x80, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0xFD, 0xFF, 0x80,
  0x3E, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x0F,
  0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8,
  0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3,
  0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x3F,
  0x87, 0xE0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFD, 0xFF, 0xC0, 0x3F,
  0x1F, 0xE0, 0x0F, 0xC0, 0x80, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x3F, 0x03, 0xFF, 0x3F, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFE,
  0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFB, 0xF0, 0x0F,
  0xF3, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0xC3, 0xFE, 0x1F,
  0x9F, 0xF8, 0x3F, 0x7F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x07, 0xFE, 0x02, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFE, 0x3F, 0xE7, 0xF0,
  0x1F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x07, 0xF7, 0xF0, 0x0F, 0xCF, 0xF0, 0x7F, 0x8F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0,
  0x0F, 0xEF, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F,
  0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xFC, 0xFC, 0x03, 0xF9,
  0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xF0, 0x7F, 0x8F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFE, 0xFC, 0x1F, 0xF9, 0xF0, 0x1F, 0xE7, 0xE0, 0x02,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0x8F,
  0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xC1, 0xF8,
  0x03, 0xE0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x3C, 0x1F,
  0xFC, 0x1E, 0x0F, 0xFE, 0x1F, 0x07, 0xFF, 0x0F, 0x87, 0xEF, 0x87, 0xC3,
  0xF7, 0xC7, 0xE1, 0xF3, 0xE3, 0xF0, 0xF9, 0xF1, 0xF8, 0xFC, 0xF9, 0xFC,
  0x7C, 0x7C, 0xFE, 0x3E, 0x3E, 0x77, 0x3F, 0x1F, 0x7B, 0x9F, 0x0F, 0xBD,
  0xCF, 0x87, 0x9C, 0xE7, 0xC3, 0xDE, 0x77, 0xC1, 0xEF, 0x3B, 0xE0, 0xFF,
  0x1D, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F,
  0xE1, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x87,
  0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0xFE,
  0x1F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0xFE,
  0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x07,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x80, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x1E, 0x00, 0x01, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0xC3, 0xFF,
  0xC0, 0x7C, 0xFF, 0xF8, 0x1F, 0x7F, 0xFF, 0x0F, 0x9F, 0x9F, 0xFF, 0xE7,
  0x81, 0xFF, 0xF3, 0xE0, 0x3F, 0xFC, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0x00,
};

const GFXglyph RobotoMono_BoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 12, 33, 28, 8, -33 },
  { 51, 15, 12, 28, 8, -35 },
  { 74, 28, 33, 28, 0, -33 },
  { 190, 25, 44, 28, 2, -39 },
  { 328, 23, 35, 28, 3, -34 },
  { 429, 26, 35, 28, 1, -34 },
  { 543, 6, 12, 28, 12, -35 },
  { 552, 16, 47, 28, 7, -37 },
  { 646, 16, 48, 28, 4, -37 },
  { 742, 22, 23, 28, 4, -33 },
  { 806, 23, 25, 28, 2, -28 },
  { 878, 10, 15, 28, 4, -6 },
  { 897, 19, 5, 28, 6, -17 },
  { 909, 8, 8, 28, 8, -8 },
  { 917, 24, 36, 28, 2, -33 },
  { 1025, 23, 35, 28, 3, -34 },
  { 1126, 17, 33, 28, 5, -33 },
  { 1197, 25, 34, 28, 0, -34 },
  { 1304, 25, 35, 28, 1, -34 },
  { 1414, 25, 33, 28, 0, -33 },
  { 1518, 25, 34, 28, 2, -33 },
  { 1625, 22, 35, 28, 2, -34 },
  { 1722, 24, 33, 28, 3, -33 },
  { 1821, 25, 35, 28, 1, -34 },
  { 1931, 22, 34, 28, 3, -34 },
  { 2025, 12, 27, 28, 8, -27 },
  { 2066, 15, 36, 28, 6, -27 },
  { 2134, 22, 22, 28, 3, -25 },
  { 2195, 24, 15, 28, 2, -22 },
  { 2240, 22, 22, 28, 2, -25 },
  { 2301, 21, 34, 28, 6, -34 },
  { 2391, 26, 33, 28, 1, -33 },
  { 2499, 27, 33, 28, -2, -33 },
  { 2611, 28, 33, 28, 0, -33 },
  { 2727, 25, 35, 28, 2, -34 },
  { 2837, 26, 33, 28, 0, -33 },
  { 2945, 27, 33, 28, 1, -33 },
  { 3057, 28, 33, 28, 1, -33 },
  { 3173, 25, 35, 28, 2, -34 },
  { 3283, 28, 33, 28, 0, -33 },
  { 3399, 24, 33, 28, 2, -33 },
  { 3498, 26, 34, 28, 2, -33 },
  { 3609, 31, 33, 28, 0, -33 },
  { 3737, 22, 33, 28, 1, -33 },
  { 3828, 28, 33, 28, 0, -33 },
  { 3944, 28, 33, 28, 0, -33 },
  { 4060, 25, 35, 28, 2, -34 },
  { 4170, 27, 33, 28, 1, -33 },
  { 4282, 25, 40, 28, 2, -34 },
  { 4407, 27, 33, 28, 0, -33 },
  { 4519, 27, 34, 28, 1, -34 },
  { 4634, 27, 33, 28, 3, -33 },
  { 4746, 26, 34, 28, 2, -33 },
  { 4857, 26, 33, 28, 4, -33 },
  { 4965, 27, 33, 28, 3, -33 },
  { 5077, 32, 33, 28, -2, -33 },
  { 5209, 27, 33, 28, 4, -33 },
  { 5321, 28, 33, 28, 0, -33 },
  { 5437, 17, 47, 28, 6, -39 },
  { 5537, 11, 36, 28, 9, -33 },
  { 5587, 17, 47, 28, 6, -39 },
  { 5687, 19, 17, 28, 5, -33 },
  { 5728, 21, 5, 28, 0, 0 },
  { 5742, 10, 6, 28, 12, -34 },
  { 5750, 23, 25, 28, 1, -25 },
  { 5822, 24, 36, 28, 1, -35 },
  { 5930, 23, 26, 28, 2, -25 },
  { 6005, 26, 35, 28, 2, -35 },
  { 6119, 23, 25, 28, 2, -25 },
  { 6191, 25, 36, 28, 4, -36 },
  { 6304, 25, 35, 28, 1, -25 },
  { 6414, 24, 35, 28, 1, -35 },
  { 6519, 21, 35, 28, 2, -35 },
  { 6611, 22, 45, 28, 1, -35 },
  { 6735, 27, 35, 28, 1, -35 },
  { 6854, 21, 35, 28, 2, -35 },
  { 6946, 27, 25, 28, -1, -25 },
  { 7031, 24, 25, 28, 1, -25 },
  { 7106, 23, 26, 28, 2, -25 },
  { 7181, 26, 35, 28, -1, -25 },
  { 7295, 24, 35, 28, 2, -25 },
  { 7400, 23, 25, 28, 4, -25 },
  { 7472, 23, 26, 28, 2, -25 },
  { 7547, 21, 32, 28, 4, -31 },
  { 7631, 23, 26, 28, 3, -25 },
  { 7706, 25, 25, 28, 3, -25 },
  { 7785, 25, 25, 28, 3, -25 },
  { 7864, 28, 25, 28, 0, -25 },
  { 7952, 29, 35, 28, 0, -25 },
  { 8079, 26, 25, 28, 0, -25 },
  { 8161, 18, 45, 28, 7, -37 },
  { 8263, 11, 42, 28, 8, -33 },
  { 8321, 19, 45, 28, 4, -37 },
  { 8428, 26, 10, 28, 0, -19 },
};

const GFXfont RobotoMono_BoldItalic47pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic47pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOMONO_BOLDITALIC47PT7B_H_
