#ifndef _ROBOTOMONO_BOLDITALIC56PT7B_H_
#define _ROBOTOMONO_BOLDITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x3F,
  0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C,
  0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0,
  0x3E, 0x3E, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0xF8, 0x3E, 0x06, 0x1F, 0x07, 0xC1, 0xF3, 0xE0, 0xF8, 0x7C,
  0x7C, 0x1F, 0x0F, 0x9F, 0x83, 0xE3, 0xE3, 0xF0, 0xF8, 0xF8, 0x3E, 0x1F,
  0x1E, 0x07, 0xEF, 0xE7, 0xC0, 0xFF, 0xF9, 0xF0, 0x0F, 0xFE, 0x3C, 0x00,
  0xFF, 0x8F, 0x80, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0xFF, 0x80, 0x1F, 0x3F,
  0xF8, 0x07, 0xCF, 0xFF, 0x81, 0xF3, 0xFF, 0xF0, 0x3E, 0x7C, 0x3E, 0x0F,
  0x9F, 0x87, 0xC3, 0xE3, 0xE0, 0xF8, 0x78, 0x7C, 0x1F, 0x1F, 0x0F, 0x83,
  0xE1, 0xC1, 0xF0, 0x7C, 0x08, 0x3E, 0x0F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0x87, 0xFF, 0xE0,
  0x7F, 0x1F, 0xFF, 0xE0, 0xFE, 0x7F, 0x9F, 0xE1, 0xF9, 0xFE, 0x3F, 0xC7,
  0xF3, 0xFC, 0x3F, 0xCF, 0xEF, 0xF0, 0x3F, 0xBF, 0x9F, 0xE0, 0x7F, 0xFF,
  0x3F, 0xC0, 0x7F, 0xFC, 0x7F, 0x80, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xE1,
  0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xE7, 0xF8, 0x07, 0xFF, 0x07, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x3F,
  0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8,
  0xF8, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x07, 0x80, 0xE7,
  0xC1, 0xF0, 0x7D, 0xFE, 0x3E, 0x3F, 0xBF, 0xF7, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0xC7, 0xE0, 0x07, 0xF0, 0x7E, 0x01, 0xFC,
  0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x38, 0x03, 0xC0,
  0x02, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0x7C, 0x01,
  0x80, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0x3F, 0x1F,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x01, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE,
  0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x07, 0xFE, 0x3F, 0x80, 0xFF, 0xE3, 0xF8,
  0x3F, 0xFE, 0x3F, 0x87, 0xFF, 0xE7, 0xF9, 0xFF, 0xFE, 0x7F, 0xBF, 0x9F,
  0xC7, 0xFF, 0xF1, 0xFC, 0x7F, 0xFC, 0x1F, 0xC7, 0xFF, 0x81, 0xFC, 0x7F,
  0xE0, 0x3F, 0xC7, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x03,
  0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7F, 0x1F, 0xC7, 0x83, 0xFC, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0x81,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x3F, 0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF8, 0x07,
  0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0x7F, 0xC0, 0x06, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x81,
  0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x80, 0x07, 0xF1, 0xFF, 0x00, 0xFE, 0xFF, 0xF0,
  0x3F, 0xBF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x07, 0xFB,
  0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFD, 0xFC, 0x00,
  0x7F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F,
  0xC0, 0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x1F,
  0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE4,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F,
  0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x03, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF8,
  0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x3F,
  0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF,
  0x00, 0x7F, 0x8F, 0xF8, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0x3F,
  0x9F, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE, 0x03, 0xFE,
  0x7F, 0xC1, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0x9F, 0xC0, 0x3F, 0x8F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFF,
  0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F,
  0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x1F,
  0xC0, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0x07, 0xFD, 0xFF, 0x01,
  0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0xFC, 0x1E, 0x0F, 0x83, 0xFF, 0x1E, 0x0F, 0x87, 0xFF,
  0x9E, 0x1F, 0x0F, 0xFF, 0x1E, 0x1F, 0x1F, 0x8F, 0x1E, 0x3E, 0x3F, 0x0F,
  0x1E, 0x3E, 0x3E, 0x0F, 0x1E, 0x3C, 0x7C, 0x1E, 0x1E, 0x7C, 0x7C, 0x1E,
  0x1E, 0x7C, 0x7C, 0x1E, 0x1E, 0x78, 0xF8, 0x1E, 0x1E, 0x78, 0xF8, 0x3E,
  0x1E, 0xF8, 0xF8, 0x3C, 0x3C, 0xF8, 0xF8, 0x3C, 0x3C, 0xF8, 0xF8, 0x3C,
  0x3C, 0xF8, 0xF8, 0x7C, 0x38, 0xF8, 0xF8, 0x78, 0x78, 0xF8, 0xF8, 0xF8,
  0x70, 0xF8, 0xFF, 0xFD, 0xF0, 0xF8, 0xFF, 0xFF, 0xE0, 0xF8, 0x7F, 0xBF,
  0xC0, 0x78, 0x3F, 0x3F, 0x80, 0x78, 0x08, 0x0E, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x10, 0x00, 0x1F, 0xC0, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00,
  0xFE, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x1F,
  0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF0, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03,
  0xFC, 0x0F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xC0, 0x3F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x7F,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x7F,
  0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x3F, 0xC0,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0xFF, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x0F,
  0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0x1F, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xF0,
  0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFC,
  0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F,
  0xC0, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0x07, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0x81, 0xFE, 0x00, 0xFE, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0xF9, 0xFC,
  0x07, 0xFF, 0xC7, 0xF0, 0x3F, 0xFF, 0x3F, 0xC0, 0xFF, 0xFC, 0xFF, 0x03,
  0xFF, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03,
  0xF8, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE,
  0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F,
  0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0,
  0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x03,
  0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0,
  0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x80, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xF0, 0x3F, 0xC0, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0x80,
  0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xF8,
  0x00, 0x7F, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x0F,
  0xE3, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xEF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF9, 0xFE, 0x00,
  0x03, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x87,
  0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFE,
  0x7F, 0xFC, 0x07, 0xF7, 0xDF, 0x7F, 0x01, 0xFD, 0xFF, 0xDF, 0x80, 0x7F,
  0x7F, 0xE7, 0xE0, 0x1F, 0x9F, 0xFB, 0xF8, 0x07, 0xE7, 0xFE, 0xFE, 0x03,
  0xF9, 0xFF, 0x3F, 0x80, 0xFE, 0x7F, 0xCF, 0xE0, 0x3F, 0x9F, 0xE3, 0xF0,
  0x0F, 0xE7, 0xF8, 0xFC, 0x03, 0xF1, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x1F,
  0xC0, 0x7F, 0x0F, 0x87, 0xF0, 0x1F, 0xC3, 0xE1, 0xFC, 0x07, 0xF0, 0xF0,
  0x7E, 0x01, 0xFC, 0x3C, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x1F, 0xF8,
  0x03, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0x01, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xE0, 0x3F, 0x80, 0xFF,
  0xF0, 0x1F, 0xC0, 0x7F, 0xFC, 0x1F, 0xE0, 0x3F, 0xFE, 0x0F, 0xF0, 0x1F,
  0xDF, 0x07, 0xF8, 0x0F, 0xEF, 0x83, 0xF8, 0x0F, 0xF7, 0xE1, 0xFC, 0x07,
  0xFB, 0xF1, 0xFE, 0x03, 0xFC, 0xF8, 0xFF, 0x01, 0xFE, 0x7C, 0x7F, 0x80,
  0xFE, 0x3F, 0x3F, 0xC0, 0x7F, 0x1F, 0x9F, 0xC0, 0x7F, 0x87, 0xCF, 0xE0,
  0x3F, 0xC3, 0xEF, 0xF0, 0x1F, 0xE1, 0xFF, 0xF8, 0x0F, 0xE0, 0xFF, 0xFC,
  0x07, 0xF0, 0x7F, 0xFC, 0x03, 0xF8, 0x1F, 0xFE, 0x03, 0xFC, 0x0F, 0xFF,
  0x01, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0xFF,
  0xE0, 0x3F, 0x80, 0x7F, 0xE0, 0x1F, 0xC0, 0x3F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xF8, 0x01,
  0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xE1,
  0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFE,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x80,
  0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0xFE, 0x7F, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F,
  0xBF, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xFE,
  0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFE, 0x0F, 0xE0, 0x0F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xE1, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80,
  0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03,
  0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF,
  0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x18, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x1F,
  0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x01,
  0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x1F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x7F,
  0xC1, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFC,
  0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F,
  0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF1,
  0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x3F, 0xC0,
  0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x01,
  0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0xFF, 0x9F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0x80, 0x0F,
  0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03,
  0xFC, 0x3F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x3F, 0xBF, 0x81, 0xF8,
  0x3F, 0x9F, 0xC1, 0xFC, 0x1F, 0xCF, 0xE0, 0xFC, 0x0F, 0xE7, 0xF0, 0x7E,
  0x07, 0xE3, 0xF8, 0x3F, 0x07, 0xF1, 0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x1F,
  0xC1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x1F, 0xC7,
  0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x3F, 0x07, 0xF1, 0xFE, 0x3F, 0x83, 0xF9,
  0xFF, 0x1F, 0xC1, 0xFC, 0xFF, 0x8F, 0xE0, 0xFE, 0x7F, 0xC7, 0xE0, 0x7E,
  0x7F, 0xE7, 0xF0, 0x3F, 0x3F, 0xF3, 0xF8, 0x1F, 0x9F, 0xF9, 0xF8, 0x0F,
  0xDF, 0xFD, 0xFC, 0x07, 0xEF, 0xBE, 0xFE, 0x03, 0xF7, 0xDF, 0x7F, 0x01,
  0xFB, 0xEF, 0xBF, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0xC0,
  0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xF0,
  0x07, 0xFE, 0x3F, 0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x3F,
  0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFC,
  0x7F, 0x80, 0x07, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0,
  0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3E, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xEF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8,
  0x7C, 0x07, 0xE1, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E,
  0x1F, 0x80, 0xF8, 0xFC, 0x03, 0xE7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xFE,
  0x00, 0xFC, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFC, 0x3F, 0x8F, 0xF8, 0x07, 0xF3, 0xFE, 0x00, 0xFE, 0x7F,
  0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x3F,
  0xE7, 0xF8, 0x0F, 0xF8, 0xFF, 0x87, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xE7, 0xF0, 0x1F, 0xF8, 0xFF,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xF9, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8,
  0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xFC, 0x00,
  0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF,
  0xC0, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFE, 0x7F, 0xFC, 0x07, 0xF0, 0xFF, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1,
  0xFF, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xDF, 0xE0, 0x07,
  0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x3F, 0xC0, 0x1F, 0xCF, 0xF0, 0x0F, 0xF1, 0xFE, 0x07, 0xFC, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80,
  0x1F, 0xFC, 0xFF, 0x00, 0x7F, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFE, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F,
  0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0xFE,
  0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF7, 0xF8,
  0x00, 0x7F, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x40, 0x7F, 0xC0, 0x0E, 0x03, 0xFE, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x80,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFC, 0x01, 0xFF, 0xE7, 0xF0, 0x0F,
  0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFC,
  0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F,
  0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFF, 0x00,
  0x7F, 0x83, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF7, 0xF0,
  0x07, 0xFF, 0xBF, 0xC0, 0x07, 0xFC, 0xFE, 0x00, 0x01, 0x83, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x10, 0x00, 0x7F, 0x80, 0xE0, 0x03, 0xFC, 0x03, 0xC0,
  0x1F, 0xF0, 0x1F, 0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0xFF, 0xC0, 0x1F, 0xDF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03,
  0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF8,
  0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xFC,
  0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF8,
  0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xFC,
  0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF0, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x06, 0x1F,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x03, 0xFF, 0x07, 0xF0, 0x07, 0xFE, 0x07, 0xF0, 0x0F, 0xFC, 0x07, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xE0,
  0xFF, 0x80, 0x0F, 0xE1, 0xFF, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x0F, 0xE7,
  0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xF7,
  0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x00,
  0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xE0, 0x07, 0xF3, 0xF0, 0xF8, 0x07, 0xE7, 0xF9, 0xFE, 0x07,
  0xEF, 0xFB, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xF3, 0xFE, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F,
  0xE1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F,
  0xC3, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x3F,
  0x87, 0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F,
  0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F,
  0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE,
  0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x8F, 0xFC, 0x01, 0xF9,
  0xFF, 0xF0, 0x1F, 0xDF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xE0, 0x07, 0xF8,
  0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFE,
  0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xFC,
  0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE,
  0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x7F,
  0x87, 0xFC, 0x0F, 0xF8, 0x3F, 0xF7, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF3, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x03,
  0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFE,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x0F,
  0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x03, 0xF8, 0x0E,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x1F, 0xFC, 0x7F, 0x03, 0xFF,
  0xE7, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xF0, 0x7F, 0xE3, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xE7, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x3F,
  0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07,
  0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFE, 0x00, 0x7F, 0x8F, 0xE0,
  0x00, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0xFE, 0x3F, 0xFC, 0x1F, 0x8F,
  0xFF, 0x07, 0xF3, 0xFF, 0xE0, 0xFE, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x7C, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xE7, 0xFE, 0x1F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00,
  0xFF, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x07,
  0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0xFF, 0x1F,
  0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xE7,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00,
  0x1F, 0xC7, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC,
  0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0,
  0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xF7, 0xF0, 0x1F,
  0xFE, 0x7F, 0x00, 0xFF, 0x87, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x07,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x01, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFE,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x07, 0xC0, 0xFF, 0xFC, 0x1F, 0x83, 0xFB, 0xF8, 0x3F, 0x07, 0xF7, 0xF0,
  0x7E, 0x0F, 0xEF, 0xE1, 0xFC, 0x1F, 0x9F, 0x83, 0xF8, 0x7F, 0x3F, 0x07,
  0xF0, 0xFE, 0x7E, 0x1F, 0xE1, 0xF8, 0xFC, 0x3F, 0xC7, 0xF1, 0xF8, 0x7F,
  0x8F, 0xE3, 0xF1, 0xFF, 0x1F, 0x87, 0xE3, 0xFE, 0x3F, 0x0F, 0xC7, 0xFC,
  0xFE, 0x1F, 0x9F, 0x79, 0xF8, 0x3F, 0x3C, 0xF3, 0xF0, 0x7E, 0xF9, 0xEF,
  0xE0, 0xFD, 0xF3, 0xDF, 0x81, 0xFB, 0xC7, 0xBF, 0x03, 0xFF, 0x8F, 0xFC,
  0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0,
  0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x01,
  0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01,
  0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF8, 0x0F, 0xF0,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0x3F, 0x7F, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x08, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0x40, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0xF8, 0xFF, 0xF8, 0x03, 0xF3, 0xFF, 0xFC, 0x07, 0xE7,
  0xFF, 0xFC, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0x07, 0xFF, 0xFC, 0x7C,
  0x07, 0xFF, 0xF9, 0xF0, 0x07, 0xFF, 0xE3, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00,
};

const GFXglyph RobotoMono_BoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 14, 40, 33, 10, -40 },
  { 71, 19, 14, 33, 9, -42 },
  { 105, 33, 40, 33, 0, -40 },
  { 270, 30, 52, 33, 2, -46 },
  { 465, 27, 41, 33, 3, -40 },
  { 604, 31, 42, 33, 1, -41 },
  { 767, 8, 15, 33, 14, -42 },
  { 782, 19, 57, 33, 9, -44 },
  { 918, 20, 57, 33, 4, -44 },
  { 1061, 27, 28, 33, 4, -40 },
  { 1156, 28, 29, 33, 2, -33 },
  { 1258, 12, 18, 33, 5, -7 },
  { 1285, 23, 7, 33, 7, -21 },
  { 1306, 10, 10, 33, 9, -9 },
  { 1319, 29, 43, 33, 2, -40 },
  { 1475, 28, 41, 33, 3, -40 },
  { 1619, 20, 40, 33, 6, -40 },
  { 1719, 30, 40, 33, 0, -40 },
  { 1869, 30, 41, 33, 1, -40 },
  { 2023, 29, 40, 33, 1, -40 },
  { 2168, 30, 41, 33, 2, -40 },
  { 2322, 27, 41, 33, 2, -40 },
  { 2461, 30, 40, 33, 3, -40 },
  { 2611, 28, 41, 33, 2, -40 },
  { 2755, 26, 40, 33, 4, -40 },
  { 2885, 14, 33, 33, 10, -32 },
  { 2943, 18, 43, 33, 7, -32 },
  { 3040, 26, 26, 33, 4, -30 },
  { 3125, 28, 18, 33, 3, -26 },
  { 3188, 27, 26, 33, 2, -30 },
  { 3276, 25, 40, 33, 7, -40 },
  { 3401, 32, 39, 33, 1, -39 },
  { 3557, 32, 40, 33, -2, -40 },
  { 3717, 32, 40, 33, 1, -40 },
  { 3877, 30, 41, 33, 2, -40 },
  { 4031, 31, 40, 33, 0, -40 },
  { 4186, 33, 40, 33, 1, -40 },
  { 4351, 33, 40, 33, 1, -40 },
  { 4516, 30, 41, 33, 2, -40 },
  { 4670, 33, 40, 33, 0, -40 },
  { 4835, 30, 40, 33, 2, -40 },
  { 4985, 31, 41, 33, 2, -40 },
  { 5144, 36, 40, 33, 1, -40 },
  { 5324, 27, 40, 33, 1, -40 },
  { 5459, 34, 40, 33, 0, -40 },
  { 5629, 33, 40, 33, 0, -40 },
  { 5794, 30, 41, 33, 2, -40 },
  { 5948, 32, 40, 33, 1, -40 },
  { 6108, 30, 47, 33, 2, -40 },
  { 6285, 32, 40, 33, 1, -40 },
  { 6445, 31, 41, 33, 2, -40 },
  { 6604, 32, 40, 33, 4, -40 },
  { 6764, 30, 41, 33, 3, -40 },
  { 6918, 31, 40, 33, 5, -40 },
  { 7073, 33, 40, 33, 3, -40 },
  { 7238, 38, 40, 33, -2, -40 },
  { 7428, 32, 40, 33, 5, -40 },
  { 7588, 34, 40, 33, 0, -40 },
  { 7758, 20, 55, 33, 7, -46 },
  { 7896, 13, 43, 33, 11, -40 },
  { 7966, 20, 55, 33, 7, -46 },
  { 8104, 22, 21, 33, 6, -40 },
  { 8162, 25, 6, 33, 0, 0 },
  { 8181, 11, 7, 33, 15, -40 },
  { 8191, 27, 31, 33, 2, -30 },
  { 8296, 29, 43, 33, 1, -42 },
  { 8452, 26, 31, 33, 3, -30 },
  { 8553, 31, 43, 33, 2, -42 },
  { 8720, 28, 31, 33, 2, -30 },
  { 8829, 30, 43, 33, 5, -43 },
  { 8991, 30, 42, 33, 1, -30 },
  { 9149, 29, 42, 33, 1, -42 },
  { 9302, 24, 41, 33, 3, -41 },
  { 9425, 26, 53, 33, 1, -41 },
  { 9598, 32, 42, 33, 1, -42 },
  { 9766, 26, 42, 33, 2, -42 },
  { 9903, 32, 30, 33, -1, -30 },
  { 10023, 29, 30, 33, 1, -30 },
  { 10132, 28, 31, 33, 2, -30 },
  { 10241, 30, 41, 33, -1, -30 },
  { 10395, 28, 41, 33, 3, -30 },
  { 10539, 27, 30, 33, 5, -30 },
  { 10641, 28, 31, 33, 2, -30 },
  { 10750, 25, 38, 33, 5, -37 },
  { 10869, 28, 31, 33, 3, -30 },
  { 10978, 29, 30, 33, 4, -30 },
  { 11087, 31, 30, 33, 3, -30 },
  { 11204, 33, 30, 33, 0, -30 },
  { 11328, 35, 42, 33, 0, -30 },
  { 11512, 31, 30, 33, 1, -30 },
  { 11629, 22, 54, 33, 8, -44 },
  { 11778, 12, 51, 33, 10, -40 },
  { 11855, 22, 54, 33, 5, -44 },
  { 12004, 31, 13, 33, 0, -23 },
};

const GFXfont RobotoMono_BoldItalic56pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic56pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOMONO_BOLDITALIC56PT7B_H_
