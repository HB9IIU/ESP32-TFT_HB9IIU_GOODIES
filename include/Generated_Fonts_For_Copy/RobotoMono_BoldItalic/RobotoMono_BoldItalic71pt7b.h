#ifndef _ROBOTOMONO_BOLDITALIC71PT7B_H_
#define _ROBOTOMONO_BOLDITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0x40, 0x00, 0x3F, 0xC0, 0xFE, 0x7F,
  0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xE0,
  0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03,
  0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F,
  0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x02, 0x03, 0xF8, 0x3F, 0x80, 0xF0,
  0x7E, 0x07, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0xC1,
  0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC1, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0x83, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x1F, 0x80, 0x7F,
  0xFF, 0xC7, 0xE0, 0x0F, 0xFF, 0xF9, 0xF8, 0x00, 0xFF, 0xFE, 0x3F, 0x00,
  0x0F, 0xFF, 0x8F, 0xC0, 0x00, 0xFF, 0xE3, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE1, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0xF8, 0x00, 0x3F, 0x3F,
  0xFF, 0x80, 0x0F, 0xCF, 0xFF, 0xF0, 0x03, 0xF1, 0xFF, 0xFF, 0x00, 0x7E,
  0x7F, 0x9F, 0xE0, 0x1F, 0x8F, 0xE0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x80,
  0xFC, 0x7F, 0x03, 0xF8, 0x3F, 0x0F, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC, 0x0F,
  0xC3, 0xF8, 0x3F, 0x01, 0xF8, 0x1E, 0x07, 0xE0, 0x3F, 0x00, 0x80, 0xFC,
  0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0x83,
  0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xFF, 0xFF,
  0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0xFD, 0xFF, 0x81, 0xFE,
  0x1F, 0xF9, 0xFF, 0x83, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x3F, 0xF0,
  0x7F, 0xC7, 0xFC, 0x7F, 0xE0, 0x7F, 0xE7, 0xFC, 0x7F, 0xE0, 0x3F, 0xFF,
  0xF8, 0x7F, 0xC0, 0x3F, 0xFF, 0xF8, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x3F, 0xF0, 0x01,
  0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xE3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0x00, 0x1F, 0x80, 0x18, 0x78, 0x03, 0xF0, 0x0F,
  0x1F, 0xC0, 0x7C, 0x07, 0xE3, 0xFE, 0x0F, 0x87, 0xFC, 0x7F, 0xF1, 0xF3,
  0xFF, 0x9F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xC0, 0x03, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x81, 0xFE, 0x1F, 0xF9, 0xFF, 0xEF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF,
  0xC3, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF0, 0x00,
  0x7F, 0xE3, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0x9F, 0xF8,
  0x01, 0xFF, 0xE3, 0xFF, 0x00, 0x7F, 0xFC, 0x7F, 0xE0, 0x3F, 0xFF, 0x8F,
  0xF8, 0x0F, 0xFF, 0xF1, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xE1, 0xFF, 0xFF,
  0xC7, 0xFC, 0xFF, 0xDF, 0xF1, 0xFF, 0xBF, 0xE3, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7F, 0xC7, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0x1F, 0xFF,
  0x80, 0x7F, 0xE3, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0x1F,
  0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF,
  0x8F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFC, 0x7F, 0xC3, 0xF0, 0x3F, 0xE3, 0xE0, 0x1F, 0xF1, 0x80, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xE3, 0xFE,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0xC0,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x01, 0xFE, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0xF8, 0x00, 0x18, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x03,
  0x80, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xCF, 0xFF, 0xC0, 0x1F, 0xF7,
  0xFF, 0xF8, 0x0F, 0xFB, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xC7,
  0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF,
  0x9F, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xF0,
  0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xFC, 0x7F,
  0xC0, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0,
  0x07, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0x9F, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0xF7, 0xFC, 0x00,
  0xFF, 0xE3, 0xFE, 0x00, 0x03, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F,
  0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x0F, 0xF8, 0x3E, 0x03,
  0xF0, 0x3F, 0xFE, 0x3F, 0x07, 0xF0, 0x7F, 0xFF, 0x1F, 0x07, 0xE0, 0xFF,
  0xFE, 0x1F, 0x0F, 0xC1, 0xFF, 0xFE, 0x1F, 0x0F, 0xC3, 0xFC, 0x3E, 0x1F,
  0x1F, 0x83, 0xF8, 0x3E, 0x1F, 0x1F, 0x87, 0xF0, 0x7C, 0x1F, 0x1F, 0x87,
  0xE0, 0x7C, 0x1F, 0x3F, 0x0F, 0xC0, 0x7C, 0x1F, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x3F, 0x1F, 0xC0, 0xFC, 0x3E, 0x7E, 0x1F, 0x80, 0xF8, 0x3E, 0x7E,
  0x1F, 0x80, 0xF8, 0x3E, 0x7E, 0x1F, 0x81, 0xF8, 0x3E, 0x7E, 0x1F, 0x81,
  0xF8, 0x3E, 0x7C, 0x3F, 0x01, 0xF0, 0x7C, 0x7C, 0x3F, 0x01, 0xF0, 0x7C,
  0x7C, 0x3F, 0x03, 0xF0, 0x7C, 0xFC, 0x3F, 0x03, 0xF0, 0x78, 0xFC, 0x3F,
  0x03, 0xE0, 0xF8, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0xFC, 0x3F, 0x8F, 0xE1,
  0xF0, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7C, 0x1F, 0xFF, 0xFF, 0xE0, 0x7C,
  0x0F, 0xFD, 0xFF, 0xC0, 0x7E, 0x0F, 0xF9, 0xFF, 0x80, 0x7E, 0x07, 0xF0,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x01, 0x80, 0x00, 0x0F, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00,
  0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xE0,
  0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xC7, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xF0,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xFF,
  0x3F, 0xF0, 0x0F, 0xFF, 0xFC, 0xFF, 0xC0, 0x3F, 0xFF, 0xE3, 0xFF, 0x00,
  0xFF, 0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0xF8,
  0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF9, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC7,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x03,
  0xFD, 0xF8, 0xFF, 0xFF, 0x00, 0xFF, 0x7E, 0x3F, 0xFF, 0x80, 0x3F, 0xDF,
  0x9F, 0xDF, 0xE0, 0x0F, 0xF7, 0xE7, 0xF7, 0xF8, 0x07, 0xFD, 0xFB, 0xF9,
  0xFE, 0x01, 0xFF, 0x7E, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xFF, 0x3F, 0xE0,
  0x1F, 0xE7, 0xFF, 0xCF, 0xF0, 0x07, 0xF9, 0xFF, 0xE3, 0xFC, 0x01, 0xFE,
  0x7F, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF,
  0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC7, 0xFC, 0x03, 0xFC, 0x3F, 0xE1, 0xFE,
  0x00, 0xFF, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x3F, 0xE0, 0x1F,
  0xF0, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0x83, 0xFE, 0x01, 0xFF, 0x0F,
  0xE0, 0xFF, 0x00, 0x7F, 0xC3, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7C, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F,
  0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xF0,
  0x0F, 0xFF, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xBF, 0xC1,
  0xFF, 0x00, 0x7F, 0xCF, 0xE0, 0xFF, 0x80, 0x7F, 0xE7, 0xF0, 0xFF, 0xC0,
  0x3F, 0xF3, 0xF8, 0x7F, 0xE0, 0x1F, 0xF9, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x7F, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0x8F, 0xF8, 0x03, 0xFE, 0x1F, 0xC7,
  0xFC, 0x03, 0xFF, 0x0F, 0xE7, 0xFE, 0x01, 0xFF, 0x83, 0xFB, 0xFF, 0x00,
  0xFF, 0xC1, 0xFD, 0xFF, 0x80, 0x7F, 0xC0, 0xFE, 0xFF, 0xC0, 0x3F, 0xE0,
  0x7F, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFF,
  0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFE, 0x00,
  0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xF8,
  0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x00, 0xFF, 0xDF,
  0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03,
  0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F,
  0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x7F,
  0xC7, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x07,
  0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0xFF,
  0x80, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x01,
  0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0xFF, 0xF1, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x3F,
  0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0x81, 0xFF,
  0x80, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFB,
  0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x01,
  0xFF, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF,
  0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x9F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xDF, 0xF0, 0x1F, 0xE0, 0x3F, 0xCF, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xF8, 0x0F,
  0xF9, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x7F,
  0xC1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xF0, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0xFF,
  0x0F, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xFF,
  0x87, 0xF8, 0x1F, 0xE3, 0xFF, 0xC7, 0xFC, 0x0F, 0xF1, 0xFF, 0xE3, 0xFC,
  0x07, 0xF8, 0xFF, 0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0xF9, 0xFF, 0x01, 0xFE,
  0x7E, 0xFC, 0xFF, 0x80, 0xFF, 0x3F, 0x7E, 0x7F, 0x80, 0x7F, 0xBF, 0xBF,
  0x3F, 0xC0, 0x3F, 0xDF, 0x9F, 0xBF, 0xE0, 0x1F, 0xEF, 0xCF, 0xDF, 0xE0,
  0x0F, 0xFF, 0xE7, 0xEF, 0xF0, 0x07, 0xFF, 0xF3, 0xF7, 0xF8, 0x03, 0xFF,
  0xF1, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0x83, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x81, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xBF,
  0xF0, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x87, 0xFC, 0x00,
  0x03, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x10, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFD, 0xFC,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xF1, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x1F,
  0xC0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF7, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC1, 0xFF, 0x03, 0xFE,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFE, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xE7, 0xFF, 0x80, 0x1F,
  0xF9, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x07, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xEF, 0xF8, 0x0F, 0xFF, 0xE3, 0xFE,
  0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x3F,
  0xFE, 0x00, 0x3F, 0xF7, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF,
  0x80, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x03, 0xFF,
  0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF,
  0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFD, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xFF, 0xF8, 0x07, 0xF8,
  0x7F, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0x7F,
  0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xFF,
  0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF7,
  0xF8, 0x00, 0x3F, 0xFF, 0xCF, 0xF0, 0x00, 0x3F, 0xFF, 0x1F, 0xE0, 0x00,
  0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x08,
  0x07, 0xFF, 0x00, 0x07, 0x80, 0x7F, 0xF0, 0x01, 0xF8, 0x0F, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x08, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xC0, 0xFF,
  0xC3, 0xDE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xFF,
  0x9F, 0xF0, 0x01, 0xFF, 0xFF, 0xBF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xDF, 0xF8, 0x00,
  0x0F, 0xFE, 0x3F, 0xE0, 0x00, 0x03, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00,
  0x70, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFF, 0x1F, 0xFF,
  0x00, 0x1F, 0xF1, 0xFF, 0xFC, 0x00, 0xFF, 0x9F, 0xFF, 0xF0, 0x07, 0xFD,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F,
  0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFC, 0x3F,
  0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xF0,
  0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x7F, 0xC0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x1F,
  0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xFE, 0x00,
  0x0F, 0xFC, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xFE, 0x00, 0x03, 0xFE,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xFE,
  0x00, 0x00, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x3F, 0x01, 0xF8, 0x01,
  0xFE, 0x7F, 0xE3, 0xFE, 0x00, 0xFF, 0x7F, 0xF3, 0xFF, 0x80, 0x7F, 0xBF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFC, 0x3F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F,
  0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7F,
  0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF,
  0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFC,
  0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xFC,
  0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xF8, 0x00, 0xFF, 0x8F, 0xFF, 0xE0, 0x07,
  0xFC, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F,
  0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x07, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xFB, 0xFE,
  0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xF7, 0xFC, 0x00,
  0x07, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xF0,
  0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0xFF, 0x00, 0x1F,
  0xF3, 0xFF, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0xF0, 0xFF,
  0x00, 0x7F, 0xFF, 0x9F, 0xF0, 0x1F, 0xFF, 0xFD, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFE,
  0x1F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xE7,
  0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xC0, 0x00, 0x3C, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0xFC, 0x0F, 0xF9,
  0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x07, 0xC0, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F,
  0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x03, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFE,
  0x1F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0x87, 0xFE,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8,
  0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0xF7, 0xFC, 0x01, 0xFF, 0xFE, 0x7F, 0xC0,
  0x0F, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x9F,
  0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x07,
  0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xCF,
  0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xF0, 0x1F,
  0xF7, 0xF8, 0x0F, 0xE0, 0x3F, 0xEF, 0xF0, 0x1F, 0xC0, 0x7F, 0x9F, 0xE0,
  0x7F, 0x81, 0xFF, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0xFF, 0x07, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xF8, 0x3F, 0xE3, 0xFC,
  0x3F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0xC3,
  0xFE, 0x1F, 0xE3, 0xFF, 0x87, 0xF8, 0x3F, 0xC7, 0xFF, 0x0F, 0xF0, 0x7F,
  0x8F, 0xBE, 0x1F, 0xE0, 0xFF, 0x3F, 0x7C, 0x7F, 0x81, 0xFC, 0x7E, 0xF8,
  0xFF, 0x03, 0xF8, 0xF9, 0xF1, 0xFE, 0x07, 0xF3, 0xF3, 0xE7, 0xF8, 0x0F,
  0xE7, 0xE7, 0xCF, 0xF0, 0x1F, 0xCF, 0x8F, 0x9F, 0xC0, 0x3F, 0xBF, 0x1F,
  0x7F, 0x80, 0x7F, 0x7C, 0x3E, 0xFF, 0x00, 0xFE, 0xF8, 0x7D, 0xFC, 0x01,
  0xFF, 0xF0, 0xFB, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x1F, 0xF0,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x3F,
  0xF3, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0x80, 0x7F, 0xFF, 0x80, 0x07, 0xF1, 0xFF, 0xFF, 0x80, 0x0F,
  0xE3, 0xFF, 0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0xFF, 0x80, 0x7F, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFE, 0x7F, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0xFF,
  0xF1, 0xFC, 0x01, 0xFF, 0xFF, 0xE7, 0xF0, 0x01, 0xFF, 0xFF, 0x8F, 0xE0,
  0x01, 0xFF, 0xFE, 0x03, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
};

const GFXglyph RobotoMono_BoldItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 18, 51, 42, 12, -50 },
  { 116, 23, 18, 42, 12, -53 },
  { 168, 42, 50, 42, 0, -50 },
  { 431, 38, 66, 42, 3, -59 },
  { 745, 35, 52, 42, 4, -51 },
  { 973, 40, 52, 42, 1, -51 },
  { 1233, 11, 19, 42, 17, -53 },
  { 1260, 24, 72, 42, 11, -56 },
  { 1476, 24, 72, 42, 6, -56 },
  { 1692, 35, 35, 42, 5, -50 },
  { 1846, 35, 37, 42, 3, -42 },
  { 2008, 15, 22, 42, 7, -8 },
  { 2050, 29, 8, 42, 9, -26 },
  { 2079, 13, 13, 42, 12, -12 },
  { 2101, 37, 54, 42, 3, -50 },
  { 2351, 35, 52, 42, 4, -51 },
  { 2579, 25, 50, 42, 8, -50 },
  { 2736, 38, 51, 42, 0, -51 },
  { 2979, 37, 52, 42, 2, -51 },
  { 3220, 36, 50, 42, 1, -50 },
  { 3445, 37, 51, 42, 3, -50 },
  { 3681, 34, 52, 42, 3, -51 },
  { 3902, 37, 50, 42, 4, -50 },
  { 4134, 37, 52, 42, 2, -51 },
  { 4375, 33, 51, 42, 5, -51 },
  { 4586, 18, 42, 42, 12, -41 },
  { 4681, 22, 55, 42, 9, -41 },
  { 4833, 33, 33, 42, 5, -38 },
  { 4970, 36, 23, 42, 3, -33 },
  { 5074, 34, 33, 42, 3, -38 },
  { 5215, 32, 52, 42, 8, -51 },
  { 5423, 40, 50, 42, 1, -50 },
  { 5673, 41, 50, 42, -3, -50 },
  { 5930, 41, 50, 42, 1, -50 },
  { 6187, 38, 52, 42, 3, -51 },
  { 6434, 39, 50, 42, 1, -50 },
  { 6678, 42, 50, 42, 1, -50 },
  { 6941, 42, 50, 42, 1, -50 },
  { 7204, 38, 52, 42, 3, -51 },
  { 7451, 41, 50, 42, 1, -50 },
  { 7708, 37, 50, 42, 3, -50 },
  { 7940, 40, 51, 42, 2, -50 },
  { 8195, 46, 50, 42, 1, -50 },
  { 8483, 34, 50, 42, 1, -50 },
  { 8696, 42, 50, 42, 1, -50 },
  { 8959, 41, 50, 42, 1, -50 },
  { 9216, 37, 52, 42, 3, -51 },
  { 9457, 41, 50, 42, 1, -50 },
  { 9714, 39, 60, 42, 2, -51 },
  { 10007, 41, 50, 42, 1, -50 },
  { 10264, 40, 52, 42, 2, -51 },
  { 10524, 41, 50, 42, 5, -50 },
  { 10781, 39, 51, 42, 3, -50 },
  { 11030, 39, 50, 42, 6, -50 },
  { 11274, 41, 50, 42, 4, -50 },
  { 11531, 49, 50, 42, -3, -50 },
  { 11838, 41, 50, 42, 6, -50 },
  { 12095, 43, 50, 42, 0, -50 },
  { 12364, 26, 71, 42, 8, -59 },
  { 12595, 18, 54, 42, 13, -50 },
  { 12717, 26, 71, 42, 8, -59 },
  { 12948, 29, 26, 42, 7, -50 },
  { 13043, 32, 8, 42, 0, 0 },
  { 13075, 14, 9, 42, 19, -51 },
  { 13091, 34, 39, 42, 2, -38 },
  { 13257, 36, 54, 42, 1, -53 },
  { 13500, 34, 39, 42, 3, -38 },
  { 13666, 39, 54, 42, 3, -53 },
  { 13930, 35, 39, 42, 3, -38 },
  { 14101, 38, 55, 42, 6, -55 },
  { 14363, 39, 53, 42, 1, -38 },
  { 14622, 37, 53, 42, 1, -53 },
  { 14868, 31, 52, 42, 4, -52 },
  { 15070, 32, 67, 42, 2, -52 },
  { 15338, 41, 53, 42, 1, -53 },
  { 15610, 32, 53, 42, 3, -53 },
  { 15822, 41, 38, 42, -1, -38 },
  { 16017, 37, 38, 42, 1, -38 },
  { 16193, 35, 39, 42, 3, -38 },
  { 16364, 38, 52, 42, -1, -38 },
  { 16611, 36, 52, 42, 3, -38 },
  { 16845, 34, 38, 42, 6, -38 },
  { 17007, 35, 39, 42, 3, -38 },
  { 17178, 32, 48, 42, 6, -47 },
  { 17370, 36, 39, 42, 4, -38 },
  { 17546, 37, 38, 42, 5, -38 },
  { 17722, 39, 38, 42, 4, -38 },
  { 17908, 43, 38, 42, -1, -38 },
  { 18113, 44, 53, 42, 0, -38 },
  { 18405, 39, 38, 42, 1, -38 },
  { 18591, 27, 67, 42, 10, -55 },
  { 18818, 16, 64, 42, 12, -50 },
  { 18946, 27, 68, 42, 7, -55 },
  { 19176, 39, 16, 42, 0, -29 },
};

const GFXfont RobotoMono_BoldItalic71pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic71pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _ROBOTOMONO_BOLDITALIC71PT7B_H_
