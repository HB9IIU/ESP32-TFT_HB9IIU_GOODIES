#ifndef _ROBOTOMONO_BOLDITALIC17PT7B_H_
#define _ROBOTOMONO_BOLDITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x37, 0x66, 0x66, 0x00, 0xEC, 0xCE, 0x77, 0x39, 0x80, 0x04,
  0x83, 0x60, 0x98, 0xFF, 0x7F, 0xC4, 0x81, 0x23, 0xFE, 0xFF, 0x09, 0x06,
  0xC1, 0x20, 0x04, 0x02, 0x07, 0xC7, 0xE7, 0x3B, 0x1D, 0xC0, 0x78, 0x1E,
  0x03, 0xB0, 0xD8, 0xEF, 0xE3, 0xE0, 0x40, 0x20, 0x70, 0xDB, 0xDA, 0xD6,
  0x7C, 0x08, 0x18, 0x3F, 0x29, 0x49, 0x0B, 0x0E, 0x0F, 0x07, 0xC3, 0x30,
  0xCC, 0x1E, 0x07, 0x03, 0xCD, 0xB6, 0xE7, 0xB9, 0xC7, 0xF1, 0xFE, 0x69,
  0x6C, 0x19, 0xCC, 0xC6, 0x63, 0x18, 0xC6, 0x21, 0x0C, 0x63, 0x0C, 0x20,
  0x10, 0x60, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC6, 0x18, 0xC7, 0x38,
  0x80, 0x0C, 0x06, 0x12, 0x5F, 0xF1, 0xC1, 0xE1, 0x90, 0xCC, 0x0C, 0x1C,
  0x18, 0xFF, 0xFF, 0x18, 0x38, 0x30, 0x30, 0x6D, 0xEC, 0xFF, 0xFC, 0xDF,
  0x80, 0x03, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x38,
  0x18, 0x1C, 0x0C, 0x00, 0x1E, 0x3F, 0x63, 0x63, 0x67, 0xEF, 0xF3, 0xE7,
  0xC7, 0xC6, 0xFE, 0x7C, 0x0D, 0xFF, 0xA6, 0x18, 0x63, 0x8E, 0x30, 0xC3,
  0x1C, 0x1F, 0x1F, 0xDC, 0x6C, 0x30, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x3F, 0xDF, 0xE0, 0x1F, 0x1F, 0xCC, 0x60, 0x30, 0x38, 0x78, 0x7C, 0x06,
  0x03, 0xF1, 0x9F, 0xC7, 0xC0, 0x03, 0x83, 0xC1, 0xC1, 0xE1, 0xB1, 0x99,
  0x8C, 0xCE, 0xFF, 0x83, 0x01, 0x80, 0xC0, 0x3F, 0x9F, 0x98, 0x0C, 0x07,
  0xC7, 0xF0, 0x1C, 0x0E, 0x07, 0x63, 0x3F, 0x8F, 0x80, 0x0E, 0x3E, 0x70,
  0x60, 0xFE, 0xFE, 0xC7, 0xC7, 0xC7, 0xC6, 0xFE, 0x7C, 0x7F, 0xFF, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x38, 0x18, 0x18, 0x1C, 0x00, 0x3E,
  0x7F, 0x63, 0x63, 0x67, 0x3E, 0x7E, 0xC6, 0xC6, 0xC6, 0xFE, 0x7C, 0x3E,
  0x7E, 0x63, 0xE3, 0xC3, 0xE7, 0x7F, 0x7E, 0x06, 0x0C, 0x78, 0x70, 0x37,
  0x70, 0x00, 0x0E, 0xEE, 0x19, 0xC6, 0x00, 0x00, 0x00, 0x33, 0x98, 0xCC,
  0x00, 0x03, 0x0F, 0x7E, 0xF0, 0xF0, 0x3E, 0x0E, 0x02, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x40, 0x78, 0x3E, 0x07, 0x1E, 0xFC, 0xE0, 0x80, 0x7E,
  0x7E, 0xC7, 0x06, 0x0E, 0x1C, 0x38, 0x30, 0x00, 0x00, 0x70, 0x60, 0x0F,
  0x06, 0x63, 0x0D, 0xBD, 0x5B, 0x54, 0xBD, 0x2B, 0x5A, 0xDF, 0x90, 0x06,
  0x40, 0xF0, 0x03, 0x01, 0xE0, 0x78, 0x3E, 0x0D, 0x83, 0x61, 0x98, 0x7E,
  0x3F, 0xCC, 0x76, 0x0F, 0x83, 0x3F, 0x8F, 0xF3, 0x1C, 0xC3, 0x71, 0x9F,
  0xC7, 0xF9, 0x86, 0x61, 0x98, 0xEF, 0xF3, 0xF8, 0x1E, 0x3F, 0x98, 0xFC,
  0x3C, 0x06, 0x03, 0x01, 0x80, 0xC3, 0x63, 0xBF, 0x8F, 0x80, 0x3E, 0x0F,
  0xC3, 0x18, 0xC6, 0x71, 0x9C, 0x66, 0x19, 0x86, 0x63, 0x99, 0xCF, 0xE3,
  0xF0, 0x3F, 0xCF, 0xF3, 0x00, 0xC0, 0x30, 0x1F, 0xE7, 0xF1, 0x80, 0x60,
  0x18, 0x07, 0xFB, 0xFC, 0x3F, 0xCF, 0xF3, 0x00, 0xC0, 0x30, 0x1F, 0xE7,
  0xF9, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0x1E, 0x1F, 0x98, 0xFC, 0x3C,
  0x06, 0x03, 0x3D, 0x9E, 0xC3, 0x63, 0xBF, 0xCF, 0x80, 0x30, 0xCC, 0x33,
  0x1C, 0xC6, 0x71, 0x9F, 0xE7, 0xF9, 0x8E, 0x63, 0x98, 0xCE, 0x33, 0x0C,
  0x3F, 0xBF, 0x83, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x3F,
  0x9F, 0xC0, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xC7,
  0x63, 0x3F, 0x8F, 0x80, 0x38, 0xE6, 0x38, 0xCE, 0x1B, 0x87, 0xE0, 0xF8,
  0x1F, 0x83, 0xB0, 0x67, 0x0C, 0x63, 0x8E, 0x71, 0xC0, 0x38, 0x30, 0x30,
  0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0x7F, 0xFF, 0x39, 0xCE, 0x73,
  0xBC, 0xEB, 0x6F, 0x9B, 0xE6, 0xD9, 0xB6, 0x61, 0x98, 0xEC, 0x33, 0x0C,
  0x38, 0xCE, 0x73, 0x9C, 0xE6, 0x7D, 0x9F, 0x66, 0xD9, 0x9E, 0x67, 0x99,
  0xCE, 0x73, 0x8C, 0x3E, 0x3F, 0x98, 0xDC, 0x7C, 0x3E, 0x1B, 0x0D, 0x86,
  0xC3, 0x63, 0x3F, 0x8F, 0x80, 0x3F, 0x0F, 0xE3, 0x1C, 0xC3, 0x31, 0xDC,
  0xE7, 0xF1, 0xF0, 0x60, 0x18, 0x06, 0x03, 0x80, 0x1E, 0x3F, 0x98, 0xDC,
  0x7C, 0x3E, 0x1F, 0x0D, 0x86, 0xC3, 0x63, 0xBF, 0x8F, 0xC0, 0x70, 0x10,
  0x3F, 0x0F, 0xE3, 0x1C, 0xC3, 0x71, 0xDC, 0xE7, 0xF1, 0x98, 0x67, 0x18,
  0xCE, 0x33, 0x8E, 0x1F, 0x8F, 0xE3, 0x0C, 0xC0, 0x38, 0x07, 0x80, 0xF0,
  0x0E, 0xE1, 0x98, 0x67, 0xF0, 0xF8, 0xFF, 0xFF, 0xF0, 0xC0, 0x70, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x71, 0xB0, 0xD8,
  0xEC, 0x6E, 0x37, 0x1B, 0x0D, 0x86, 0xC7, 0x63, 0x3F, 0x8F, 0x80, 0xE1,
  0xD8, 0x66, 0x39, 0x8C, 0x67, 0x19, 0x86, 0x61, 0xF0, 0x3C, 0x0E, 0x03,
  0x80, 0xE0, 0xCC, 0xF3, 0x6D, 0xDB, 0x76, 0xDF, 0xB7, 0xCF, 0xF3, 0xBC,
  0xEE, 0x3B, 0x8E, 0xE3, 0x30, 0x38, 0x71, 0xCE, 0x0C, 0xC0, 0xD8, 0x0F,
  0x80, 0x70, 0x0F, 0x00, 0xF0, 0x1B, 0x83, 0x98, 0x71, 0x8F, 0x1C, 0xC3,
  0xE1, 0xB9, 0x8D, 0xC6, 0xC3, 0xE1, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0C,
  0x00, 0x3F, 0xCF, 0xF0, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x30,
  0x1C, 0x0F, 0xFB, 0xFE, 0x1C, 0xF3, 0x0C, 0x30, 0xC3, 0x1C, 0x71, 0x86,
  0x18, 0x61, 0x8E, 0x3C, 0xF0, 0xCC, 0x66, 0x66, 0x66, 0x33, 0x33, 0x30,
  0x1C, 0xF0, 0xC7, 0x1C, 0x61, 0x86, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x3C,
  0xF0, 0x18, 0x30, 0xF3, 0x66, 0xD8, 0xC0, 0xFF, 0xFE, 0xCC, 0x1F, 0x1F,
  0x9C, 0xE1, 0x77, 0xF3, 0x1B, 0x8C, 0xFE, 0x7B, 0x00, 0x38, 0x1C, 0x0C,
  0x06, 0x03, 0xF1, 0xFD, 0xC6, 0xE3, 0x61, 0xB1, 0xD8, 0xCF, 0xEF, 0xE0,
  0x3E, 0x7E, 0xE3, 0xC0, 0xC0, 0xC0, 0xC6, 0xFE, 0x7C, 0x01, 0x80, 0xC0,
  0xE0, 0x63, 0xF3, 0xFB, 0x8D, 0x86, 0xC7, 0x63, 0x31, 0x9F, 0xC7, 0x60,
  0x3E, 0x7F, 0xE3, 0xC3, 0xFF, 0xC0, 0xC2, 0xFE, 0x7C, 0x07, 0xC3, 0xE1,
  0xC0, 0x60, 0x7F, 0x3F, 0xC1, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x00, 0x1F, 0xCF, 0xE7, 0x19, 0x86, 0x63, 0x98, 0xE6, 0x31, 0xFC,
  0x3F, 0x00, 0xC4, 0x63, 0xF8, 0x10, 0x00, 0x38, 0x18, 0x0C, 0x06, 0x03,
  0x71, 0xFD, 0xC6, 0xC3, 0x61, 0xB1, 0xD8, 0xCC, 0x6E, 0x30, 0x04, 0x1C,
  0x30, 0x07, 0xCF, 0x87, 0x0E, 0x18, 0x30, 0x67, 0xFF, 0xE0, 0x02, 0x03,
  0x03, 0x00, 0x1F, 0x1E, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C,
  0x1C, 0x78, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x31, 0xCC, 0xC7, 0xE1,
  0xF0, 0x7C, 0x1F, 0x86, 0x61, 0x9C, 0xE3, 0x80, 0x3E, 0x7C, 0x30, 0x60,
  0xC1, 0x87, 0x0E, 0x18, 0x30, 0x67, 0xFF, 0xE0, 0x7F, 0xBF, 0xDB, 0x6D,
  0xB6, 0xDE, 0x6F, 0x67, 0xB3, 0xDB, 0x00, 0x3F, 0x1F, 0xDC, 0x6C, 0x36,
  0x1B, 0x1D, 0x8C, 0xC6, 0xE3, 0x00, 0x3E, 0x7E, 0xE3, 0xC3, 0xC3, 0xC7,
  0xC6, 0xFE, 0x7C, 0x3F, 0x1F, 0xDC, 0xEE, 0x36, 0x1B, 0x1D, 0x8C, 0xFE,
  0xFE, 0x70, 0x30, 0x18, 0x00, 0x3F, 0x7F, 0xE3, 0xC3, 0xC7, 0xC6, 0xC6,
  0xFE, 0x7E, 0x06, 0x0E, 0x0C, 0x37, 0x9F, 0x8E, 0x0E, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x00, 0x3E, 0x7F, 0xE3, 0x60, 0x7E, 0x0E, 0xC7, 0xFE,
  0x7C, 0x18, 0x18, 0x7F, 0xFF, 0x38, 0x30, 0x30, 0x30, 0x30, 0x3E, 0x1E,
  0x63, 0xB1, 0xB8, 0xDC, 0x6C, 0x36, 0x3B, 0x19, 0xFC, 0x76, 0x00, 0xE3,
  0xB1, 0x99, 0xCC, 0xC6, 0x63, 0x60, 0xB0, 0x70, 0x38, 0x00, 0xC9, 0xEC,
  0xF6, 0xDB, 0x6F, 0xB7, 0x53, 0xB9, 0x9C, 0xCC, 0x00, 0x31, 0xCE, 0xE1,
  0xB0, 0x78, 0x0C, 0x07, 0x83, 0xE1, 0xCC, 0xE3, 0x80, 0x70, 0xE6, 0x38,
  0xC6, 0x19, 0xC3, 0x30, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xC0,
  0x78, 0x0C, 0x00, 0x3F, 0xDF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0xFE, 0xFF, 0x00, 0x06, 0x18, 0x60, 0xC1, 0x83, 0x0E, 0x30, 0xE0, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x0C, 0x33, 0x22, 0x22, 0x66, 0x44, 0x44, 0xCC,
  0xC0, 0x30, 0x41, 0x86, 0x18, 0xC1, 0x87, 0x1C, 0xC3, 0x18, 0x61, 0x8E,
  0x20, 0x70, 0x3C, 0xF3, 0xE0, 0xE0,
};

const GFXglyph RobotoMono_BoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 5, 5, 10, 3, -13 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 9, 16, 10, 1, -14 },
  { 44, 8, 12, 10, 1, -12 },
  { 56, 10, 12, 10, 0, -12 },
  { 71, 3, 5, 10, 4, -13 },
  { 73, 5, 17, 10, 3, -13 },
  { 84, 6, 17, 10, 1, -13 },
  { 97, 9, 8, 10, 1, -12 },
  { 106, 8, 9, 10, 1, -10 },
  { 115, 3, 5, 10, 2, -2 },
  { 117, 7, 2, 10, 2, -6 },
  { 119, 3, 3, 10, 3, -3 },
  { 121, 9, 13, 10, 1, -12 },
  { 136, 8, 12, 10, 1, -12 },
  { 148, 6, 12, 10, 2, -12 },
  { 157, 9, 12, 10, 0, -12 },
  { 171, 9, 12, 10, 0, -12 },
  { 185, 9, 12, 10, 0, -12 },
  { 199, 9, 12, 10, 1, -12 },
  { 213, 8, 12, 10, 1, -12 },
  { 225, 9, 12, 10, 1, -12 },
  { 239, 8, 12, 10, 1, -12 },
  { 251, 8, 12, 10, 1, -12 },
  { 263, 4, 10, 10, 3, -10 },
  { 268, 5, 13, 10, 2, -10 },
  { 277, 8, 8, 10, 1, -9 },
  { 285, 8, 6, 10, 1, -8 },
  { 291, 8, 8, 10, 1, -9 },
  { 299, 8, 12, 10, 2, -12 },
  { 311, 10, 12, 10, 0, -12 },
  { 326, 10, 12, 10, -1, -12 },
  { 341, 10, 12, 10, 0, -12 },
  { 356, 9, 12, 10, 1, -12 },
  { 370, 10, 12, 10, 0, -12 },
  { 385, 10, 12, 10, 0, -12 },
  { 400, 10, 12, 10, 0, -12 },
  { 415, 9, 12, 10, 1, -12 },
  { 429, 10, 12, 10, 0, -12 },
  { 444, 9, 12, 10, 1, -12 },
  { 458, 9, 12, 10, 1, -12 },
  { 472, 11, 12, 10, 0, -12 },
  { 489, 8, 12, 10, 0, -12 },
  { 501, 10, 12, 10, 0, -12 },
  { 516, 10, 12, 10, 0, -12 },
  { 531, 9, 12, 10, 1, -12 },
  { 545, 10, 12, 10, 0, -12 },
  { 560, 9, 14, 10, 1, -12 },
  { 576, 10, 12, 10, 0, -12 },
  { 591, 10, 12, 10, 0, -12 },
  { 606, 10, 12, 10, 1, -12 },
  { 621, 9, 12, 10, 1, -12 },
  { 635, 10, 12, 10, 1, -12 },
  { 650, 10, 12, 10, 1, -12 },
  { 665, 12, 12, 10, -1, -12 },
  { 683, 9, 12, 10, 2, -12 },
  { 697, 10, 12, 10, 0, -12 },
  { 712, 6, 17, 10, 2, -14 },
  { 725, 4, 13, 10, 3, -12 },
  { 732, 6, 17, 10, 2, -14 },
  { 745, 7, 6, 10, 2, -12 },
  { 751, 8, 2, 10, 0, 0 },
  { 753, 3, 2, 10, 5, -12 },
  { 754, 9, 9, 10, 0, -9 },
  { 765, 9, 13, 10, 0, -13 },
  { 780, 8, 9, 10, 1, -9 },
  { 789, 9, 13, 10, 1, -13 },
  { 804, 8, 9, 10, 1, -9 },
  { 813, 10, 13, 10, 1, -13 },
  { 830, 10, 13, 10, 0, -9 },
  { 847, 9, 13, 10, 0, -13 },
  { 862, 7, 13, 10, 1, -13 },
  { 874, 8, 17, 10, 0, -13 },
  { 891, 10, 13, 10, 0, -13 },
  { 908, 7, 13, 10, 1, -13 },
  { 920, 9, 9, 10, 0, -9 },
  { 931, 9, 9, 10, 0, -9 },
  { 942, 8, 9, 10, 1, -9 },
  { 951, 9, 12, 10, 0, -9 },
  { 965, 8, 12, 10, 1, -9 },
  { 977, 9, 9, 10, 1, -9 },
  { 988, 8, 9, 10, 1, -9 },
  { 997, 8, 11, 10, 1, -11 },
  { 1008, 9, 9, 10, 1, -9 },
  { 1019, 9, 9, 10, 1, -9 },
  { 1030, 9, 9, 10, 1, -9 },
  { 1041, 10, 9, 10, 0, -9 },
  { 1053, 11, 13, 10, 0, -9 },
  { 1071, 10, 9, 10, 0, -9 },
  { 1083, 7, 16, 10, 2, -13 },
  { 1097, 4, 15, 10, 3, -12 },
  { 1105, 6, 16, 10, 2, -13 },
  { 1117, 9, 4, 10, 0, -7 },
};

const GFXfont RobotoMono_BoldItalic17pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic17pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOMONO_BOLDITALIC17PT7B_H_
