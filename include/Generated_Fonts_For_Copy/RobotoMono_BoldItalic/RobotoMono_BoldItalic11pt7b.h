#ifndef _ROBOTOMONO_BOLDITALIC11PT7B_H_
#define _ROBOTOMONO_BOLDITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x25, 0x26, 0xB6, 0x80, 0x14, 0x57, 0xCA, 0x2B, 0xF5, 0x3C,
  0x08, 0xF2, 0x59, 0x30, 0x60, 0xD3, 0x78, 0x80, 0xC5, 0x7C, 0x42, 0x3E,
  0xA7, 0x38, 0xA6, 0x8C, 0x77, 0x5D, 0x9F, 0xE0, 0x25, 0x69, 0x24, 0x91,
  0x00, 0x42, 0x23, 0x33, 0x22, 0x24, 0x80, 0x31, 0x3E, 0x45, 0x48, 0x10,
  0x4F, 0xCC, 0x30, 0x58, 0xF8, 0xF0, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10,
  0xC0, 0x72, 0xF3, 0x7D, 0xCE, 0x5C, 0x1F, 0xB2, 0x22, 0x26, 0x39, 0xB4,
  0xC2, 0x18, 0x84, 0x3E, 0x39, 0xB0, 0x4E, 0x38, 0x3C, 0x9E, 0x0C, 0x73,
  0x8A, 0x4B, 0xF1, 0x84, 0x3C, 0x86, 0x1E, 0x0C, 0x3C, 0x9E, 0x18, 0xC6,
  0x1E, 0x4F, 0x34, 0x9E, 0xF8, 0x44, 0x62, 0x31, 0x18, 0x39, 0xB6, 0xDE,
  0x7B, 0x2C, 0x9E, 0x76, 0xE7, 0x3F, 0x88, 0xDC, 0x4C, 0x0D, 0x80, 0x33,
  0x00, 0x06, 0x4C, 0x0B, 0xF1, 0xC3, 0x00, 0xF8, 0x3E, 0x41, 0xC0, 0xDE,
  0xC0, 0x7E, 0x42, 0x32, 0x11, 0x0C, 0x18, 0x95, 0xEB, 0xAE, 0xF8, 0x1C,
  0x18, 0x63, 0x8A, 0x69, 0xEC, 0xE3, 0x79, 0xB6, 0x5F, 0x7D, 0x1C, 0xFE,
  0x39, 0xB4, 0x50, 0xC3, 0x04, 0xDE, 0x79, 0xB6, 0x51, 0x45, 0x3D, 0xBC,
  0x3E, 0xC1, 0x83, 0xE7, 0x88, 0x31, 0x7C, 0x3E, 0xC1, 0x82, 0x07, 0xC8,
  0x30, 0x60, 0x39, 0x94, 0x50, 0x5F, 0x34, 0xDE, 0x66, 0xC9, 0x13, 0xE7,
  0xC9, 0xB2, 0x64, 0x3C, 0x41, 0x04, 0x30, 0xC3, 0x3E, 0x06, 0x08, 0x10,
  0x60, 0xC1, 0xB2, 0x3C, 0x66, 0xD9, 0xE3, 0x87, 0x0B, 0x32, 0x66, 0x23,
  0x18, 0x84, 0x23, 0x1F, 0x66, 0xD9, 0xB2, 0xA5, 0x49, 0xB3, 0x64, 0x65,
  0x96, 0x57, 0x5D, 0x7D, 0xB2, 0x39, 0xB4, 0x51, 0xC7, 0x34, 0x9E, 0x39,
  0xB6, 0x51, 0x79, 0x0C, 0x30, 0x39, 0xB4, 0x51, 0xC7, 0x34, 0x9E, 0x0C,
  0x79, 0xB6, 0x53, 0x79, 0x6C, 0xB3, 0x39, 0x96, 0x1C, 0x18, 0x3C, 0xDE,
  0xFC, 0x82, 0x08, 0x61, 0x86, 0x10, 0x66, 0xC9, 0x92, 0x24, 0xC9, 0x92,
  0x3C, 0xCF, 0x2D, 0xB4, 0xD1, 0xC6, 0x18, 0xA6, 0xBA, 0xBA, 0xFB, 0xCB,
  0x2C, 0x66, 0xD8, 0xA1, 0xC3, 0x0F, 0x12, 0x66, 0xCF, 0x25, 0x94, 0x61,
  0x86, 0x18, 0x7E, 0x08, 0x20, 0xC3, 0x0C, 0x10, 0x7E, 0x32, 0x26, 0x66,
  0x44, 0x4C, 0xE0, 0x9B, 0x24, 0x93, 0x60, 0x31, 0x33, 0x32, 0x22, 0x26,
  0xE0, 0x31, 0x95, 0xB0, 0xF8, 0xD0, 0x39, 0xB3, 0xD2, 0xC9, 0xE0, 0x21,
  0x87, 0x9B, 0x4D, 0x3C, 0xBE, 0x76, 0xE1, 0x09, 0x78, 0x06, 0x08, 0xD3,
  0x64, 0xD9, 0x92, 0x3C, 0x39, 0xB4, 0xFF, 0x49, 0xE0, 0x08, 0xF2, 0x3E,
  0x61, 0x84, 0x10, 0x40, 0x35, 0xB4, 0xD3, 0x49, 0xE9, 0xBC, 0x61, 0x87,
  0x9B, 0x4D, 0x3C, 0xB2, 0x31, 0xF2, 0x22, 0x6F, 0x08, 0x4E, 0x31, 0x88,
  0x42, 0x37, 0x00, 0x61, 0x86, 0xD6, 0x71, 0xCD, 0xB3, 0x38, 0xC6, 0x21,
  0x08, 0xDF, 0x7D, 0x5D, 0x7D, 0xBE, 0xA0, 0x79, 0xB4, 0xD3, 0xCB, 0x20,
  0x39, 0xB4, 0xF3, 0x49, 0xE0, 0x79, 0xB4, 0xD3, 0xCB, 0xEC, 0x20, 0x35,
  0xB4, 0xD3, 0x49, 0xE0, 0x86, 0x5B, 0xD1, 0x8C, 0x40, 0x39, 0xB6, 0x0E,
  0xCD, 0xE0, 0x27, 0xD8, 0x84, 0x21, 0xC0, 0xCC, 0xE7, 0x39, 0x78, 0x8C,
  0xF4, 0xE6, 0x30, 0xAE, 0xAE, 0xBC, 0xB2, 0xC0, 0x66, 0x50, 0xE1, 0x87,
  0x99, 0x80, 0x46, 0xC9, 0xB1, 0xC3, 0x06, 0x08, 0x60, 0x7C, 0x31, 0x8C,
  0x63, 0xF0, 0x12, 0x66, 0x48, 0xC4, 0xC4, 0x40, 0x55, 0x5A, 0xA0, 0x42,
  0x22, 0x21, 0x26, 0x44, 0x80, 0xF6, 0x60,
};

const GFXglyph RobotoMono_BoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 8, 6, 2, -8 },
  { 4, 3, 3, 6, 2, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 6, 10, 6, 0, -9 },
  { 20, 5, 8, 6, 1, -8 },
  { 25, 6, 8, 6, 0, -8 },
  { 31, 1, 3, 6, 3, -8 },
  { 32, 3, 11, 6, 2, -9 },
  { 37, 4, 11, 6, 1, -9 },
  { 43, 5, 6, 6, 1, -8 },
  { 47, 6, 5, 6, 0, -6 },
  { 51, 2, 3, 6, 1, -1 },
  { 52, 5, 1, 6, 1, -4 },
  { 53, 2, 2, 6, 2, -2 },
  { 54, 6, 9, 6, 0, -8 },
  { 61, 5, 8, 6, 1, -8 },
  { 66, 4, 8, 6, 1, -8 },
  { 70, 6, 8, 6, 0, -8 },
  { 76, 6, 8, 6, 0, -8 },
  { 82, 6, 8, 6, 0, -8 },
  { 88, 6, 8, 6, 0, -8 },
  { 94, 6, 8, 6, 0, -8 },
  { 100, 5, 8, 6, 1, -8 },
  { 105, 6, 8, 6, 0, -8 },
  { 111, 5, 8, 6, 1, -8 },
  { 116, 3, 6, 6, 2, -6 },
  { 119, 4, 8, 6, 1, -6 },
  { 123, 5, 5, 6, 1, -6 },
  { 127, 5, 3, 6, 1, -5 },
  { 129, 6, 5, 6, 0, -6 },
  { 133, 5, 8, 6, 1, -8 },
  { 138, 6, 8, 6, 0, -8 },
  { 144, 6, 8, 6, 0, -8 },
  { 150, 6, 8, 6, 0, -8 },
  { 156, 6, 8, 6, 0, -8 },
  { 162, 6, 8, 6, 0, -8 },
  { 168, 7, 8, 6, 0, -8 },
  { 175, 7, 8, 6, 0, -8 },
  { 182, 6, 8, 6, 0, -8 },
  { 188, 7, 8, 6, 0, -8 },
  { 195, 6, 8, 6, 0, -8 },
  { 201, 7, 8, 6, 0, -8 },
  { 208, 7, 8, 6, 0, -8 },
  { 215, 5, 8, 6, 0, -8 },
  { 220, 7, 8, 6, 0, -8 },
  { 227, 6, 8, 6, 0, -8 },
  { 233, 6, 8, 6, 0, -8 },
  { 239, 6, 8, 6, 0, -8 },
  { 245, 6, 9, 6, 0, -8 },
  { 252, 6, 8, 6, 0, -8 },
  { 258, 6, 8, 6, 0, -8 },
  { 264, 6, 8, 6, 1, -8 },
  { 270, 7, 8, 6, 0, -8 },
  { 277, 6, 8, 6, 1, -8 },
  { 283, 6, 8, 6, 1, -8 },
  { 289, 7, 8, 6, 0, -8 },
  { 296, 6, 8, 6, 1, -8 },
  { 302, 7, 8, 6, 0, -8 },
  { 309, 4, 11, 6, 1, -9 },
  { 315, 3, 9, 6, 2, -8 },
  { 319, 4, 11, 6, 1, -9 },
  { 325, 5, 4, 6, 1, -8 },
  { 328, 5, 1, 6, 0, 0 },
  { 329, 2, 2, 6, 3, -8 },
  { 330, 6, 6, 6, 0, -6 },
  { 335, 6, 8, 6, 0, -8 },
  { 341, 5, 6, 6, 1, -6 },
  { 345, 7, 8, 6, 0, -8 },
  { 352, 6, 6, 6, 0, -6 },
  { 357, 6, 9, 6, 1, -9 },
  { 364, 6, 8, 6, 0, -6 },
  { 370, 6, 8, 6, 0, -8 },
  { 376, 4, 8, 6, 1, -8 },
  { 380, 5, 10, 6, 0, -8 },
  { 387, 6, 8, 6, 0, -8 },
  { 393, 5, 8, 6, 0, -8 },
  { 398, 6, 6, 6, 0, -6 },
  { 403, 6, 6, 6, 0, -6 },
  { 408, 6, 6, 6, 0, -6 },
  { 413, 6, 8, 6, 0, -6 },
  { 419, 6, 8, 6, 0, -6 },
  { 425, 5, 6, 6, 1, -6 },
  { 429, 6, 6, 6, 0, -6 },
  { 434, 5, 7, 6, 1, -7 },
  { 439, 5, 6, 6, 1, -6 },
  { 443, 5, 6, 6, 1, -6 },
  { 447, 6, 6, 6, 1, -6 },
  { 452, 7, 6, 6, 0, -6 },
  { 458, 7, 8, 6, 0, -6 },
  { 465, 6, 6, 6, 0, -6 },
  { 470, 4, 11, 6, 2, -9 },
  { 476, 2, 10, 6, 2, -8 },
  { 479, 4, 11, 6, 1, -9 },
  { 485, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_BoldItalic11pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic11pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOMONO_BOLDITALIC11PT7B_H_
