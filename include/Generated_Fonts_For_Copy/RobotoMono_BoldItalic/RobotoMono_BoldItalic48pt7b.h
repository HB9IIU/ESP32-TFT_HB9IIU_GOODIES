#ifndef _ROBOTOMONO_BOLDITALIC48PT7B_H_
#define _ROBOTOMONO_BOLDITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xE0,
  0x3F, 0x03, 0xFC, 0x1F, 0xE0, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x1F, 0x3C,
  0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78,
  0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x78,
  0x7C, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80,
  0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07,
  0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0,
  0x3F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xCF,
  0x80, 0x1F, 0x0F, 0x06, 0x3E, 0x1E, 0x0F, 0x78, 0x3C, 0x3C, 0xF0, 0x78,
  0xF1, 0xE1, 0xF3, 0xE3, 0xE3, 0xE7, 0x87, 0xFF, 0x9E, 0x07, 0xFF, 0x78,
  0x0F, 0xFC, 0xF0, 0x07, 0xE3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0xFF, 0x00, 0xF3, 0xFF, 0x01, 0xEF, 0xFE, 0x07, 0x9F, 0x3E, 0x1E,
  0x7C, 0x7C, 0x7C, 0xF8, 0x78, 0xF1, 0xE0, 0xF3, 0xC3, 0xC1, 0xE3, 0x87,
  0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x1F, 0x87,
  0xFF, 0x03, 0xE1, 0xFF, 0xF0, 0x7C, 0x7F, 0x7F, 0x1F, 0x9F, 0xCF, 0xE3,
  0xF3, 0xF0, 0xFE, 0xFC, 0xFE, 0x0F, 0xDF, 0x9F, 0x81, 0xFF, 0xE3, 0xF0,
  0x1F, 0xFC, 0x7E, 0x03, 0xFF, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF8,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xEF, 0xE0, 0x3F, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x79, 0xF3,
  0xE7, 0xCF, 0x9E, 0x3C, 0xF9, 0xF3, 0xE7, 0x8F, 0x00, 0x00, 0x01, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x08, 0x0F, 0x01, 0x3C, 0x1E, 0x0E, 0x7E, 0x3C, 0x7F, 0xFF, 0x77,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xDE, 0x00, 0x1F, 0x1E, 0x00,
  0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x06,
  0x00, 0xC0, 0x04, 0x01, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x07, 0xE1, 0xF8, 0x0E, 0x00, 0x80, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x3E, 0x3F, 0xBF,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF8, 0x3F,
  0x0F, 0xE0, 0x7F, 0x1F, 0x80, 0x7E, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x3F, 0xDF, 0xC0, 0xFF, 0xBF,
  0x87, 0xFF, 0x7E, 0x1F, 0xFE, 0xFC, 0xFD, 0xF9, 0xFB, 0xF3, 0xF7, 0xFF,
  0xC7, 0xEF, 0xFE, 0x0F, 0xDF, 0xF0, 0x3F, 0xBF, 0xC0, 0x7F, 0x7F, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F,
  0x8F, 0xE0, 0x7F, 0x0F, 0xC1, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0x7F, 0x3C, 0x3F, 0x30, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xF8,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x01,
  0xF8, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x47, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8,
  0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xF0,
  0x07, 0xE3, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0x80, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0xFE,
  0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0x7F, 0x83, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x7C, 0x03, 0xF3, 0xFE, 0x07, 0xEF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0xF7, 0xFC, 0xFF, 0x03, 0xF9, 0xFC, 0x03, 0xF7,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF0,
  0x1F, 0xC7, 0xF0, 0x7F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0xFE,
  0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC3, 0xF8, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFE, 0x3F, 0xC1, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F,
  0xC7, 0xF0, 0x1F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xF0, 0x7E, 0x1F, 0xC0,
  0xFE, 0x7F, 0x00, 0xFC, 0xFE, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07,
  0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x3F, 0x00, 0x7E,
  0x7E, 0x01, 0xFC, 0xFE, 0x07, 0xF9, 0xFE, 0x1F, 0xF1, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0x7E, 0x01, 0xF9, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x7F, 0x07, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x87, 0xF0, 0x3E, 0x00,
  0x80, 0x00, 0x78, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x00, 0x7E, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xC0, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x10, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x7C, 0x0C, 0x0E, 0x0F,
  0x0F, 0xF1, 0xC3, 0xC3, 0xFF, 0x3C, 0x78, 0xFF, 0xE7, 0x9E, 0x3E, 0x3C,
  0xF3, 0xC7, 0x87, 0x1E, 0xF1, 0xE0, 0xE3, 0xDE, 0x3C, 0x3C, 0x7B, 0xCF,
  0x87, 0x8E, 0x71, 0xE0, 0xE1, 0xDE, 0x3C, 0x3C, 0x3B, 0xC7, 0x87, 0x8F,
  0x78, 0xF0, 0xF1, 0xCF, 0x1E, 0x1C, 0x39, 0xE3, 0xC7, 0x8F, 0x3C, 0x78,
  0xF1, 0xC7, 0x8F, 0xFF, 0xF8, 0xF1, 0xFF, 0xFE, 0x1E, 0x1F, 0xBF, 0x83,
  0xC1, 0xC1, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x02,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF9, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F,
  0x80, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0,
  0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFB,
  0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFC, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC1,
  0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x80,
  0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0xC3, 0xF0, 0x07, 0xF8,
  0x7F, 0x01, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xC1, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xE1, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F,
  0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x03,
  0xF8, 0x1F, 0x81, 0xFF, 0x07, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0x80,
  0xFE, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0xFF,
  0xF3, 0xF8, 0x3F, 0xFC, 0xFE, 0x0F, 0xFF, 0x3F, 0x83, 0xFF, 0xCF, 0xC0,
  0x07, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x03, 0xF8, 0x03,
  0xFC, 0x03, 0xF0, 0x07, 0xFC, 0x03, 0xF0, 0x0F, 0xF8, 0x03, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x7F,
  0x80, 0x07, 0xE0, 0xFF, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x07, 0xE3, 0xFC,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x03,
  0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF,
  0xC0, 0xFF, 0xCF, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x3E, 0xF3, 0xDF, 0x01,
  0xF7, 0xBF, 0xF8, 0x1F, 0xBD, 0xEF, 0xC0, 0xFD, 0xFF, 0x7E, 0x07, 0xEF,
  0xF3, 0xF0, 0x3F, 0x7F, 0x9F, 0x01, 0xF3, 0xFD, 0xF8, 0x1F, 0x9F, 0xCF,
  0xC0, 0xFC, 0xFE, 0x7E, 0x07, 0xE3, 0xE3, 0xF0, 0x3F, 0x1F, 0x1F, 0x81,
  0xF8, 0xF0, 0xF8, 0x0F, 0x87, 0x8F, 0xC0, 0xFC, 0x38, 0x7E, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF8,
  0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x07, 0xFC, 0x07, 0xF0, 0x7F, 0xC0, 0x7E,
  0x07, 0xFC, 0x07, 0xE0, 0x7F, 0xC0, 0x7E, 0x07, 0xFE, 0x0F, 0xE0, 0x7F,
  0xE0, 0xFE, 0x0F, 0xFE, 0x0F, 0xC0, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0x0F,
  0xC0, 0xFD, 0xF1, 0xFC, 0x0F, 0xDF, 0x1F, 0xC0, 0xFC, 0xF1, 0xFC, 0x1F,
  0xCF, 0x9F, 0x81, 0xFC, 0xF9, 0xF8, 0x1F, 0xCF, 0x9F, 0x81, 0xF8, 0x7B,
  0xF8, 0x1F, 0x87, 0xFF, 0x81, 0xF8, 0x7F, 0xF8, 0x3F, 0x87, 0xFF, 0x03,
  0xF8, 0x3F, 0xF0, 0x3F, 0x03, 0xFF, 0x03, 0xF0, 0x3F, 0xF0, 0x3F, 0x03,
  0xFF, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0,
  0x7E, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC1, 0xFC,
  0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xFB, 0xF0,
  0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x3F,
  0x00, 0x3F, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0xC1,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xC0, 0x7F, 0x81, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x03,
  0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x0C, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFC,
  0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07,
  0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x9F, 0xC0, 0x3F, 0x87, 0xE0, 0x3F, 0xC3, 0xF8, 0x3F, 0xC1,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xC0, 0xFF, 0x83, 0xF8, 0x07, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F,
  0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0,
  0x0F, 0xF0, 0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7E, 0x0F,
  0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0xFC,
  0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F,
  0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00,
  0xFE, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFF, 0x01, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xF8,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x07, 0xF0, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x03, 0xF0,
  0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0x3F, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xCF,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x0F, 0x07, 0xF7, 0xE1, 0xF0, 0x7E, 0x7C, 0x1F, 0x07, 0xE7,
  0xC1, 0xF0, 0x7E, 0x7C, 0x3F, 0x0F, 0xC7, 0xC3, 0xF0, 0xFC, 0x7C, 0x3F,
  0x0F, 0xC7, 0xC7, 0xF0, 0xF8, 0x7C, 0x7F, 0x1F, 0x87, 0xC7, 0xF1, 0xF8,
  0x7C, 0x7F, 0x1F, 0x8F, 0xCF, 0xF3, 0xF0, 0xFC, 0xFF, 0x3F, 0x0F, 0xCF,
  0xF3, 0xF0, 0xFD, 0xFF, 0x3E, 0x0F, 0xDE, 0xF7, 0xE0, 0xFD, 0xEF, 0x7E,
  0x0F, 0xFE, 0xF7, 0xE0, 0xFF, 0xEF, 0x7C, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF,
  0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF,
  0x80, 0xFF, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x3F,
  0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC3, 0xF0,
  0x07, 0xF8, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0,
  0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE3,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xE0, 0x1F, 0x7C, 0x07,
  0xEF, 0x80, 0xF8, 0xF0, 0x3E, 0x1E, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x8F, 0x80, 0xF3, 0xF0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7C, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x3E, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x0F, 0xE1, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x0C, 0x7E, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x3F, 0xF0, 0xFE, 0x7F, 0x80, 0xFC, 0x7F, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x07, 0xFC,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFD, 0xF8,
  0x0F, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC3, 0xE0, 0x0F, 0xCF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F,
  0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7F,
  0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x83, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFC, 0xFF, 0xE0, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3,
  0xFE, 0x7F, 0x87, 0xF0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFE,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x01,
  0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xF0, 0x7F, 0x87, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x07, 0xC3, 0xF8, 0x07, 0xFC, 0xFC, 0x07, 0xFF, 0xBF, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xDF, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0,
  0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F,
  0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC,
  0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xDF, 0x00, 0x3F, 0xCF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFB, 0xFE, 0x1F, 0xC0,
  0xFE, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x3E, 0x7F, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x20, 0x7F, 0x00, 0x70, 0x7F, 0x80, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF0, 0x20, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x08, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xF3, 0xF0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x7F, 0xE1, 0xFE, 0x07,
  0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F,
  0x87, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x83, 0xFE, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFE, 0xFC, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x20, 0x03, 0xF8,
  0x0C, 0x01, 0xFC, 0x07, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x78, 0x01, 0xF9, 0xFF,
  0x00, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFB,
  0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0x8F,
  0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8,
  0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x87, 0xE0, 0x1F, 0xE0, 0xFC, 0x07, 0xF8,
  0x1F, 0x81, 0xFE, 0x03, 0xF0, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0xC7,
  0xF8, 0x03, 0xF1, 0xFE, 0x00, 0x7E, 0x7F, 0x80, 0x0F, 0xDF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x3F, 0x00, 0x3F,
  0xC7, 0xF0, 0x07, 0xE0, 0xFF, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xFE,
  0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0,
  0x07, 0xF8, 0x7E, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x10, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x07, 0x87,
  0x80, 0xFD, 0xFC, 0xFC, 0x0F, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFE, 0xFF, 0x7F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C,
  0x3F, 0x1F, 0x87, 0xC3, 0xF1, 0xF8, 0xFC, 0x3E, 0x1F, 0x8F, 0xC7, 0xE1,
  0xF8, 0xFC, 0x7E, 0x1F, 0x0F, 0xC7, 0xE3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F,
  0x87, 0xE3, 0xF1, 0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFC,
  0x3E, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC7, 0xE3,
  0xF0, 0xF8, 0x7E, 0x3F, 0x1F, 0x87, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x1F,
  0x8F, 0xC3, 0xE1, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xE7, 0xFE, 0x03, 0xF7,
  0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xEF, 0xF8, 0x7F,
  0x81, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F,
  0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF8,
  0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x3F,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07,
  0xF3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xF3, 0xFC, 0x3F, 0xC0, 0xFE, 0x3F,
  0x80, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0x7E,
  0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFC, 0x1F, 0xC0,
  0x7F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F,
  0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xFC,
  0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x03,
  0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xC7, 0xF8, 0x03,
  0xF0, 0x30, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x80,
  0xFF, 0x8F, 0x81, 0xFF, 0xEF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0x9F, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0x7E,
  0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE7, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x7F, 0x07, 0xF0,
  0x7F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x07, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x1F, 0x8F, 0xFC, 0x3F, 0x3F, 0xF8, 0x7E, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x80,
  0x7F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x02, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x3F,
  0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7F,
  0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFC,
  0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFB, 0xF0, 0x3F, 0xF3, 0xF0, 0x1F, 0xE3, 0xF0, 0x01,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF,
  0xC0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0,
  0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0x81, 0xF8, 0x07, 0xE1, 0xFC,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x0F,
  0xFE, 0x0F, 0x87, 0xEF, 0x83, 0xE1, 0xFB, 0xE1, 0xF8, 0x7E, 0xF8, 0x7E,
  0x1F, 0x3E, 0x3F, 0x8F, 0xCF, 0x8F, 0xE3, 0xF3, 0xE3, 0xF8, 0xF8, 0xF9,
  0xFE, 0x7E, 0x3E, 0x7F, 0x9F, 0x8F, 0x9F, 0xE7, 0xC3, 0xEF, 0x7B, 0xF0,
  0xFB, 0xDE, 0xF8, 0x3E, 0xE7, 0xBE, 0x0F, 0xF9, 0xEF, 0x83, 0xFE, 0x7F,
  0xC0, 0xF7, 0x1F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xF8,
  0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xC1, 0xFC, 0x03,
  0xF0, 0x7F, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0x87,
  0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0,
  0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x0F, 0xC0, 0x1F,
  0xE0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x80, 0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80,
  0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x01,
  0xF8, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0xF3, 0xFF, 0xC0, 0x3C, 0xFF, 0xF8, 0x1F, 0x7F, 0xFF, 0x8F,
  0xDF, 0x0F, 0xFF, 0xEF, 0x81, 0xFF, 0xFB, 0xE0, 0x3F, 0xFC, 0x30, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoMono_BoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 13, 34, 28, 8, -34 },
  { 57, 16, 12, 28, 8, -36 },
  { 81, 28, 34, 28, 0, -34 },
  { 200, 26, 45, 28, 2, -40 },
  { 347, 23, 36, 28, 3, -35 },
  { 451, 27, 36, 28, 1, -35 },
  { 573, 7, 13, 28, 12, -36 },
  { 585, 17, 49, 28, 7, -38 },
  { 690, 16, 49, 28, 4, -38 },
  { 788, 23, 24, 28, 4, -34 },
  { 857, 24, 25, 28, 2, -28 },
  { 932, 11, 16, 28, 4, -6 },
  { 954, 20, 6, 28, 6, -18 },
  { 969, 9, 9, 28, 8, -8 },
  { 980, 25, 37, 28, 2, -34 },
  { 1096, 23, 36, 28, 3, -35 },
  { 1200, 17, 34, 28, 5, -34 },
  { 1273, 26, 35, 28, 0, -35 },
  { 1387, 26, 36, 28, 1, -35 },
  { 1504, 25, 34, 28, 0, -34 },
  { 1611, 25, 35, 28, 2, -34 },
  { 1721, 23, 35, 28, 2, -34 },
  { 1822, 25, 34, 28, 3, -34 },
  { 1929, 25, 36, 28, 1, -35 },
  { 2042, 23, 35, 28, 3, -35 },
  { 2143, 12, 28, 28, 8, -27 },
  { 2185, 15, 37, 28, 6, -27 },
  { 2255, 23, 23, 28, 3, -26 },
  { 2322, 25, 15, 28, 2, -22 },
  { 2369, 23, 23, 28, 2, -26 },
  { 2436, 21, 35, 28, 6, -35 },
  { 2528, 27, 34, 28, 1, -34 },
  { 2643, 27, 34, 28, -2, -34 },
  { 2758, 28, 34, 28, 0, -34 },
  { 2877, 26, 36, 28, 2, -35 },
  { 2994, 27, 34, 28, 0, -34 },
  { 3109, 28, 34, 28, 1, -34 },
  { 3228, 28, 34, 28, 1, -34 },
  { 3347, 26, 36, 28, 2, -35 },
  { 3464, 28, 34, 28, 0, -34 },
  { 3583, 25, 34, 28, 2, -34 },
  { 3690, 27, 35, 28, 2, -34 },
  { 3809, 32, 34, 28, 0, -34 },
  { 3945, 23, 34, 28, 1, -34 },
  { 4043, 29, 34, 28, 0, -34 },
  { 4167, 28, 34, 28, 0, -34 },
  { 4286, 25, 36, 28, 2, -35 },
  { 4399, 27, 34, 28, 1, -34 },
  { 4514, 25, 41, 28, 2, -35 },
  { 4643, 27, 34, 28, 1, -34 },
  { 4758, 27, 36, 28, 1, -35 },
  { 4880, 28, 34, 28, 3, -34 },
  { 4999, 27, 35, 28, 2, -34 },
  { 5118, 27, 34, 28, 4, -34 },
  { 5233, 28, 34, 28, 3, -34 },
  { 5352, 33, 34, 28, -2, -34 },
  { 5493, 27, 34, 28, 4, -34 },
  { 5608, 29, 34, 28, 0, -34 },
  { 5732, 17, 48, 28, 6, -40 },
  { 5834, 12, 37, 28, 9, -34 },
  { 5890, 17, 48, 28, 6, -40 },
  { 5992, 19, 18, 28, 5, -34 },
  { 6035, 22, 5, 28, 0, 0 },
  { 6049, 9, 7, 28, 13, -35 },
  { 6057, 24, 27, 28, 1, -26 },
  { 6138, 24, 37, 28, 1, -36 },
  { 6249, 23, 27, 28, 2, -26 },
  { 6327, 26, 37, 28, 2, -36 },
  { 6448, 24, 27, 28, 2, -26 },
  { 6529, 26, 37, 28, 4, -37 },
  { 6650, 26, 36, 28, 1, -26 },
  { 6767, 25, 36, 28, 1, -36 },
  { 6880, 21, 35, 28, 2, -35 },
  { 6972, 22, 45, 28, 1, -35 },
  { 7096, 27, 36, 28, 1, -36 },
  { 7218, 22, 36, 28, 2, -36 },
  { 7317, 28, 26, 28, -1, -26 },
  { 7408, 25, 26, 28, 1, -26 },
  { 7490, 24, 27, 28, 2, -26 },
  { 7571, 26, 36, 28, -1, -26 },
  { 7688, 25, 36, 28, 2, -26 },
  { 7801, 23, 26, 28, 4, -26 },
  { 7876, 24, 27, 28, 2, -26 },
  { 7957, 22, 33, 28, 4, -32 },
  { 8048, 24, 26, 28, 3, -25 },
  { 8126, 25, 25, 28, 3, -25 },
  { 8205, 26, 25, 28, 3, -25 },
  { 8287, 29, 25, 28, 0, -25 },
  { 8378, 30, 35, 28, 0, -25 },
  { 8510, 27, 25, 28, 0, -25 },
  { 8595, 18, 46, 28, 7, -38 },
  { 8699, 11, 44, 28, 8, -34 },
  { 8760, 18, 46, 28, 5, -37 },
  { 8864, 26, 10, 28, 0, -19 },
};

const GFXfont RobotoMono_BoldItalic48pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic48pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOMONO_BOLDITALIC48PT7B_H_
