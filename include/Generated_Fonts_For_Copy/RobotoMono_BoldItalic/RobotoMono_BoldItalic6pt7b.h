#ifndef _ROBOTOMONO_BOLDITALIC6PT7B_H_
#define _ROBOTOMONO_BOLDITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0xF0, 0x6F, 0xEC, 0x2D, 0x1E, 0x80, 0xE9, 0xB0, 0x6B, 0xF0,
  0xC0, 0x6A, 0xA0, 0x44, 0x95, 0x80, 0x39, 0x80, 0x5D, 0x20, 0xC0, 0xC0,
  0x80, 0x25, 0x60, 0x77, 0xB0, 0xDA, 0xE5, 0x70, 0x6C, 0xF0, 0x2F, 0x90,
  0x7C, 0xF0, 0x7E, 0xB0, 0xF2, 0x4C, 0x6E, 0xF0, 0x75, 0xA0, 0xC8, 0x4A,
  0x78, 0x80, 0x7C, 0x4E, 0x00, 0xDA, 0x7E, 0xAE, 0x6D, 0xD0, 0x6E, 0xAE,
  0x72, 0x70, 0x76, 0xF0, 0x76, 0x8E, 0x7E, 0x88, 0x72, 0xF0, 0x5E, 0xAA,
  0x69, 0x70, 0x12, 0x2E, 0x7C, 0xAA, 0x52, 0x70, 0x7E, 0xEA, 0x7E, 0xAA,
  0x76, 0xF0, 0x7A, 0xC8, 0x76, 0xF2, 0x6A, 0xEA, 0x74, 0x2E, 0xF4, 0x44,
  0x5A, 0xAE, 0xD6, 0x64, 0xBE, 0xEA, 0x76, 0x6A, 0xFA, 0x40, 0x72, 0x4E,
  0x6A, 0xA0, 0xA9, 0x56, 0xA0, 0xF0, 0xE0, 0x80, 0xFF, 0x80, 0x49, 0xDE,
  0x73, 0x80, 0x12, 0x6A, 0xE0, 0x7D, 0x80, 0x34, 0xE4, 0x40, 0x77, 0xF0,
  0x49, 0xDA, 0x2D, 0x70, 0x2C, 0xAC, 0x45, 0xAC, 0xA0, 0x64, 0xAE, 0xFF,
  0x80, 0x76, 0x80, 0x77, 0x80, 0x77, 0xC0, 0x77, 0x90, 0xE8, 0xEF, 0x80,
  0x5D, 0x30, 0xB7, 0x80, 0xB6, 0x40, 0xDE, 0xA0, 0x74, 0xA0, 0xB6, 0x4C,
  0xEB, 0x80, 0x56, 0xA0, 0xF8, 0x99, 0xA0, 0xE0,
};

const GFXglyph RobotoMono_BoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 4, 4, 1, -4 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 3, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 2, 4, 1, -5 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 3, 6, 4, 0, -5 },
  { 18, 3, 3, 4, 0, -4 },
  { 20, 3, 4, 4, 0, -4 },
  { 22, 1, 2, 4, 1, -1 },
  { 23, 2, 1, 4, 1, -2 },
  { 24, 1, 1, 4, 1, -1 },
  { 25, 3, 4, 4, 0, -4 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 2, 4, 4, 1, -4 },
  { 30, 3, 4, 4, 0, -4 },
  { 32, 3, 4, 4, 0, -4 },
  { 34, 3, 4, 4, 0, -4 },
  { 36, 3, 4, 4, 0, -4 },
  { 38, 3, 4, 4, 0, -4 },
  { 40, 4, 4, 4, 0, -4 },
  { 42, 3, 4, 4, 0, -4 },
  { 44, 3, 4, 4, 0, -4 },
  { 46, 2, 3, 4, 1, -3 },
  { 47, 2, 4, 4, 1, -3 },
  { 48, 3, 3, 4, 0, -3 },
  { 50, 3, 2, 4, 0, -3 },
  { 51, 3, 3, 4, 0, -3 },
  { 53, 2, 4, 4, 1, -4 },
  { 54, 4, 4, 4, 0, -4 },
  { 56, 3, 4, 4, 0, -4 },
  { 58, 4, 4, 4, 0, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 3, 4, 4, 0, -4 },
  { 64, 4, 4, 4, 0, -4 },
  { 66, 4, 4, 4, 0, -4 },
  { 68, 3, 4, 4, 0, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 3, 4, 4, 0, -4 },
  { 74, 4, 4, 4, 0, -4 },
  { 76, 4, 4, 4, 0, -4 },
  { 78, 3, 4, 4, 0, -4 },
  { 80, 4, 4, 4, 0, -4 },
  { 82, 4, 4, 4, 0, -4 },
  { 84, 3, 4, 4, 0, -4 },
  { 86, 4, 4, 4, 0, -4 },
  { 88, 3, 5, 4, 0, -4 },
  { 90, 4, 4, 4, 0, -4 },
  { 92, 4, 4, 4, 0, -4 },
  { 94, 4, 4, 4, 0, -4 },
  { 96, 4, 4, 4, 0, -4 },
  { 98, 4, 4, 4, 0, -4 },
  { 100, 4, 4, 4, 0, -4 },
  { 102, 4, 4, 4, 0, -4 },
  { 104, 3, 4, 4, 1, -4 },
  { 106, 4, 4, 4, 0, -4 },
  { 108, 2, 6, 4, 1, -5 },
  { 110, 2, 4, 4, 1, -4 },
  { 111, 2, 6, 4, 1, -5 },
  { 113, 2, 2, 4, 1, -4 },
  { 114, 3, 1, 4, 0, 0 },
  { 115, 1, 1, 4, 2, -4 },
  { 116, 3, 3, 4, 0, -3 },
  { 118, 3, 5, 4, 0, -5 },
  { 120, 3, 3, 4, 0, -3 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 3, 3, 4, 0, -3 },
  { 127, 4, 5, 4, 0, -5 },
  { 130, 3, 4, 4, 0, -3 },
  { 132, 3, 5, 4, 0, -5 },
  { 134, 3, 4, 4, 0, -4 },
  { 136, 3, 5, 4, 0, -4 },
  { 138, 4, 5, 4, 0, -5 },
  { 141, 3, 5, 4, 0, -5 },
  { 143, 3, 3, 4, 0, -3 },
  { 145, 3, 3, 4, 0, -3 },
  { 147, 3, 3, 4, 0, -3 },
  { 149, 3, 4, 4, 0, -3 },
  { 151, 3, 4, 4, 0, -3 },
  { 153, 2, 3, 4, 1, -3 },
  { 154, 3, 3, 4, 0, -3 },
  { 156, 3, 4, 4, 0, -4 },
  { 158, 3, 3, 4, 0, -3 },
  { 160, 4, 3, 4, 0, -3 },
  { 162, 4, 3, 4, 0, -3 },
  { 164, 4, 3, 4, 0, -3 },
  { 166, 4, 4, 4, 0, -3 },
  { 168, 3, 3, 4, 0, -3 },
  { 170, 2, 6, 4, 1, -5 },
  { 172, 1, 5, 4, 1, -4 },
  { 173, 2, 6, 4, 1, -5 },
  { 175, 3, 1, 4, 0, -2 },
};

const GFXfont RobotoMono_BoldItalic6pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic6pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOMONO_BOLDITALIC6PT7B_H_
