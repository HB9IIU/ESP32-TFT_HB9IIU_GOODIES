#ifndef _ROBOTOMONO_BOLDITALIC70PT7B_H_
#define _ROBOTOMONO_BOLDITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x40, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x1F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x3E, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xFC, 0x00,
  0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x1F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x60, 0x7E, 0x07, 0xF0,
  0x1E, 0x1F, 0x81, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x07, 0xE3, 0xF8, 0x1F,
  0x81, 0xF8, 0xFE, 0x07, 0xE0, 0xFC, 0x3F, 0x81, 0xF8, 0x7E, 0x0F, 0xE0,
  0xFE, 0x3F, 0x03, 0xF8, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0xC7, 0xE0, 0x1F,
  0xFF, 0xF3, 0xF0, 0x03, 0xFF, 0xF8, 0xFC, 0x00, 0xFF, 0xFC, 0x7E, 0x00,
  0x1F, 0xFE, 0x3F, 0x00, 0x01, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0x3F, 0xFF, 0x00, 0x1F, 0x9F, 0xFF, 0xE0,
  0x0F, 0xC7, 0xFF, 0xF8, 0x03, 0xF3, 0xFF, 0xFF, 0x01, 0xF8, 0xFE, 0x1F,
  0xC0, 0xFC, 0x7F, 0x07, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x07, 0xF0, 0xF8, 0x1F,
  0x81, 0xFC, 0x0C, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0x80,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0x8F,
  0xFC, 0xFF, 0xC1, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x7F, 0xE1, 0xFF,
  0x8F, 0xF9, 0xFF, 0x81, 0xFF, 0x9F, 0xE3, 0xFE, 0x03, 0xFF, 0x7F, 0xC7,
  0xFC, 0x03, 0xFF, 0xFF, 0x1F, 0xF8, 0x07, 0xFF, 0xFE, 0x3F, 0xF0, 0x07,
  0xFF, 0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0xC1,
  0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x04, 0x00, 0x3F, 0x00, 0x01, 0xC0,
  0x0F, 0x80, 0x18, 0x7C, 0x03, 0xE0, 0x3E, 0x3F, 0xC0, 0xF8, 0x3F, 0xCF,
  0xFC, 0x7E, 0x3F, 0xF7, 0xFF, 0xDF, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xC0,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0x07, 0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xF7, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFB, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x07, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0xF3, 0xFE,
  0x03, 0xFF, 0xF8, 0xFF, 0x81, 0xFF, 0xFE, 0x3F, 0xE1, 0xFF, 0xFF, 0x8F,
  0xF8, 0xFF, 0xBF, 0xE7, 0xFE, 0xFF, 0x8F, 0xF9, 0xFF, 0xFF, 0xC7, 0xFE,
  0x7F, 0xFF, 0xC1, 0xFF, 0x9F, 0xFF, 0xE0, 0x7F, 0xC7, 0xFF, 0xE0, 0x1F,
  0xF1, 0xFF, 0xF0, 0x07, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0x3F, 0xF8, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xF7, 0xFC, 0xFF, 0x87, 0xFC,
  0xFC, 0x07, 0xFC, 0xE0, 0x0F, 0xFC, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x80, 0x01,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC1, 0xC0, 0x00, 0x01, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0xF8, 0x03, 0xFE, 0xFF, 0xFE,
  0x03, 0xFE, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x03,
  0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF7, 0xFC, 0x00,
  0x1F, 0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFE,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0x7F,
  0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xC0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x3F,
  0xF8, 0x03, 0xFE, 0x3F, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x7F,
  0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x7F,
  0xE0, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF7, 0xFC, 0x01, 0xFF, 0xCF, 0xF8, 0x00,
  0x7E, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0x80,
  0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xF0,
  0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F,
  0xFC, 0x3E, 0x03, 0xF0, 0x7F, 0xFE, 0x3E, 0x07, 0xE0, 0xFF, 0xFE, 0x3E,
  0x07, 0xC1, 0xFF, 0xFE, 0x3E, 0x0F, 0xC3, 0xFE, 0x3E, 0x3E, 0x0F, 0x83,
  0xF8, 0x7C, 0x3E, 0x1F, 0x87, 0xF0, 0x7C, 0x3E, 0x1F, 0x87, 0xE0, 0x7C,
  0x3E, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x3F, 0x0F, 0xC0, 0xF8, 0x3E, 0x3F,
  0x1F, 0x80, 0xF8, 0x3E, 0x3E, 0x1F, 0x80, 0xF8, 0x3E, 0x7E, 0x1F, 0x81,
  0xF8, 0x3E, 0x7E, 0x1F, 0x81, 0xF0, 0x7C, 0x7E, 0x3F, 0x01, 0xF0, 0x7C,
  0x7C, 0x3F, 0x01, 0xF0, 0x7C, 0x7C, 0x3F, 0x03, 0xF0, 0x7C, 0x7C, 0x3F,
  0x03, 0xF0, 0x78, 0xFC, 0x3F, 0x03, 0xE0, 0xF8, 0xFC, 0x3F, 0x03, 0xE0,
  0xF8, 0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xF0, 0xFC,
  0x1F, 0xFF, 0xF7, 0xE0, 0x7C, 0x1F, 0xFF, 0xFF, 0xC0, 0x7C, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7C, 0x0F, 0xF9, 0xFF, 0x80, 0x7E, 0x07, 0xE0, 0xFE, 0x00,
  0x7E, 0x00, 0x80, 0x30, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x00,
  0x00, 0x0F, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00,
  0x7F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFC, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFC, 0x7F,
  0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x3F, 0xF0, 0x0F, 0xFF, 0xF9, 0xFF,
  0x80, 0x7F, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF,
  0xF3, 0xFE, 0x01, 0xFF, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xF8, 0xFF, 0x80,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xF1,
  0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFB, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC7, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE0, 0x1F, 0xFF, 0xCF, 0xFF, 0xF0, 0x0F, 0xF7, 0xE7,
  0xF7, 0xF8, 0x07, 0xFB, 0xF3, 0xFF, 0xFC, 0x07, 0xFD, 0xFB, 0xFB, 0xFC,
  0x03, 0xFE, 0xFD, 0xFD, 0xFE, 0x01, 0xFE, 0x7F, 0xFC, 0xFF, 0x00, 0xFF,
  0x3F, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xFE, 0x7F, 0xC0, 0x3F, 0xCF, 0xFF,
  0x3F, 0xE0, 0x3F, 0xE7, 0xFF, 0x1F, 0xE0, 0x1F, 0xF3, 0xFF, 0x8F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0xC7, 0xFC, 0x03, 0xFC,
  0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x87, 0xF0, 0x7F, 0x80, 0x7F, 0xC3, 0xF8, 0x7F, 0xC0,
  0x3F, 0xC1, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0,
  0x7C, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x03,
  0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x01,
  0xFF, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x07, 0xFD, 0xFC, 0x0F,
  0xF8, 0x07, 0xFD, 0xFC, 0x0F, 0xF8, 0x07, 0xFD, 0xFC, 0x1F, 0xF8, 0x0F,
  0xFC, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0x3F, 0xF0,
  0x0F, 0xF8, 0x7F, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0x3F, 0xF0, 0x1F, 0xF8,
  0x7F, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xBF, 0xE0, 0x1F, 0xF0, 0x3F, 0xBF,
  0xE0, 0x1F, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFF,
  0x80, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00,
  0x3F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x3F,
  0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00,
  0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0xC7,
  0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xFF, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00,
  0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F,
  0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF3, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x07,
  0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00,
  0xFF, 0xC7, 0xFC, 0x00, 0x07, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x80,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0xFF, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0xFF,
  0xBF, 0xE0, 0x3F, 0x80, 0x7F, 0x9F, 0xF0, 0x1F, 0xC0, 0x7F, 0xCF, 0xF8,
  0x1F, 0xE0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF0, 0x1F, 0xE3, 0xFE, 0x07, 0xF8,
  0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x07, 0xFC,
  0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xFC, 0x3F, 0xE0,
  0xFF, 0x0F, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xFF, 0x1F, 0xF0, 0x3F, 0xC7,
  0xFF, 0x8F, 0xF8, 0x1F, 0xE3, 0xFF, 0xC7, 0xF8, 0x0F, 0xF1, 0xFF, 0xE3,
  0xFC, 0x07, 0xF9, 0xFF, 0xF3, 0xFE, 0x03, 0xFC, 0xFF, 0xF9, 0xFF, 0x01,
  0xFE, 0x7E, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0x7E, 0x7F, 0x80, 0x7F, 0xBF,
  0xBF, 0x7F, 0xC0, 0x3F, 0xDF, 0x9F, 0xBF, 0xC0, 0x1F, 0xEF, 0xCF, 0xDF,
  0xE0, 0x0F, 0xFF, 0xE7, 0xFF, 0xF0, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x03,
  0xFF, 0xF1, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFD, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xF8,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0,
  0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0xFF,
  0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x1F, 0x80, 0x1F, 0xC1, 0xFC,
  0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0xFF,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F,
  0xE3, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFF, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xFE, 0x07,
  0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xC3, 0xFF,
  0x80, 0x1F, 0xF1, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8,
  0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x8F, 0xFE, 0x03, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xCF, 0xF8, 0x0F, 0xFF,
  0xE3, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x3C, 0x00, 0x01,
  0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE7, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFE, 0x3F,
  0xF0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xFF, 0xF0,
  0x07, 0xF8, 0xFF, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F,
  0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F,
  0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0xFC,
  0xFF, 0x80, 0x0F, 0xFF, 0xFB, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0x1F,
  0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0x9F, 0xF8, 0x00, 0x0F, 0xF3, 0xFF,
  0x00, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x18, 0x07, 0xFE, 0x00, 0x07, 0x00,
  0xFF, 0xE0, 0x01, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0xFC, 0x7F, 0xC0, 0x0F, 0xFF, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0xC7,
  0xFC, 0x00, 0x00, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x01, 0xC0, 0x00, 0xFF,
  0xC0, 0x0F, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x1E,
  0x00, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0xF0, 0x03, 0xFE,
  0x7F, 0xFF, 0x80, 0x3F, 0xEF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x07,
  0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xFE, 0x00,
  0x07, 0xFC, 0x3F, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xF8, 0x00, 0x07, 0xFC,
  0xFF, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFE,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF8,
  0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x03, 0xFC, 0x7F,
  0x87, 0xF8, 0x03, 0xFC, 0xFF, 0xCF, 0xFC, 0x03, 0xFD, 0xFF, 0xDF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x3F, 0xF1,
  0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0,
  0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F,
  0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1,
  0xFE, 0x0F, 0xF8, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF,
  0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFC,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x03,
  0xFE, 0x3F, 0xFF, 0x00, 0x3F, 0xE7, 0xFF, 0xF8, 0x03, 0xFC, 0xFF, 0xFF,
  0xC0, 0x3F, 0xDF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x00,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0xC3, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xF3,
  0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF,
  0x87, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xF8,
  0x00, 0x0F, 0xF9, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFD, 0xFF, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0xF8, 0x00, 0xFF,
  0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xFF, 0x1F, 0xE0,
  0x0F, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x0F,
  0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xE7, 0xFC, 0x00, 0x1F, 0xF8, 0xFF,
  0x80, 0x00, 0x3C, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xE1, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0xFE, 0x03, 0xFC, 0xFF,
  0xFF, 0x80, 0xFF, 0x7F, 0xFF, 0xE0, 0x7F, 0xDF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x20, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x01,
  0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x7F,
  0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF8,
  0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0x8F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0x0F,
  0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0xFF, 0x80, 0x7F, 0xFF, 0x9F, 0xE0, 0x07, 0xFF, 0xC3, 0xFC, 0x00, 0x7F,
  0xF0, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xE7, 0xFC, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xBF,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x07, 0xFF,
  0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xBF, 0xC0, 0xFF,
  0x03, 0xFE, 0xFF, 0x03, 0xFC, 0x0F, 0xFB, 0xFC, 0x0F, 0xF0, 0x3F, 0xCF,
  0xF0, 0x7F, 0xC0, 0xFF, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFC,
  0x1F, 0xE3, 0xFC, 0x3F, 0xF0, 0x7F, 0x8F, 0xF0, 0xFF, 0xC3, 0xFE, 0x3F,
  0xC3, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0xF1,
  0xFE, 0x0F, 0xE1, 0xF7, 0xC7, 0xF8, 0x3F, 0x8F, 0xDF, 0x1F, 0xE0, 0xFE,
  0x3F, 0x7C, 0x7F, 0x03, 0xF8, 0xF9, 0xF3, 0xFC, 0x0F, 0xE7, 0xE7, 0xCF,
  0xF0, 0x3F, 0x9F, 0x1F, 0x3F, 0x80, 0xFE, 0x7C, 0x7D, 0xFE, 0x03, 0xFB,
  0xF1, 0xF7, 0xF8, 0x0F, 0xEF, 0x87, 0xDF, 0xC0, 0x3F, 0xFE, 0x1F, 0x7F,
  0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x1F, 0xF7,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xF8, 0x7F, 0xFF, 0x80, 0x07, 0xE1, 0xFF, 0xFF, 0xC0, 0x1F, 0xC7, 0xFF,
  0xFF, 0xC0, 0x3F, 0x8F, 0xFF, 0xFF, 0xC0, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0x81, 0xFF, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xFF, 0xE1, 0xF8,
  0x01, 0xFF, 0xFF, 0xC7, 0xF0, 0x00, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
};

const GFXglyph RobotoMono_BoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 18, 51, 41, 12, -50 },
  { 116, 24, 19, 41, 11, -53 },
  { 173, 41, 50, 41, 0, -50 },
  { 430, 37, 65, 41, 3, -58 },
  { 731, 34, 52, 41, 4, -51 },
  { 952, 39, 52, 41, 1, -51 },
  { 1206, 10, 19, 41, 17, -53 },
  { 1230, 23, 71, 41, 11, -55 },
  { 1435, 24, 71, 41, 6, -55 },
  { 1648, 34, 35, 41, 5, -50 },
  { 1797, 35, 36, 41, 3, -41 },
  { 1955, 16, 22, 41, 6, -8 },
  { 1999, 29, 8, 41, 9, -26 },
  { 2028, 13, 13, 41, 11, -12 },
  { 2050, 36, 54, 41, 3, -50 },
  { 2293, 34, 52, 41, 4, -51 },
  { 2514, 24, 50, 41, 8, -50 },
  { 2664, 37, 51, 41, 0, -51 },
  { 2900, 37, 52, 41, 2, -51 },
  { 3141, 36, 50, 41, 1, -50 },
  { 3366, 37, 51, 41, 3, -50 },
  { 3602, 33, 51, 41, 3, -50 },
  { 3813, 37, 50, 41, 4, -50 },
  { 4045, 36, 52, 41, 2, -51 },
  { 4279, 32, 51, 41, 5, -51 },
  { 4483, 18, 41, 41, 12, -40 },
  { 4576, 22, 54, 41, 9, -40 },
  { 4725, 33, 33, 41, 5, -38 },
  { 4862, 36, 22, 41, 3, -32 },
  { 4961, 33, 33, 41, 3, -38 },
  { 5098, 32, 52, 41, 8, -51 },
  { 5306, 40, 49, 41, 1, -49 },
  { 5551, 40, 50, 41, -3, -50 },
  { 5801, 40, 50, 41, 1, -50 },
  { 6051, 37, 52, 41, 3, -51 },
  { 6292, 38, 50, 41, 1, -50 },
  { 6530, 41, 50, 41, 1, -50 },
  { 6787, 42, 50, 41, 1, -50 },
  { 7050, 37, 51, 41, 3, -50 },
  { 7286, 40, 50, 41, 1, -50 },
  { 7536, 36, 50, 41, 3, -50 },
  { 7761, 40, 51, 41, 2, -50 },
  { 8016, 46, 50, 41, 1, -50 },
  { 8304, 34, 50, 41, 1, -50 },
  { 8517, 41, 50, 41, 1, -50 },
  { 8774, 40, 50, 41, 1, -50 },
  { 9024, 38, 52, 41, 2, -51 },
  { 9271, 40, 50, 41, 1, -50 },
  { 9521, 38, 60, 41, 2, -51 },
  { 9806, 40, 50, 41, 1, -50 },
  { 10056, 39, 52, 41, 2, -51 },
  { 10310, 40, 50, 41, 5, -50 },
  { 10560, 39, 51, 41, 3, -50 },
  { 10809, 38, 50, 41, 6, -50 },
  { 11047, 41, 50, 41, 4, -50 },
  { 11304, 47, 50, 41, -2, -50 },
  { 11598, 40, 50, 41, 6, -50 },
  { 11848, 42, 50, 41, 0, -50 },
  { 12111, 26, 69, 41, 8, -58 },
  { 12336, 17, 54, 41, 13, -50 },
  { 12451, 26, 69, 41, 8, -58 },
  { 12676, 28, 27, 41, 7, -50 },
  { 12771, 32, 7, 41, 0, 0 },
  { 12799, 14, 10, 41, 19, -51 },
  { 12817, 34, 39, 41, 2, -38 },
  { 12983, 36, 54, 41, 1, -53 },
  { 13226, 34, 39, 41, 3, -38 },
  { 13392, 38, 54, 41, 3, -53 },
  { 13649, 35, 39, 41, 3, -38 },
  { 13820, 38, 54, 41, 6, -54 },
  { 14077, 38, 53, 41, 1, -38 },
  { 14329, 36, 53, 41, 1, -53 },
  { 14568, 30, 52, 41, 4, -52 },
  { 14763, 32, 67, 41, 2, -52 },
  { 15031, 40, 53, 41, 1, -53 },
  { 15296, 32, 53, 41, 3, -53 },
  { 15508, 40, 38, 41, -1, -38 },
  { 15698, 36, 38, 41, 1, -38 },
  { 15869, 34, 39, 41, 3, -38 },
  { 16035, 38, 52, 41, -1, -38 },
  { 16282, 36, 52, 41, 3, -38 },
  { 16516, 34, 38, 41, 6, -38 },
  { 16678, 35, 39, 41, 3, -38 },
  { 16849, 32, 47, 41, 6, -46 },
  { 17037, 35, 38, 41, 4, -37 },
  { 17204, 36, 37, 41, 5, -37 },
  { 17371, 38, 37, 41, 4, -37 },
  { 17547, 43, 37, 41, -1, -37 },
  { 17746, 44, 52, 41, 0, -37 },
  { 18032, 38, 37, 41, 1, -37 },
  { 18208, 27, 67, 41, 10, -55 },
  { 18435, 16, 64, 41, 12, -50 },
  { 18563, 27, 67, 41, 7, -55 },
  { 18790, 39, 15, 41, 0, -28 },
};

const GFXfont RobotoMono_BoldItalic70pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic70pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic70pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _ROBOTOMONO_BOLDITALIC70PT7B_H_
