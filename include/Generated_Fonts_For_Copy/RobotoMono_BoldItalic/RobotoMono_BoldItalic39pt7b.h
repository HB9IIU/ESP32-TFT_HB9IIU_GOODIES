#ifndef _ROBOTOMONO_BOLDITALIC39PT7B_H_
#define _ROBOTOMONO_BOLDITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0xE0, 0xFC, 0x3F, 0x0F, 0x81, 0xE0,
  0x3C, 0x79, 0xE3, 0xCE, 0x1E, 0xF0, 0xF7, 0x87, 0x3C, 0x39, 0xC1, 0xCE,
  0x1E, 0x70, 0xF7, 0x87, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x70, 0x00,
  0xF1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0x70, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF0, 0x0F, 0x1E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0xF1, 0xE0,
  0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x00, 0xF1, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0F,
  0x1E, 0x00, 0x1C, 0x38, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xC7,
  0xF1, 0xF8, 0x3F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xFC, 0x07, 0xCF, 0xC1, 0xFC,
  0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x07, 0xF8,
  0x01, 0xFF, 0x80, 0x3C, 0xF0, 0x87, 0x0E, 0x1C, 0xE1, 0xC7, 0xBC, 0x78,
  0xE7, 0x8F, 0x38, 0x71, 0xEE, 0x0F, 0xFB, 0xC0, 0xFE, 0x70, 0x0F, 0x9C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xCF,
  0x00, 0x73, 0xF8, 0x1C, 0xFF, 0x87, 0xBC, 0xF0, 0xE7, 0x0E, 0x38, 0xE1,
  0xCF, 0x3C, 0x38, 0xC7, 0x8F, 0x00, 0xF1, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0x1F,
  0xFC, 0x7C, 0xFD, 0xF9, 0xF7, 0xE3, 0xE7, 0x9F, 0x0F, 0xFE, 0x7C, 0x1F,
  0xF9, 0xF0, 0x7F, 0xC7, 0xC0, 0xFE, 0x1F, 0x87, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFC, 0x7E, 0x7B, 0xDE, 0xFF, 0x7B,
  0xDE, 0xE7, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x18, 0x00, 0x40, 0x02, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x06, 0x00, 0x10, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x80, 0xE0, 0x5C, 0x3C, 0x33, 0xE7,
  0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x1F, 0xF8, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x1E, 0xF0, 0x07, 0xCE, 0x01, 0xF1, 0xE0, 0x7C, 0x3E, 0x0F, 0x83,
  0xC0, 0x60, 0x70, 0x08, 0x08, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0xF0, 0x20, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x18, 0xFD, 0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC,
  0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0x7C, 0xF8, 0x1F, 0xBF, 0x0F, 0xF7, 0xC3, 0xFE, 0xF9, 0xFF, 0xDF, 0x7D,
  0xFB, 0xFE, 0x3E, 0x7F, 0x87, 0xCF, 0xC0, 0xFB, 0xF0, 0x1F, 0x7C, 0x07,
  0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x1F, 0x07, 0xE3, 0xE1, 0xF8, 0x7F, 0xFE,
  0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x04, 0x00, 0xF0,
  0x1F, 0xC3, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0x3E, 0x61, 0xFA,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFE, 0x7F, 0x07, 0xC0,
  0xF8, 0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFC, 0x3F,
  0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xF0, 0x3F, 0x1F,
  0x83, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7B,
  0xE0, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x07, 0xCF, 0xC0, 0x7C, 0x7C, 0x03,
  0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xE0, 0x7C,
  0x5F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xDF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x7E, 0x7E, 0x03,
  0xE1, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xCF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0xFF,
  0xEF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x81, 0xF9, 0xF0, 0xFC, 0x7F,
  0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xE7, 0xF0, 0xF8,
  0x3F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x3F, 0x1F,
  0x83, 0xE0, 0xFC, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x3F, 0x0F, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C,
  0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x0F, 0xC7, 0xE1, 0xFC, 0x7F, 0xFF,
  0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x01, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x1F, 0x9F, 0x83, 0xE7, 0xC0, 0xFB,
  0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8,
  0x0F, 0xBF, 0x07, 0xEF, 0xE3, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF,
  0xC0, 0xF9, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x06,
  0x0F, 0xC7, 0xE7, 0xF3, 0xF8, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x3E, 0x3F, 0x9F, 0xCF, 0xE7, 0xE1,
  0xF0, 0x00, 0xC0, 0x3E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xF8,
  0x00, 0x1E, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x80, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F,
  0xF0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF8, 0x0F,
  0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xEF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFE, 0xFC, 0x07, 0x80, 0x70, 0x3C,
  0x00, 0xE1, 0xE0, 0xC3, 0x87, 0x1F, 0xEE, 0x3C, 0xFF, 0x98, 0xE7, 0xCE,
  0x67, 0x9C, 0x71, 0xDC, 0xF1, 0xC6, 0x73, 0x87, 0x3B, 0xCE, 0x1C, 0xEE,
  0x78, 0xE3, 0xB9, 0xE3, 0x8E, 0xE7, 0x0E, 0x33, 0x9C, 0x39, 0xCE, 0x79,
  0xE7, 0x39, 0xFF, 0xF8, 0xE3, 0xFF, 0xC3, 0x87, 0x9E, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7C, 0x08, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xE7,
  0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F,
  0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF8, 0x01, 0xF7, 0xE0, 0x03, 0xF0, 0x07,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F, 0x80,
  0x7E, 0x1F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0x01, 0xF8,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87,
  0xC0, 0x3F, 0x1F, 0x80, 0xFE, 0x3E, 0x07, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFE, 0x3F, 0x0F, 0xC0, 0xFC,
  0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3E, 0x0F, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xFC, 0x3E,
  0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7C, 0x03,
  0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x07, 0xE3,
  0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x3E, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0,
  0xFC, 0x1F, 0x0F, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xC7, 0xF1, 0xF0, 0x3F,
  0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0xEF, 0x87,
  0xFE, 0xF8, 0x7F, 0xEF, 0x87, 0xFE, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8,
  0x07, 0xCF, 0x80, 0x7C, 0xFC, 0x07, 0xC7, 0xE1, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x7C, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F,
  0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF0,
  0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x1F, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F,
  0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x07, 0xE3,
  0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x1F, 0xC1, 0xF0,
  0x0F, 0xE0, 0x7C, 0x07, 0xF0, 0x1F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x8F, 0xC0,
  0x03, 0xE7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0x7D, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xF7, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0xFC, 0x3E, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x83, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F,
  0xF3, 0xFC, 0x0F, 0x73, 0xFC, 0x0F, 0x77, 0xBC, 0x0F, 0x77, 0xFC, 0x1F,
  0x7F, 0x7C, 0x1F, 0x7F, 0x7C, 0x1F, 0x7E, 0x78, 0x1F, 0x7E, 0x78, 0x1E,
  0x7C, 0xF8, 0x1E, 0x7C, 0xF8, 0x3E, 0x78, 0xF8, 0x3E, 0x38, 0xF8, 0x3E,
  0x38, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x78,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F,
  0x81, 0xF8, 0x3F, 0x03, 0xE0, 0xFE, 0x07, 0xC1, 0xFE, 0x0F, 0x83, 0xFC,
  0x1F, 0x07, 0xF8, 0x7E, 0x0F, 0xF0, 0xFC, 0x3F, 0xE1, 0xF0, 0x7F, 0xE3,
  0xE0, 0xFB, 0xC7, 0xC1, 0xF7, 0x8F, 0x83, 0xE7, 0x3F, 0x07, 0xCF, 0x7E,
  0x1F, 0x9E, 0xF8, 0x3F, 0x3D, 0xF0, 0x7C, 0x3B, 0xE0, 0xF8, 0x7F, 0xC1,
  0xF0, 0xFF, 0x83, 0xE1, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3E,
  0x07, 0xF0, 0x7C, 0x0F, 0xE0, 0xF8, 0x1F, 0xC1, 0xF0, 0x1F, 0x07, 0xE0,
  0x3E, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFE, 0x7F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xE7, 0xE0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x3E, 0x7C, 0x01, 0xF7, 0xE0,
  0x0F, 0xBF, 0x00, 0x7D, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xF1,
  0xF0, 0x3F, 0x0F, 0xC3, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3E, 0x03, 0xE1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0,
  0x3E, 0x3F, 0x01, 0xF8, 0xFE, 0x3F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0x7F, 0x07, 0xC0,
  0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07,
  0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8,
  0x07, 0xE7, 0xC0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0xC3, 0xF8,
  0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x01, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F,
  0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF0,
  0x1F, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xFC,
  0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xE0,
  0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0x80, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE3, 0xF8, 0x7E,
  0x03, 0xE1, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F,
  0x1F, 0x81, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x9F, 0x80, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0xFC, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F,
  0x80, 0xFC, 0x7C, 0x07, 0xC3, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0x9F, 0x00, 0x7C, 0x7C, 0x03, 0xF1, 0xF0,
  0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x03,
  0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x00, 0x79, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x7C, 0x3C, 0x3E, 0xF8, 0x78, 0x7D, 0xF1, 0xF1, 0xF3, 0xE3,
  0xE3, 0xE7, 0xC7, 0xC7, 0xCF, 0x9F, 0x8F, 0x1F, 0x3F, 0x3E, 0x3C, 0x7E,
  0x7C, 0x78, 0xFC, 0xF8, 0xF3, 0xF9, 0xE1, 0xE7, 0xF7, 0xC3, 0xCF, 0xEF,
  0x87, 0xBF, 0xDE, 0x0F, 0x7F, 0xFC, 0x1E, 0xEF, 0xF8, 0x3F, 0xDD, 0xE0,
  0x7F, 0xBB, 0xC0, 0xFE, 0x7F, 0x81, 0xFC, 0xFF, 0x03, 0xF9, 0xFC, 0x07,
  0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7C,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x00, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x0F, 0x80, 0xFC,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE7,
  0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x7C,
  0x00, 0x0F, 0xDF, 0x00, 0x07, 0xE7, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x1F, 0xC0, 0x7E, 0x07,
  0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xEF,
  0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xE0,
  0xFC, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x01, 0xF3, 0xE0,
  0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03,
  0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xF8,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x81,
  0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x03, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xB8, 0x07, 0xBC, 0x0F, 0xBC, 0x0F, 0x3C, 0x1E, 0x1C, 0x1E,
  0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x0F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFC, 0x3E, 0x3E, 0x1E, 0x0F, 0x00,
  0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x7E,
  0x0F, 0xCF, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFF, 0x1F, 0xFF, 0xE7, 0xE0, 0x7D, 0xF8, 0x0F, 0xBF, 0x03, 0xF7, 0xC0,
  0x7E, 0xFC, 0x1F, 0x9F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFC,
  0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x3F, 0x01,
  0xF7, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xCF, 0xE3, 0xF0, 0x3E,
  0x3E, 0x03, 0xE3, 0xE0, 0x3F, 0x3E, 0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x03,
  0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xC0,
  0x7C, 0x7E, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xBF, 0xE0, 0xF9,
  0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0x9F, 0xCF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFB,
  0xE0, 0x3E, 0x7C, 0x1F, 0x9F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x03,
  0xF3, 0xF0, 0x7F, 0xDF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xF9, 0xFE,
  0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xFC, 0x3F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0x7F, 0xDE, 0x01, 0xFD, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xF8, 0xFC, 0x7E, 0x0F, 0x9F, 0x80, 0xFB,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x10, 0x7E, 0x0F, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xE0, 0x80, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x7C, 0x07, 0xFD, 0xF0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x0F, 0xE3, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0x87,
  0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0xC0, 0xF8,
  0x3F, 0x0F, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFE, 0xF8, 0x07,
  0xF7, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x0C, 0x03, 0xF0, 0x3C, 0x3F,
  0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x1F, 0x01, 0xF7,
  0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xCF, 0xE3, 0xF0, 0x3F, 0x3E,
  0x03, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0x3E, 0x7E, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0x7C,
  0xFC, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F,
  0xC0, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x01, 0xFC, 0x7C, 0x0F, 0xE1, 0xF0, 0x7F, 0x07, 0xC3, 0xF8,
  0x1F, 0x1F, 0xC0, 0xFC, 0xFC, 0x03, 0xE7, 0xE0, 0x0F, 0xBF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFD, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0xFC, 0x1F, 0x83,
  0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0x07,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x3C, 0x78, 0x1E, 0xFD, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF1, 0xFB, 0xF3, 0xE3, 0xE3, 0xC7, 0xC7, 0xCF, 0x8F, 0x8F, 0x1F, 0x1E,
  0x1E, 0x3E, 0x3C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF1, 0xF1, 0xF1, 0xE3, 0xE3,
  0xE7, 0xC7, 0xC7, 0x8F, 0x8F, 0x0F, 0x1F, 0x1E, 0x3E, 0x3E, 0x7C, 0x7C,
  0x78, 0xF8, 0xF8, 0xF1, 0xF1, 0xF3, 0xE3, 0xE3, 0xC7, 0xC7, 0x8F, 0x8F,
  0x9F, 0x00, 0x1F, 0x1F, 0x01, 0xF7, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3F, 0xCF, 0xE3, 0xF0, 0x3F, 0x3E, 0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x03,
  0xF3, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0x80, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF9, 0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xF7,
  0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF,
  0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xC0, 0x7C, 0xFC, 0x3F, 0x8F,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xCF, 0x80,
  0x1F, 0x7F, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xF3, 0xF8, 0x3F,
  0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03,
  0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xBF, 0xE0, 0x3E, 0x7F, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0xFF, 0x9E, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0x9F, 0xE7, 0xE0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0,
  0x7C, 0xFC, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xFC, 0x3F, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x8F, 0xE1, 0xF3, 0xFC, 0x3D,
  0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xE1, 0x87, 0xF0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x83, 0xF1, 0xF0, 0x1F, 0x3E,
  0x01, 0xF3, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0xF8, 0x03, 0xEF, 0xC0, 0x3E,
  0x7C, 0x07, 0xC7, 0xFB, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x1F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x40, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0x80, 0xFC, 0xF8,
  0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x83,
  0xFE, 0xF8, 0x1F, 0x8F, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x07,
  0xEF, 0x80, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC1,
  0xF0, 0x3C, 0x1F, 0x03, 0xC3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x70,
  0x7F, 0xE1, 0xC3, 0xEF, 0x8F, 0x0F, 0xBE, 0x3C, 0x3C, 0xF8, 0xF1, 0xF3,
  0xE7, 0xC7, 0xCF, 0x1F, 0x1E, 0x3C, 0xFC, 0x78, 0xF3, 0xF3, 0xE3, 0xCF,
  0xCF, 0x0F, 0x7B, 0x3C, 0x3D, 0xCD, 0xF0, 0xF7, 0x37, 0x83, 0xF8, 0xDE,
  0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0xC3, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x1F,
  0x01, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x0F, 0xC0, 0x3E, 0x3F, 0x00, 0x7C,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xE0, 0x07, 0xE7, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x0F, 0x80,
  0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x3F,
  0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0xFC,
  0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xF0,
  0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xEF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x1C,
  0x00, 0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0xFF, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x07, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C,
  0x00, 0x07, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x01,
  0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xFE, 0x01, 0x8F, 0xFC, 0x0E, 0xFF, 0xF0, 0xF7, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFB, 0xC0, 0xFF, 0xC4, 0x03, 0xFC, 0x00, 0x07, 0x80,
};

const GFXglyph RobotoMono_BoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 10, 28, 23, 7, -28 },
  { 36, 13, 10, 23, 6, -29 },
  { 53, 23, 28, 23, 0, -28 },
  { 134, 20, 36, 23, 2, -32 },
  { 224, 19, 28, 23, 2, -28 },
  { 291, 22, 28, 23, 0, -28 },
  { 368, 5, 10, 23, 10, -29 },
  { 375, 13, 40, 23, 6, -31 },
  { 440, 14, 40, 23, 3, -31 },
  { 510, 19, 20, 23, 3, -28 },
  { 558, 19, 20, 23, 2, -23 },
  { 606, 8, 13, 23, 4, -5 },
  { 619, 16, 4, 23, 5, -14 },
  { 627, 7, 7, 23, 6, -7 },
  { 634, 20, 30, 23, 2, -28 },
  { 709, 19, 28, 23, 2, -28 },
  { 776, 14, 28, 23, 4, -28 },
  { 825, 21, 28, 23, 0, -28 },
  { 899, 21, 28, 23, 1, -28 },
  { 973, 21, 28, 23, 0, -28 },
  { 1047, 21, 28, 23, 1, -28 },
  { 1121, 18, 28, 23, 2, -28 },
  { 1184, 21, 28, 23, 2, -28 },
  { 1258, 20, 28, 23, 1, -28 },
  { 1328, 18, 28, 23, 3, -28 },
  { 1391, 9, 23, 23, 7, -23 },
  { 1417, 12, 31, 23, 5, -23 },
  { 1464, 18, 18, 23, 3, -21 },
  { 1505, 20, 13, 23, 2, -18 },
  { 1538, 19, 18, 23, 1, -21 },
  { 1581, 17, 28, 23, 5, -28 },
  { 1641, 22, 28, 23, 1, -28 },
  { 1718, 23, 28, 23, -2, -28 },
  { 1799, 23, 28, 23, 0, -28 },
  { 1880, 21, 28, 23, 1, -28 },
  { 1954, 22, 28, 23, 0, -28 },
  { 2031, 23, 28, 23, 1, -28 },
  { 2112, 23, 28, 23, 1, -28 },
  { 2193, 20, 28, 23, 2, -28 },
  { 2263, 23, 28, 23, 0, -28 },
  { 2344, 20, 28, 23, 2, -28 },
  { 2414, 22, 28, 23, 1, -28 },
  { 2491, 26, 28, 23, 0, -28 },
  { 2582, 18, 28, 23, 1, -28 },
  { 2645, 24, 28, 23, 0, -28 },
  { 2729, 23, 28, 23, 0, -28 },
  { 2810, 21, 28, 23, 1, -28 },
  { 2884, 22, 28, 23, 1, -28 },
  { 2961, 21, 33, 23, 1, -28 },
  { 3048, 23, 28, 23, 0, -28 },
  { 3129, 22, 28, 23, 1, -28 },
  { 3206, 22, 28, 23, 3, -28 },
  { 3283, 21, 28, 23, 2, -28 },
  { 3357, 22, 28, 23, 3, -28 },
  { 3434, 23, 28, 23, 2, -28 },
  { 3515, 26, 28, 23, -1, -28 },
  { 3606, 22, 28, 23, 4, -28 },
  { 3683, 24, 28, 23, 0, -28 },
  { 3767, 14, 38, 23, 5, -32 },
  { 3834, 10, 30, 23, 7, -28 },
  { 3872, 14, 38, 23, 5, -32 },
  { 3939, 16, 15, 23, 4, -28 },
  { 3969, 18, 4, 23, 0, 0 },
  { 3978, 8, 5, 23, 10, -28 },
  { 3983, 19, 21, 23, 1, -21 },
  { 4033, 20, 29, 23, 1, -29 },
  { 4106, 18, 21, 23, 2, -21 },
  { 4154, 21, 29, 23, 2, -29 },
  { 4231, 19, 21, 23, 2, -21 },
  { 4281, 21, 30, 23, 3, -30 },
  { 4360, 22, 29, 23, 0, -21 },
  { 4440, 20, 29, 23, 1, -29 },
  { 4513, 17, 29, 23, 2, -29 },
  { 4575, 18, 37, 23, 1, -29 },
  { 4659, 22, 29, 23, 1, -29 },
  { 4739, 17, 29, 23, 2, -29 },
  { 4801, 23, 21, 23, -1, -21 },
  { 4862, 20, 21, 23, 1, -21 },
  { 4915, 19, 21, 23, 2, -21 },
  { 4965, 22, 29, 23, -1, -21 },
  { 5045, 20, 29, 23, 2, -21 },
  { 5118, 19, 21, 23, 3, -21 },
  { 5168, 20, 21, 23, 1, -21 },
  { 5221, 18, 26, 23, 3, -26 },
  { 5280, 20, 21, 23, 2, -21 },
  { 5333, 20, 21, 23, 3, -21 },
  { 5386, 22, 21, 23, 2, -21 },
  { 5444, 23, 21, 23, 0, -21 },
  { 5505, 24, 29, 23, 0, -21 },
  { 5592, 22, 21, 23, 0, -21 },
  { 5650, 15, 37, 23, 6, -30 },
  { 5720, 9, 36, 23, 7, -28 },
  { 5761, 15, 37, 23, 4, -30 },
  { 5831, 21, 9, 23, 0, -16 },
};

const GFXfont RobotoMono_BoldItalic39pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic39pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _ROBOTOMONO_BOLDITALIC39PT7B_H_
