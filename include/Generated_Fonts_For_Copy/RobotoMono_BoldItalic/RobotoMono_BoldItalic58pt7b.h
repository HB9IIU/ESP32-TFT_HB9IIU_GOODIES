#ifndef _ROBOTOMONO_BOLDITALIC58PT7B_H_
#define _ROBOTOMONO_BOLDITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x1F,
  0x03, 0xF3, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xE3,
  0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0xFC,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x08, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0xF8, 0x3F, 0x04, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC3,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x3F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x3F,
  0xE1, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x81,
  0xF0, 0x7C, 0x06, 0x0F, 0x83, 0xF0, 0x7C, 0x7C, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x3E, 0x07, 0xC3, 0xF3,
  0xE0, 0x3F, 0x3F, 0x1F, 0x01, 0xFF, 0xF9, 0xF0, 0x07, 0xFF, 0x9F, 0x00,
  0x1F, 0xF8, 0xF8, 0x00, 0x7F, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x04, 0x00, 0x03, 0xE3, 0xFC,
  0x00, 0x1F, 0x3F, 0xF8, 0x01, 0xF3, 0xFF, 0xC0, 0x1F, 0x3F, 0xFF, 0x01,
  0xF3, 0xF9, 0xF8, 0x0F, 0x9F, 0x87, 0xC0, 0xF8, 0xF8, 0x3E, 0x0F, 0x87,
  0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xF0, 0x7C, 0x0C, 0x1F, 0x83,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC,
  0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC,
  0x7F, 0x80, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0x0F, 0xFF,
  0xE0, 0x7F, 0x1F, 0xFF, 0xF0, 0x7F, 0x3F, 0xEF, 0xF0, 0x7F, 0x3F, 0xC7,
  0xF8, 0xFE, 0x7F, 0x87, 0xF8, 0xFE, 0x7F, 0x83, 0xFD, 0xFE, 0xFF, 0x03,
  0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0x00,
  0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x81,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xE7, 0xF8, 0x03, 0xFF,
  0x87, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x8F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xE3, 0xF1, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x02, 0x00, 0xF8,
  0x02, 0x18, 0x07, 0xC0, 0x71, 0xF8, 0x3C, 0x0F, 0x8F, 0xF1, 0xE3, 0xFC,
  0xFF, 0xEF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x1F, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x3F,
  0x80, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xA0,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07,
  0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFE, 0x00, 0xE0,
  0x02, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0xF1, 0xFF,
  0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF0, 0x30, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00,
  0xFE, 0x3F, 0xC0, 0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xF7,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xE7, 0xF8, 0x0F, 0xFE, 0x7F, 0x83,
  0xFF, 0xE7, 0xF8, 0x7F, 0xFE, 0x7F, 0x1F, 0xFF, 0xEF, 0xF3, 0xF9, 0xFE,
  0xFF, 0xFF, 0x1F, 0xCF, 0xFF, 0xC1, 0xFC, 0xFF, 0xF8, 0x3F, 0xCF, 0xFE,
  0x03, 0xFC, 0xFF, 0xC0, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x0F, 0xFE,
  0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0x3F, 0xCF, 0x83, 0xFC, 0xC0, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x07,
  0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x70,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFE, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x80,
  0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x81, 0xFC, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x78,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x40,
  0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xCF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0x03,
  0xFE, 0x7F, 0xE0, 0x1F, 0xE7, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF7,
  0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE,
  0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE,
  0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xF0,
  0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07,
  0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xFC,
  0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0x83, 0xFE, 0x3F, 0xE0,
  0x3F, 0xC7, 0xF8, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xF7,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x7F,
  0x80, 0x1F, 0xE7, 0xF8, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x9F, 0xFD, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFE, 0xFE, 0x01, 0xFF, 0x3F, 0x80, 0x07, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x3F,
  0x81, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F,
  0xE0, 0x3F, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0E,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0x01, 0xFE, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xF8,
  0x03, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x1F, 0x03, 0xF0, 0x7F, 0x07, 0x81, 0xF0, 0xFF, 0xE3, 0xC1, 0xF0,
  0xFF, 0xF9, 0xE0, 0xF0, 0xFF, 0xF8, 0xF0, 0xF8, 0x7E, 0x3C, 0x78, 0x78,
  0x7E, 0x1E, 0x3C, 0x7C, 0x7E, 0x1F, 0x1E, 0x3E, 0x3E, 0x0F, 0x0F, 0x1E,
  0x1F, 0x07, 0x87, 0x9F, 0x1F, 0x03, 0xC3, 0xCF, 0x8F, 0x83, 0xE1, 0xE7,
  0x87, 0xC1, 0xE0, 0xF3, 0xC7, 0xC0, 0xF0, 0xF3, 0xE3, 0xE0, 0x78, 0x79,
  0xF1, 0xF0, 0x7C, 0x3C, 0xF8, 0xF8, 0x3E, 0x1E, 0x7C, 0x7C, 0x1E, 0x1E,
  0x3E, 0x3E, 0x1F, 0x0F, 0x1F, 0x1F, 0x9F, 0x8F, 0x0F, 0x87, 0xFF, 0xFF,
  0x87, 0xC3, 0xFF, 0xFF, 0x83, 0xE0, 0xFE, 0x7F, 0x80, 0xF0, 0x3E, 0x3F,
  0x80, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x02, 0x00, 0x01, 0xFE, 0x0F, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFC,
  0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x1F, 0xFC, 0x0F, 0xF0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x0F,
  0xF0, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x0F,
  0xFC, 0x1F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x81, 0xFF,
  0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0xF0, 0x07,
  0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0,
  0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xE1, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x08, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0x9F,
  0xE0, 0x7F, 0xFF, 0x3F, 0xC0, 0xFF, 0xFC, 0x7F, 0x01, 0xFF, 0xF9, 0xFE,
  0x03, 0xFF, 0xF3, 0xFC, 0x0F, 0xFF, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00,
  0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8,
  0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x0F,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0x83, 0xFF, 0x00, 0x01,
  0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0x03, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x8F, 0xFF,
  0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xF0, 0x1F, 0xBE, 0x7F,
  0xFC, 0x0F, 0xEF, 0xBF, 0x7F, 0x03, 0xFB, 0xEF, 0xDF, 0xC0, 0xFE, 0xFB,
  0xE7, 0xE0, 0x3F, 0xBF, 0xFB, 0xF8, 0x0F, 0xEF, 0xFC, 0xFE, 0x03, 0xFB,
  0xFF, 0x3F, 0x81, 0xFC, 0x7F, 0x8F, 0xE0, 0x7F, 0x1F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF9, 0xFC, 0x07, 0xF1, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x1F, 0xC0,
  0x7F, 0x1F, 0x87, 0xF0, 0x3F, 0x87, 0xE1, 0xFC, 0x0F, 0xE1, 0xF0, 0xFF,
  0x03, 0xF8, 0x7C, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x3F, 0x80, 0x7F, 0xE0, 0x1F, 0xE0, 0x3F, 0xF8, 0x07, 0xF8, 0x0F,
  0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xF0, 0x1F, 0xE0,
  0x3F, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0x83,
  0xF8, 0x07, 0xFF, 0xE1, 0xFE, 0x03, 0xFC, 0xFC, 0x7F, 0x80, 0xFF, 0x3F,
  0x1F, 0xE0, 0x3F, 0xCF, 0xC7, 0xF8, 0x0F, 0xF3, 0xF1, 0xFE, 0x03, 0xFC,
  0x7E, 0x7F, 0x00, 0xFE, 0x1F, 0xBF, 0xC0, 0x7F, 0x87, 0xEF, 0xF0, 0x1F,
  0xE1, 0xFB, 0xFC, 0x07, 0xF8, 0x3E, 0xFF, 0x01, 0xFE, 0x0F, 0xFF, 0xC0,
  0x7F, 0x83, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xFE,
  0x03, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xF8,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x1F,
  0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xFC,
  0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0x81, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x01,
  0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFC,
  0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFE, 0xFF, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x61, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xE0, 0x1F, 0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x03,
  0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF0, 0x01,
  0xFF, 0x03, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x1F,
  0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xF0,
  0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07,
  0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC,
  0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF,
  0x00, 0x7F, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80,
  0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x03,
  0xE0, 0x3F, 0xFF, 0x03, 0xF0, 0x3F, 0xFF, 0x81, 0xF8, 0x1F, 0xDF, 0xC0,
  0xFC, 0x0F, 0xEF, 0xE0, 0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0x07, 0xF3, 0xF8,
  0x3F, 0x83, 0xF9, 0xFC, 0x3F, 0xC1, 0xFC, 0xFE, 0x1F, 0xE1, 0xFC, 0x7F,
  0x0F, 0xF0, 0xFE, 0x3F, 0x87, 0xF8, 0x7F, 0x1F, 0xC7, 0xFC, 0x3F, 0x8F,
  0xE3, 0xFE, 0x3F, 0x87, 0xF1, 0xFF, 0x1F, 0xC3, 0xF9, 0xFF, 0x8F, 0xE1,
  0xFC, 0xFF, 0xCF, 0xE0, 0xFE, 0x7F, 0xE7, 0xF0, 0x7F, 0x3F, 0xF3, 0xF8,
  0x3F, 0xBF, 0xF9, 0xFC, 0x1F, 0xDF, 0x7D, 0xFC, 0x0F, 0xEF, 0xBE, 0xFE,
  0x07, 0xFF, 0xDF, 0x7F, 0x03, 0xFF, 0xCF, 0xBF, 0x01, 0xFF, 0xE7, 0xFF,
  0x80, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF,
  0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x1F,
  0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8,
  0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xF1,
  0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF,
  0xBF, 0xC0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F,
  0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xE7,
  0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x1F, 0x03, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x01, 0xF3,
  0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F,
  0xF3, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0x01, 0xFC, 0x7F, 0xC0, 0x1F, 0xCF,
  0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00,
  0x3F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xBF, 0x81, 0xFF,
  0xF3, 0xF8, 0x0F, 0xFC, 0x3F, 0x80, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x7F, 0xBF, 0xF8, 0x01, 0xFD, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x87, 0xFE,
  0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07,
  0xF8, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC,
  0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFD, 0xFF, 0xFC, 0x0F, 0xF3,
  0xFF, 0xE0, 0x3F, 0x87, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0xFF, 0x00,
  0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xBF,
  0xC0, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xFE, 0x00, 0x7F,
  0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x81, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xF9, 0xFE, 0x01, 0xFF, 0xFB, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC3, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x1F,
  0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xF9, 0xFC, 0x00, 0x3F, 0xE3, 0xF8,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xC1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0,
  0x07, 0xF0, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x07,
  0xF7, 0xF8, 0x00, 0x3F, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x0C, 0x07, 0xF8, 0x00, 0xE0, 0x3F, 0xF0, 0x1F, 0x81,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x7F, 0xF9, 0xFC, 0x03, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x07,
  0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0x80,
  0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFB, 0xFC, 0x00, 0x7F, 0xC7, 0xF0, 0x00, 0x1C, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x20, 0x00, 0xFF, 0x80, 0x60, 0x01, 0xFE, 0x01,
  0xE0, 0x0F, 0xFC, 0x07, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0x1F, 0xFC, 0x01, 0xFC, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x87, 0xFE, 0x0F, 0xF8,
  0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80,
  0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x03,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x40, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x1F,
  0xE0, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xF0, 0x0F, 0xFC, 0x03,
  0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x01, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0x8F, 0xF8, 0x00,
  0x1F, 0xDF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF7, 0xF8,
  0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xF1, 0xF0, 0x7E,
  0x03, 0xFB, 0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFD, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xE7, 0xFC,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xF1, 0xFC, 0x1F,
  0x83, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x3F, 0x8F, 0xE0,
  0xFC, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x7F,
  0x07, 0xE0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0x7E, 0x0F, 0xE3,
  0xF8, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC7, 0xFF, 0x00,
  0x7F, 0x3F, 0xFE, 0x01, 0xFD, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80,
  0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF0, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00,
  0x3F, 0x8F, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F,
  0xBF, 0xC0, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0xFF,
  0x8F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0xFF, 0xE0, 0x01, 0xFD, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x87,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xDF, 0xFF, 0xC0, 0x3F, 0xCF, 0xFF, 0x00, 0x3F, 0xC7, 0xFE,
  0x00, 0x3F, 0xC0, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x83, 0xF8, 0x0F, 0xFF, 0x1F, 0xC0, 0xFF, 0xFD, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xE1, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00,
  0x7F, 0x9F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE,
  0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00,
  0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xBF, 0x80, 0x1F, 0xF3, 0xFC, 0x00, 0x0C, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x3F, 0xF0, 0x7F, 0x0F, 0xFF, 0x07, 0xF3, 0xFF, 0xF0,
  0x7F, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xC0, 0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFE,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x3F, 0x9F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xE3, 0xFF, 0x07, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x18, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F,
  0xE1, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8,
  0x7F, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0,
  0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x01,
  0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F,
  0x8F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F,
  0x81, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xEF, 0xE0, 0x3F, 0xFF, 0x3F, 0x80, 0x7F, 0xF8, 0xFE, 0x00, 0x7F, 0xC7,
  0xF0, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1,
  0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x1F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x07, 0xC0, 0x7F, 0xFE, 0x07, 0xC0, 0xFF, 0xFE, 0x07,
  0xC0, 0xFE, 0xFE, 0x0F, 0xC0, 0xFE, 0xFE, 0x0F, 0xE0, 0xFE, 0xFE, 0x0F,
  0xE1, 0xFC, 0xFE, 0x1F, 0xE1, 0xFC, 0xFE, 0x1F, 0xE1, 0xF8, 0xFE, 0x3F,
  0xE3, 0xF8, 0xFE, 0x3F, 0xE3, 0xF8, 0xFE, 0x3F, 0xE3, 0xF0, 0xFC, 0x7F,
  0xE7, 0xF0, 0xFC, 0x7F, 0xE7, 0xF0, 0xFC, 0x7B, 0xE7, 0xE0, 0xFC, 0xFB,
  0xE7, 0xE0, 0xFC, 0xFB, 0xEF, 0xE0, 0xFC, 0xF3, 0xEF, 0xC0, 0xFD, 0xF3,
  0xEF, 0xC0, 0xFD, 0xF3, 0xFF, 0xC0, 0xFD, 0xE3, 0xFF, 0x80, 0xFF, 0xE3,
  0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F,
  0xF1, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0xFE,
  0x1F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x08, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1C, 0x1F, 0xFF, 0x80,
  0x3F, 0x3F, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0xE0, 0x7E, 0x7F, 0xFF, 0xF8,
  0xFE, 0x7F, 0x0F, 0xFF, 0xFE, 0x7E, 0x07, 0xFF, 0xFC, 0xFC, 0x03, 0xFF,
  0xFC, 0xF8, 0x00, 0xFF, 0xF8, 0x08, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0,
};

const GFXglyph RobotoMono_BoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 15, 41, 34, 10, -41 },
  { 78, 20, 15, 34, 9, -44 },
  { 116, 34, 41, 34, 0, -41 },
  { 291, 30, 54, 34, 3, -48 },
  { 494, 29, 43, 34, 3, -42 },
  { 650, 32, 43, 34, 1, -42 },
  { 822, 9, 16, 34, 14, -44 },
  { 840, 20, 59, 34, 9, -46 },
  { 988, 20, 59, 34, 5, -46 },
  { 1136, 29, 29, 34, 4, -41 },
  { 1242, 29, 30, 34, 2, -34 },
  { 1351, 13, 19, 34, 5, -7 },
  { 1382, 24, 6, 34, 7, -21 },
  { 1400, 11, 11, 34, 9, -10 },
  { 1416, 31, 45, 34, 2, -41 },
  { 1591, 28, 43, 34, 4, -42 },
  { 1742, 20, 41, 34, 7, -41 },
  { 1845, 31, 42, 34, 0, -42 },
  { 2008, 31, 43, 34, 1, -42 },
  { 2175, 30, 41, 34, 1, -41 },
  { 2329, 31, 42, 34, 2, -41 },
  { 2492, 28, 43, 34, 2, -42 },
  { 2643, 30, 41, 34, 4, -41 },
  { 2797, 30, 43, 34, 2, -42 },
  { 2959, 27, 42, 34, 4, -42 },
  { 3101, 14, 34, 34, 10, -33 },
  { 3161, 19, 45, 34, 7, -33 },
  { 3268, 27, 27, 34, 4, -31 },
  { 3360, 29, 19, 34, 3, -27 },
  { 3429, 28, 27, 34, 2, -31 },
  { 3524, 26, 42, 34, 7, -42 },
  { 3661, 33, 41, 34, 1, -41 },
  { 3831, 33, 41, 34, -2, -41 },
  { 4001, 33, 41, 34, 1, -41 },
  { 4171, 31, 43, 34, 2, -42 },
  { 4338, 33, 41, 34, 0, -41 },
  { 4508, 34, 41, 34, 1, -41 },
  { 4683, 34, 41, 34, 1, -41 },
  { 4858, 31, 43, 34, 2, -42 },
  { 5025, 34, 41, 34, 0, -41 },
  { 5200, 31, 41, 34, 2, -41 },
  { 5359, 32, 42, 34, 2, -41 },
  { 5527, 38, 41, 34, 1, -41 },
  { 5722, 28, 41, 34, 1, -41 },
  { 5866, 34, 41, 34, 1, -41 },
  { 6041, 34, 41, 34, 0, -41 },
  { 6216, 31, 43, 34, 2, -42 },
  { 6383, 33, 41, 34, 1, -41 },
  { 6553, 31, 49, 34, 2, -42 },
  { 6743, 33, 41, 34, 1, -41 },
  { 6913, 32, 43, 34, 2, -42 },
  { 7085, 33, 41, 34, 4, -41 },
  { 7255, 31, 42, 34, 3, -41 },
  { 7418, 32, 41, 34, 5, -41 },
  { 7582, 33, 41, 34, 4, -41 },
  { 7752, 39, 41, 34, -2, -41 },
  { 7952, 33, 41, 34, 5, -41 },
  { 8122, 35, 41, 34, 0, -41 },
  { 8302, 21, 57, 34, 7, -48 },
  { 8452, 14, 45, 34, 11, -41 },
  { 8531, 21, 57, 34, 7, -48 },
  { 8681, 23, 22, 34, 6, -41 },
  { 8745, 26, 6, 34, 0, 0 },
  { 8765, 12, 8, 34, 15, -42 },
  { 8777, 28, 32, 34, 2, -31 },
  { 8889, 30, 45, 34, 1, -44 },
  { 9058, 27, 32, 34, 3, -31 },
  { 9166, 31, 45, 34, 3, -44 },
  { 9341, 29, 32, 34, 2, -31 },
  { 9457, 31, 45, 34, 5, -45 },
  { 9632, 31, 43, 34, 1, -31 },
  { 9799, 30, 44, 34, 1, -44 },
  { 9964, 25, 43, 34, 3, -43 },
  { 10099, 27, 55, 34, 1, -43 },
  { 10285, 33, 44, 34, 1, -44 },
  { 10467, 27, 44, 34, 2, -44 },
  { 10616, 33, 31, 34, -1, -31 },
  { 10744, 30, 31, 34, 1, -31 },
  { 10861, 29, 32, 34, 2, -31 },
  { 10977, 32, 43, 34, -1, -31 },
  { 11149, 29, 43, 34, 3, -31 },
  { 11305, 28, 31, 34, 5, -31 },
  { 11414, 29, 32, 34, 2, -31 },
  { 11530, 26, 39, 34, 5, -38 },
  { 11657, 30, 32, 34, 3, -31 },
  { 11777, 30, 31, 34, 4, -31 },
  { 11894, 32, 31, 34, 3, -31 },
  { 12018, 35, 31, 34, 0, -31 },
  { 12154, 36, 43, 34, 0, -31 },
  { 12348, 32, 31, 34, 1, -31 },
  { 12472, 23, 55, 34, 8, -45 },
  { 12631, 13, 53, 34, 10, -41 },
  { 12718, 23, 55, 34, 5, -45 },
  { 12877, 32, 12, 34, 0, -23 },
};

const GFXfont RobotoMono_BoldItalic58pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic58pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOMONO_BOLDITALIC58PT7B_H_
