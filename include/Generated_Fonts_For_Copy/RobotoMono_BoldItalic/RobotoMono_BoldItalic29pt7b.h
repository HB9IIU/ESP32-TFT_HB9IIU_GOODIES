#ifndef _ROBOTOMONO_BOLDITALIC29PT7B_H_
#define _ROBOTOMONO_BOLDITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x1E, 0x3C, 0x78, 0xF1, 0xC3,
  0x8F, 0x00, 0x00, 0x00, 0xE3, 0xC7, 0x8F, 0x00, 0x71, 0xB9, 0xD8, 0xFC,
  0x7E, 0x3F, 0x1B, 0x0D, 0x8E, 0x00, 0xE7, 0x00, 0x63, 0x80, 0x31, 0x80,
  0x39, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x7F, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF,
  0x83, 0x9C, 0x01, 0x8E, 0x01, 0xC6, 0x00, 0xE7, 0x07, 0xFF, 0xF3, 0xFF,
  0xF8, 0x39, 0xC0, 0x18, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x06, 0x30, 0x07,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x01, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0x3E, 0x1E, 0x1E, 0x1C, 0x0F, 0x1C, 0x0F, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3C,
  0x00, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xE0, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x0E,
  0xF0, 0x39, 0xC6, 0xC7, 0x33, 0x1D, 0xCE, 0xE6, 0x3F, 0xB0, 0x7D, 0xC0,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x70, 0x37, 0xE1, 0xBF, 0xCE, 0xE7,
  0x73, 0x1D, 0x8C, 0x70, 0x39, 0x80, 0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xFC, 0x01, 0xFF, 0x01, 0xF7, 0x80, 0xF1, 0xC0, 0x70, 0xE0, 0x38, 0xF0,
  0x1E, 0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xF8, 0xF3, 0xFC,
  0x73, 0xCF, 0x39, 0xE3, 0xFC, 0xE1, 0xFC, 0xF0, 0x7E, 0x3C, 0x3E, 0x1F,
  0xFF, 0x07, 0xFF, 0xC1, 0xF9, 0xF0, 0x77, 0x77, 0x66, 0xEE, 0x00, 0x40,
  0x70, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x04,
  0x01, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x60, 0x20,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x41, 0x85, 0xCE, 0x7F,
  0xFF, 0xCF, 0xFE, 0x07, 0x80, 0x3E, 0x01, 0xDC, 0x0F, 0x30, 0x78, 0xE0,
  0xC3, 0xC1, 0x04, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x0F, 0xFF, 0xDF, 0xFF, 0x3F, 0xFE, 0xFF, 0xFC, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0xF3, 0x8E,
  0x79, 0xCF, 0x38, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x77, 0xFF,
  0xFF, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x3F, 0xC1, 0xFF, 0x8F, 0x9E, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F,
  0x70, 0xFF, 0xC7, 0xEF, 0x7F, 0xBF, 0xDE, 0xFC, 0x7B, 0xE1, 0xEF, 0x07,
  0xBC, 0x1C, 0xF0, 0xF3, 0xC7, 0xC7, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x00,
  0x40, 0x70, 0xFD, 0xFF, 0x7F, 0xDE, 0xEC, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78,
  0x1E, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0xF9, 0xF3, 0xE1, 0xE7,
  0x83, 0xCF, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1,
  0xF9, 0xF3, 0xC1, 0xE7, 0x83, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x0F,
  0xF0, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x78, 0x1E,
  0xF0, 0x79, 0xE1, 0xF3, 0xFF, 0xC3, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x01,
  0xDE, 0x07, 0x3C, 0x1E, 0x78, 0x78, 0xE1, 0xE3, 0xC3, 0x87, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF1, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x40, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE0, 0x43,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x78, 0x1E, 0xF0, 0x79, 0xF1, 0xF1,
  0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x38, 0x07, 0xE0, 0x7F, 0x83,
  0xFC, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x70, 0x7F, 0xF1, 0xFF, 0xE7,
  0xEF, 0x9E, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x70, 0x79,
  0xE3, 0xE7, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF9, 0xE3, 0xC1, 0xE7, 0x83, 0xCF, 0x07,
  0x9E, 0x1E, 0x1E, 0x7C, 0x3F, 0xF0, 0x3F, 0x81, 0xFF, 0x87, 0xC7, 0x8F,
  0x0F, 0x3C, 0x0E, 0x78, 0x1C, 0xF0, 0x79, 0xF1, 0xF1, 0xFF, 0xC3, 0xFF,
  0x01, 0xFC, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xF9, 0xF7, 0x87, 0xB8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFE, 0x3E, 0xFF, 0xF7, 0xFF,
  0x9F, 0xB8, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x7E, 0x1F, 0xE0, 0xFE, 0x07,
  0xC0, 0x00, 0x1C, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x1F, 0x3E, 0x7C, 0x70, 0x07, 0x07, 0xC7, 0xE1, 0xF0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x38,
  0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x01, 0x00, 0x00, 0x04, 0x00, 0x60, 0x0F,
  0x81, 0xFE, 0x1F, 0xF3, 0xFE, 0x0F, 0xC0, 0x3E, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x80, 0x3F, 0xFE, 0x7F, 0xFD,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0xFF,
  0xF8, 0x20, 0x00, 0xE0, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xC0, 0x1F, 0x03, 0xF8, 0x7F, 0xC7, 0xF8, 0x3F, 0x80, 0xF0, 0x03,
  0x00, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFE, 0xF9, 0xF7, 0x87, 0xF8, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xC0,
  0x00, 0x03, 0xF8, 0x07, 0xFC, 0x1E, 0x0E, 0x18, 0x06, 0x39, 0xF7, 0x73,
  0xF3, 0x67, 0x33, 0x66, 0x33, 0xEE, 0x77, 0xCC, 0x66, 0xCC, 0x66, 0xCC,
  0x66, 0xCC, 0xE4, 0xCF, 0xEC, 0xCF, 0x78, 0xC6, 0x30, 0xE0, 0x00, 0x70,
  0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xDC, 0x03, 0xDE, 0x07,
  0x9E, 0x07, 0x9E, 0x0F, 0x1E, 0x0F, 0x0E, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xFF, 0x3F, 0xFF, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0x0F,
  0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x1F, 0x1F, 0xFF, 0x0F, 0xFE, 0x07, 0xFF,
  0xC3, 0xC1, 0xE1, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1E, 0x3C,
  0x1F, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x07, 0xF8,
  0x0F, 0xFC, 0x1F, 0x3E, 0x3C, 0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x3C, 0xF0, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3C,
  0x78, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFF,
  0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0x3E, 0x3E, 0x1E,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0xFE,
  0xF0, 0xFE, 0xF1, 0xFE, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0x70, 0x3C,
  0x78, 0x7C, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0x0F, 0x07, 0x87, 0x03,
  0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x78, 0x78, 0x3C, 0x38,
  0x1E, 0x3C, 0x0F, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xC1, 0xE1,
  0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x38, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F,
  0x1E, 0x07, 0x8F, 0x03, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF,
  0xF0, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x01, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF8, 0xF8, 0x7F, 0xF0, 0x7F,
  0xE0, 0x1F, 0xC0, 0x0F, 0x03, 0xE1, 0xE0, 0xF8, 0x78, 0x3E, 0x0F, 0x07,
  0x81, 0xE1, 0xF0, 0x3C, 0x7C, 0x07, 0x9F, 0x00, 0xF7, 0xC0, 0x3D, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xE0,
  0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x7C, 0x0F, 0x07, 0x81, 0xE0, 0xF8,
  0x38, 0x0F, 0x0F, 0x01, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x87, 0xC3, 0xE3, 0xE1, 0xF8, 0xF8, 0x7E,
  0x7E, 0x1F, 0x9F, 0x87, 0xEF, 0xE1, 0xFB, 0xF0, 0x77, 0xDC, 0x3D, 0xF7,
  0x0F, 0x7B, 0xC3, 0xDE, 0xF0, 0xE7, 0x3C, 0x39, 0xCE, 0x0E, 0x63, 0x87,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x87, 0x01, 0xC1, 0xC0,
  0x70, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0x87, 0x83, 0xC7, 0xC1, 0xE3, 0xE0,
  0xF1, 0xF8, 0xF0, 0xFC, 0x78, 0x7E, 0x3C, 0x3F, 0x1E, 0x3D, 0xCF, 0x1E,
  0xE7, 0x8F, 0x77, 0x87, 0xBB, 0xC3, 0xCF, 0xE1, 0xC7, 0xF1, 0xE3, 0xF8,
  0xF1, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x1E, 0x1F, 0x1E, 0x0F, 0x8F, 0x03,
  0xC0, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFB, 0xF3, 0xC1, 0xE7, 0x83,
  0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x0F, 0x78, 0x1E, 0xF0, 0x78, 0xF1, 0xF1, 0xFF,
  0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F,
  0xFE, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x38,
  0x1E, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF0, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0x7E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78,
  0x0E, 0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x7C, 0x78, 0xF8, 0x7F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x38, 0x00,
  0x10, 0x0F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0, 0xF8,
  0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0x01, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78,
  0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0E, 0x07, 0xCF, 0x01, 0xE0, 0x01, 0xF0,
  0x07, 0xFC, 0x1F, 0xFE, 0x1F, 0x3E, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x00,
  0x3C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF8, 0x7C, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x78, 0x78, 0x78,
  0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0xF8, 0x0F, 0xF8, 0x0F, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x78,
  0x78, 0x38, 0xF0, 0x3C, 0xF0, 0x3D, 0xE0, 0x3D, 0xE0, 0x3D, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0xF1, 0xC7, 0xF8, 0xE3, 0xBC, 0xF3, 0xDE, 0x79, 0xEF, 0x3C, 0xE7,
  0xBE, 0xF3, 0xDF, 0x79, 0xCF, 0xB8, 0xEF, 0xDC, 0x77, 0xFE, 0x3B, 0xFF,
  0x1D, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9,
  0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x3C, 0x0E, 0x1E, 0x00, 0x0F, 0x01,
  0xF0, 0xF0, 0x3E, 0x0F, 0x83, 0xC0, 0x78, 0x78, 0x07, 0x8F, 0x80, 0x3C,
  0xF0, 0x03, 0xDE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xBC, 0x00,
  0xF3, 0xC0, 0x1F, 0x1E, 0x03, 0xE1, 0xE0, 0x3C, 0x1E, 0x07, 0xC0, 0xF0,
  0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0x70, 0x3C, 0x78,
  0x78, 0x78, 0x78, 0x78, 0xF0, 0x39, 0xE0, 0x3D, 0xE0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xC7,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0xFC,
  0x1F, 0x87, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF8, 0x3F, 0x0F,
  0xE0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x78, 0x78, 0x38, 0x38, 0x38, 0x3C,
  0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F,
  0x07, 0xE0, 0xFC, 0x3F, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC1,
  0xF8, 0x3F, 0x0F, 0xE0, 0x03, 0x80, 0x38, 0x07, 0xC0, 0x7C, 0x0F, 0xC1,
  0xDC, 0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x0E, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF1, 0xC3, 0x8F, 0x01, 0x80, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E,
  0x78, 0x3C, 0x00, 0xF0, 0x03, 0xC7, 0xFE, 0x7F, 0xF9, 0xE1, 0xEF, 0x07,
  0xBC, 0x1E, 0xF0, 0xFB, 0xFF, 0xE7, 0xFF, 0x0F, 0xDE, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xCC, 0x0F, 0xFC, 0x3F,
  0xF8, 0xFF, 0xF3, 0xC3, 0xDE, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xDE,
  0x0F, 0xF0, 0x3F, 0xC1, 0xEF, 0x87, 0xBF, 0xFC, 0xFF, 0xF3, 0x9F, 0x00,
  0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x3C, 0x3D, 0xE0, 0xF7, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x1E, 0x78, 0x79, 0xFF,
  0xC3, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x03, 0x1E, 0x0F, 0xDE, 0x1F, 0xFE, 0x3F, 0xFE,
  0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x78, 0xF0, 0x78, 0x78, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0x70,
  0x01, 0xC0, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xC3, 0xCF, 0x03, 0x9E,
  0x07, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xC0, 0x07, 0xC0, 0x87, 0x83,
  0x0F, 0xFF, 0x0F, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x7F, 0xFC, 0x7F, 0xFC,
  0xFF, 0xFC, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x01, 0x80, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1E, 0x1F,
  0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x3C, 0x3C, 0x7C, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xBC, 0x00, 0x3C,
  0x20, 0x78, 0x70, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x8C, 0x0F,
  0x7E, 0x1F, 0xFE, 0x3F, 0xFC, 0xF8, 0x79, 0xE0, 0x73, 0xC0, 0xE7, 0x83,
  0xCF, 0x07, 0x9C, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0xC1, 0xE7,
  0x83, 0xDE, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x1F, 0xFE, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x02, 0x3C, 0x3E, 0x1E, 0x3E, 0x0E, 0x3E, 0x0F, 0x3E, 0x07, 0xBE,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7C, 0xF0, 0x3C,
  0x78, 0x1E, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xC7, 0x81, 0xF0, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x21, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x04, 0x84,
  0x3B, 0xDE, 0x3F, 0xFF, 0x3F, 0xFF, 0x39, 0xE7, 0x79, 0xC7, 0x79, 0xCF,
  0x79, 0xCF, 0x73, 0xCF, 0x73, 0xCE, 0xF3, 0xCE, 0xF3, 0x8E, 0xF3, 0x9E,
  0xE3, 0x9E, 0xE7, 0x9E, 0xE7, 0x9C, 0x02, 0x30, 0x39, 0xF8, 0x77, 0xF8,
  0xFF, 0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x70,
  0x3D, 0xE0, 0x7B, 0xC0, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x78, 0x1E,
  0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x7C, 0x3D, 0xE0, 0xF7, 0x83,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1E, 0x78, 0x79, 0xFF,
  0xC3, 0xFE, 0x07, 0xF0, 0x00, 0x30, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF,
  0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x1E, 0x3E, 0x3E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3D, 0xF0,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x1F, 0xBC, 0x7F, 0xF9, 0xFF, 0xF7, 0xC3, 0xCF, 0x07, 0x9E,
  0x0F, 0x38, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xE7, 0x83, 0xC7, 0x8F,
  0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xB8, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x1A, 0x3D, 0xF8, 0x77, 0xF0,
  0xFF, 0xE3, 0xF8, 0xC7, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x01, 0x80, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0x81, 0xE7, 0x00, 0x0F,
  0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xF7, 0x81, 0xEF, 0x07,
  0x8F, 0xFF, 0x1F, 0xFC, 0x0F, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0x83, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x00, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xDC, 0x0F, 0xF0,
  0x3B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0x81, 0xEF, 0x07, 0x3C,
  0x7C, 0xFF, 0xF1, 0xFF, 0xC7, 0xEF, 0x00, 0xF0, 0x1F, 0xE0, 0x79, 0xC0,
  0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x1E, 0x0E, 0x38, 0x1C, 0xF0, 0x39, 0xC0,
  0x77, 0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0xE3, 0x8F, 0xC7, 0x3F, 0x9E, 0x77, 0x3C, 0xEE, 0xFB, 0xDD, 0xB7, 0x3B,
  0x6E, 0x7E, 0xDC, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x0F, 0x1E,
  0x1E, 0x3C, 0x38, 0x70, 0x00, 0x1E, 0x0F, 0x8F, 0x0F, 0x83, 0xC7, 0x81,
  0xE7, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xF0,
  0x07, 0xF8, 0x07, 0xDE, 0x03, 0xCF, 0x03, 0xC3, 0xC3, 0xC1, 0xE3, 0xE0,
  0x78, 0x3C, 0x07, 0xCF, 0x01, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E,
  0x07, 0x87, 0x80, 0xE3, 0xC0, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x20, 0x1C, 0x07, 0x81,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x03,
  0xE1, 0xF0, 0x3C, 0x07, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xE0, 0x38, 0x03, 0x00, 0x0E, 0x18,
  0x30, 0x60, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x18,
  0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x80, 0x08, 0x01,
  0xC0, 0x7C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x78, 0x07, 0xC0, 0xF8, 0x3F, 0x0F, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70,
  0x00, 0x1C, 0x00, 0x3F, 0x07, 0x7F, 0x87, 0x7F, 0xFE, 0xE1, 0xFE, 0xE0,
  0xFC, 0x00, 0x30,
};

const GFXglyph RobotoMono_BoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 7, 21, 17, 5, -21 },
  { 20, 9, 8, 17, 5, -22 },
  { 29, 17, 21, 17, 0, -21 },
  { 74, 16, 27, 17, 1, -24 },
  { 128, 14, 21, 17, 2, -21 },
  { 165, 17, 21, 17, 0, -21 },
  { 210, 4, 8, 17, 7, -22 },
  { 214, 10, 29, 17, 4, -23 },
  { 251, 10, 30, 17, 2, -23 },
  { 289, 14, 15, 17, 2, -21 },
  { 316, 15, 15, 17, 1, -17 },
  { 345, 6, 9, 17, 3, -3 },
  { 352, 12, 4, 17, 4, -11 },
  { 358, 5, 5, 17, 5, -5 },
  { 362, 15, 23, 17, 1, -21 },
  { 406, 14, 21, 17, 2, -21 },
  { 443, 10, 21, 17, 3, -21 },
  { 470, 15, 21, 17, 0, -21 },
  { 510, 15, 21, 17, 1, -21 },
  { 550, 15, 21, 17, 0, -21 },
  { 590, 15, 21, 17, 1, -21 },
  { 630, 14, 21, 17, 1, -21 },
  { 667, 15, 21, 17, 2, -21 },
  { 707, 15, 21, 17, 1, -21 },
  { 747, 13, 21, 17, 2, -21 },
  { 782, 7, 17, 17, 5, -17 },
  { 797, 9, 23, 17, 4, -17 },
  { 823, 14, 14, 17, 2, -16 },
  { 848, 15, 9, 17, 1, -13 },
  { 865, 14, 14, 17, 1, -16 },
  { 890, 13, 21, 17, 3, -21 },
  { 925, 16, 20, 17, 1, -20 },
  { 965, 16, 21, 17, -1, -21 },
  { 1007, 17, 21, 17, 0, -21 },
  { 1052, 16, 21, 17, 1, -21 },
  { 1094, 16, 21, 17, 0, -21 },
  { 1136, 17, 21, 17, 1, -21 },
  { 1181, 17, 21, 17, 1, -21 },
  { 1226, 16, 21, 17, 1, -21 },
  { 1268, 17, 21, 17, 0, -21 },
  { 1313, 15, 21, 17, 1, -21 },
  { 1353, 16, 21, 17, 1, -21 },
  { 1395, 19, 21, 17, 0, -21 },
  { 1445, 13, 21, 17, 1, -21 },
  { 1480, 18, 21, 17, 0, -21 },
  { 1528, 17, 21, 17, 0, -21 },
  { 1573, 15, 21, 17, 1, -21 },
  { 1613, 16, 21, 17, 1, -21 },
  { 1655, 16, 25, 17, 1, -21 },
  { 1705, 17, 21, 17, 0, -21 },
  { 1750, 16, 21, 17, 1, -21 },
  { 1792, 17, 21, 17, 2, -21 },
  { 1837, 16, 21, 17, 1, -21 },
  { 1879, 16, 21, 17, 2, -21 },
  { 1921, 17, 21, 17, 2, -21 },
  { 1966, 20, 21, 17, -1, -21 },
  { 2019, 16, 21, 17, 3, -21 },
  { 2061, 18, 21, 17, 0, -21 },
  { 2109, 11, 29, 17, 3, -24 },
  { 2149, 8, 23, 17, 5, -21 },
  { 2172, 11, 29, 17, 3, -24 },
  { 2212, 12, 11, 17, 3, -21 },
  { 2229, 13, 3, 17, 0, 0 },
  { 2234, 6, 4, 17, 8, -21 },
  { 2237, 14, 16, 17, 1, -16 },
  { 2265, 14, 22, 17, 1, -22 },
  { 2304, 14, 16, 17, 1, -16 },
  { 2332, 16, 22, 17, 1, -22 },
  { 2376, 15, 16, 17, 1, -16 },
  { 2406, 16, 22, 17, 2, -22 },
  { 2450, 16, 22, 17, 0, -16 },
  { 2494, 15, 22, 17, 0, -22 },
  { 2536, 13, 21, 17, 1, -21 },
  { 2571, 13, 27, 17, 1, -21 },
  { 2615, 17, 22, 17, 0, -22 },
  { 2662, 13, 22, 17, 1, -22 },
  { 2698, 16, 16, 17, 0, -16 },
  { 2730, 15, 16, 17, 0, -16 },
  { 2760, 14, 16, 17, 1, -16 },
  { 2788, 16, 22, 17, -1, -16 },
  { 2832, 15, 22, 17, 1, -16 },
  { 2874, 15, 16, 17, 2, -16 },
  { 2904, 15, 16, 17, 1, -16 },
  { 2934, 14, 19, 17, 2, -19 },
  { 2968, 14, 15, 17, 2, -15 },
  { 2995, 15, 15, 17, 2, -15 },
  { 3024, 15, 15, 17, 2, -15 },
  { 3053, 17, 15, 17, 0, -15 },
  { 3085, 18, 21, 17, 0, -15 },
  { 3133, 16, 15, 17, 0, -15 },
  { 3163, 11, 28, 17, 4, -23 },
  { 3202, 7, 27, 17, 5, -21 },
  { 3226, 11, 28, 17, 3, -23 },
  { 3265, 16, 7, 17, 0, -12 },
};

const GFXfont RobotoMono_BoldItalic29pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic29pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOMONO_BOLDITALIC29PT7B_H_
