#ifndef _ROBOTOMONO_BOLDITALIC9PT7B_H_
#define _ROBOTOMONO_BOLDITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0xEA, 0x20, 0x6E, 0x80, 0x2B, 0xD5, 0xF6, 0x50, 0x13, 0xD2, 0xE1,
  0xED, 0xC4, 0x8D, 0xE4, 0x6D, 0x30, 0x03, 0x94, 0xCE, 0xCF, 0xE0, 0x68,
  0x2D, 0x29, 0x22, 0x40, 0x44, 0x92, 0xD2, 0x80, 0x2F, 0x6A, 0x33, 0xFE,
  0x40, 0x68, 0xF0, 0x70, 0x18, 0x8C, 0x46, 0x23, 0x00, 0x0F, 0x9F, 0xBA,
  0xE0, 0xF5, 0xA4, 0x80, 0x03, 0xD2, 0x22, 0x23, 0xC0, 0x03, 0xC2, 0x61,
  0x4D, 0xC0, 0x19, 0x95, 0xAF, 0x98, 0x7A, 0x1C, 0x3D, 0x38, 0x32, 0x1D,
  0xBD, 0x38, 0xF2, 0x24, 0xC8, 0x03, 0xD2, 0xE5, 0x69, 0xC0, 0x0F, 0x9B,
  0xE2, 0xC0, 0xB0, 0xA0, 0x2C, 0x00, 0x94, 0x1E, 0x86, 0x78, 0x3E, 0x43,
  0x87, 0xC0, 0x0F, 0x12, 0x40, 0x40, 0x7B, 0xF7, 0xBB, 0x30, 0x31, 0x9C,
  0xAF, 0xCC, 0x7A, 0x5E, 0x9C, 0xF8, 0x03, 0xD3, 0x8C, 0x6D, 0xC0, 0x7A,
  0x52, 0x9D, 0x70, 0x7A, 0x1E, 0x8C, 0x7C, 0x7A, 0x1E, 0x8C, 0x40, 0x7A,
  0x51, 0xBD, 0xB8, 0x4A, 0x5F, 0xBD, 0x48, 0x79, 0x88, 0x42, 0x78, 0x08,
  0x42, 0x3D, 0x38, 0x4D, 0x46, 0x1C, 0xD2, 0x60, 0x64, 0x44, 0xCF, 0x6B,
  0xDA, 0xD9, 0xC8, 0x6B, 0x5B, 0xFD, 0x48, 0x03, 0xD3, 0x9C, 0xED, 0xC0,
  0x7A, 0x56, 0xEC, 0x40, 0x03, 0xD2, 0x9C, 0xED, 0xC3, 0x7A, 0x56, 0xED,
  0x4C, 0x03, 0xD0, 0xE1, 0xE5, 0xC0, 0xFB, 0x10, 0x84, 0x20, 0x4A, 0x52,
  0xBD, 0x38, 0x9C, 0xA9, 0x4E, 0x20, 0xFF, 0xBD, 0x6A, 0x50, 0x4C, 0xC3,
  0x1C, 0x52, 0x60, 0x9F, 0x98, 0x84, 0x20, 0x78, 0x8C, 0xC4, 0x7C, 0x69,
  0x24, 0xB6, 0xAA, 0xD4, 0x64, 0x96, 0x96, 0x66, 0xB0, 0xF0, 0xD0, 0x72,
  0xDD, 0xAF, 0x00, 0x62, 0x1C, 0xB4, 0xEF, 0xC0, 0x32, 0xF1, 0xA7, 0x00,
  0x08, 0x5E, 0xBD, 0xE9, 0xC0, 0x32, 0x7F, 0x87, 0x00, 0x3B, 0x3C, 0x84,
  0x23, 0x00, 0x3A, 0x77, 0xA7, 0x49, 0x80, 0x62, 0x1C, 0x94, 0xEE, 0x40,
  0x11, 0x73, 0x22, 0xF0, 0x11, 0x35, 0x32, 0x22, 0xC0, 0x62, 0x16, 0xE6,
  0x7A, 0x60, 0x71, 0x13, 0x22, 0xF0, 0x7F, 0x6B, 0x5B, 0x80, 0x72, 0x57,
  0xB9, 0x00, 0x32, 0xF3, 0xB7, 0x00, 0x72, 0xD3, 0xAF, 0x42, 0x00, 0x7A,
  0x77, 0xA7, 0x08, 0x40, 0x7D, 0x88, 0x80, 0x32, 0x5D, 0x37, 0x00, 0x4F,
  0x44, 0xC6, 0x4A, 0x56, 0xA7, 0x00, 0x9B, 0xAA, 0x40, 0xED, 0x6B, 0xAD,
  0x00, 0x4B, 0x8C, 0xED, 0x80, 0x4D, 0x25, 0x1C, 0x21, 0x0C, 0x00, 0x78,
  0x88, 0x8F, 0x80, 0x32, 0x24, 0xC4, 0x44, 0x20, 0x6A, 0xAA, 0x45, 0x32,
  0x96, 0x80, 0x45, 0xC0,
};

const GFXglyph RobotoMono_BoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 2, -6 },
  { 3, 3, 3, 5, 1, -7 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 5, 8, 5, 0, -7 },
  { 14, 4, 7, 5, 1, -7 },
  { 18, 5, 7, 5, 0, -7 },
  { 23, 2, 3, 5, 2, -7 },
  { 24, 3, 9, 5, 1, -7 },
  { 28, 3, 9, 5, 1, -7 },
  { 32, 4, 4, 5, 1, -6 },
  { 34, 5, 4, 5, 0, -5 },
  { 37, 2, 3, 5, 1, -1 },
  { 38, 4, 1, 5, 1, -3 },
  { 39, 2, 2, 5, 1, -2 },
  { 40, 5, 7, 5, 0, -6 },
  { 45, 4, 7, 5, 1, -7 },
  { 49, 3, 6, 5, 1, -6 },
  { 52, 5, 7, 5, 0, -7 },
  { 57, 5, 7, 5, 0, -7 },
  { 62, 5, 6, 5, 0, -6 },
  { 66, 5, 6, 5, 0, -6 },
  { 70, 5, 6, 5, 0, -6 },
  { 74, 4, 6, 5, 1, -6 },
  { 77, 5, 7, 5, 0, -7 },
  { 82, 4, 7, 5, 1, -7 },
  { 86, 2, 6, 5, 2, -6 },
  { 88, 3, 8, 5, 1, -6 },
  { 91, 4, 4, 5, 1, -5 },
  { 93, 5, 3, 5, 0, -4 },
  { 95, 5, 4, 5, 0, -5 },
  { 98, 4, 7, 5, 1, -7 },
  { 102, 5, 6, 5, 0, -6 },
  { 106, 5, 6, 5, 0, -6 },
  { 110, 5, 6, 5, 0, -6 },
  { 114, 5, 7, 5, 0, -7 },
  { 119, 5, 6, 5, 0, -6 },
  { 123, 5, 6, 5, 0, -6 },
  { 127, 5, 6, 5, 0, -6 },
  { 131, 5, 6, 5, 0, -6 },
  { 135, 5, 6, 5, 0, -6 },
  { 139, 5, 6, 5, 0, -6 },
  { 143, 5, 6, 5, 0, -6 },
  { 147, 6, 6, 5, 0, -6 },
  { 152, 4, 6, 5, 0, -6 },
  { 155, 5, 6, 5, 0, -6 },
  { 159, 5, 6, 5, 0, -6 },
  { 163, 5, 7, 5, 0, -7 },
  { 168, 5, 6, 5, 0, -6 },
  { 172, 5, 8, 5, 0, -7 },
  { 177, 5, 6, 5, 0, -6 },
  { 181, 5, 7, 5, 0, -7 },
  { 186, 5, 6, 5, 1, -6 },
  { 190, 5, 6, 5, 0, -6 },
  { 194, 5, 6, 5, 1, -6 },
  { 198, 5, 6, 5, 1, -6 },
  { 202, 6, 6, 5, 0, -6 },
  { 207, 5, 6, 5, 1, -6 },
  { 211, 5, 6, 5, 0, -6 },
  { 215, 3, 8, 5, 1, -7 },
  { 218, 2, 7, 5, 2, -6 },
  { 220, 3, 8, 5, 1, -7 },
  { 223, 4, 3, 5, 1, -6 },
  { 225, 4, 1, 5, 0, 0 },
  { 226, 2, 2, 5, 2, -7 },
  { 227, 5, 5, 5, 0, -5 },
  { 231, 5, 7, 5, 0, -7 },
  { 236, 5, 5, 5, 0, -5 },
  { 240, 5, 7, 5, 0, -7 },
  { 245, 5, 5, 5, 0, -5 },
  { 249, 5, 7, 5, 1, -7 },
  { 254, 5, 7, 5, 0, -5 },
  { 259, 5, 7, 5, 0, -7 },
  { 264, 4, 7, 5, 0, -7 },
  { 268, 4, 9, 5, 0, -7 },
  { 273, 5, 7, 5, 0, -7 },
  { 278, 4, 7, 5, 0, -7 },
  { 282, 5, 5, 5, 0, -5 },
  { 286, 5, 5, 5, 0, -5 },
  { 290, 5, 5, 5, 0, -5 },
  { 294, 5, 7, 5, 0, -5 },
  { 299, 5, 7, 5, 0, -5 },
  { 304, 4, 5, 5, 1, -5 },
  { 307, 5, 5, 5, 0, -5 },
  { 311, 4, 6, 5, 1, -6 },
  { 314, 5, 5, 5, 0, -5 },
  { 318, 4, 5, 5, 1, -5 },
  { 321, 5, 5, 5, 0, -5 },
  { 325, 5, 5, 5, 0, -5 },
  { 329, 6, 7, 5, 0, -5 },
  { 335, 5, 5, 5, 0, -5 },
  { 339, 4, 9, 5, 1, -7 },
  { 344, 2, 8, 5, 2, -6 },
  { 346, 3, 9, 5, 1, -7 },
  { 350, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoMono_BoldItalic9pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic9pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOMONO_BOLDITALIC9PT7B_H_
