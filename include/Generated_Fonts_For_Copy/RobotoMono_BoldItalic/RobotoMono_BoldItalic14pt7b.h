#ifndef _ROBOTOMONO_BOLDITALIC14PT7B_H_
#define _ROBOTOMONO_BOLDITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x66, 0x60, 0x4E, 0x4A, 0xD7, 0xA0, 0x0B, 0x0A, 0x12,
  0x7F, 0x34, 0x24, 0xFE, 0x68, 0x48, 0x58, 0x08, 0x10, 0xF3, 0xF6, 0x6C,
  0x1C, 0x0E, 0x0D, 0x9B, 0x33, 0xC2, 0x00, 0xE1, 0x6A, 0xF7, 0x41, 0x06,
  0x0F, 0x2B, 0xD6, 0x38, 0x1C, 0x36, 0x36, 0x3C, 0x38, 0x7B, 0x7B, 0xCE,
  0xEE, 0x7F, 0x57, 0x08, 0x88, 0xC4, 0x23, 0x18, 0xC6, 0x30, 0x84, 0x10,
  0x20, 0x84, 0x31, 0x8C, 0x63, 0x18, 0x8C, 0x46, 0x40, 0x18, 0x23, 0x5B,
  0xE3, 0x0D, 0x33, 0x00, 0x18, 0x23, 0xFF, 0xE3, 0x06, 0x08, 0x00, 0x2D,
  0xAC, 0xFC, 0xFC, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x83,
  0x00, 0x3C, 0xD9, 0x1E, 0x3D, 0xDD, 0xB3, 0x66, 0xD8, 0xF0, 0x1F, 0xF3,
  0x33, 0x66, 0x66, 0x1E, 0x6D, 0x88, 0x30, 0x61, 0x8E, 0x38, 0xFF, 0xFC,
  0x1E, 0x37, 0x63, 0x02, 0x1E, 0x1E, 0x06, 0xC6, 0x6E, 0x7C, 0x06, 0x1C,
  0x78, 0xB3, 0x6C, 0xBF, 0xFF, 0x0C, 0x18, 0x7E, 0xFD, 0x82, 0x8F, 0xC1,
  0x83, 0x46, 0xDC, 0xF0, 0x1C, 0xF6, 0x36, 0xFF, 0x38, 0xF3, 0xDD, 0xE0,
  0xFF, 0xFC, 0x30, 0x61, 0x82, 0x0C, 0x30, 0x61, 0x80, 0x1E, 0x36, 0x63,
  0x26, 0x3E, 0x7C, 0x66, 0xC6, 0x6E, 0x7C, 0x39, 0xBC, 0x71, 0xCF, 0xF7,
  0xC6, 0x7B, 0x80, 0x77, 0x00, 0x00, 0xEE, 0x33, 0x00, 0x00, 0x66, 0x4C,
  0x80, 0x02, 0x19, 0xF7, 0x0F, 0x07, 0x82, 0x00, 0xFE, 0x03, 0xF7, 0xE0,
  0x83, 0x87, 0x83, 0x3F, 0xC8, 0x00, 0x7B, 0xFC, 0xC3, 0x38, 0xC6, 0x00,
  0x63, 0x80, 0x0E, 0x33, 0x6D, 0x55, 0x75, 0xA5, 0xAE, 0x96, 0x40, 0x38,
  0x06, 0x06, 0x0E, 0x0B, 0x1B, 0x13, 0x3F, 0x3F, 0x63, 0xE3, 0x3E, 0x3F,
  0x63, 0x63, 0x7E, 0x7E, 0x63, 0x43, 0xFE, 0xFC, 0x1E, 0x37, 0x63, 0x60,
  0x60, 0x60, 0x40, 0x46, 0x6E, 0x3C, 0x3C, 0x3E, 0x63, 0x63, 0x63, 0x63,
  0x66, 0x46, 0xFC, 0xF8, 0x3F, 0x3F, 0x20, 0x60, 0x7E, 0x7E, 0x60, 0x60,
  0x7E, 0xFE, 0x3F, 0x9F, 0x88, 0x0C, 0x07, 0xE3, 0xF1, 0x80, 0xC0, 0x40,
  0x60, 0x00, 0x3C, 0xDF, 0x1E, 0x0C, 0x1B, 0xE1, 0x66, 0xCC, 0xF0, 0x33,
  0x23, 0x63, 0x63, 0x7E, 0x7E, 0x66, 0x46, 0xC6, 0xC6, 0x7E, 0xFC, 0x60,
  0x83, 0x06, 0x0C, 0x18, 0xF9, 0xF0, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06,
  0x06, 0xC6, 0x6E, 0x7C, 0x31, 0x91, 0x99, 0x8D, 0x87, 0x83, 0xE1, 0xB0,
  0x9C, 0xC6, 0x63, 0x80, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F,
  0xFC, 0x33, 0x37, 0x77, 0x77, 0x7B, 0x7B, 0x5A, 0x46, 0xC6, 0xC6, 0x33,
  0x33, 0x73, 0x7B, 0x7A, 0x6E, 0x6E, 0x4E, 0xCE, 0xC6, 0x1E, 0x3E, 0x63,
  0x63, 0x63, 0x63, 0x42, 0x46, 0x6E, 0x3C, 0x3E, 0x3F, 0x23, 0x63, 0x67,
  0x7E, 0x60, 0x60, 0x40, 0xC0, 0x1E, 0x3F, 0x63, 0x63, 0x63, 0x63, 0x43,
  0x46, 0x6E, 0x3C, 0x06, 0x04, 0x3E, 0x3F, 0x63, 0x63, 0x67, 0x7E, 0x6C,
  0x44, 0xC6, 0xC6, 0x1E, 0x37, 0x63, 0x60, 0x3C, 0x1E, 0x06, 0xC3, 0x66,
  0x3C, 0xFF, 0xFF, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x66,
  0x8F, 0x1E, 0x3C, 0x78, 0xB3, 0x66, 0xDC, 0xF0, 0xC3, 0xC6, 0xC6, 0x4C,
  0x6C, 0x68, 0x78, 0x78, 0x70, 0x70, 0xDB, 0xDB, 0xDA, 0xFE, 0xFE, 0xFC,
  0xFC, 0xDC, 0xD8, 0xD8, 0x31, 0xC6, 0x61, 0xB0, 0x2C, 0x0E, 0x03, 0x81,
  0xE0, 0xD8, 0x33, 0x38, 0xC0, 0xC3, 0x66, 0x66, 0x6C, 0x38, 0x38, 0x30,
  0x30, 0x30, 0x60, 0x7F, 0x7F, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0xFE,
  0xFE, 0x39, 0xD8, 0xC6, 0x31, 0x8C, 0x46, 0x31, 0x8C, 0x70, 0x9B, 0x6C,
  0x93, 0x6D, 0x80, 0x39, 0xC4, 0x63, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x70,
  0x18, 0x63, 0x8B, 0xCC, 0xFC, 0xCC, 0x08, 0x7D, 0x98, 0x77, 0xF8, 0xFB,
  0xBB, 0x30, 0x60, 0xC1, 0x47, 0xEC, 0xD8, 0xB3, 0x66, 0xDF, 0xF0, 0x11,
  0xFC, 0xF0, 0xC3, 0x3D, 0xDE, 0x06, 0x0C, 0x19, 0x37, 0xF9, 0xB3, 0x66,
  0xCD, 0xBB, 0xF0, 0x10, 0xFB, 0x16, 0x2F, 0xD8, 0x33, 0x3C, 0x0F, 0x1F,
  0x30, 0x30, 0xFE, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x08, 0x3F, 0x67,
  0x66, 0x66, 0x66, 0x6E, 0x7E, 0x04, 0xFC, 0x78, 0x30, 0x60, 0xC1, 0x27,
  0xEC, 0xD8, 0xB3, 0x67, 0x8F, 0x18, 0x18, 0x20, 0x1E, 0x18, 0x43, 0x0C,
  0xFF, 0xF0, 0x06, 0x08, 0x01, 0xE0, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x63,
  0xCF, 0x00, 0x30, 0x30, 0x30, 0x21, 0x66, 0x6C, 0x78, 0x78, 0x6C, 0xCC,
  0xC6, 0x79, 0xE1, 0x86, 0x18, 0x61, 0x0C, 0x33, 0xFF, 0xC0, 0x12, 0x7F,
  0x5B, 0x5B, 0xDA, 0xDA, 0xD6, 0xD6, 0x04, 0xFD, 0x9B, 0x16, 0x6C, 0xF1,
  0xE3, 0x11, 0xFC, 0xF1, 0x8E, 0x3D, 0xDE, 0x08, 0xFD, 0x9B, 0x36, 0x6C,
  0xDB, 0xFE, 0xC1, 0x83, 0x00, 0x20, 0xFF, 0x36, 0x6C, 0xD9, 0xB7, 0x7E,
  0x08, 0x30, 0x60, 0x04, 0xFD, 0xCB, 0x06, 0x08, 0x30, 0x60, 0x08, 0x3E,
  0x63, 0x70, 0x3E, 0x86, 0x66, 0x7C, 0x30, 0x67, 0xF1, 0x82, 0x0C, 0x18,
  0x3A, 0x3C, 0xC7, 0x8F, 0x16, 0x6C, 0xDB, 0xBF, 0x00, 0xC7, 0x99, 0x32,
  0xC7, 0x8E, 0x0C, 0x00, 0x97, 0x6E, 0xD5, 0xAD, 0xDB, 0x36, 0x00, 0x73,
  0x36, 0x1C, 0x18, 0x3C, 0x6C, 0xC6, 0x63, 0xB1, 0x8D, 0x86, 0x83, 0xC1,
  0xC0, 0x60, 0x60, 0xE0, 0x70, 0x00, 0x7F, 0x06, 0x0C, 0x18, 0x30, 0x7E,
  0xFE, 0x08, 0xCC, 0x63, 0x13, 0x1C, 0x63, 0x18, 0xC3, 0x00, 0x32, 0x22,
  0x22, 0x64, 0x44, 0x44, 0xC0, 0x30, 0x41, 0x84, 0x10, 0x61, 0xC6, 0x30,
  0xC2, 0x18, 0xE0, 0x20, 0xFB, 0x9E,
};

const GFXglyph RobotoMono_BoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 10, 8, 2, -10 },
  { 6, 5, 4, 8, 2, -11 },
  { 9, 8, 10, 8, 0, -10 },
  { 19, 7, 13, 8, 1, -12 },
  { 31, 7, 10, 8, 1, -10 },
  { 40, 8, 10, 8, 0, -10 },
  { 50, 2, 4, 8, 3, -11 },
  { 51, 5, 14, 8, 2, -11 },
  { 60, 5, 14, 8, 1, -11 },
  { 69, 7, 7, 8, 1, -10 },
  { 76, 7, 7, 8, 1, -8 },
  { 83, 3, 5, 8, 1, -2 },
  { 85, 6, 1, 8, 2, -5 },
  { 86, 3, 2, 8, 2, -2 },
  { 87, 7, 11, 8, 1, -10 },
  { 97, 7, 10, 8, 1, -10 },
  { 106, 4, 10, 8, 2, -10 },
  { 111, 7, 10, 8, 0, -10 },
  { 120, 8, 10, 8, 0, -10 },
  { 130, 7, 10, 8, 0, -10 },
  { 139, 7, 10, 8, 1, -10 },
  { 148, 6, 10, 8, 1, -10 },
  { 156, 7, 10, 8, 1, -10 },
  { 165, 8, 10, 8, 0, -10 },
  { 175, 6, 10, 8, 1, -10 },
  { 183, 4, 8, 8, 2, -8 },
  { 187, 4, 11, 8, 2, -8 },
  { 193, 7, 7, 8, 1, -8 },
  { 200, 7, 4, 8, 1, -6 },
  { 204, 6, 7, 8, 1, -8 },
  { 210, 6, 10, 8, 2, -10 },
  { 218, 8, 10, 8, 0, -10 },
  { 228, 8, 10, 8, -1, -10 },
  { 238, 8, 10, 8, 0, -10 },
  { 248, 8, 10, 8, 0, -10 },
  { 258, 8, 10, 8, 0, -10 },
  { 268, 8, 10, 8, 0, -10 },
  { 278, 9, 10, 8, 0, -10 },
  { 290, 7, 10, 8, 1, -10 },
  { 299, 8, 10, 8, 0, -10 },
  { 309, 7, 10, 8, 1, -10 },
  { 318, 8, 10, 8, 0, -10 },
  { 328, 9, 10, 8, 0, -10 },
  { 340, 7, 10, 8, 0, -10 },
  { 349, 8, 10, 8, 0, -10 },
  { 359, 8, 10, 8, 0, -10 },
  { 369, 8, 10, 8, 0, -10 },
  { 379, 8, 10, 8, 0, -10 },
  { 389, 8, 12, 8, 0, -10 },
  { 401, 8, 10, 8, 0, -10 },
  { 411, 8, 10, 8, 0, -10 },
  { 421, 8, 10, 8, 1, -10 },
  { 431, 7, 10, 8, 1, -10 },
  { 440, 8, 10, 8, 1, -10 },
  { 450, 8, 10, 8, 1, -10 },
  { 460, 10, 10, 8, -1, -10 },
  { 473, 8, 10, 8, 1, -10 },
  { 483, 8, 10, 8, 0, -10 },
  { 493, 5, 14, 8, 2, -12 },
  { 502, 3, 11, 8, 3, -10 },
  { 507, 5, 14, 8, 2, -12 },
  { 516, 6, 5, 8, 1, -10 },
  { 520, 6, 1, 8, 0, 0 },
  { 521, 3, 2, 8, 4, -10 },
  { 522, 7, 8, 8, 0, -8 },
  { 529, 7, 11, 8, 0, -11 },
  { 539, 6, 8, 8, 1, -8 },
  { 545, 7, 11, 8, 1, -11 },
  { 555, 7, 8, 8, 1, -8 },
  { 562, 8, 11, 8, 1, -11 },
  { 573, 8, 11, 8, 0, -8 },
  { 584, 7, 11, 8, 0, -11 },
  { 594, 6, 10, 8, 1, -10 },
  { 602, 7, 13, 8, 0, -10 },
  { 614, 8, 11, 8, 0, -11 },
  { 625, 6, 11, 8, 1, -11 },
  { 634, 8, 8, 8, 0, -8 },
  { 642, 7, 8, 8, 0, -8 },
  { 649, 6, 8, 8, 1, -8 },
  { 655, 7, 11, 8, 0, -8 },
  { 665, 7, 11, 8, 1, -8 },
  { 675, 7, 8, 8, 1, -8 },
  { 682, 8, 8, 8, 0, -8 },
  { 690, 7, 9, 8, 1, -9 },
  { 698, 7, 7, 8, 1, -7 },
  { 705, 7, 7, 8, 1, -7 },
  { 712, 7, 7, 8, 1, -7 },
  { 719, 8, 7, 8, 0, -7 },
  { 726, 9, 10, 8, 0, -7 },
  { 738, 8, 7, 8, 0, -7 },
  { 745, 5, 13, 8, 2, -11 },
  { 754, 4, 13, 8, 2, -10 },
  { 761, 6, 13, 8, 1, -11 },
  { 771, 8, 3, 8, 0, -6 },
};

const GFXfont RobotoMono_BoldItalic14pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic14pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOMONO_BOLDITALIC14PT7B_H_
