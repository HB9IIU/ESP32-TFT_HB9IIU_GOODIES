#ifndef _ROBOTOMONO_BOLDITALIC37PT7B_H_
#define _ROBOTOMONO_BOLDITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x07, 0xC3, 0xF0, 0xFC, 0x1E, 0x00, 0x38, 0x77,
  0x87, 0x78, 0xF7, 0x8F, 0x70, 0xF7, 0x0E, 0x70, 0xEF, 0x0E, 0xF1, 0xEE,
  0x1C, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x1C, 0x07, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x1C, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x87,
  0x00, 0x0E, 0x3C, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x03, 0x8F, 0x00, 0x1E, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xCF, 0xC3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x3C, 0xF8, 0x0F,
  0x9F, 0x01, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xF8,
  0x03, 0xFC, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0x71, 0xC3,
  0x3C, 0x70, 0xEF, 0x1C, 0x73, 0xC7, 0x38, 0xF3, 0xDE, 0x1F, 0xE7, 0x07,
  0xFB, 0x80, 0x79, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x9F, 0x01, 0xDF, 0xE0, 0xF7, 0xFC, 0x3B, 0xC7, 0x1C, 0xE1,
  0xCE, 0x38, 0x73, 0x8E, 0x1C, 0x03, 0x8F, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0xF8, 0x07,
  0x87, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0xC1, 0xE3, 0xFF, 0x0F, 0x3F, 0xFC, 0xF9, 0xF3,
  0xE7, 0xDF, 0x1F, 0xFC, 0xF8, 0x7F, 0xE7, 0xC1, 0xFE, 0x3E, 0x0F, 0xE1,
  0xF0, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFC,
  0xFC, 0x3B, 0xDE, 0xF7, 0xB9, 0xCE, 0xF7, 0x80, 0x00, 0x30, 0x0F, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x04, 0x00, 0x02, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x01, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x1C, 0x38, 0x67, 0xCE, 0x7B, 0xFF, 0xFF, 0x7F,
  0xFF, 0xC1, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0x70, 0x07, 0x9E,
  0x03, 0xC7, 0x81, 0xE0, 0xF0, 0x38, 0x3C, 0x04, 0x04, 0x00, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E,
  0x3C, 0x7C, 0xF8, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7D, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFE, 0x1F, 0xCF, 0x87, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07,
  0xCF, 0x81, 0xF7, 0xC0, 0xFD, 0xF0, 0xFF, 0x7C, 0x7F, 0xDF, 0x7D, 0xF7,
  0xFE, 0xF9, 0xFE, 0x3E, 0xFF, 0x0F, 0xBF, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0xC7, 0xC3, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x0F, 0xC1, 0xFE, 0x7F, 0xE7,
  0xFF, 0x3F, 0xF9, 0xE7, 0xDC, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE1, 0xF8, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x3F,
  0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFC, 0xFE, 0x3F, 0x07, 0xC7, 0xC0,
  0xF8, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F,
  0x3F, 0x07, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xF7, 0xC0,
  0x1E, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x78, 0x0F, 0x8F, 0x81, 0xF0, 0xF8,
  0x1E, 0x0F, 0x83, 0xC0, 0xF8, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xEF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0x80, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0xF8, 0x7C, 0x0F, 0x87, 0xC1,
  0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x10, 0x1F, 0x7F, 0x0F, 0x7F,
  0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xF0, 0xFC,
  0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0xFE, 0xFE, 0x3F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0xFC, 0x7C, 0x1F, 0x07, 0xEF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x1E, 0x7C,
  0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3F, 0x07, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC3, 0xF3, 0xF3, 0xE0, 0xFB, 0xF0, 0x3D, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xEF, 0x81, 0xF7, 0xC1,
  0xFB, 0xFB, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xEF, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x07, 0xE1, 0xFC, 0x7F, 0x1F, 0x83,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0x7C, 0x00, 0x03, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x0F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xC7, 0xFF, 0x81, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x78, 0x00,
  0x06, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00,
  0x07, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF8, 0x1F, 0xF8,
  0x07, 0xF0, 0x01, 0xF0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x01, 0xE0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xF3, 0xFB, 0xE0, 0xFD, 0xF0,
  0x3F, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0x01, 0xC0, 0xF0, 0x07, 0x0F, 0x0C, 0x38,
  0x71, 0xFD, 0xC7, 0x1F, 0xE6, 0x39, 0xE7, 0x33, 0x9E, 0x31, 0x9C, 0xE3,
  0x8D, 0xC7, 0x1C, 0xEE, 0x70, 0xE7, 0x73, 0x86, 0x3B, 0x9C, 0x71, 0x9C,
  0xE3, 0x8C, 0xE7, 0x1C, 0xE7, 0x39, 0xEE, 0x39, 0xFF, 0xF1, 0xC7, 0x9F,
  0x0E, 0x00, 0x20, 0x38, 0x00, 0x01, 0xE0, 0x20, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xC7,
  0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC0,
  0x0F, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x7F, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xE0, 0x7E, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xF1,
  0xF0, 0x3F, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x0F, 0xEF, 0xE1, 0xF8, 0x3F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01,
  0xF3, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7E, 0x1F, 0x83,
  0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xF8, 0x7E, 0x07,
  0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x1F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xEF, 0xE1, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F,
  0x3E, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x3F, 0xE7, 0xC3, 0xFE, 0x7C, 0x3F, 0xE7, 0x84,
  0x3E, 0x78, 0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7E,
  0x0F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFC, 0x00,
  0x07, 0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F,
  0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x3C, 0x1F, 0x01,
  0xF0, 0x7C, 0x07, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8,
  0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F,
  0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x3E, 0x00,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0xC0, 0xF8,
  0x3E, 0x0F, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xC0, 0x3F, 0x83, 0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x3F, 0x00,
  0x1F, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x9F, 0x80, 0x07, 0xDF, 0x80,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x9F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x87,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0xFC, 0x1F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE3, 0xFC, 0x3F, 0x9F,
  0xE0, 0xFE, 0x7F, 0x83, 0xFD, 0xDE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFB, 0xE1,
  0xE7, 0xEF, 0x07, 0x9F, 0x3C, 0x1E, 0x7C, 0xF0, 0xF9, 0xE7, 0xC3, 0xE7,
  0x9F, 0x0F, 0x9E, 0x7C, 0x3E, 0x71, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E,
  0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x3C, 0x1E,
  0x00, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x1F,
  0x01, 0xF0, 0xFC, 0x0F, 0x83, 0xF8, 0x3E, 0x0F, 0xE0, 0xF8, 0x3F, 0x83,
  0xE0, 0xFE, 0x0F, 0x87, 0xFC, 0x7C, 0x1F, 0xF1, 0xF0, 0x7F, 0xC7, 0xC1,
  0xF7, 0x1F, 0x07, 0xDE, 0x7C, 0x1F, 0x79, 0xF0, 0xF9, 0xEF, 0x83, 0xE3,
  0xBE, 0x0F, 0x8F, 0xF8, 0x3E, 0x3F, 0xE0, 0xF8, 0xFF, 0x83, 0xE1, 0xFE,
  0x1F, 0x07, 0xF0, 0x7C, 0x1F, 0xC1, 0xF0, 0x7F, 0x07, 0xC0, 0xFC, 0x1F,
  0x03, 0xF0, 0x7C, 0x0F, 0xC3, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xF8, 0x3E, 0x1F,
  0x03, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0x7C, 0x07,
  0xC7, 0xC0, 0xF8, 0x7E, 0x1F, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE1, 0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x0F, 0xE3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x0F,
  0xFF, 0xE1, 0xF8, 0x3E, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3,
  0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7E, 0x1F, 0x83, 0xFF,
  0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x20, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x81, 0xF8, 0x3E,
  0x03, 0xE0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7E, 0x03, 0xE0,
  0xF8, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C,
  0x1F, 0x01, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFE, 0x7F, 0x0F, 0xC0,
  0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF9, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x7E, 0x03, 0xF1, 0xF0, 0x3F, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF1, 0xF0,
  0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7,
  0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0xF8,
  0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0xC3, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE,
  0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xF8, 0xF8, 0x0F, 0xC7,
  0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F,
  0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0xC0, 0x78, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x78,
  0x7D, 0xE1, 0xE1, 0xE7, 0x8F, 0x8F, 0x9E, 0x3E, 0x3C, 0x78, 0xF8, 0xF1,
  0xE3, 0xE7, 0xC7, 0x9F, 0x9F, 0x1E, 0x7E, 0x78, 0x79, 0xF9, 0xE1, 0xEF,
  0xEF, 0x87, 0xBF, 0xBC, 0x1E, 0xEE, 0xF0, 0x7B, 0xBF, 0xC1, 0xFE, 0xFF,
  0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x83, 0xF8, 0xFC, 0x0F,
  0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0x83, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x3E,
  0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF9, 0xF0, 0x01, 0xF8, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x7E, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFB, 0xE0,
  0x0F, 0x9F, 0x00, 0xF8, 0xFC, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xE0,
  0xF8, 0x3E, 0x03, 0xC3, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x03, 0xDF,
  0x00, 0x1E, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0xF8, 0x7C,
  0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x04, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x80, 0xEF, 0x03, 0xDE,
  0x0F, 0x1C, 0x1E, 0x38, 0x78, 0x78, 0xF0, 0xF3, 0xC1, 0xE7, 0x81, 0xDE,
  0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0xF8,
  0xF1, 0xF1, 0xE1, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x7F,
  0xFE, 0x3F, 0x0F, 0xCF, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xFF,
  0xC7, 0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0x3E, 0x7C, 0x0F, 0xBE, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0x7C, 0xFF, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F,
  0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x3E, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE3, 0xF8, 0xFC, 0x7E, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x79, 0xF0, 0x1F, 0x3E, 0x03,
  0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xE7, 0xE0, 0xFC, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x79, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1, 0xFB, 0xF0, 0x7D, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x7B, 0xE0, 0x7D, 0xF8, 0x7E, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x03,
  0xE7, 0xC0, 0xFF, 0x7C, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0x1F, 0xC7,
  0xE0, 0xFC, 0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8,
  0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xDE, 0x01, 0xF9,
  0xE0, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0x1F,
  0x9F, 0x81, 0xE7, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x43, 0xF0,
  0x38, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x03,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0xF8, 0x1F, 0xF7, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFC, 0x7F,
  0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF8, 0x1F, 0x07, 0xE1, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xCF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0xC0, 0x7E, 0x0F,
  0x8F, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x1E, 0x03, 0xEF,
  0xF0, 0x7B, 0xFF, 0x1F, 0xFF, 0xE3, 0xF8, 0xFC, 0x7C, 0x0F, 0xCF, 0x80,
  0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03,
  0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9E, 0x01, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x82, 0x1F, 0x81, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x03, 0xF8, 0xF8, 0x3F, 0x87, 0xC3, 0xF8, 0x7C, 0x3F,
  0x03, 0xE3, 0xF0, 0x1F, 0x3F, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xF7, 0xC0,
  0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0,
  0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x38, 0xF0, 0x3F, 0xF7, 0xE1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0x3E, 0x7C, 0x78, 0xF9, 0xF1, 0xE3, 0xC7, 0x87, 0x8F,
  0x1E, 0x3E, 0x3C, 0x78, 0xF9, 0xF1, 0xE3, 0xE7, 0xCF, 0x8F, 0x1E, 0x3E,
  0x3C, 0x78, 0xF0, 0xF1, 0xE3, 0xC7, 0xC7, 0x8F, 0x1F, 0x3E, 0x7C, 0x7C,
  0xF9, 0xF1, 0xE3, 0xC7, 0xC7, 0x8F, 0x1E, 0x3E, 0x3C, 0x78, 0x1E, 0x1E,
  0x03, 0xCF, 0xF0, 0x7B, 0xFF, 0x1F, 0xFF, 0xE3, 0xF8, 0xFC, 0x7E, 0x0F,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9E, 0x01, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xF8, 0xFC, 0x7C, 0x0F,
  0x8F, 0x81, 0xF3, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F,
  0x3C, 0x03, 0xE7, 0x80, 0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xE3, 0xE0, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xCF,
  0x80, 0x7B, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xE3, 0xF0, 0xFC,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF1, 0xF0, 0x1F, 0x1F,
  0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xE3,
  0xF0, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xEF, 0xE0,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0xC3, 0xFE,
  0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x1F, 0xDF, 0x83, 0xF7, 0xC0, 0xFB,
  0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8,
  0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xF0, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFD, 0xE0, 0x7E, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x0F,
  0x0F, 0xC7, 0xCF, 0xF1, 0xF7, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xF0,
  0x23, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xF0, 0x7E, 0x7C, 0x07, 0xCF, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xBE, 0x01, 0xF3, 0xE0, 0x7C, 0x7E, 0x1F,
  0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x07, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x3E,
  0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x1F, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xE0,
  0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xE1,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0x7C, 0x0F, 0xCF, 0x00, 0xF8,
  0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xC7, 0x80, 0xF8, 0xF0,
  0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x07, 0x8F, 0x80, 0xF1,
  0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x7D, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0xF0, 0xFF, 0x0F, 0x1F, 0xF0, 0xF1, 0xFF, 0x1F, 0x1E, 0xF1, 0xF1, 0xEF,
  0x1F, 0x3E, 0xF3, 0xF3, 0xCF, 0x3F, 0x3C, 0xF3, 0xF7, 0xCF, 0x77, 0x78,
  0xF7, 0x77, 0x8F, 0x67, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7E,
  0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87,
  0xC0, 0x1F, 0x00, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xF0, 0xFC,
  0x07, 0xC7, 0xE0, 0x0F, 0xBF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0xFD, 0xF0, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80,
  0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0xFC, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF0,
  0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x78, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0E, 0x00, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x00, 0x03, 0x00, 0x07, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xC0, 0x02,
  0x00, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x07, 0x3F, 0xE0, 0x77, 0xFF, 0x8F,
  0x79, 0xFF, 0xFF, 0x07, 0xFE, 0xE0, 0x3F, 0xC0, 0x00, 0xF8,
};

const GFXglyph RobotoMono_BoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 10, 26, 22, 6, -26 },
  { 34, 12, 10, 22, 6, -28 },
  { 49, 22, 26, 22, 0, -26 },
  { 121, 19, 35, 22, 2, -31 },
  { 205, 18, 27, 22, 2, -27 },
  { 266, 21, 27, 22, 0, -27 },
  { 337, 5, 10, 22, 9, -28 },
  { 344, 12, 37, 22, 6, -29 },
  { 400, 13, 37, 22, 3, -29 },
  { 461, 18, 18, 22, 3, -26 },
  { 502, 18, 19, 22, 2, -22 },
  { 545, 8, 11, 22, 3, -4 },
  { 556, 15, 4, 22, 5, -14 },
  { 564, 7, 6, 22, 6, -6 },
  { 570, 20, 28, 22, 1, -26 },
  { 640, 18, 27, 22, 2, -27 },
  { 701, 13, 26, 22, 4, -26 },
  { 744, 20, 27, 22, 0, -27 },
  { 812, 19, 27, 22, 1, -27 },
  { 877, 20, 26, 22, 0, -26 },
  { 942, 20, 26, 22, 1, -26 },
  { 1007, 17, 27, 22, 2, -27 },
  { 1065, 20, 26, 22, 2, -26 },
  { 1130, 19, 27, 22, 1, -27 },
  { 1195, 17, 27, 22, 3, -27 },
  { 1253, 10, 21, 22, 6, -21 },
  { 1280, 11, 28, 22, 5, -21 },
  { 1319, 18, 17, 22, 2, -20 },
  { 1358, 18, 12, 22, 2, -17 },
  { 1385, 18, 18, 22, 1, -20 },
  { 1426, 17, 27, 22, 4, -27 },
  { 1484, 21, 26, 22, 1, -26 },
  { 1553, 21, 26, 22, -1, -26 },
  { 1622, 22, 26, 22, 0, -26 },
  { 1694, 20, 27, 22, 1, -27 },
  { 1762, 21, 26, 22, 0, -26 },
  { 1831, 21, 26, 22, 1, -26 },
  { 1900, 22, 26, 22, 1, -26 },
  { 1972, 20, 27, 22, 1, -27 },
  { 2040, 22, 26, 22, 0, -26 },
  { 2112, 20, 26, 22, 1, -26 },
  { 2177, 21, 26, 22, 1, -26 },
  { 2246, 25, 26, 22, 0, -26 },
  { 2328, 17, 26, 22, 1, -26 },
  { 2384, 22, 26, 22, 0, -26 },
  { 2456, 22, 26, 22, 0, -26 },
  { 2528, 20, 27, 22, 1, -27 },
  { 2596, 21, 26, 22, 1, -26 },
  { 2665, 20, 32, 22, 1, -27 },
  { 2745, 22, 26, 22, 0, -26 },
  { 2817, 21, 27, 22, 1, -27 },
  { 2888, 22, 26, 22, 2, -26 },
  { 2960, 20, 26, 22, 2, -26 },
  { 3025, 21, 26, 22, 3, -26 },
  { 3094, 22, 26, 22, 2, -26 },
  { 3166, 25, 26, 22, -1, -26 },
  { 3248, 21, 26, 22, 3, -26 },
  { 3317, 22, 26, 22, 0, -26 },
  { 3389, 14, 37, 22, 4, -31 },
  { 3454, 9, 28, 22, 7, -26 },
  { 3486, 14, 37, 22, 4, -31 },
  { 3551, 15, 14, 22, 4, -26 },
  { 3578, 17, 4, 22, 0, 0 },
  { 3587, 7, 5, 22, 10, -27 },
  { 3592, 18, 20, 22, 1, -20 },
  { 3637, 19, 28, 22, 1, -28 },
  { 3704, 17, 20, 22, 2, -20 },
  { 3747, 20, 28, 22, 2, -28 },
  { 3817, 18, 20, 22, 2, -20 },
  { 3862, 20, 29, 22, 3, -29 },
  { 3935, 21, 28, 22, 0, -20 },
  { 4009, 19, 28, 22, 1, -28 },
  { 4076, 16, 27, 22, 2, -27 },
  { 4130, 17, 35, 22, 1, -27 },
  { 4205, 21, 28, 22, 1, -28 },
  { 4279, 16, 28, 22, 2, -28 },
  { 4335, 22, 20, 22, -1, -20 },
  { 4390, 19, 20, 22, 1, -20 },
  { 4438, 19, 20, 22, 1, -20 },
  { 4486, 20, 28, 22, -1, -20 },
  { 4556, 18, 28, 22, 2, -20 },
  { 4619, 18, 20, 22, 3, -20 },
  { 4664, 19, 20, 22, 1, -20 },
  { 4712, 17, 24, 22, 3, -24 },
  { 4763, 19, 20, 22, 2, -20 },
  { 4811, 19, 20, 22, 3, -20 },
  { 4859, 20, 20, 22, 2, -20 },
  { 4909, 22, 20, 22, 0, -20 },
  { 4964, 23, 28, 22, 0, -20 },
  { 5045, 21, 20, 22, 0, -20 },
  { 5098, 15, 35, 22, 5, -29 },
  { 5164, 9, 33, 22, 6, -26 },
  { 5202, 15, 36, 22, 3, -29 },
  { 5270, 20, 8, 22, 0, -15 },
};

const GFXfont RobotoMono_BoldItalic37pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic37pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOMONO_BOLDITALIC37PT7B_H_
