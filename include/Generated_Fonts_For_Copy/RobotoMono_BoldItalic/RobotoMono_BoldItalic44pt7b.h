#ifndef _ROBOTOMONO_BOLDITALIC44PT7B_H_
#define _ROBOTOMONO_BOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1E, 0x00, 0x3C, 0x3E, 0x78, 0x7C,
  0xF0, 0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x78,
  0x79, 0xE0, 0xF3, 0xC1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xF0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x07,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x78, 0x03, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x10, 0xF0, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x1F, 0xE3, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F,
  0x1F, 0x80, 0xFC, 0x3F, 0xCF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x8F, 0x04, 0x78, 0x78, 0x7B,
  0xC3, 0xC7, 0x9E, 0x1E, 0x3C, 0xF0, 0xF3, 0xC7, 0x8F, 0x3C, 0x3F, 0xF9,
  0xC1, 0xFF, 0x9E, 0x07, 0xF9, 0xE0, 0x0F, 0x9E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x9F,
  0x80, 0x39, 0xFF, 0x03, 0xDF, 0xF8, 0x3D, 0xF3, 0xE3, 0xCF, 0x0F, 0x1E,
  0x78, 0x79, 0xE3, 0xC3, 0xCE, 0x1E, 0x1E, 0x10, 0xF1, 0xE0, 0x07, 0x8F,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03,
  0xF1, 0xF0, 0x07, 0xE1, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x07,
  0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xFC, 0x1F, 0x3F, 0xFC, 0x1F, 0x3F, 0x7E, 0x1F, 0x7E, 0x7F, 0x3F, 0xFE,
  0x3F, 0x3E, 0xFC, 0x1F, 0xFE, 0xFC, 0x1F, 0xFC, 0xFC, 0x0F, 0xFC, 0xFC,
  0x0F, 0xF8, 0xFC, 0x07, 0xF0, 0xFF, 0x3F, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xF8, 0xFE, 0x3D, 0xF7, 0xDF, 0x79,
  0xE7, 0xBE, 0xF3, 0xCF, 0x3C, 0x00, 0x04, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x03, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x70, 0x00, 0x40, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x80, 0xF0, 0x03, 0x83, 0x81, 0x9F, 0x8E, 0x3E, 0x7F, 0xBB,
  0xFB, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x8F, 0x00, 0x7C,
  0x3E, 0x07, 0xE0, 0xF8, 0x0F, 0x01, 0xF0, 0x0C, 0x07, 0x00, 0x20, 0x10,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x87,
  0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0x70, 0x04, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x3E,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xE1, 0xF8,
  0x7E, 0x07, 0xC7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0xDF, 0x80,
  0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x7F, 0xBF, 0x07, 0xFD, 0xF8, 0xFF, 0xCF,
  0x8F, 0xFE, 0xFD, 0xFB, 0xF7, 0xFF, 0x9F, 0xBF, 0xF0, 0xFD, 0xFF, 0x07,
  0xEF, 0xE0, 0x3F, 0x7E, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xF8,
  0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xF0, 0xFC, 0x7F, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x7C, 0x07, 0xF8, 0x7F, 0xF7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF,
  0x7F, 0x7E, 0xF0, 0xFD, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFE, 0x3F, 0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFE, 0x1F, 0xC3,
  0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF1, 0xF8, 0x1F, 0xC3,
  0xFC, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x3E, 0xFC, 0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xF8,
  0x0F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x20, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0x87, 0xF8, 0x06, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC1, 0xFE,
  0x7F, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x3C, 0x03,
  0xE7, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x87,
  0xF7, 0xF0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x3F,
  0x9F, 0x83, 0xF8, 0xFF, 0x3F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xE0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7E, 0x07, 0xE0,
  0xFC, 0x1F, 0xC0, 0xFE, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0x3F, 0xC1, 0xF8, 0x1F, 0x87, 0xE0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xFC, 0xFC, 0x01,
  0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xFC, 0xFF, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFC, 0x7E,
  0x3F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0x7E, 0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F,
  0xF7, 0xE0, 0x3C, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F,
  0xE0, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x7F,
  0x0F, 0xF8, 0x7F, 0x07, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF0,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xE0,
  0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC0, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x0F, 0xFF,
  0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF8,
  0xFF, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x1F, 0x80, 0x3E, 0x01, 0xE0, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0x1C, 0x3C, 0x3F, 0x8E, 0x1E, 0x3F, 0xE7, 0x1E, 0x3F,
  0xF3, 0x8F, 0x3E, 0x39, 0xCF, 0x1E, 0x38, 0xE7, 0x9E, 0x1C, 0x73, 0x8F,
  0x0E, 0x39, 0xC7, 0x0F, 0x1D, 0xE7, 0x87, 0x8E, 0xF3, 0xC3, 0x8F, 0x79,
  0xE1, 0xC7, 0x38, 0xF1, 0xE3, 0x9C, 0x78, 0xF1, 0xCE, 0x3C, 0xF9, 0xC7,
  0x1F, 0xFF, 0xE3, 0xC7, 0xEF, 0xE1, 0xE3, 0xE7, 0xE0, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE1, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xE0,
  0x03, 0xF1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x3E,
  0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xC0,
  0x1F, 0x0F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xF0,
  0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC,
  0x01, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x87, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0x8F, 0xC0, 0x3F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xFD, 0xFF, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC7,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0,
  0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x3F, 0x07, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0xFD,
  0xF8, 0x3F, 0xFB, 0xF0, 0x7F, 0xF7, 0xE0, 0xFF, 0xEF, 0xC3, 0xFF, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8,
  0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81,
  0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0x80,
  0x3F, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xF8,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x80,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x04, 0x03, 0xF0,
  0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0,
  0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0x00, 0x7F, 0x81, 0xF8,
  0x07, 0xF8, 0x0F, 0xC0, 0x7F, 0x80, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x3F,
  0x80, 0x1F, 0x83, 0xF8, 0x00, 0xF8, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00,
  0x7E, 0x3F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xDF, 0xC0, 0x03, 0xFC, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xE0,
  0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xFC, 0x0F,
  0xF0, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x7F, 0xE7, 0xFC, 0x0F, 0xBD, 0xFF,
  0x81, 0xF7, 0xBD, 0xF0, 0x3E, 0xFF, 0xFE, 0x07, 0xDF, 0xEF, 0xC0, 0xFB,
  0xFD, 0xF0, 0x3F, 0x7F, 0x3E, 0x07, 0xEF, 0xE7, 0xC0, 0xF9, 0xF8, 0xF8,
  0x1F, 0x1F, 0x3F, 0x03, 0xE3, 0xC7, 0xC0, 0x7C, 0x78, 0xF8, 0x1F, 0x8E,
  0x1F, 0x03, 0xF1, 0xC3, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x81,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03,
  0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x3F,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x00,
  0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF8, 0x1F, 0x81, 0xFE, 0x07, 0xE0, 0x7F,
  0x81, 0xF8, 0x3F, 0xE0, 0x7E, 0x0F, 0xFC, 0x1F, 0x03, 0xFF, 0x0F, 0xC0,
  0xFF, 0xC3, 0xF0, 0x3F, 0xF0, 0xFC, 0x0F, 0xBE, 0x3F, 0x07, 0xEF, 0x8F,
  0xC1, 0xF9, 0xE7, 0xE0, 0x7E, 0x79, 0xF8, 0x1F, 0x9F, 0x7E, 0x07, 0xE7,
  0xDF, 0x83, 0xF0, 0xF7, 0xE0, 0xFC, 0x3D, 0xF8, 0x3F, 0x0F, 0xFC, 0x0F,
  0xC3, 0xFF, 0x03, 0xF0, 0x7F, 0xC0, 0xFC, 0x1F, 0xF0, 0x7E, 0x07, 0xFC,
  0x1F, 0x81, 0xFE, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x7E, 0x03,
  0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFC,
  0x7F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF8,
  0x3F, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8,
  0x7E, 0x0F, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFE, 0x7F, 0x87, 0xF0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xE3, 0xF8, 0x1F, 0x83, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x3F, 0x83, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x7F,
  0x0F, 0xFD, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F,
  0xBF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0x7E,
  0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3E,
  0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x3E, 0x1F, 0xFE, 0x1F, 0x0F, 0xFF, 0x0F, 0x87, 0xDF,
  0x8F, 0xC3, 0xEF, 0xC7, 0xE3, 0xF7, 0xE3, 0xF1, 0xF3, 0xE3, 0xF8, 0xF9,
  0xF1, 0xFC, 0xFC, 0xF8, 0xFE, 0x7E, 0x7C, 0x7F, 0x3E, 0x3E, 0x7F, 0x9F,
  0x1F, 0x3F, 0xDF, 0x8F, 0x9F, 0xEF, 0x87, 0xDE, 0xF7, 0xC3, 0xEF, 0x7B,
  0xE1, 0xF7, 0xBF, 0xF0, 0xFB, 0x9D, 0xF0, 0x7F, 0xCE, 0xF8, 0x3F, 0xE7,
  0xFC, 0x1F, 0xF3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x03,
  0xE0, 0x7C, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0x80, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0,
  0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F,
  0x87, 0xE0, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF3,
  0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x1E, 0xF0, 0x1F, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0x8F, 0x87, 0xC7,
  0xC7, 0xC1, 0xE3, 0xE0, 0xF3, 0xE0, 0x7D, 0xF0, 0x3F, 0xF0, 0x0F, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE1,
  0xF8, 0x1F, 0x87, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x87, 0xE7, 0xF0, 0x1F,
  0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F,
  0x87, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x83, 0xFF, 0xBF, 0x03, 0xFC,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x1C, 0x00, 0xF9, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFE, 0x3F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC,
  0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC,
  0x03, 0xF3, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xF9, 0xF8, 0x07,
  0xE7, 0xE0, 0x1F, 0x9F, 0xC0, 0xFC, 0x7F, 0xDF, 0xF3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0x7F, 0xE0, 0xF8, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8,
  0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0x1F, 0x81, 0xF8, 0xFE, 0x3F,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x70, 0xFC, 0x03, 0xFC, 0xFC, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xC7, 0xFC, 0x3F,
  0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0x7F, 0xBF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xF7, 0xE0, 0x0F, 0xE7, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x0F, 0xE3, 0xF8, 0x1F,
  0x8F, 0xC0, 0x3E, 0x7E, 0x00, 0xF9, 0xF8, 0x03, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x02, 0x07, 0xE0, 0x1C, 0x1F, 0xF3, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFD, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x3F, 0x03,
  0xFF, 0xBE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F,
  0xC0, 0xFE, 0x3F, 0x80, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F,
  0x03, 0xF8, 0x3F, 0xDF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xF3, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x20,
  0x07, 0xE0, 0x70, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x0E, 0x00,
  0xF9, 0xFE, 0x07, 0xEF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFE,
  0x3F, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x0F, 0xDF,
  0x80, 0x3E, 0x7E, 0x00, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x00,
  0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x43, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC1, 0xF8, 0x3F, 0xC0, 0xFC,
  0x3F, 0xC0, 0x7E, 0x3F, 0xC0, 0x3F, 0x3F, 0xC0, 0x1F, 0x3F, 0xC0, 0x1F,
  0xBF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x9F, 0x80,
  0x3F, 0x8F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0xFC, 0x03,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x00, 0x0E, 0x0E, 0x03, 0xEF, 0xCF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xF7, 0xF3, 0xE1, 0xF8, 0xF8, 0xF8,
  0x7E, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xE3, 0xE1, 0xF1, 0xF0,
  0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1,
  0xF1, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x8F, 0x8F, 0xC7,
  0xE3, 0xE3, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x1F, 0x0F,
  0x87, 0xC7, 0xC3, 0xE3, 0xF1, 0xF1, 0xF8, 0x00, 0x03, 0x80, 0x3E, 0x7F,
  0xC1, 0xFB, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0x87, 0xF1,
  0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xF7, 0xE0, 0x0F,
  0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xBF,
  0x00, 0x7E, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x1F, 0xE3, 0xF8, 0xFC, 0x0F, 0xEF, 0xC0, 0x3F, 0x7E, 0x01,
  0xFB, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x1F,
  0xBF, 0x81, 0xF8, 0xFE, 0x3F, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xE7,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8,
  0xFF, 0x07, 0xE0, 0x7F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3F, 0x7F, 0xE0, 0x3F, 0x3F, 0xC0, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0xF9, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0xFF, 0x0F, 0xF3, 0xF0, 0x1F, 0x9F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8,
  0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F,
  0xE0, 0xFE, 0x1F, 0xEF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF,
  0x7E, 0x03, 0xF9, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x7C, 0x7F, 0xC7, 0xE7,
  0xFE, 0x3F, 0x7F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xE0, 0xC3,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFE, 0x07,
  0xE3, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F,
  0x3F, 0x81, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xF7, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8,
  0x03, 0xFF, 0x00, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xF8, 0xFC, 0x03, 0xF1,
  0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0x7C, 0x03, 0xF0, 0xFC, 0x0F, 0xE1, 0xFE, 0xFF, 0x83, 0xFF, 0xFF,
  0x03, 0xFF, 0xBE, 0x07, 0xFE, 0x7C, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xFE, 0xF8, 0x01, 0xF9, 0xF0, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E,
  0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x00, 0xF8, 0xFC, 0x01, 0xF1,
  0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x07, 0xBF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x3C, 0x1F, 0xFE, 0x1E,
  0x0F, 0xBF, 0x1F, 0x0F, 0xDF, 0x0F, 0x87, 0xCF, 0x87, 0xC3, 0xE7, 0xC7,
  0xE3, 0xF3, 0xE3, 0xF1, 0xF1, 0xF1, 0xF8, 0xF8, 0xF9, 0xFC, 0xF8, 0x7C,
  0xEE, 0x7C, 0x3E, 0x77, 0x3E, 0x1F, 0x7B, 0x9E, 0x0F, 0xB9, 0xDF, 0x07,
  0xDC, 0xEF, 0x83, 0xFE, 0x77, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0,
  0x7F, 0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8,
  0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xF7, 0xE0, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0x80,
  0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE1, 0xF8,
  0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x05, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x03, 0xC0, 0xE0, 0x38,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x03,
  0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x08, 0x3F, 0xF8,
  0x0F, 0x3F, 0xFC, 0x0F, 0x7F, 0xFE, 0x1F, 0x7C, 0x7F, 0xFE, 0xF8, 0x3F,
  0xFE, 0xF0, 0x1F, 0xFC, 0x10, 0x07, 0xF8, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoMono_BoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 11, 31, 26, 8, -31 },
  { 44, 15, 11, 26, 7, -33 },
  { 65, 26, 31, 26, 0, -31 },
  { 166, 23, 41, 26, 2, -36 },
  { 284, 21, 32, 26, 3, -32 },
  { 368, 24, 32, 26, 1, -32 },
  { 464, 6, 12, 26, 11, -33 },
  { 473, 15, 45, 26, 7, -35 },
  { 558, 16, 45, 26, 3, -35 },
  { 648, 22, 22, 26, 3, -31 },
  { 709, 22, 23, 26, 2, -26 },
  { 773, 10, 14, 26, 4, -5 },
  { 791, 18, 5, 26, 6, -16 },
  { 803, 8, 7, 26, 7, -7 },
  { 810, 23, 34, 26, 2, -31 },
  { 908, 21, 33, 26, 3, -32 },
  { 995, 15, 31, 26, 5, -31 },
  { 1054, 23, 32, 26, 0, -32 },
  { 1146, 23, 32, 26, 1, -32 },
  { 1238, 23, 31, 26, 0, -31 },
  { 1328, 23, 32, 26, 2, -31 },
  { 1420, 21, 33, 26, 2, -32 },
  { 1507, 23, 31, 26, 3, -31 },
  { 1597, 23, 32, 26, 1, -32 },
  { 1689, 20, 32, 26, 3, -32 },
  { 1769, 12, 25, 26, 7, -25 },
  { 1807, 13, 34, 26, 6, -25 },
  { 1863, 21, 21, 26, 3, -24 },
  { 1919, 22, 14, 26, 2, -20 },
  { 1958, 21, 21, 26, 2, -24 },
  { 2014, 20, 32, 26, 5, -32 },
  { 2094, 25, 31, 26, 1, -31 },
  { 2191, 25, 31, 26, -2, -31 },
  { 2288, 26, 31, 26, 0, -31 },
  { 2389, 23, 33, 26, 2, -32 },
  { 2484, 25, 31, 26, 0, -31 },
  { 2581, 26, 31, 26, 1, -31 },
  { 2682, 26, 31, 26, 1, -31 },
  { 2783, 23, 32, 26, 2, -32 },
  { 2875, 26, 31, 26, 0, -31 },
  { 2976, 23, 31, 26, 2, -31 },
  { 3066, 24, 31, 26, 2, -31 },
  { 3159, 29, 31, 26, 0, -31 },
  { 3272, 21, 31, 26, 1, -31 },
  { 3354, 27, 31, 26, 0, -31 },
  { 3459, 26, 31, 26, 0, -31 },
  { 3560, 23, 32, 26, 2, -32 },
  { 3652, 25, 31, 26, 1, -31 },
  { 3749, 23, 38, 26, 2, -32 },
  { 3859, 26, 31, 26, 0, -31 },
  { 3960, 25, 32, 26, 1, -32 },
  { 4060, 25, 31, 26, 3, -31 },
  { 4157, 24, 32, 26, 2, -31 },
  { 4253, 24, 31, 26, 4, -31 },
  { 4346, 25, 31, 26, 3, -31 },
  { 4443, 30, 31, 26, -2, -31 },
  { 4560, 25, 31, 26, 4, -31 },
  { 4657, 27, 31, 26, 0, -31 },
  { 4762, 16, 43, 26, 5, -36 },
  { 4848, 11, 34, 26, 8, -31 },
  { 4895, 16, 43, 26, 5, -36 },
  { 4981, 17, 16, 26, 5, -31 },
  { 5015, 20, 5, 26, 0, 0 },
  { 5028, 9, 6, 26, 12, -32 },
  { 5035, 22, 24, 26, 1, -24 },
  { 5101, 22, 33, 26, 1, -33 },
  { 5192, 21, 25, 26, 2, -24 },
  { 5258, 24, 33, 26, 2, -33 },
  { 5357, 22, 24, 26, 2, -24 },
  { 5423, 24, 34, 26, 4, -34 },
  { 5525, 24, 33, 26, 1, -24 },
  { 5624, 22, 33, 26, 1, -33 },
  { 5715, 20, 32, 26, 2, -32 },
  { 5795, 20, 41, 26, 1, -32 },
  { 5898, 25, 33, 26, 1, -33 },
  { 6002, 20, 33, 26, 2, -33 },
  { 6085, 26, 24, 26, -1, -24 },
  { 6163, 22, 24, 26, 1, -24 },
  { 6229, 21, 25, 26, 2, -24 },
  { 6295, 24, 33, 26, -1, -24 },
  { 6394, 22, 33, 26, 2, -24 },
  { 6485, 21, 24, 26, 4, -24 },
  { 6548, 22, 24, 26, 2, -24 },
  { 6614, 20, 29, 26, 4, -29 },
  { 6687, 23, 24, 26, 2, -23 },
  { 6756, 23, 23, 26, 3, -23 },
  { 6823, 25, 23, 26, 2, -23 },
  { 6895, 26, 23, 26, 0, -23 },
  { 6970, 28, 32, 26, 0, -23 },
  { 7082, 25, 23, 26, 0, -23 },
  { 7154, 17, 42, 26, 6, -34 },
  { 7244, 10, 40, 26, 8, -31 },
  { 7294, 17, 42, 26, 4, -34 },
  { 7384, 24, 10, 26, 0, -18 },
};

const GFXfont RobotoMono_BoldItalic44pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic44pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _ROBOTOMONO_BOLDITALIC44PT7B_H_
