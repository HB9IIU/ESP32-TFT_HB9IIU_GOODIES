#ifndef _ROBOTOMONO_BOLDITALIC13PT7B_H_
#define _ROBOTOMONO_BOLDITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x66, 0x64, 0x0C, 0xC0, 0x5D, 0x99, 0x1A, 0x16, 0x7F, 0x34,
  0x2C, 0xFE, 0x68, 0x58, 0x50, 0x08, 0x47, 0xD9, 0x45, 0x83, 0x83, 0x8F,
  0x7F, 0x88, 0xE2, 0xBA, 0x94, 0x20, 0xF5, 0x6D, 0x1C, 0x3C, 0x68, 0xB1,
  0xC3, 0x2F, 0x73, 0xE6, 0x7E, 0x5E, 0x13, 0x64, 0xCC, 0xC8, 0x88, 0xC4,
  0x20, 0x21, 0x84, 0x21, 0x88, 0x42, 0x31, 0x18, 0x88, 0x00, 0x12, 0x5F,
  0xCC, 0x73, 0x20, 0x10, 0xC3, 0x3F, 0x20, 0x86, 0x00, 0x6D, 0xE4, 0xFF,
  0xC0, 0xF8, 0x0C, 0x21, 0x84, 0x30, 0x86, 0x10, 0xC2, 0x00, 0x79, 0x3C,
  0xF7, 0xFF, 0x38, 0xB6, 0x70, 0x1B, 0xE6, 0x23, 0x18, 0xC6, 0x20, 0x3C,
  0xCD, 0x98, 0x20, 0xC3, 0x0C, 0x70, 0xFC, 0x3E, 0xCC, 0x18, 0x71, 0xC0,
  0xB1, 0xE6, 0x78, 0x0E, 0x1C, 0x51, 0xE6, 0xD9, 0xBF, 0x84, 0x18, 0x3E,
  0x60, 0x83, 0xE6, 0xC0, 0xF1, 0xB6, 0x78, 0x39, 0x8C, 0x3E, 0xCE, 0x38,
  0xF6, 0x70, 0xFE, 0x18, 0x20, 0xC1, 0x06, 0x18, 0x30, 0xC0, 0x3E, 0x4D,
  0x99, 0xE3, 0xCC, 0xB1, 0x36, 0x78, 0x7B, 0x3C, 0xF3, 0xDD, 0xE1, 0x8C,
  0xE0, 0x6C, 0x01, 0xF0, 0x77, 0x00, 0x04, 0x4C, 0xC8, 0x04, 0xFE, 0x38,
  0x38, 0x20, 0xFC, 0x00, 0x3F, 0x60, 0xF0, 0x38, 0xE7, 0x98, 0x00, 0xFE,
  0xC6, 0x33, 0x30, 0x08, 0xC0, 0x1E, 0x22, 0x5D, 0x76, 0xAA, 0xAA, 0xBC,
  0x40, 0x78, 0x06, 0x0E, 0x0E, 0x1A, 0x12, 0x32, 0x3F, 0x63, 0xE3, 0x3E,
  0x63, 0x63, 0x66, 0x7C, 0x46, 0x46, 0xCE, 0xFC, 0x3E, 0xCD, 0x8B, 0x04,
  0x18, 0x11, 0xB6, 0x38, 0x3C, 0xCD, 0x9B, 0x36, 0x68, 0xD1, 0xEE, 0xF8,
  0x3F, 0x20, 0x60, 0x62, 0x7C, 0x60, 0x40, 0xC2, 0xFC, 0x3F, 0x20, 0x60,
  0x60, 0x7E, 0x60, 0x40, 0x40, 0xC0, 0x7D, 0x3C, 0x70, 0x9E, 0x78, 0xF3,
  0x78, 0x23, 0x62, 0x66, 0x66, 0x7E, 0x46, 0x44, 0xC4, 0xCC, 0x7C, 0x43,
  0x0C, 0x30, 0xC2, 0x18, 0xF8, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0xC6,
  0x6C, 0x78, 0x23, 0xB3, 0x1B, 0x0F, 0x07, 0x83, 0x61, 0x31, 0x98, 0xC6,
  0x00, 0x30, 0x86, 0x18, 0x61, 0x84, 0x10, 0xFC, 0x37, 0x77, 0x7E, 0x7A,
  0x5E, 0x56, 0x46, 0xC4, 0xC4, 0x33, 0x72, 0x76, 0x76, 0x7E, 0x4E, 0x4C,
  0xCC, 0xCC, 0x3E, 0xCD, 0x8B, 0x14, 0x78, 0xD1, 0xB6, 0x78, 0x3E, 0x22,
  0x63, 0x62, 0x7E, 0x78, 0x40, 0x40, 0xC0, 0x3E, 0x4D, 0x8B, 0x14, 0x78,
  0xD1, 0xB6, 0x7C, 0x0C, 0x10, 0x3E, 0x66, 0x63, 0x66, 0x7E, 0x7C, 0x4C,
  0xCC, 0xC6, 0x3E, 0x62, 0x61, 0x30, 0x1C, 0x06, 0xC6, 0x66, 0x7C, 0xFE,
  0x20, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x60, 0x47, 0x8B, 0x16, 0x6C, 0xD9,
  0xA3, 0x6C, 0xF0, 0xC7, 0x8B, 0x32, 0x65, 0x8B, 0x1C, 0x38, 0x60, 0xD7,
  0xEE, 0xD5, 0xAB, 0xDB, 0xB6, 0x6C, 0xD8, 0x63, 0x36, 0x3C, 0x1C, 0x18,
  0x3C, 0x6C, 0x6C, 0xC6, 0xC7, 0x44, 0x6C, 0x78, 0x30, 0x30, 0x30, 0x20,
  0x60, 0x7F, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xFE, 0x37, 0x66,
  0x64, 0x4C, 0xCC, 0xCA, 0xC0, 0xC4, 0x46, 0x66, 0x22, 0x23, 0x37, 0x33,
  0x32, 0x26, 0x66, 0x66, 0xC0, 0x18, 0xA2, 0x92, 0xCC, 0xFC, 0xE0, 0x3C,
  0xCC, 0x1B, 0xEC, 0x59, 0x9F, 0x00, 0x30, 0x40, 0x83, 0xE7, 0xEC, 0xD9,
  0xA3, 0xED, 0xF0, 0x7B, 0xBC, 0xE0, 0x83, 0x67, 0x00, 0x06, 0x08, 0x13,
  0xEF, 0xD9, 0xA3, 0x44, 0xD9, 0xF0, 0x7B, 0xBC, 0xFF, 0x83, 0x27, 0x80,
  0x1E, 0x34, 0xC7, 0xE3, 0x04, 0x18, 0x30, 0x60, 0xC0, 0x3A, 0xED, 0x9A,
  0x34, 0x6D, 0x9D, 0x06, 0xF8, 0xE0, 0x30, 0x40, 0x83, 0xE7, 0x6C, 0xD9,
  0xA3, 0xC5, 0x98, 0x10, 0xC0, 0xE7, 0x18, 0xC6, 0x37, 0xC0, 0x04, 0x30,
  0x0F, 0x3C, 0x20, 0x86, 0x18, 0x61, 0xBC, 0xE0, 0x30, 0x20, 0x20, 0x67,
  0x6C, 0x78, 0x78, 0x78, 0xCC, 0xCE, 0x7B, 0xC6, 0x21, 0x18, 0xC6, 0x37,
  0xC0, 0x5E, 0xF5, 0x6E, 0xBD, 0x7A, 0xED, 0x00, 0x7C, 0xED, 0x9B, 0x34,
  0x78, 0xB3, 0x00, 0x7B, 0xFC, 0xE3, 0x8F, 0x6F, 0x00, 0x7C, 0xFD, 0x9B,
  0x34, 0x7D, 0xBE, 0x60, 0xC1, 0x80, 0x77, 0xBC, 0xE3, 0x8B, 0x6F, 0x86,
  0x18, 0x60, 0x6D, 0xF6, 0x10, 0x43, 0x0C, 0x00, 0x3C, 0xCD, 0x81, 0xE0,
  0xF8, 0x9F, 0x00, 0x30, 0xCF, 0xC8, 0x61, 0x86, 0x19, 0x38, 0xC7, 0x3C,
  0xF3, 0x8F, 0x6E, 0x80, 0xC7, 0x9B, 0x22, 0xC5, 0x0E, 0x18, 0x00, 0x97,
  0x6A, 0xD7, 0xED, 0x9B, 0x26, 0x00, 0x67, 0x36, 0x3C, 0x18, 0x38, 0x6C,
  0xC6, 0x63, 0x66, 0x66, 0x2C, 0x3C, 0x38, 0x10, 0x30, 0xE0, 0xC0, 0x7E,
  0xFC, 0x30, 0xC3, 0x0C, 0x7F, 0x00, 0x19, 0x8C, 0x42, 0x73, 0x0C, 0x63,
  0x10, 0xC0, 0x24, 0x94, 0x92, 0x4B, 0x40, 0x30, 0x84, 0x63, 0x0C, 0x66,
  0x21, 0x19, 0x80, 0x73, 0xBC, 0x30,
};

const GFXglyph RobotoMono_BoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 9, 8, 2, -9 },
  { 6, 4, 4, 8, 2, -10 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 6, 12, 8, 1, -11 },
  { 26, 6, 9, 8, 1, -9 },
  { 33, 7, 9, 8, 0, -9 },
  { 41, 2, 4, 8, 3, -10 },
  { 42, 4, 13, 8, 2, -10 },
  { 49, 5, 13, 8, 1, -10 },
  { 58, 6, 6, 8, 1, -9 },
  { 63, 6, 7, 8, 1, -8 },
  { 69, 3, 5, 8, 1, -2 },
  { 71, 5, 2, 8, 2, -5 },
  { 73, 3, 2, 8, 2, -2 },
  { 74, 6, 10, 8, 1, -9 },
  { 82, 6, 9, 8, 1, -9 },
  { 89, 5, 9, 8, 1, -9 },
  { 95, 7, 9, 8, 0, -9 },
  { 103, 7, 9, 8, 0, -9 },
  { 111, 7, 9, 8, 0, -9 },
  { 119, 7, 9, 8, 0, -9 },
  { 127, 6, 9, 8, 1, -9 },
  { 134, 7, 9, 8, 1, -9 },
  { 142, 7, 9, 8, 0, -9 },
  { 150, 6, 9, 8, 1, -9 },
  { 157, 3, 7, 8, 2, -7 },
  { 160, 4, 10, 8, 2, -7 },
  { 165, 6, 6, 8, 1, -7 },
  { 170, 6, 4, 8, 1, -6 },
  { 173, 7, 6, 8, 0, -7 },
  { 179, 5, 9, 8, 2, -9 },
  { 185, 8, 9, 8, 0, -9 },
  { 194, 8, 9, 8, -1, -9 },
  { 203, 8, 9, 8, 0, -9 },
  { 212, 7, 9, 8, 0, -9 },
  { 220, 7, 9, 8, 0, -9 },
  { 228, 8, 9, 8, 0, -9 },
  { 237, 8, 9, 8, 0, -9 },
  { 246, 6, 9, 8, 1, -9 },
  { 253, 8, 9, 8, 0, -9 },
  { 262, 6, 9, 8, 1, -9 },
  { 269, 8, 9, 8, 0, -9 },
  { 278, 9, 9, 8, 0, -9 },
  { 289, 6, 9, 8, 0, -9 },
  { 296, 8, 9, 8, 0, -9 },
  { 305, 8, 9, 8, 0, -9 },
  { 314, 7, 9, 8, 0, -9 },
  { 322, 8, 9, 8, 0, -9 },
  { 331, 7, 11, 8, 0, -9 },
  { 341, 8, 9, 8, 0, -9 },
  { 350, 8, 9, 8, 0, -9 },
  { 359, 7, 9, 8, 1, -9 },
  { 367, 7, 9, 8, 1, -9 },
  { 375, 7, 9, 8, 1, -9 },
  { 383, 7, 9, 8, 1, -9 },
  { 391, 8, 9, 8, 0, -9 },
  { 400, 8, 9, 8, 1, -9 },
  { 409, 8, 9, 8, 0, -9 },
  { 418, 4, 13, 8, 2, -11 },
  { 425, 4, 10, 8, 2, -9 },
  { 430, 4, 13, 8, 2, -11 },
  { 437, 6, 5, 8, 1, -9 },
  { 441, 6, 1, 8, 0, 0 },
  { 442, 3, 1, 8, 3, -9 },
  { 443, 7, 7, 8, 0, -7 },
  { 450, 7, 10, 8, 0, -10 },
  { 459, 6, 7, 8, 1, -7 },
  { 465, 7, 10, 8, 1, -10 },
  { 474, 6, 7, 8, 1, -7 },
  { 480, 7, 10, 8, 1, -10 },
  { 489, 7, 10, 8, 0, -7 },
  { 498, 7, 10, 8, 0, -10 },
  { 507, 5, 10, 8, 1, -10 },
  { 514, 6, 13, 8, 0, -10 },
  { 524, 8, 10, 8, 0, -10 },
  { 534, 5, 10, 8, 1, -10 },
  { 541, 7, 7, 8, 0, -7 },
  { 548, 7, 7, 8, 0, -7 },
  { 555, 6, 7, 8, 1, -7 },
  { 561, 7, 10, 8, 0, -7 },
  { 570, 6, 10, 8, 1, -7 },
  { 578, 6, 7, 8, 1, -7 },
  { 584, 7, 7, 8, 0, -7 },
  { 591, 6, 9, 8, 1, -9 },
  { 598, 6, 7, 8, 1, -7 },
  { 604, 7, 7, 8, 1, -7 },
  { 611, 7, 7, 8, 1, -7 },
  { 618, 8, 7, 8, 0, -7 },
  { 625, 8, 10, 8, 0, -7 },
  { 635, 7, 7, 8, 0, -7 },
  { 642, 5, 12, 8, 2, -10 },
  { 650, 3, 12, 8, 2, -9 },
  { 655, 5, 12, 8, 1, -10 },
  { 663, 7, 3, 8, 0, -5 },
};

const GFXfont RobotoMono_BoldItalic13pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic13pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _ROBOTOMONO_BOLDITALIC13PT7B_H_
