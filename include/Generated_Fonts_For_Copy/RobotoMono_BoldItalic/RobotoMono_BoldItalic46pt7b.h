#ifndef _ROBOTOMONO_BOLDITALIC46PT7B_H_
#define _ROBOTOMONO_BOLDITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x07, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7C, 0x00, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xC1, 0xE7, 0x83,
  0xCF, 0x07, 0xBE, 0x1F, 0x7C, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0xC0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x80,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x07,
  0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x7E,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xF8, 0xF0, 0x23, 0xC3,
  0xC1, 0xEF, 0x0F, 0x0F, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xCF,
  0x0F, 0xFF, 0x78, 0x1F, 0xF9, 0xE0, 0x7F, 0xCF, 0x00, 0x7E, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0xF8, 0x03, 0xCF, 0xF0, 0x0F, 0x7F, 0xE0, 0x7B, 0xFF,
  0xC3, 0xCF, 0x1F, 0x1E, 0x3C, 0x3C, 0x79, 0xF0, 0xF3, 0xC7, 0xC3, 0xC6,
  0x1E, 0x0F, 0x08, 0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFE, 0x07, 0xC7, 0xFF, 0x83, 0xE7, 0xFF, 0xE1, 0xF7, 0xF3, 0xF1,
  0xFB, 0xF1, 0xFC, 0xFB, 0xF8, 0x7E, 0xFD, 0xF8, 0x3F, 0xFE, 0xFC, 0x0F,
  0xFE, 0x7E, 0x03, 0xFE, 0x3F, 0x01, 0xFF, 0x1F, 0xC0, 0xFF, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xF8, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9F,
  0x3E, 0x78, 0xF1, 0xE3, 0xCF, 0x00, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x01, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x04, 0x03, 0x80, 0x9C, 0x0E, 0x0E, 0x7C, 0x78, 0xFB, 0xFD,
  0xEF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0x9E, 0x00, 0x7C, 0x7C, 0x03,
  0xF1, 0xF0, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0xC0, 0xE0, 0x1C, 0x00, 0x80,
  0x60, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87,
  0xE1, 0xF0, 0xF8, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x1C, 0x1F, 0x9F, 0xEF, 0xFF, 0xFB, 0xFD,
  0xFC, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0xC7, 0xE0, 0x3F,
  0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E,
  0x03, 0xFD, 0xF8, 0x1F, 0xF7, 0xE1, 0xFF, 0xDF, 0x8F, 0xFE, 0x7E, 0xFD,
  0xFB, 0xFF, 0xE7, 0xEF, 0xFE, 0x1F, 0xBF, 0xF0, 0x7E, 0xFF, 0x01, 0xFB,
  0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x83, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x0F, 0x00, 0x7F, 0x03, 0xFF, 0x0F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x7E, 0xF8, 0x7E, 0xC0, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xF0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC,
  0x03, 0xE1, 0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xCF, 0xF8, 0x0F, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8,
  0xFC, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC3, 0xC0, 0x3F, 0x7F, 0xC0,
  0xFB, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xC7, 0xF9, 0xFC,
  0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xE7,
  0xE0, 0x3F, 0x1F, 0xC1, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0x83,
  0xF8, 0x3F, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xE1, 0xF8, 0xFC,
  0x07, 0xEF, 0xE0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xEF, 0xC0,
  0x7F, 0x7F, 0x07, 0xFB, 0xFC, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x03, 0xF9, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x81,
  0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x07, 0xE1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE1, 0xF8, 0x00,
  0x00, 0x70, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80,
  0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00,
  0x10, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x3F, 0xC3, 0xFD, 0xFC, 0x0F, 0xEF, 0xC0, 0x3F, 0xFE, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x1F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x01, 0xE0,
  0xF8, 0x30, 0x38, 0x3C, 0x3F, 0x8E, 0x1E, 0x3F, 0xF3, 0x87, 0x1F, 0xFC,
  0xE3, 0xC7, 0xCF, 0x3C, 0xE3, 0xC3, 0x8F, 0x78, 0xF0, 0xE3, 0x9E, 0x78,
  0x38, 0xE7, 0x1E, 0x1E, 0x3B, 0xC7, 0x87, 0x0E, 0xF1, 0xC1, 0xC3, 0xBC,
  0xF0, 0xF1, 0xEF, 0x3C, 0x3C, 0x73, 0xCF, 0x0F, 0x1C, 0xF3, 0xC3, 0x8E,
  0x3C, 0xFB, 0xE7, 0x8F, 0x1F, 0xFF, 0xC3, 0xC7, 0xFF, 0xE0, 0xF0, 0xF1,
  0xF0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x04, 0x00, 0x3F,
  0x0F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFB, 0xE0,
  0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE3,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x1F,
  0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0,
  0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC1, 0xFF, 0x81, 0xF8, 0x03, 0xF8,
  0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x80,
  0x3F, 0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x7F,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x87, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x9F,
  0xC0, 0x0F, 0xEF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xF8, 0xFF, 0xC0, 0x7E,
  0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07,
  0xF0, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x8F,
  0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0xFE,
  0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x3F, 0xC1, 0xFC, 0x3F, 0xE0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F, 0x3F,
  0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x0F, 0xFE, 0xFC, 0x0F, 0xFE, 0xFC, 0x1F, 0xFE, 0xFC, 0x1F, 0xFE, 0xFC,
  0x1F, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFE, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC1,
  0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF1,
  0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFC,
  0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x01, 0xFE, 0x07, 0xE0, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F,
  0x80, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0xFC, 0x07, 0xF8, 0x01, 0xF8,
  0x1F, 0xE0, 0x03, 0xF0, 0x7F, 0x80, 0x07, 0xE1, 0xFE, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0xFE,
  0x00, 0x01, 0xFB, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x00, 0x07, 0xFC, 0xFE, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x1F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07,
  0xFC, 0x7F, 0xE0, 0x7F, 0xC7, 0xFE, 0x07, 0xFC, 0xFF, 0xC0, 0xFF, 0xCF,
  0x7C, 0x0F, 0xFD, 0xF7, 0xC0, 0xFF, 0xDF, 0xFC, 0x0F, 0xBF, 0xEF, 0xC0,
  0xF9, 0xFE, 0xF8, 0x0F, 0x9F, 0xCF, 0x81, 0xF9, 0xFC, 0xF8, 0x1F, 0x9F,
  0x9F, 0x81, 0xF9, 0xF9, 0xF8, 0x1F, 0x9F, 0x1F, 0x81, 0xF1, 0xF1, 0xF0,
  0x1F, 0x1E, 0x1F, 0x03, 0xF1, 0xE3, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x83, 0xFC, 0x07, 0xF0,
  0x7F, 0x80, 0xFC, 0x0F, 0xF0, 0x1F, 0x81, 0xFF, 0x03, 0xF0, 0x3F, 0xE0,
  0x7E, 0x07, 0xFC, 0x0F, 0xC1, 0xFF, 0x83, 0xF8, 0x3F, 0xF8, 0x7E, 0x07,
  0xFF, 0x0F, 0xC0, 0xFF, 0xE1, 0xF8, 0x1F, 0xBC, 0x3F, 0x03, 0xF7, 0xCF,
  0xE0, 0xFE, 0xF9, 0xFC, 0x1F, 0x9F, 0x3F, 0x03, 0xF1, 0xE7, 0xE0, 0x7E,
  0x3E, 0xFC, 0x0F, 0xC7, 0xDF, 0x81, 0xF8, 0xFF, 0xF0, 0x7F, 0x0F, 0xFC,
  0x0F, 0xC1, 0xFF, 0x81, 0xF8, 0x3F, 0xF0, 0x3F, 0x07, 0xFE, 0x07, 0xE0,
  0x7F, 0xC1, 0xFC, 0x0F, 0xF8, 0x3F, 0x01, 0xFE, 0x07, 0xE0, 0x3F, 0xC0,
  0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xE1, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F,
  0x80, 0x7F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7E,
  0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xF8, 0x3F, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F,
  0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x03, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F,
  0xF0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC,
  0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0,
  0xFF, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0x7E, 0x07, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8,
  0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0,
  0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80,
  0x1F, 0x83, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07,
  0xE1, 0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8,
  0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0xFE, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x07,
  0xF1, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0x80,
  0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x07, 0xE7, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x03,
  0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0,
  0x7E, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0x7E,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7D, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0x07, 0xDF,
  0x07, 0x83, 0xF7, 0xC3, 0xE0, 0xFD, 0xF0, 0xF8, 0x3E, 0x7C, 0x3E, 0x1F,
  0xBF, 0x0F, 0x87, 0xEF, 0xC7, 0xE1, 0xFB, 0xF1, 0xF8, 0x7C, 0xFC, 0x7E,
  0x3F, 0x3F, 0x3F, 0x8F, 0xCF, 0xCF, 0xE3, 0xE3, 0xF3, 0xF8, 0xF8, 0xFD,
  0xFE, 0x7E, 0x3F, 0x7F, 0x9F, 0x8F, 0xDF, 0xE7, 0xC3, 0xF7, 0xFB, 0xF0,
  0xFB, 0xDE, 0xFC, 0x3E, 0xF7, 0xBE, 0x0F, 0xBD, 0xEF, 0x83, 0xFF, 0x7F,
  0xE0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFC,
  0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE1, 0xFE, 0x03,
  0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xFC,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0x80,
  0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xDF,
  0x80, 0x0F, 0xE7, 0xE0, 0x03, 0xF9, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7E,
  0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0x83,
  0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0xCF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F,
  0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xF0, 0x0F, 0x7C, 0x07, 0xCF, 0x03, 0xE3, 0xC0, 0xF8, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x8F, 0x81, 0xE3, 0xE0, 0x79, 0xF0, 0x1F, 0xFC, 0x07,
  0xFE, 0x01, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xFE, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3C,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xE0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01,
  0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0xC7, 0xF1, 0xFF,
  0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xF1, 0xF8,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x1E, 0x00, 0x7E, 0xFF, 0x80, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xF9, 0xFF, 0x1F, 0xC0,
  0xFE, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x07,
  0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E,
  0xFE, 0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xF0, 0x1F, 0xCF,
  0xE0, 0x7F, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFB,
  0xFF, 0x83, 0xF3, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x8F,
  0xE3, 0xF8, 0x1F, 0xCF, 0xC0, 0x3F, 0x7F, 0x00, 0xFD, 0xF8, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0B, 0xF0, 0x07, 0xC7, 0xE0, 0x3F,
  0x1F, 0x81, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x1E, 0x1F, 0x80, 0x7F, 0xCF, 0xC0, 0x7F, 0xF7,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC7, 0xFC, 0x3F, 0x81,
  0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x0F,
  0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFD, 0xF0, 0x03, 0xFC, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xFC, 0x7F, 0x8F, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x7F, 0x00, 0x7C,
  0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x01, 0x03, 0xF8, 0x0F, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xCF, 0xC0, 0xFF, 0xF7,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0x8F, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xF8,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F,
  0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFB, 0xF0, 0x07, 0xF9, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x04, 0x00, 0xFE, 0x07, 0x00, 0xFE, 0x07, 0xF1, 0xFF,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC3, 0xC0, 0x0F, 0xCF, 0xF0, 0x0F, 0xDF, 0xFC, 0x1F, 0xBF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x1F, 0xF3, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0x0F, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x04, 0x3F,
  0x01, 0xFE, 0x0F, 0xC0, 0xFF, 0x03, 0xF0, 0x7F, 0x81, 0xF8, 0x3F, 0xC0,
  0x7E, 0x1F, 0xE0, 0x1F, 0x8F, 0xF0, 0x07, 0xE7, 0xF8, 0x01, 0xFB, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF7, 0xE0, 0x07,
  0xF9, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x81, 0xFC,
  0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00,
  0x7F, 0x0F, 0xC0, 0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x01,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFC, 0x00, 0x0F, 0x07, 0x01, 0xFB, 0xF3, 0xF0, 0x3E, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0x9F, 0xDF, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x8F, 0xC7, 0xC3, 0xF1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xC3, 0xE1, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x8F, 0xF8, 0x0F, 0x9F, 0xFC, 0x1F,
  0xBF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0x8F, 0xE3, 0xF8, 0x1F,
  0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xE0, 0x3F, 0x9F, 0x81, 0xFC,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFB, 0xFE, 0x00,
  0xFB, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xE7, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7E, 0xFF, 0xE0, 0x3F, 0x3F, 0xC0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFC, 0x7C, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFC, 0x7F, 0xCF, 0xE0, 0x7F,
  0x1F, 0x80, 0x7E, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF7,
  0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF3, 0xF8, 0x0F, 0xC3, 0xF0,
  0x3F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFD,
  0xF0, 0x0F, 0xF7, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x3F, 0x1F, 0xF0,
  0xFD, 0xFF, 0xC3, 0xEF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xE7, 0x87, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x8F, 0xC0, 0x3F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xF9, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F,
  0xCF, 0xF0, 0x7F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xFC, 0xFC, 0x03,
  0xF3, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F,
  0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xE7,
  0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFD, 0xF8, 0x0F, 0xE3,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x3E, 0x01, 0xF8, 0x3E, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x07,
  0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0x9F,
  0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0xF8, 0x3C, 0x1F, 0xFC, 0x3E, 0x1F, 0xBE, 0x1F,
  0x0F, 0xDF, 0x0F, 0x87, 0xCF, 0x8F, 0xC3, 0xE7, 0xC7, 0xE3, 0xF3, 0xE3,
  0xF1, 0xF1, 0xF3, 0xF8, 0xF8, 0xF9, 0xFC, 0xFC, 0x78, 0xEE, 0x7C, 0x3C,
  0xF7, 0x3E, 0x1E, 0x73, 0x9F, 0x0F, 0x79, 0xDF, 0x07, 0xBC, 0xEF, 0x83,
  0xDC, 0x77, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0,
  0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x87, 0xF0,
  0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x0F,
  0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x1F,
  0x87, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x7E, 0x00, 0x3F, 0x83,
  0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7F,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0xF9, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFE, 0x01, 0xE7, 0xFF, 0x80, 0xF7, 0xFF, 0xE0, 0xFB,
  0xFF, 0xFF, 0xFD, 0xF0, 0xFF, 0xFD, 0xF0, 0x3F, 0xFE, 0xF0, 0x07, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x08, 0x00,
};

const GFXglyph RobotoMono_BoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 12, 33, 27, 8, -33 },
  { 51, 15, 12, 27, 8, -35 },
  { 74, 27, 33, 27, 0, -33 },
  { 186, 25, 43, 27, 2, -38 },
  { 321, 22, 34, 27, 3, -33 },
  { 415, 25, 34, 27, 1, -33 },
  { 522, 7, 13, 27, 11, -35 },
  { 534, 16, 46, 27, 7, -36 },
  { 626, 16, 46, 27, 4, -36 },
  { 718, 22, 23, 27, 4, -33 },
  { 782, 23, 24, 27, 2, -27 },
  { 851, 10, 14, 27, 4, -5 },
  { 869, 19, 5, 27, 6, -17 },
  { 881, 9, 8, 27, 7, -8 },
  { 890, 24, 36, 27, 2, -33 },
  { 998, 22, 34, 27, 3, -33 },
  { 1092, 16, 33, 27, 5, -33 },
  { 1158, 24, 33, 27, 0, -33 },
  { 1257, 24, 34, 27, 1, -33 },
  { 1359, 24, 33, 27, 0, -33 },
  { 1458, 24, 34, 27, 2, -33 },
  { 1560, 22, 34, 27, 2, -33 },
  { 1654, 24, 33, 27, 3, -33 },
  { 1753, 24, 34, 27, 1, -33 },
  { 1855, 21, 33, 27, 3, -33 },
  { 1942, 11, 27, 27, 8, -27 },
  { 1980, 14, 36, 27, 6, -27 },
  { 2043, 22, 22, 27, 3, -25 },
  { 2104, 23, 15, 27, 2, -21 },
  { 2148, 22, 22, 27, 2, -25 },
  { 2209, 21, 33, 27, 5, -33 },
  { 2296, 26, 32, 27, 1, -32 },
  { 2400, 26, 33, 27, -2, -33 },
  { 2508, 27, 33, 27, 0, -33 },
  { 2620, 25, 34, 27, 2, -33 },
  { 2727, 26, 33, 27, 0, -33 },
  { 2835, 27, 33, 27, 1, -33 },
  { 2947, 27, 33, 27, 1, -33 },
  { 3059, 24, 34, 27, 2, -33 },
  { 3161, 27, 33, 27, 0, -33 },
  { 3273, 24, 33, 27, 2, -33 },
  { 3372, 25, 34, 27, 2, -33 },
  { 3479, 31, 33, 27, 0, -33 },
  { 3607, 22, 33, 27, 1, -33 },
  { 3698, 28, 33, 27, 0, -33 },
  { 3814, 27, 33, 27, 0, -33 },
  { 3926, 24, 34, 27, 2, -33 },
  { 4028, 26, 33, 27, 1, -33 },
  { 4136, 24, 39, 27, 2, -33 },
  { 4253, 27, 33, 27, 0, -33 },
  { 4365, 26, 33, 27, 1, -33 },
  { 4473, 27, 33, 27, 3, -33 },
  { 4585, 25, 34, 27, 2, -33 },
  { 4692, 25, 33, 27, 4, -33 },
  { 4796, 26, 33, 27, 3, -33 },
  { 4904, 32, 33, 27, -2, -33 },
  { 5036, 26, 33, 27, 4, -33 },
  { 5144, 28, 33, 27, 0, -33 },
  { 5260, 17, 46, 27, 5, -38 },
  { 5358, 11, 36, 27, 9, -33 },
  { 5408, 17, 46, 27, 5, -38 },
  { 5506, 18, 18, 27, 5, -33 },
  { 5547, 21, 5, 27, 0, 0 },
  { 5561, 9, 6, 27, 12, -33 },
  { 5568, 23, 25, 27, 1, -25 },
  { 5640, 23, 36, 27, 1, -35 },
  { 5744, 22, 26, 27, 2, -25 },
  { 5816, 25, 35, 27, 2, -35 },
  { 5926, 23, 25, 27, 2, -25 },
  { 5998, 25, 36, 27, 4, -36 },
  { 6111, 25, 35, 27, 1, -25 },
  { 6221, 24, 35, 27, 1, -35 },
  { 6326, 20, 34, 27, 2, -34 },
  { 6411, 21, 44, 27, 1, -34 },
  { 6527, 26, 35, 27, 1, -35 },
  { 6641, 21, 35, 27, 2, -35 },
  { 6733, 27, 25, 27, -1, -25 },
  { 6818, 24, 25, 27, 1, -25 },
  { 6893, 22, 26, 27, 2, -25 },
  { 6965, 25, 34, 27, -1, -25 },
  { 7072, 23, 34, 27, 2, -25 },
  { 7170, 22, 25, 27, 4, -25 },
  { 7239, 23, 26, 27, 2, -25 },
  { 7314, 21, 31, 27, 4, -30 },
  { 7396, 23, 25, 27, 3, -24 },
  { 7468, 24, 24, 27, 3, -24 },
  { 7540, 25, 24, 27, 3, -24 },
  { 7615, 27, 24, 27, 0, -24 },
  { 7696, 29, 34, 27, 0, -24 },
  { 7820, 26, 24, 27, 0, -24 },
  { 7898, 17, 44, 27, 7, -36 },
  { 7992, 10, 42, 27, 8, -33 },
  { 8045, 18, 44, 27, 4, -36 },
  { 8144, 25, 11, 27, 0, -19 },
};

const GFXfont RobotoMono_BoldItalic46pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic46pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOMONO_BOLDITALIC46PT7B_H_
