#ifndef _ROBOTOMONO_BOLDITALIC72PT7B_H_
#define _ROBOTOMONO_BOLDITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x07,
  0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x60, 0x7F, 0x03, 0xF0, 0x1F, 0x0F,
  0xC0, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x3F,
  0x0F, 0xE0, 0x7F, 0x07, 0xE1, 0xFC, 0x0F, 0xE1, 0xF8, 0x3F, 0x81, 0xFC,
  0x7E, 0x03, 0xF0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xE3, 0xF0, 0x0F, 0xFF,
  0xF8, 0xFC, 0x00, 0xFF, 0xFF, 0x3F, 0x80, 0x1F, 0xFF, 0xC7, 0xE0, 0x01,
  0xFF, 0xF1, 0xF8, 0x00, 0x0F, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x3C, 0x00,
  0x00, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0x9F, 0xFF, 0x00, 0x07, 0xE7, 0xFF,
  0xF0, 0x01, 0xF8, 0xFF, 0xFF, 0x00, 0x7F, 0x3F, 0xFF, 0xE0, 0x0F, 0xCF,
  0xF1, 0xFE, 0x03, 0xF1, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x03, 0xF8, 0x1F,
  0x87, 0xE0, 0x3F, 0x07, 0xE1, 0xFC, 0x0F, 0xE1, 0xF8, 0x3F, 0x81, 0xFC,
  0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xC0, 0xFE, 0x07, 0xF0, 0x10, 0x1F, 0xC0,
  0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xFE, 0x00, 0x00,
  0x7F, 0xDF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0x1F,
  0xFD, 0xFF, 0x81, 0xFF, 0x1F, 0xF8, 0xFF, 0xC1, 0xFE, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFE, 0x7F, 0xF0, 0x7F, 0xE3, 0xFE, 0x7F, 0xE0, 0x3F, 0xF7, 0xFC,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFC, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x7F,
  0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xBF, 0xF0, 0x03, 0xFF,
  0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x7F,
  0x9F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x04, 0x00, 0x7E, 0x00, 0x13,
  0x80, 0x1F, 0x80, 0x18, 0xF8, 0x07, 0xE0, 0x3F, 0x7F, 0xC1, 0xF8, 0x3F,
  0xDF, 0xFC, 0x7C, 0x7F, 0xFF, 0xFF, 0xDF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFE, 0x7E, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF0,
  0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xC1, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0x00, 0x3F, 0xFE,
  0x7F, 0xE0, 0x1F, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xF9, 0xFF, 0x83, 0xFF,
  0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xC7, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0x9F,
  0xFB, 0xFF, 0x3F, 0xF7, 0xFC, 0x7F, 0xE7, 0xFF, 0xFF, 0x0F, 0xFC, 0xFF,
  0xFF, 0x81, 0xFF, 0x1F, 0xFF, 0xE0, 0x3F, 0xE3, 0xFF, 0xF0, 0x07, 0xFC,
  0x7F, 0xFC, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x80,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0x7F,
  0xE3, 0xFC, 0x3F, 0xF1, 0xF0, 0x1F, 0xF9, 0xC0, 0x0F, 0xF8, 0x80, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xC1,
  0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x60, 0x00, 0x00, 0x7F, 0xDF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x00,
  0x08, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFA,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xE7, 0xFF, 0xC0, 0x1F,
  0xF3, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xF0, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFE,
  0x7F, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x07, 0xFD, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0xBF, 0xF0, 0x03, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0xCF, 0xFF, 0x07, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFB, 0xFE, 0x01, 0xFF, 0xFB,
  0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x1F, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0xFE, 0x03, 0xE0, 0x3F, 0x81, 0xFF, 0xE1, 0xF0, 0x1F, 0x81,
  0xFF, 0xF8, 0xF8, 0x1F, 0x83, 0xFF, 0xFC, 0x7C, 0x0F, 0xC1, 0xFF, 0xFE,
  0x3E, 0x0F, 0xC1, 0xFF, 0x3E, 0x1F, 0x87, 0xE1, 0xFC, 0x1F, 0x0F, 0xC7,
  0xE0, 0xFC, 0x0F, 0x87, 0xE3, 0xF0, 0xFE, 0x0F, 0xC3, 0xE1, 0xF0, 0x7E,
  0x07, 0xE1, 0xF1, 0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0xFC, 0x3F, 0x01, 0xF0,
  0x7C, 0x7E, 0x1F, 0x81, 0xF8, 0x3E, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x3F,
  0x0F, 0xC0, 0x7C, 0x1F, 0x9F, 0x87, 0xE0, 0x3E, 0x0F, 0x8F, 0xC3, 0xF0,
  0x3F, 0x07, 0xC7, 0xE1, 0xF8, 0x1F, 0x83, 0xE3, 0xE1, 0xF8, 0x0F, 0x81,
  0xF1, 0xF0, 0xFC, 0x07, 0xC1, 0xF1, 0xF8, 0x7E, 0x07, 0xE0, 0xF8, 0xFC,
  0x3F, 0x83, 0xF0, 0x78, 0x7E, 0x0F, 0xC3, 0xF8, 0x7C, 0x3F, 0x07, 0xE3,
  0xFC, 0x7C, 0x0F, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xC1, 0xFF, 0xFF, 0xFE,
  0x03, 0xF0, 0x7F, 0xEF, 0xFE, 0x01, 0xF8, 0x1F, 0xE3, 0xFE, 0x00, 0xFC,
  0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xE0, 0x7C, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00,
  0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x3F, 0xE1, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xBF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x1F, 0xF8,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00,
  0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xE1,
  0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xE0,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xFF,
  0x1F, 0xF0, 0x0F, 0xFF, 0xFC, 0xFF, 0xC0, 0x3F, 0xFF, 0xF3, 0xFF, 0x00,
  0xFF, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0xFF, 0x3F, 0xF0, 0x0F, 0xFF, 0xFC,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xEF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF7, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x3F, 0xBF, 0xC0,
  0x3F, 0xDF, 0x8F, 0xFF, 0xF0, 0x0F, 0xF7, 0xE7, 0xF7, 0xFC, 0x03, 0xFD,
  0xFD, 0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xFF,
  0x9F, 0xE0, 0x1F, 0xF7, 0xFF, 0xEF, 0xF8, 0x07, 0xFC, 0xFF, 0xF3, 0xFE,
  0x01, 0xFE, 0x3F, 0xFC, 0xFF, 0x80, 0x7F, 0x8F, 0xFE, 0x3F, 0xE0, 0x3F,
  0xE3, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x3F,
  0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x3F, 0xC1, 0xFE, 0x01,
  0xFF, 0x07, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0,
  0x7E, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xC0,
  0x07, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xEF, 0xE0,
  0xFF, 0xC0, 0x3F, 0xE7, 0xF0, 0x7F, 0xE0, 0x3F, 0xF3, 0xF8, 0x3F, 0xF0,
  0x1F, 0xF9, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0x1F, 0xF8, 0x07, 0xFE,
  0x3F, 0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xC7, 0xFE, 0x01, 0xFF, 0x0F, 0xF3,
  0xFF, 0x01, 0xFF, 0x83, 0xF9, 0xFF, 0x00, 0xFF, 0xC1, 0xFC, 0xFF, 0x80,
  0x7F, 0xE0, 0xFE, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF,
  0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0xFF, 0x87,
  0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF,
  0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x3F,
  0xF3, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x7F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFC,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF1,
  0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF,
  0x9F, 0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x7F,
  0xE3, 0xFE, 0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xF3, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3C, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xF9,
  0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0xCF, 0xF0, 0x0F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x03,
  0xFE, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x9F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC7,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x7F, 0xC1,
  0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF8,
  0x3F, 0xE1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x87, 0xFC,
  0x1F, 0xF0, 0xFF, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xF8, 0x7F, 0xC1, 0xFF,
  0x1F, 0xFE, 0x1F, 0xE0, 0x7F, 0xC7, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF,
  0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xF8, 0xFF, 0x81, 0xFF, 0x3F, 0xFE, 0x3F,
  0xC0, 0x7F, 0x8F, 0xFF, 0x9F, 0xF0, 0x1F, 0xE3, 0xFF, 0xE7, 0xFC, 0x07,
  0xF9, 0xFF, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0xFE, 0xFF, 0x80, 0x7F, 0x9F,
  0xBF, 0xBF, 0xE0, 0x1F, 0xEF, 0xEF, 0xEF, 0xF0, 0x07, 0xFB, 0xFB, 0xFB,
  0xFC, 0x01, 0xFE, 0xFC, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xCF, 0xFF, 0xE0, 0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xBF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x07, 0xFC,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x81, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00,
  0xFE, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xE0, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF0,
  0x03, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xE7, 0xFE, 0x00, 0xFF, 0xF0,
  0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x01, 0xFF, 0x1F, 0xFC,
  0x00, 0x0F, 0xF9, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x07, 0xFE,
  0x1F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFE, 0x1F,
  0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF7, 0xFF,
  0xFF, 0x00, 0xFF, 0x9F, 0xFF, 0xF0, 0x07, 0xFC, 0x7F, 0xFF, 0x00, 0x7F,
  0xC1, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87,
  0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xE0, 0x1F, 0xF8,
  0x00, 0x1F, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x1F, 0xF8, 0x00, 0xFF,
  0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFB, 0xFE, 0x00,
  0x03, 0xFF, 0xE3, 0xFC, 0x00, 0x01, 0xFF, 0xC3, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x00,
  0x3F, 0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xE7, 0xFE,
  0x00, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x18, 0x07, 0xFF, 0x00, 0x03, 0xC0, 0x3F, 0xF8, 0x00, 0xFC, 0x03, 0xFF,
  0xE0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x3C, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xFC, 0x00, 0x3F,
  0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xFF, 0x9F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xEF, 0xF8,
  0x00, 0x1F, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x03,
  0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x20, 0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xE0,
  0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x3E, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xFC, 0x00,
  0xFF, 0xCF, 0xFF, 0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00,
  0xFF, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF,
  0xC3, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x80,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8,
  0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFF, 0x00, 0x00,
  0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xFF, 0x00, 0x00, 0x7F, 0xEF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x01, 0xFF, 0x3F, 0xE1, 0xFE, 0x00,
  0xFF, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xBF, 0xFD, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0x83,
  0xFE, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x03,
  0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F,
  0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xE1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE,
  0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFE,
  0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0x87, 0xFF, 0xE0, 0x07,
  0xFC, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x07,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x07, 0xFE,
  0x1F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x0F,
  0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0xFF,
  0xC7, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0x8F, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x3F, 0xFF, 0x80, 0x0F, 0xFC,
  0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x7F, 0xC0, 0x0F, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0xFF, 0xBF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xC3, 0xFF,
  0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFB, 0xFE,
  0x00, 0x07, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xC0, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x7F, 0xFC,
  0x0F, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0x1F, 0xFF, 0xE0, 0x3F, 0xE7, 0xFF,
  0xFC, 0x07, 0xFD, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x0E, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFE, 0x7F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF,
  0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF,
  0x1F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x01,
  0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC3, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF3,
  0xFC, 0x01, 0xFF, 0xFE, 0x3F, 0xC0, 0x0F, 0xFF, 0xC7, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x80,
  0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0xEF,
  0xF0, 0x1F, 0xE0, 0x7F, 0xDF, 0xE0, 0x7F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF,
  0x81, 0xFE, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFE, 0x0F, 0xF1,
  0xFE, 0x0F, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xF8, 0x7F, 0xC7, 0xF8, 0x7F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xE1, 0xFE, 0x1F, 0xE1, 0xFF, 0xC7, 0xFC,
  0x3F, 0xC7, 0xFF, 0x8F, 0xF0, 0x7F, 0x8F, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F,
  0x7E, 0x3F, 0xC1, 0xFE, 0x7E, 0xFC, 0xFF, 0x03, 0xFC, 0xFD, 0xF9, 0xFE,
  0x07, 0xF3, 0xF3, 0xF3, 0xFC, 0x0F, 0xE7, 0xE7, 0xEF, 0xF0, 0x1F, 0xCF,
  0x8F, 0xDF, 0xE0, 0x3F, 0xBF, 0x1F, 0xBF, 0xC0, 0x7F, 0x7E, 0x3F, 0xFF,
  0x00, 0xFE, 0xF8, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x03, 0xFF,
  0xE1, 0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFB,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE1, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0x1F, 0xFF, 0xFC, 0x00, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0xFE, 0x3F,
  0xFF, 0xFF, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFE, 0x7F, 0xC3, 0xFF,
  0xFF, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xFC, 0x7F, 0x00, 0x7F, 0xFF, 0xF8,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x04, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00,
};

const GFXglyph RobotoMono_BoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 19, 52, 42, 12, -51 },
  { 125, 24, 19, 42, 12, -54 },
  { 182, 42, 51, 42, 0, -51 },
  { 450, 38, 66, 42, 3, -59 },
  { 764, 35, 53, 42, 4, -52 },
  { 996, 40, 53, 42, 1, -52 },
  { 1261, 10, 19, 42, 18, -54 },
  { 1285, 24, 73, 42, 11, -57 },
  { 1504, 25, 73, 42, 6, -57 },
  { 1733, 34, 36, 42, 6, -51 },
  { 1886, 36, 37, 42, 3, -42 },
  { 2053, 15, 23, 42, 7, -9 },
  { 2097, 30, 8, 42, 9, -27 },
  { 2127, 13, 13, 42, 12, -12 },
  { 2149, 37, 55, 42, 3, -51 },
  { 2404, 35, 53, 42, 4, -52 },
  { 2636, 25, 51, 42, 8, -51 },
  { 2796, 38, 52, 42, 0, -52 },
  { 3043, 38, 53, 42, 2, -52 },
  { 3295, 37, 51, 42, 1, -51 },
  { 3531, 38, 52, 42, 3, -51 },
  { 3778, 34, 53, 42, 3, -52 },
  { 4004, 38, 51, 42, 4, -51 },
  { 4247, 37, 53, 42, 2, -52 },
  { 4493, 33, 52, 42, 5, -52 },
  { 4708, 18, 42, 42, 12, -41 },
  { 4803, 23, 55, 42, 9, -41 },
  { 4962, 34, 34, 42, 5, -39 },
  { 5107, 37, 23, 42, 3, -33 },
  { 5214, 34, 34, 42, 3, -39 },
  { 5359, 32, 53, 42, 9, -52 },
  { 5571, 41, 51, 42, 1, -51 },
  { 5833, 41, 51, 42, -3, -51 },
  { 6095, 41, 51, 42, 1, -51 },
  { 6357, 38, 53, 42, 3, -52 },
  { 6609, 39, 51, 42, 1, -51 },
  { 6858, 43, 51, 42, 1, -51 },
  { 7133, 43, 51, 42, 1, -51 },
  { 7408, 38, 53, 42, 3, -52 },
  { 7660, 42, 51, 42, 1, -51 },
  { 7928, 38, 51, 42, 3, -51 },
  { 8171, 41, 52, 42, 2, -51 },
  { 8438, 47, 51, 42, 1, -51 },
  { 8738, 35, 51, 42, 1, -51 },
  { 8962, 42, 51, 42, 1, -51 },
  { 9230, 41, 51, 42, 1, -51 },
  { 9492, 38, 53, 42, 3, -52 },
  { 9744, 41, 51, 42, 1, -51 },
  { 10006, 39, 61, 42, 2, -52 },
  { 10304, 41, 51, 42, 1, -51 },
  { 10566, 40, 53, 42, 2, -52 },
  { 10831, 41, 51, 42, 5, -51 },
  { 11093, 40, 52, 42, 3, -51 },
  { 11353, 40, 51, 42, 6, -51 },
  { 11608, 42, 51, 42, 4, -51 },
  { 11876, 49, 51, 42, -3, -51 },
  { 12189, 40, 51, 42, 7, -51 },
  { 12444, 43, 51, 42, 0, -51 },
  { 12719, 27, 71, 42, 8, -59 },
  { 12959, 17, 55, 42, 14, -51 },
  { 13076, 27, 71, 42, 8, -59 },
  { 13316, 28, 27, 42, 8, -51 },
  { 13411, 33, 8, 42, 0, 0 },
  { 13444, 15, 10, 42, 19, -52 },
  { 13463, 35, 40, 42, 2, -39 },
  { 13638, 37, 55, 42, 1, -54 },
  { 13893, 35, 40, 42, 3, -39 },
  { 14068, 40, 55, 42, 3, -54 },
  { 14343, 36, 40, 42, 3, -39 },
  { 14523, 39, 56, 42, 6, -56 },
  { 14796, 39, 54, 42, 1, -39 },
  { 15060, 37, 54, 42, 1, -54 },
  { 15310, 31, 53, 42, 4, -53 },
  { 15516, 33, 68, 42, 2, -53 },
  { 15797, 41, 54, 42, 1, -54 },
  { 16074, 33, 54, 42, 3, -54 },
  { 16297, 41, 39, 42, -1, -39 },
  { 16497, 37, 39, 42, 1, -39 },
  { 16678, 35, 40, 42, 3, -39 },
  { 16853, 39, 54, 42, -1, -39 },
  { 17117, 37, 54, 42, 3, -39 },
  { 17367, 35, 39, 42, 6, -39 },
  { 17538, 36, 40, 42, 3, -39 },
  { 17718, 33, 48, 42, 6, -47 },
  { 17916, 36, 39, 42, 4, -38 },
  { 18092, 37, 38, 42, 5, -38 },
  { 18268, 39, 38, 42, 4, -38 },
  { 18454, 44, 38, 42, -1, -38 },
  { 18663, 45, 53, 42, 0, -38 },
  { 18962, 40, 38, 42, 1, -38 },
  { 19152, 28, 69, 42, 10, -56 },
  { 19394, 16, 65, 42, 13, -51 },
  { 19524, 27, 69, 42, 7, -56 },
  { 19757, 40, 16, 42, 0, -29 },
};

const GFXfont RobotoMono_BoldItalic72pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic72pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _ROBOTOMONO_BOLDITALIC72PT7B_H_
