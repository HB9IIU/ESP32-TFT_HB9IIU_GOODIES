#ifndef _ROBOTOMONO_BOLDITALIC31PT7B_H_
#define _ROBOTOMONO_BOLDITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0x70, 0x71,
  0xDC, 0x77, 0x1D, 0xC7, 0x61, 0xB8, 0xEE, 0x3B, 0x8E, 0x00, 0x73, 0x80,
  0x38, 0xE0, 0x0E, 0x30, 0x03, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0x81, 0xFF,
  0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xC0, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xE0,
  0x06, 0x38, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x1C, 0x60, 0x07,
  0x38, 0x03, 0x8E, 0x00, 0xE3, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xFC, 0x3E, 0x1E, 0x1E, 0x0F, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0x9F, 0x03, 0xCF, 0x81, 0xE3, 0xC0, 0xF1, 0xF1, 0xF8,
  0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0xFE, 0x03, 0x9C, 0x27, 0x18, 0xEE, 0x31, 0x9C, 0xE7,
  0x39, 0xDC, 0x7F, 0x30, 0x7C, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xDF, 0x83, 0x7F, 0x0E, 0xE7, 0x3B, 0x8E, 0xE7, 0x1C, 0x8E,
  0x38, 0x1E, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0xE0, 0x1E, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x3D,
  0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0x0F, 0x3F, 0xE3,
  0xCF, 0x7C, 0xE7, 0x8F, 0x79, 0xE3, 0xFE, 0x78, 0x7F, 0x1E, 0x1F, 0x87,
  0x87, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xF3, 0xE0, 0x77, 0xFE, 0xEE,
  0xEE, 0x00, 0x40, 0x30, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x3C,
  0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xC0, 0x20, 0x04, 0x00, 0xC0, 0x1C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC1, 0xF0, 0x1C, 0x02,
  0x00, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x02, 0x1C, 0x2F, 0x33,
  0xFF, 0xFF, 0x9F, 0xFF, 0x03, 0xC0, 0x0F, 0x80, 0x3B, 0x00, 0xE7, 0x03,
  0xC7, 0x0F, 0x0F, 0x04, 0x18, 0x00, 0x20, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xFE, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x1E, 0x78, 0xF1, 0xE3, 0xC7, 0x1E, 0x38, 0xF0, 0xC0,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC1, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F,
  0x78, 0x7E, 0xF1, 0xFF, 0xEF, 0xF7, 0xBD, 0xEF, 0xE3, 0xDF, 0x87, 0xBC,
  0x0F, 0x78, 0x3E, 0xF0, 0x79, 0xE0, 0xF3, 0xE3, 0xC3, 0xFF, 0x87, 0xFE,
  0x03, 0xF0, 0x00, 0x00, 0xC1, 0xF1, 0xFF, 0xFF, 0xFF, 0xBD, 0xEC, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0xC3, 0xE3, 0xE1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE,
  0x1F, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFE, 0x03, 0xDE, 0x07, 0x9E, 0x0F, 0x1E, 0x0E, 0x3C,
  0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x07, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0x87, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0xF0, 0x3C, 0x7C, 0x1E,
  0x1E, 0x1F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x03,
  0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x70,
  0x7B, 0xF8, 0xFF, 0xF9, 0xFF, 0xF3, 0xE1, 0xF7, 0x81, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0x78, 0x3C, 0xF0, 0x79, 0xF1, 0xF1, 0xFF, 0xC3, 0xFF,
  0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x80, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x03,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0x1F, 0x1E, 0x1F, 0x3C, 0x0F, 0x3C,
  0x1F, 0x3E, 0x1E, 0x1E, 0x3E, 0x1F, 0xFC, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E,
  0xFC, 0x78, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8,
  0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0xE0, 0x7F, 0xE3, 0xFF,
  0x8F, 0x1F, 0x78, 0x3D, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x87, 0xDF, 0x3F, 0x7F, 0xFC, 0xFE, 0xE0, 0xF7, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0xFE, 0x0F, 0xF0, 0x7F, 0x01, 0xF0, 0x00, 0x1E, 0x1F,
  0x3F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0xFC, 0xFC, 0xFC, 0x78, 0x07, 0x83, 0xE0, 0xFC, 0x3E, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x70,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x38, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0xCF, 0xFC, 0x1F, 0xC0, 0x7C,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x0E,
  0x00, 0x04, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFC, 0x20,
  0x00, 0x70, 0x00, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0x80, 0x0F, 0x00, 0xFE, 0x1F, 0xF9, 0xFF, 0x83, 0xFC, 0x07, 0xC0, 0x1E,
  0x00, 0x20, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBE, 0x3E, 0xF0,
  0x7B, 0xC1, 0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0x81, 0xC0, 0xE1, 0xC0, 0x31, 0xCF, 0xDC, 0xCF, 0xE6, 0xE7, 0x33,
  0x67, 0x39, 0xF3, 0x19, 0xFB, 0x8C, 0xF9, 0xC6, 0x6C, 0xE7, 0x36, 0x63,
  0x9B, 0x39, 0x99, 0x9F, 0xFC, 0xC7, 0xBC, 0x70, 0x00, 0x38, 0x00, 0x0F,
  0x18, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xB8, 0x03, 0xDC, 0x03,
  0xCF, 0x01, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0, 0x78, 0x78,
  0x7F, 0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0x9E, 0x03, 0xDF, 0x01, 0xEF, 0x00,
  0xF7, 0x80, 0x7F, 0x80, 0x3C, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3C, 0x7F, 0x1F, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x1E,
  0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3C, 0x1F, 0x0F, 0x03,
  0xE3, 0xC0, 0x79, 0xF0, 0x1E, 0x78, 0x0F, 0x9E, 0x03, 0xC7, 0x87, 0xF1,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0xC3, 0xE3, 0xE3, 0xE0, 0xF1, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x3C, 0xF0, 0x1E, 0x3C, 0x1F, 0x1F, 0x1F, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF,
  0x83, 0xE7, 0xE1, 0xE0, 0xF8, 0xF0, 0x7C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E,
  0x07, 0x9F, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x7C,
  0xF0, 0x3C, 0xF8, 0x3E, 0x78, 0x1E, 0x3C, 0x1F, 0x1E, 0x7F, 0x0F, 0xFF,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x23,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xFF, 0xF8, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xE3, 0xE3, 0xE0, 0xF1, 0xE0, 0x3C, 0xF0, 0x1E,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x1F, 0xEF, 0x8F,
  0xF7, 0x87, 0xFB, 0xC0, 0x79, 0xE0, 0x3C, 0xF8, 0x1E, 0x3C, 0x0F, 0x1F,
  0x1F, 0x87, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0x03, 0xC3, 0xC0,
  0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x1E, 0x1E, 0x07, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3C,
  0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x1E, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3C, 0x0F, 0x80, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x10, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x79, 0x00, 0x3C, 0xF0, 0x3E, 0x7C, 0x1E, 0x1E, 0x3F, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0x01, 0xF8, 0x78, 0x1F, 0x03, 0xC1,
  0xF0, 0x1E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x1F, 0x80, 0x78, 0xF8, 0x03,
  0xCF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xBC, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x78,
  0x3C, 0x03, 0xC1, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xF0,
  0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E,
  0x3F, 0x0F, 0xC7, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xF0, 0xEF,
  0xDC, 0x1D, 0xFB, 0x87, 0xBE, 0xF0, 0xF7, 0xDE, 0x1E, 0xF3, 0xC3, 0xDE,
  0x78, 0x79, 0x8E, 0x0E, 0x33, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01,
  0xE1, 0xE0, 0x38, 0x3C, 0x0F, 0x07, 0x01, 0xE1, 0xE0, 0x3C, 0x00, 0x0F,
  0x03, 0xC3, 0xE0, 0xF0, 0xF8, 0x3C, 0x7E, 0x0F, 0x1F, 0x87, 0x87, 0xE1,
  0xE1, 0xFC, 0x78, 0x7F, 0x1E, 0x1F, 0xC7, 0x8F, 0xF3, 0xE3, 0xCE, 0xF0,
  0xF3, 0xBC, 0x3C, 0xEF, 0x0F, 0x3B, 0xC3, 0xC7, 0xF1, 0xF1, 0xFC, 0x78,
  0x7E, 0x1E, 0x1F, 0x87, 0x83, 0xE1, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F,
  0x80, 0x03, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xE3, 0xE3, 0xE0, 0xF1,
  0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0x9E, 0x03,
  0xDF, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x7D, 0xE0, 0x3C, 0xF0,
  0x1E, 0x3C, 0x1E, 0x1F, 0x1F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00,
  0x1F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xC3, 0xF1, 0xE0, 0x79, 0xF0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0x8F, 0xDF, 0xCF,
  0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xE3, 0xE3, 0xE0, 0xF1, 0xE0, 0x78,
  0xF0, 0x3E, 0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x01,
  0xEF, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x7D, 0xE0, 0x3C, 0xF0, 0x1E, 0x3C,
  0x1E, 0x1F, 0x1F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3C, 0x7F, 0x1F, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x0F, 0x1E, 0x07, 0xCF, 0x83, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFE, 0x03, 0xC7, 0xC1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1F, 0x3E, 0x03, 0xC0, 0x03, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x01, 0xF0, 0x00, 0x79, 0xE0, 0x1E, 0xF0, 0x1F, 0x7C, 0x0F, 0x1F,
  0x0F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x07,
  0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x78, 0xF0,
  0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7,
  0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x3C, 0x3C, 0x1E,
  0x1F, 0x1F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0xF0, 0x0F, 0xF8,
  0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x03, 0xE7, 0xC1, 0xE3, 0xE1, 0xF0,
  0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x07, 0x9E,
  0x03, 0xDF, 0x00, 0xEF, 0x00, 0x77, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF1, 0xC3, 0xFC, 0x71,
  0xEF, 0x1C, 0x7B, 0xCF, 0x1E, 0xF3, 0xC7, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xDF, 0x3C, 0xF7, 0xCE, 0x3D, 0xF7, 0x8F, 0xED, 0xE3, 0xFB, 0x70, 0xFE,
  0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x00, 0x0F, 0x80,
  0xF8, 0x7C, 0x0F, 0x81, 0xE0, 0xF8, 0x0F, 0x87, 0x80, 0x7C, 0x7C, 0x01,
  0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0xF8, 0xF8, 0x0F, 0x83, 0xC0,
  0x7C, 0x1E, 0x07, 0xC0, 0xF8, 0x7C, 0x03, 0xC0, 0xF0, 0x0F, 0xFC, 0x07,
  0x9E, 0x07, 0xCF, 0x07, 0xC7, 0x83, 0xC3, 0xE3, 0xE0, 0xF1, 0xE0, 0x79,
  0xF0, 0x3C, 0xF0, 0x0E, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x0F, 0xE1, 0xF8, 0x3F, 0x00, 0xF1, 0xE3, 0xC7, 0x87, 0x0E,
  0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x38, 0x78,
  0xF1, 0xE3, 0xC7, 0x87, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x0F, 0xE1, 0xFC, 0x3F, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0x70, 0x73, 0x83, 0x8E,
  0x38, 0x73, 0xC3, 0x9C, 0x1D, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0xE3, 0xC7, 0x01, 0xC0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFB, 0xE3,
  0xC3, 0xE6, 0x83, 0xC0, 0x07, 0x87, 0xFF, 0x3F, 0xFC, 0xFE, 0x7B, 0xE0,
  0xF7, 0x81, 0xEF, 0x07, 0xDE, 0x1F, 0xBF, 0xFE, 0x3F, 0xFC, 0x3F, 0x7C,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x1C, 0x1E, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0xF8, 0x79, 0xE0, 0xF7, 0xC1,
  0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x7F, 0xE0, 0xF7,
  0xE3, 0xEF, 0xFF, 0x9F, 0xFE, 0x39, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC1, 0xE7, 0x83, 0xCF, 0x8F, 0x8F, 0xFE,
  0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x0E, 0x3C, 0x1F, 0xDE, 0x1F, 0xFF, 0x1F,
  0xFF, 0x8F, 0x87, 0x8F, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x79,
  0xF0, 0x7C, 0xF0, 0x3C, 0x7C, 0x1E, 0x1E, 0x0F, 0x0F, 0x9F, 0x87, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7C, 0xE0, 0x00, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F,
  0xFE, 0x3E, 0x1E, 0x7C, 0x0E, 0x78, 0x0F, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFE, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x08, 0x7C, 0x38, 0x3F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xF7, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x01, 0xC0, 0x03, 0xFB, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1,
  0xF0, 0xF9, 0xF0, 0x7C, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x07,
  0x9F, 0x03, 0xCF, 0x83, 0xE3, 0xC1, 0xE1, 0xF1, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0xDE, 0x00, 0x1E, 0x08, 0x0F, 0x0E, 0x0F, 0x8F, 0xFF, 0x83,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0xE0, 0x3D, 0xFC, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0x83, 0xC7, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x78,
  0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x07, 0x9E, 0x07, 0x8F, 0x03,
  0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xE0, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x7C,
  0x01, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x02, 0x78, 0x3E, 0x3C, 0x3E, 0x1E, 0x3E, 0x0F,
  0x3E, 0x07, 0xBE, 0x07, 0xBE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7C, 0xF8, 0x3C, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0xC7, 0x83,
  0xE3, 0xC0, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC6, 0x1F, 0xF7,
  0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xCE, 0x79, 0xCF, 0x3D, 0xE7, 0x9E, 0xF3,
  0xCF, 0x79, 0xE7, 0xBC, 0xF3, 0x9C, 0x71, 0xDE, 0x79, 0xEF, 0x3C, 0xF7,
  0x9E, 0x7B, 0xCF, 0x3D, 0xE7, 0x1C, 0xE3, 0x9E, 0x00, 0x00, 0x38, 0x0F,
  0x7F, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0xF1, 0xF0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xCF, 0x81, 0xE7, 0x81,
  0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x00, 0x01, 0xC0,
  0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3C, 0x3E, 0x7C, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0x78, 0x3C,
  0x7C, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x18, 0x07, 0xBF,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xF8, 0xF8, 0x78, 0x3C, 0x78, 0x1E, 0x3C,
  0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1,
  0xF0, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3D, 0xF8, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x0F,
  0xEF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3E, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C, 0x78, 0x3C, 0x7C,
  0x7C, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3C, 0x79, 0xFC, 0xF7,
  0xF1, 0xFF, 0xE3, 0xFD, 0xC7, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0x3E, 0x3C,
  0x1F, 0x3C, 0x0F, 0x3C, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0xFC, 0x00, 0x3E, 0xF0, 0x1E, 0xF8, 0x3C, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0x87, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x10, 0xFF, 0xC1, 0xFF, 0x03, 0xFC,
  0x7C, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x83, 0xFF, 0x07, 0xBC,
  0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xF7, 0x83, 0xCF, 0x8F,
  0x9F, 0xFF, 0x1F, 0xDE, 0x1F, 0x3C, 0xF0, 0x1F, 0x78, 0x1E, 0x78, 0x3E,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x38, 0x78, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3D, 0xE0, 0x1D, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x0F, 0x00, 0xE3, 0x87, 0xF1, 0xC7, 0xB8, 0xF3, 0xDC, 0xF9, 0xCE, 0x7D,
  0xE7, 0x3E, 0xF3, 0xBF, 0x71, 0xDB, 0xF8, 0xED, 0xFC, 0x7E, 0xFC, 0x3E,
  0x7E, 0x1F, 0x3F, 0x0F, 0x9F, 0x07, 0x8F, 0x83, 0xC7, 0xC1, 0xE3, 0xC0,
  0x1E, 0x07, 0xC3, 0xC3, 0xE0, 0xF1, 0xF0, 0x1E, 0x78, 0x07, 0xBE, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x7D, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x87, 0xC1, 0xE3, 0xE0, 0x7C,
  0x3E, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xC1, 0xE0, 0xF8,
  0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x79, 0xF0, 0x0F, 0x3C, 0x00, 0xEF, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xFF,
  0xF9, 0xFF, 0xF9, 0xFF, 0xFC, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x1F,
  0x07, 0xE0, 0x78, 0x0F, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x06, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x70, 0xE1,
  0x83, 0x06, 0x1C, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0xC1,
  0x87, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3F, 0x01,
  0xF0, 0x3F, 0x07, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x00,
  0x00, 0x1F, 0x81, 0x9F, 0xE0, 0xEF, 0xFC, 0xFF, 0x1F, 0xF7, 0x07, 0xF8,
  0x01, 0xF8,
};

const GFXglyph RobotoMono_BoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 8, 22, 18, 5, -22 },
  { 23, 10, 8, 18, 5, -23 },
  { 33, 18, 22, 18, 0, -22 },
  { 83, 17, 29, 18, 1, -26 },
  { 145, 15, 22, 18, 2, -22 },
  { 187, 18, 22, 18, 0, -22 },
  { 237, 4, 8, 18, 8, -23 },
  { 241, 10, 32, 18, 5, -25 },
  { 281, 11, 32, 18, 2, -25 },
  { 325, 15, 16, 18, 2, -22 },
  { 355, 16, 16, 18, 1, -18 },
  { 387, 7, 10, 18, 3, -4 },
  { 396, 13, 3, 18, 4, -11 },
  { 401, 6, 5, 18, 5, -5 },
  { 405, 16, 24, 18, 1, -22 },
  { 453, 15, 22, 18, 2, -22 },
  { 495, 10, 22, 18, 4, -22 },
  { 523, 17, 22, 18, 0, -22 },
  { 570, 16, 22, 18, 1, -22 },
  { 614, 16, 22, 18, 0, -22 },
  { 658, 17, 22, 18, 1, -22 },
  { 705, 15, 22, 18, 1, -22 },
  { 747, 16, 22, 18, 2, -22 },
  { 791, 16, 22, 18, 1, -22 },
  { 835, 14, 22, 18, 2, -22 },
  { 874, 8, 18, 18, 5, -18 },
  { 892, 10, 24, 18, 4, -18 },
  { 922, 15, 15, 18, 2, -17 },
  { 951, 16, 10, 18, 1, -14 },
  { 971, 15, 15, 18, 1, -17 },
  { 1000, 14, 22, 18, 4, -22 },
  { 1039, 17, 22, 18, 1, -22 },
  { 1086, 17, 22, 18, -1, -22 },
  { 1133, 18, 22, 18, 0, -22 },
  { 1183, 17, 22, 18, 1, -22 },
  { 1230, 17, 22, 18, 0, -22 },
  { 1277, 18, 22, 18, 1, -22 },
  { 1327, 18, 22, 18, 1, -22 },
  { 1377, 17, 22, 18, 1, -22 },
  { 1424, 18, 22, 18, 0, -22 },
  { 1474, 16, 22, 18, 1, -22 },
  { 1518, 17, 22, 18, 1, -22 },
  { 1565, 21, 22, 18, 0, -22 },
  { 1623, 14, 22, 18, 1, -22 },
  { 1662, 19, 22, 18, 0, -22 },
  { 1715, 18, 22, 18, 0, -22 },
  { 1765, 17, 22, 18, 1, -22 },
  { 1812, 17, 22, 18, 1, -22 },
  { 1859, 17, 26, 18, 1, -22 },
  { 1915, 18, 22, 18, 0, -22 },
  { 1965, 17, 22, 18, 1, -22 },
  { 2012, 18, 22, 18, 2, -22 },
  { 2062, 17, 22, 18, 1, -22 },
  { 2109, 17, 22, 18, 3, -22 },
  { 2156, 18, 22, 18, 2, -22 },
  { 2206, 21, 22, 18, -1, -22 },
  { 2264, 17, 22, 18, 3, -22 },
  { 2311, 19, 22, 18, 0, -22 },
  { 2364, 11, 31, 18, 4, -26 },
  { 2407, 7, 24, 18, 6, -22 },
  { 2428, 11, 31, 18, 4, -26 },
  { 2471, 13, 12, 18, 3, -22 },
  { 2491, 14, 3, 18, 0, 0 },
  { 2497, 6, 4, 18, 8, -22 },
  { 2500, 15, 17, 18, 1, -17 },
  { 2532, 15, 23, 18, 1, -23 },
  { 2576, 15, 17, 18, 1, -17 },
  { 2608, 17, 23, 18, 1, -23 },
  { 2657, 16, 17, 18, 1, -17 },
  { 2691, 16, 24, 18, 3, -24 },
  { 2739, 17, 24, 18, 0, -17 },
  { 2790, 17, 23, 18, 0, -23 },
  { 2839, 13, 23, 18, 2, -23 },
  { 2877, 14, 30, 18, 1, -23 },
  { 2930, 17, 23, 18, 1, -23 },
  { 2979, 14, 23, 18, 1, -23 },
  { 3020, 17, 17, 18, 0, -17 },
  { 3057, 17, 17, 18, 0, -17 },
  { 3094, 16, 17, 18, 1, -17 },
  { 3128, 17, 23, 18, -1, -17 },
  { 3177, 16, 23, 18, 1, -17 },
  { 3223, 15, 17, 18, 3, -17 },
  { 3255, 16, 17, 18, 1, -17 },
  { 3289, 14, 20, 18, 3, -20 },
  { 3324, 15, 16, 18, 2, -16 },
  { 3354, 16, 16, 18, 2, -16 },
  { 3386, 17, 16, 18, 2, -16 },
  { 3420, 18, 16, 18, 0, -16 },
  { 3456, 19, 23, 18, 0, -16 },
  { 3511, 17, 16, 18, 0, -16 },
  { 3545, 12, 29, 18, 4, -24 },
  { 3589, 7, 28, 18, 5, -22 },
  { 3614, 12, 30, 18, 3, -24 },
  { 3659, 17, 7, 18, 0, -13 },
};

const GFXfont RobotoMono_BoldItalic31pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic31pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOMONO_BOLDITALIC31PT7B_H_
