#ifndef _ROBOTOMONO_BOLDITALIC20PT7B_H_
#define _ROBOTOMONO_BOLDITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x63, 0x8E, 0x38, 0xC3, 0x0C, 0x70, 0x00, 0x18, 0xF1, 0x80,
  0x66, 0xCD, 0x92, 0x6C, 0xC0, 0x06, 0x60, 0x66, 0x06, 0xC0, 0xCC, 0x3F,
  0xF3, 0xFE, 0x19, 0x81, 0x90, 0xFF, 0xCF, 0xFC, 0x32, 0x02, 0x60, 0x66,
  0x06, 0xC0, 0x03, 0x00, 0x40, 0x7E, 0x1F, 0xE3, 0x9C, 0xE1, 0x9C, 0x01,
  0xC0, 0x1E, 0x01, 0xF0, 0x0E, 0x00, 0xCE, 0x19, 0xC7, 0x1F, 0xE1, 0xF0,
  0x18, 0x03, 0x00, 0x78, 0x33, 0x2C, 0xDB, 0x34, 0xFB, 0x1D, 0x80, 0xC0,
  0x30, 0x1B, 0x8D, 0xF2, 0xCD, 0xB3, 0x0F, 0xC1, 0xE0, 0x0F, 0x83, 0xF8,
  0x67, 0x0C, 0xE1, 0xB8, 0x3E, 0x07, 0x81, 0xF3, 0x76, 0x6C, 0xFF, 0x8F,
  0x71, 0xE7, 0xFC, 0x7D, 0xC0, 0x6F, 0x6C, 0x02, 0x1C, 0x70, 0xC3, 0x06,
  0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xC0, 0xC1,
  0x80, 0x10, 0xE1, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1C, 0x71,
  0x8E, 0x31, 0xCE, 0x30, 0x0C, 0x06, 0x23, 0x3D, 0x7F, 0xF8, 0xC0, 0xF0,
  0xCC, 0xC6, 0x22, 0x00, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0xFF, 0xFF, 0xFF,
  0xF8, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x37, 0x76, 0xEC, 0xFF, 0xFF, 0x7F,
  0x70, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C,
  0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x00, 0x1F, 0x8F, 0xE3, 0x1D,
  0xC7, 0x71, 0xD8, 0xF6, 0xFF, 0xE6, 0xF1, 0xB8, 0xEE, 0x3B, 0x8C, 0x7F,
  0x0F, 0x80, 0x06, 0x7D, 0xFF, 0x70, 0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x60,
  0xC3, 0x87, 0x00, 0x0F, 0x87, 0xF8, 0xE3, 0xB8, 0x70, 0x0C, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFD, 0xFF, 0x80, 0x1F,
  0x8F, 0xF7, 0x1C, 0x07, 0x01, 0xC0, 0xE1, 0xF0, 0x7C, 0x03, 0x80, 0xEC,
  0x3B, 0x8E, 0xFF, 0x1F, 0x80, 0x01, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0xDC,
  0x3B, 0x0E, 0x61, 0x8C, 0x63, 0xBF, 0xFB, 0xFF, 0x01, 0x80, 0x30, 0x0E,
  0x00, 0x3F, 0xCF, 0xF3, 0x00, 0xC0, 0x70, 0x1F, 0xC7, 0xF8, 0x8E, 0x01,
  0x80, 0xEC, 0x3B, 0x8E, 0xFF, 0x0F, 0x80, 0x07, 0x8F, 0x8F, 0x0E, 0x07,
  0x03, 0xFB, 0xFF, 0xC7, 0xE1, 0xF0, 0xF8, 0xFC, 0x77, 0xF1, 0xF0, 0x7F,
  0xEF, 0xF8, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x00, 0x1F, 0x8F, 0xE7, 0x1D, 0xC7,
  0x71, 0xCE, 0xE3, 0xF1, 0xFC, 0xE3, 0xB0, 0xEC, 0x3B, 0x9E, 0xFF, 0x1F,
  0x80, 0x1F, 0x0F, 0xE7, 0x19, 0x87, 0xE1, 0xF8, 0x76, 0x39, 0xFE, 0x3F,
  0x80, 0xE0, 0x70, 0x38, 0x7C, 0x1E, 0x00, 0x39, 0xCE, 0x00, 0x00, 0x00,
  0x77, 0x9C, 0x3C, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x18, 0xE3,
  0x08, 0x00, 0x00, 0x40, 0xF0, 0xF9, 0xF8, 0x70, 0x3C, 0x03, 0xE0, 0x3E,
  0x03, 0x00, 0x20, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x40,
  0x38, 0x1F, 0x03, 0xE0, 0x38, 0x3C, 0xFD, 0xF0, 0xE0, 0x40, 0x00, 0x3F,
  0x3F, 0xD8, 0xF0, 0x30, 0x38, 0x38, 0x38, 0x38, 0x18, 0x0C, 0x00, 0x06,
  0x03, 0x81, 0x80, 0x07, 0xC0, 0xCE, 0x18, 0x23, 0x7A, 0x6E, 0xB6, 0xDB,
  0x59, 0xA5, 0x92, 0xD9, 0x6D, 0xB4, 0x4D, 0xC6, 0x00, 0x72, 0x03, 0xE0,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x06, 0xC0, 0xEC, 0x0C, 0xE1, 0xCE,
  0x1C, 0xE3, 0xFE, 0x3F, 0xE7, 0x06, 0x70, 0x6E, 0x07, 0x1F, 0xC3, 0xFE,
  0x38, 0x73, 0x87, 0x38, 0x63, 0x0E, 0x3F, 0xC7, 0xFC, 0x70, 0xE7, 0x0E,
  0x60, 0xE6, 0x1C, 0xFF, 0xCF, 0xF0, 0x1F, 0x87, 0xF9, 0xC7, 0x30, 0x6E,
  0x03, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x0B, 0x86, 0x71, 0xC7, 0xF0,
  0x7C, 0x00, 0x1F, 0x87, 0xF8, 0xE7, 0x9C, 0x73, 0x8E, 0x61, 0xDC, 0x3B,
  0x87, 0x70, 0xEE, 0x19, 0x87, 0x31, 0xCF, 0xF1, 0xFC, 0x00, 0x1F, 0xF1,
  0xFF, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3F, 0xC3, 0xFC, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x7F, 0xCF, 0xFC, 0x1F, 0xF1, 0xFF, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x3F, 0xC3, 0xFC, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0x1F, 0x8F, 0xF7, 0x1D, 0xC3, 0x60, 0x38, 0x0E,
  0x03, 0x9F, 0xE7, 0xF0, 0x7E, 0x1B, 0x8E, 0x7F, 0x8F, 0xC0, 0x38, 0x73,
  0x87, 0x38, 0x63, 0x86, 0x30, 0xE3, 0x0E, 0x7F, 0xE7, 0xFC, 0x70, 0xC7,
  0x1C, 0x61, 0xC6, 0x1C, 0xE1, 0xCE, 0x18, 0x3F, 0xCF, 0xF0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xFF, 0x3F,
  0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x33, 0x0E, 0x73, 0xCF, 0xF0, 0xFC, 0x00, 0x18, 0x79, 0xC7,
  0x8E, 0x78, 0x73, 0x83, 0xB8, 0x1B, 0x80, 0xFC, 0x0F, 0xE0, 0x7B, 0x03,
  0x9C, 0x18, 0xE0, 0xC3, 0x8E, 0x1C, 0x70, 0x70, 0x1C, 0x06, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1C, 0xF3, 0xCF, 0x3D, 0xF3, 0xDE, 0x35, 0xE3, 0x76, 0x77,
  0x67, 0x6E, 0x76, 0xE6, 0x0C, 0x60, 0xC6, 0x0C, 0xE1, 0xCE, 0x1C, 0x38,
  0x73, 0xC6, 0x3C, 0x63, 0xCE, 0x3C, 0xE3, 0x6E, 0x76, 0xE7, 0x6C, 0x76,
  0xC7, 0x3C, 0x63, 0xC6, 0x3C, 0xE3, 0xCE, 0x18, 0x1F, 0x8F, 0xE7, 0x1D,
  0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x7E, 0x3B, 0x8E, 0x7F,
  0x0F, 0x80, 0x1F, 0xC1, 0xFE, 0x38, 0x73, 0x87, 0x38, 0x73, 0x86, 0x31,
  0xE3, 0xFC, 0x7F, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x1F,
  0x8F, 0xF7, 0x1D, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7E,
  0x1B, 0x8E, 0x7F, 0x0F, 0xC0, 0x38, 0x06, 0x01, 0x00, 0x1F, 0xC3, 0xFE,
  0x38, 0xE3, 0x87, 0x38, 0x73, 0x0E, 0x3F, 0xE7, 0xF8, 0x7F, 0x87, 0x38,
  0x73, 0x86, 0x1C, 0xE1, 0xCE, 0x1C, 0x1F, 0x87, 0xF9, 0xC3, 0xB8, 0x77,
  0x00, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0x80, 0x3B, 0x07, 0x71, 0xC7, 0xF8,
  0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30,
  0xEE, 0x1D, 0xC3, 0x38, 0x67, 0x1C, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0x9C,
  0x33, 0x8E, 0x71, 0xC7, 0xF0, 0x7C, 0x00, 0xE1, 0xFC, 0x3B, 0x86, 0x71,
  0xCE, 0x39, 0xCE, 0x19, 0xC3, 0x30, 0x6E, 0x0D, 0x81, 0xF0, 0x3C, 0x07,
  0x80, 0x70, 0x00, 0x66, 0x76, 0x66, 0xEE, 0x6E, 0xEE, 0xEE, 0xCF, 0xEC,
  0xFF, 0xCF, 0xFC, 0xF7, 0x8F, 0x78, 0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0x70,
  0x1C, 0x3C, 0x70, 0xE0, 0xE7, 0x03, 0xB8, 0x06, 0xE0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x37, 0x01, 0xDC, 0x0E, 0x38, 0x78, 0xE3, 0xC3,
  0xC0, 0xE0, 0xFC, 0x39, 0x8E, 0x39, 0xC7, 0x70, 0xEC, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0xFF, 0xCF, 0xFC, 0x1F, 0x1F, 0x1E, 0x1C, 0x18, 0x18,
  0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60,
  0x78, 0xF8, 0xC6, 0x39, 0xC6, 0x31, 0x8C, 0x73, 0x9C, 0x63, 0x18, 0xE0,
  0x1F, 0x1F, 0x1E, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x78, 0xF8, 0x0E, 0x1E, 0x1E, 0x36,
  0x36, 0x63, 0xE3, 0xFF, 0xFF, 0xC0, 0xE3, 0x1E, 0x1F, 0x9C, 0xEC, 0x30,
  0x3B, 0xFF, 0x8F, 0x87, 0xC7, 0x7F, 0x9E, 0xC0, 0x1C, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0xB8, 0x7F, 0x8F, 0x71, 0x86, 0x70, 0xEE, 0x19, 0xC3, 0x38,
  0xE7, 0x1C, 0xFF, 0x3B, 0xC0, 0x0E, 0x1F, 0xDE, 0xEC, 0x3E, 0x07, 0x03,
  0x81, 0xC7, 0xE3, 0xBF, 0x8F, 0x80, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x61,
  0xDC, 0x7F, 0x9E, 0xF3, 0x0E, 0xE1, 0x9C, 0x33, 0x8E, 0x71, 0xCE, 0x79,
  0xFE, 0x1E, 0xC0, 0x0E, 0x0F, 0xE7, 0xB9, 0x87, 0xE1, 0xFF, 0xFF, 0xFB,
  0x80, 0xE1, 0x1F, 0xE3, 0xE0, 0x07, 0xE1, 0xF8, 0x70, 0x0C, 0x0F, 0xF9,
  0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x00, 0x0E, 0x63, 0xFC, 0xF7, 0x98, 0x77, 0x0E, 0xE1, 0x9C, 0x73,
  0x8E, 0x71, 0xC7, 0xF8, 0xF6, 0x00, 0xC4, 0x39, 0xFE, 0x0F, 0x80, 0x1C,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0xB8, 0x7F, 0x8F, 0x71, 0x87, 0x70, 0xEE,
  0x19, 0xC3, 0x38, 0xE6, 0x1C, 0xC3, 0xB8, 0x70, 0x02, 0x03, 0x81, 0xC0,
  0x03, 0xE1, 0xF1, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC7, 0xFF,
  0xFC, 0x01, 0x80, 0x70, 0x18, 0x00, 0x0F, 0x83, 0xE1, 0xF8, 0x0C, 0x03,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x1F, 0x0F,
  0x80, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0xF3, 0x9E, 0x33, 0xC3,
  0x70, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x70, 0x63, 0x86, 0x38, 0xE1, 0xC0,
  0x3F, 0x1F, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x01, 0x81, 0xC7, 0xFF, 0xFE, 0x36, 0xCF, 0xFD, 0xDF, 0xB3, 0x36, 0x66,
  0xCD, 0xFB, 0xBF, 0x76, 0xEC, 0xD9, 0x9B, 0x37, 0x00, 0x3B, 0x86, 0xF8,
  0xF7, 0x18, 0x77, 0x0E, 0xE1, 0x9C, 0x33, 0x8E, 0x61, 0xCC, 0x3B, 0x87,
  0x00, 0x0E, 0x0F, 0xC7, 0xB9, 0x86, 0xE1, 0xF8, 0x7C, 0x1B, 0x8E, 0xE3,
  0x9F, 0xC3, 0xE0, 0x3B, 0x07, 0xF8, 0xF7, 0x18, 0x67, 0x0E, 0xE1, 0x9C,
  0x33, 0x8E, 0x71, 0xCF, 0xF3, 0xBC, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x00,
  0x1C, 0xCF, 0xF7, 0xBD, 0x87, 0xE1, 0xB8, 0x6E, 0x3B, 0x8E, 0xE3, 0xBF,
  0xC7, 0xB0, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x33, 0xBF, 0xDF, 0xEF, 0x07,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x00, 0x0E, 0x0F, 0xE7, 0x1D,
  0x87, 0x70, 0x0F, 0xC1, 0xF8, 0x0E, 0xC3, 0xBF, 0xE7, 0xE0, 0x18, 0x0C,
  0x3F, 0xFF, 0xF3, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xE3,
  0xF0, 0x70, 0xDC, 0x77, 0x1D, 0x87, 0x61, 0xF8, 0x6E, 0x1B, 0x8E, 0xE3,
  0xBF, 0xE7, 0xB0, 0xE0, 0xEC, 0x39, 0x87, 0x39, 0xC7, 0x38, 0x66, 0x0D,
  0xC1, 0xB0, 0x3E, 0x07, 0x80, 0x60, 0x00, 0xC4, 0x79, 0x9F, 0x33, 0x66,
  0x6D, 0xDD, 0xAB, 0x3D, 0x67, 0xBC, 0xE7, 0x1C, 0xE3, 0x9C, 0x00, 0x38,
  0x73, 0x8E, 0x1D, 0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x3B,
  0x87, 0x18, 0xE1, 0xC0, 0x70, 0x79, 0x83, 0x8E, 0x38, 0x71, 0xC3, 0x9C,
  0x0C, 0xC0, 0x6E, 0x03, 0xE0, 0x1F, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x7C, 0x03, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0xFB, 0xFF, 0x00, 0x02, 0x07, 0x0C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0xE0, 0xE0, 0x70, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x38, 0x08, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x31, 0x08,
  0x46, 0x31, 0x8C, 0x46, 0x00, 0x10, 0x38, 0x1C, 0x0C, 0x0C, 0x1C, 0x1C,
  0x1C, 0x0C, 0x0F, 0x0E, 0x1C, 0x38, 0x38, 0x30, 0x30, 0x30, 0x60, 0xE0,
  0x80, 0x38, 0x4F, 0x8F, 0x3F, 0xE1, 0xE0,
};

const GFXglyph RobotoMono_BoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 14, 12, 3, -14 },
  { 12, 7, 5, 12, 3, -15 },
  { 17, 12, 14, 12, 0, -14 },
  { 38, 11, 18, 12, 1, -16 },
  { 63, 10, 14, 12, 1, -14 },
  { 81, 11, 14, 12, 0, -14 },
  { 101, 3, 5, 12, 5, -15 },
  { 103, 7, 20, 12, 3, -16 },
  { 121, 6, 20, 12, 2, -16 },
  { 136, 9, 10, 12, 2, -14 },
  { 148, 10, 11, 12, 1, -12 },
  { 162, 4, 6, 12, 2, -2 },
  { 165, 8, 2, 12, 3, -7 },
  { 167, 4, 3, 12, 3, -3 },
  { 169, 10, 15, 12, 1, -14 },
  { 188, 10, 14, 12, 1, -14 },
  { 206, 7, 14, 12, 2, -14 },
  { 219, 11, 14, 12, 0, -14 },
  { 239, 10, 14, 12, 1, -14 },
  { 257, 11, 14, 12, 0, -14 },
  { 277, 10, 14, 12, 1, -14 },
  { 295, 9, 14, 12, 1, -14 },
  { 311, 11, 14, 12, 1, -14 },
  { 331, 10, 14, 12, 1, -14 },
  { 349, 10, 14, 12, 1, -14 },
  { 367, 5, 11, 12, 3, -11 },
  { 374, 6, 15, 12, 3, -11 },
  { 386, 10, 10, 12, 1, -11 },
  { 399, 10, 6, 12, 1, -9 },
  { 407, 9, 10, 12, 1, -11 },
  { 419, 9, 14, 12, 2, -14 },
  { 435, 12, 14, 12, 0, -14 },
  { 456, 12, 14, 12, -1, -14 },
  { 477, 12, 14, 12, 0, -14 },
  { 498, 11, 14, 12, 1, -14 },
  { 518, 11, 14, 12, 0, -14 },
  { 538, 12, 14, 12, 0, -14 },
  { 559, 12, 14, 12, 0, -14 },
  { 580, 10, 14, 12, 1, -14 },
  { 598, 12, 14, 12, 0, -14 },
  { 619, 10, 14, 12, 1, -14 },
  { 637, 11, 14, 12, 1, -14 },
  { 657, 13, 14, 12, 0, -14 },
  { 680, 10, 14, 12, 0, -14 },
  { 698, 12, 14, 12, 0, -14 },
  { 719, 12, 14, 12, 0, -14 },
  { 740, 10, 14, 12, 1, -14 },
  { 758, 12, 14, 12, 0, -14 },
  { 779, 10, 17, 12, 1, -14 },
  { 801, 12, 14, 12, 0, -14 },
  { 822, 11, 14, 12, 1, -14 },
  { 842, 12, 14, 12, 1, -14 },
  { 863, 11, 14, 12, 1, -14 },
  { 883, 11, 14, 12, 2, -14 },
  { 903, 12, 14, 12, 1, -14 },
  { 924, 14, 14, 12, -1, -14 },
  { 949, 11, 14, 12, 2, -14 },
  { 969, 12, 14, 12, 0, -14 },
  { 990, 8, 20, 12, 2, -17 },
  { 1010, 5, 15, 12, 4, -14 },
  { 1020, 8, 20, 12, 2, -17 },
  { 1040, 8, 7, 12, 2, -14 },
  { 1047, 9, 2, 12, 0, 0 },
  { 1050, 4, 2, 12, 5, -14 },
  { 1051, 9, 11, 12, 1, -11 },
  { 1064, 11, 15, 12, 0, -15 },
  { 1085, 9, 11, 12, 1, -11 },
  { 1098, 11, 15, 12, 1, -15 },
  { 1119, 10, 11, 12, 1, -11 },
  { 1133, 11, 15, 12, 2, -15 },
  { 1154, 11, 15, 12, 0, -11 },
  { 1175, 11, 15, 12, 0, -15 },
  { 1196, 9, 15, 12, 1, -15 },
  { 1213, 10, 19, 12, 0, -15 },
  { 1237, 12, 15, 12, 0, -15 },
  { 1260, 9, 15, 12, 1, -15 },
  { 1277, 11, 11, 12, 0, -11 },
  { 1293, 11, 11, 12, 0, -11 },
  { 1309, 10, 11, 12, 1, -11 },
  { 1323, 11, 15, 12, 0, -11 },
  { 1344, 10, 15, 12, 1, -11 },
  { 1363, 9, 11, 12, 2, -11 },
  { 1376, 10, 11, 12, 1, -11 },
  { 1390, 9, 13, 12, 2, -13 },
  { 1405, 10, 11, 12, 1, -11 },
  { 1419, 11, 11, 12, 1, -11 },
  { 1435, 11, 11, 12, 1, -11 },
  { 1451, 12, 11, 12, 0, -11 },
  { 1468, 13, 15, 12, 0, -11 },
  { 1493, 11, 11, 12, 0, -11 },
  { 1509, 8, 20, 12, 3, -16 },
  { 1529, 5, 18, 12, 3, -14 },
  { 1541, 8, 20, 12, 2, -16 },
  { 1561, 11, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_BoldItalic20pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic20pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOMONO_BOLDITALIC20PT7B_H_
