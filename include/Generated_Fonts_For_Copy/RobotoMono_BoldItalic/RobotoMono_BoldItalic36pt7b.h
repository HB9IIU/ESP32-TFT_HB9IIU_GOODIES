#ifndef _ROBOTOMONO_BOLDITALIC36PT7B_H_
#define _ROBOTOMONO_BOLDITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC3, 0xF1, 0xF8, 0xFC, 0x3C, 0x00, 0x78, 0xF7, 0x8F, 0x70, 0xE7,
  0x0E, 0x70, 0xEF, 0x0E, 0xF1, 0xEE, 0x1C, 0xE1, 0xC0, 0x00, 0x38, 0x70,
  0x01, 0xC7, 0x80, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x38,
  0xE0, 0x03, 0x87, 0x00, 0x1C, 0x78, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFE, 0x07, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x1E, 0x38,
  0x00, 0xE1, 0xC0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x1C,
  0x70, 0x01, 0xE3, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xC0, 0x07, 0x8E, 0x00,
  0x38, 0xF0, 0x03, 0xC7, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x3C, 0x03,
  0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xC7, 0x08,
  0xF1, 0xC3, 0xBC, 0x71, 0xCE, 0x1C, 0xE3, 0xCF, 0x78, 0xFF, 0x9C, 0x1F,
  0xEE, 0x03, 0xE7, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x78, 0x07, 0x7F, 0x03, 0x9F, 0xE0, 0xEF, 0x38, 0x73, 0x8F,
  0x38, 0xE3, 0x8E, 0x38, 0xE1, 0x0E, 0x38, 0x03, 0xDE, 0x00, 0xFF, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x7C, 0x78, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x8F, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xC3, 0xE7, 0xFF, 0x1E, 0x3E, 0x7C, 0xF3, 0xE3,
  0xEF, 0x9F, 0x0F, 0xF8, 0xF8, 0x7F, 0xC7, 0xC1, 0xFC, 0x3E, 0x0F, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0x9F, 0x00, 0x7B,
  0xDE, 0xE7, 0x7B, 0xDE, 0xE7, 0x00, 0x00, 0x20, 0x06, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xC0,
  0x04, 0x00, 0x06, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xE0, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x02, 0x07, 0x05, 0xC3, 0x1F, 0xF9,
  0xBF, 0xFF, 0xFF, 0x8F, 0xFF, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xF3, 0x80, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x08, 0x18, 0x00, 0x08,
  0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C,
  0x78, 0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x7B,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x0F, 0x87, 0x81,
  0xE3, 0xE0, 0x78, 0xF8, 0x1F, 0x3C, 0x07, 0xDF, 0x03, 0xF7, 0xC1, 0xF9,
  0xF1, 0xFE, 0x7C, 0xFF, 0x9F, 0xFB, 0xE7, 0xF8, 0xFB, 0xFC, 0x3E, 0xFC,
  0x0F, 0x3E, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x1E, 0x0F,
  0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x08,
  0x03, 0x80, 0xFC, 0x3F, 0xE7, 0xFF, 0x3F, 0xFB, 0xFF, 0x9E, 0x3C, 0x83,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFC, 0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xF7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x07, 0xC7, 0x80, 0xF9,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x3E, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xF7, 0x80, 0x3C, 0xF0, 0x0F, 0x3E, 0x03,
  0xE7, 0xC0, 0xF8, 0xF8, 0x1E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xCF, 0x00, 0x7F,
  0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3C, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x7C, 0x07, 0xCF, 0x80,
  0xF8, 0xF8, 0x3E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xF8,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x9F, 0x03,
  0xDF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xC0, 0xF9, 0xF0,
  0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3E, 0x7C, 0x0F,
  0x9F, 0x07, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xFC, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0,
  0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x7E, 0x3E, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0xC1, 0xF0, 0xF8, 0x7C, 0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C,
  0x07, 0xCF, 0x81, 0xF9, 0xF8, 0x3E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F,
  0xFC, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xE3, 0xF1, 0xF1, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBC,
  0x07, 0xDE, 0x03, 0xEF, 0x81, 0xF7, 0xC1, 0xFB, 0xF1, 0xFC, 0xFF, 0xFC,
  0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0x8F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x1F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x00,
  0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x7C, 0x7F, 0x3F, 0x9F, 0x87, 0xC0,
  0x03, 0xC0, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03,
  0xC0, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x03, 0xE0, 0x07, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x18, 0x00, 0x07, 0x80, 0x01,
  0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x1F, 0xC0, 0x07, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x0F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0xF8, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xE7, 0xC0, 0xF0, 0x0E,
  0x0E, 0x00, 0xE1, 0xC3, 0xC6, 0x38, 0xFF, 0x73, 0x9F, 0xE7, 0x73, 0xCE,
  0x77, 0x38, 0xE7, 0x73, 0x8E, 0x7E, 0x70, 0xC6, 0xE7, 0x1C, 0x6E, 0x71,
  0xCE, 0xE7, 0x1C, 0xEE, 0x71, 0x8C, 0xE7, 0x39, 0xCE, 0x7F, 0xF8, 0xE3,
  0xDF, 0x0E, 0x10, 0xE0, 0xF0, 0x00, 0x07, 0x81, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0x3C, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x03,
  0xE3, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xC0, 0x7C, 0x3E, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xE0, 0x1E,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x07, 0xF8,
  0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF8, 0x7F, 0x87,
  0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F,
  0x87, 0xC0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x87, 0xC0, 0x7C, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x07, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0x87, 0xE1, 0xF0, 0x3E, 0x3E, 0x01,
  0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC7, 0x80, 0x7C, 0x7C, 0x0F, 0x87,
  0xC1, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0x9F,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x07, 0xC7,
  0xC0, 0x7C, 0x7C, 0x0F, 0x87, 0xC3, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE1, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xC7, 0xE1,
  0xF0, 0x3E, 0x1F, 0x01, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC3, 0xFE, 0x7C, 0x3F,
  0xC7, 0x87, 0xFC, 0xF8, 0x7F, 0xCF, 0x80, 0x7C, 0x78, 0x07, 0xC7, 0x80,
  0x7C, 0x7C, 0x07, 0xC7, 0xE0, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F,
  0xFE, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x78, 0x3C, 0x07, 0xC3, 0xE0,
  0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xC0, 0x7C, 0x3E, 0x03,
  0xC1, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E,
  0x03, 0xE1, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x87, 0xC0, 0x7C,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x87, 0xC1, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x3F, 0x07,
  0x80, 0x7E, 0x0F, 0x80, 0xFC, 0x0F, 0x81, 0xF8, 0x0F, 0x83, 0xF0, 0x0F,
  0x87, 0xE0, 0x0F, 0x8F, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F,
  0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBE, 0x00, 0x3F,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x7C,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0xE0, 0xF8,
  0x03, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x07, 0xE0,
  0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0x9F, 0xE0, 0xFE, 0x7F, 0x83, 0xFB, 0xFE, 0x1F, 0xEF, 0xF0, 0x7B,
  0xBB, 0xC1, 0xEF, 0xEF, 0x07, 0xBF, 0x7C, 0x1E, 0xFD, 0xF0, 0xF9, 0xE7,
  0x83, 0xE7, 0x9E, 0x0F, 0x9C, 0x78, 0x3C, 0x71, 0xE0, 0xF1, 0x8F, 0x83,
  0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x7C, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0x80,
  0x7C, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x1E, 0x00, 0x07, 0x80,
  0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x87,
  0xF0, 0x78, 0x3F, 0x87, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x8F,
  0x87, 0xFC, 0x78, 0x3E, 0xE7, 0xC1, 0xE7, 0x3E, 0x1F, 0x3D, 0xF0, 0xF9,
  0xEF, 0x87, 0xC7, 0x7C, 0x3E, 0x3B, 0xC1, 0xF1, 0xFE, 0x0F, 0x0F, 0xF0,
  0xF8, 0x7F, 0x87, 0xC1, 0xFC, 0x3E, 0x0F, 0xE1, 0xF0, 0x7E, 0x0F, 0x83,
  0xF0, 0x78, 0x0F, 0x87, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x1F, 0x3E, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xDE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xDF,
  0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3E, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x0F, 0xE1, 0xF0, 0x1F,
  0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x3E, 0x01,
  0xF3, 0xE0, 0x3E, 0x3E, 0x1F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF,
  0xE0, 0x7F, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC,
  0x0F, 0xC7, 0xE1, 0xF0, 0x3E, 0x1E, 0x03, 0xE3, 0xE0, 0x1E, 0x3E, 0x01,
  0xE7, 0xC0, 0x1F, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x0F, 0x87, 0xC1, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF8, 0x7F, 0x07, 0xC0, 0xFC,
  0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x7C, 0x3E, 0x07, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x78, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3F, 0x0F, 0x80, 0xF8, 0x78,
  0x07, 0xC7, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0x83, 0xE1, 0xF0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0,
  0x1F, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0xFC,
  0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x01, 0xE3, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF1,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7,
  0xC0, 0x78, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F,
  0x01, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x03, 0xFF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xFC, 0x07, 0xC7, 0xC0, 0xFC,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E,
  0x07, 0xC3, 0xE0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x78, 0x70, 0xFB, 0xC3, 0x87, 0xDE, 0x3C, 0x3C, 0xF1, 0xE1,
  0xE7, 0x8F, 0x1F, 0x3C, 0x78, 0xF1, 0xE7, 0xC7, 0x8F, 0x3E, 0x3C, 0x79,
  0xF3, 0xE3, 0xDF, 0x9E, 0x1E, 0xFC, 0xF0, 0xF7, 0xEF, 0x87, 0xFF, 0x78,
  0x3F, 0xBB, 0xC3, 0xFD, 0xDE, 0x1F, 0xEF, 0xF0, 0xFF, 0x7F, 0x07, 0xF3,
  0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03,
  0xF1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x00, 0x0F,
  0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0xFC, 0x03,
  0xE0, 0xF8, 0x03, 0xE1, 0xF8, 0x01, 0xF3, 0xF0, 0x01, 0xF3, 0xE0, 0x01,
  0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0xC7, 0xC0, 0x0F,
  0x87, 0xC0, 0x1F, 0x87, 0xC0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E,
  0x03, 0xF0, 0xFC, 0x01, 0xF0, 0xF8, 0x01, 0xFB, 0xE0, 0x1F, 0x9F, 0x00,
  0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC3, 0xE0, 0x1E, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x1E, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFE,
  0x00, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E,
  0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0x03, 0xF8, 0x1F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1D, 0xC0, 0xF7, 0x07, 0x9E, 0x1E, 0x78,
  0xF0, 0xE3, 0xC3, 0x9E, 0x0F, 0x78, 0x3F, 0xC0, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF1, 0xF1, 0xE1, 0xE0, 0x03, 0xFC,
  0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x3C, 0x00,
  0x3E, 0x03, 0xFF, 0x0F, 0xFF, 0x9F, 0xFF, 0xDF, 0xC3, 0xEF, 0x81, 0xEF,
  0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0xFD, 0xF9, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF,
  0x87, 0xE7, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x7E, 0x07,
  0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0x0F, 0xCF, 0x81, 0xF3, 0xE0,
  0x7C, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1E,
  0x7C, 0x0F, 0x9F, 0x03, 0xEF, 0xC1, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFF, 0x0F, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF,
  0xE7, 0xE0, 0xFB, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0xF8,
  0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x07, 0xE7, 0xC3, 0xFE, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC7, 0xE1, 0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x8F, 0x01, 0xF1, 0xF0,
  0x3E, 0x3E, 0x0F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFB, 0xC0, 0x7E,
  0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0x07, 0xCF, 0x80, 0xF7, 0xC0, 0x3D, 0xF0, 0x0F, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFD, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x87, 0xE0, 0x60,
  0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0xD0,
  0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xF8, 0x20, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0x83, 0xE1, 0xF0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0,
  0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0x78, 0x07, 0xEF, 0x80, 0x00, 0xF8, 0x20, 0x1F, 0x03,
  0x01, 0xF0, 0x7C, 0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00,
  0x01, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x7F, 0x07,
  0xBF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0x7C, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1E,
  0x78, 0x0F, 0x9E, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE,
  0x03, 0xCF, 0x01, 0xF0, 0x00, 0x10, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x04,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x87, 0xE0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x07, 0xF1, 0xE0, 0xFC, 0x3E, 0x1F, 0x83,
  0xE3, 0xF0, 0x3E, 0x7E, 0x03, 0xEF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7C, 0x7C,
  0x07, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF8, 0xF0, 0x0F, 0x80, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x7D,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3E, 0x7C, 0xF8,
  0x1E, 0x7F, 0x07, 0xBF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0x07, 0xCF,
  0x81, 0xF3, 0xE0, 0x7C, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0,
  0x79, 0xF0, 0x1E, 0x78, 0x0F, 0x9E, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E,
  0xF8, 0x0F, 0x3E, 0x03, 0xCF, 0x01, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x0F, 0xCF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0,
  0x1F, 0x7C, 0x07, 0xDE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x78, 0x0F,
  0x9F, 0x03, 0xE7, 0xC1, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0x00, 0x07, 0x9F, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1E, 0x1F, 0x03, 0xE1, 0xE0,
  0x3E, 0x3F, 0x07, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3E,
  0xFE, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE7, 0xC7, 0xFF, 0xF3,
  0xFF, 0xF8, 0xFF, 0xFE, 0x7E, 0x0F, 0x9F, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x3E, 0xF8, 0x0F, 0x3E, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F,
  0x3E, 0x07, 0xCF, 0x83, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x81,
  0xFB, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1F, 0x3F, 0xC7, 0xDF, 0xE1, 0xEF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xF7, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7E, 0x3F, 0x3E, 0x07,
  0xCF, 0x80, 0xF3, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xF9, 0xF8,
  0x7E, 0x7F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x3E, 0x07, 0xCF, 0x81,
  0xF3, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0x9F, 0x03, 0xE7, 0xC0, 0xF9,
  0xF0, 0x3E, 0x78, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xF7,
  0x83, 0xF9, 0xE0, 0xF0, 0x07, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7C,
  0x78, 0x1F, 0x1E, 0x0F, 0x87, 0x83, 0xE1, 0xF0, 0xF0, 0x7C, 0x7C, 0x0F,
  0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3D, 0xF0, 0x07, 0x78, 0x01, 0xDE,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0xE1,
  0xFF, 0x0E, 0x1E, 0xF1, 0xE3, 0xEF, 0x1E, 0x3C, 0xF1, 0xE3, 0xCF, 0x3E,
  0x3C, 0xF3, 0xE7, 0x8F, 0x76, 0x78, 0xF7, 0x67, 0x8F, 0x76, 0xF0, 0xFE,
  0x6F, 0x0F, 0xE6, 0xF0, 0xFE, 0x6E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F,
  0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x78, 0x00, 0x1F, 0x00,
  0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xEF, 0x80, 0x7E,
  0x7C, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x3E, 0x3F, 0x01, 0xF0,
  0x3F, 0x00, 0x7E, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x80,
  0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x07,
  0x8F, 0x80, 0x0F, 0x1F, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x01, 0xF0, 0x0F, 0xC0,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x3F, 0xC0, 0xFC, 0x03,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0x03, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x1F,
  0xC0, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x3F, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x04, 0x00, 0x01, 0xF8, 0x08, 0x3F, 0xE0, 0xF7, 0xFF,
  0x0F, 0x7F, 0xFF, 0xEF, 0x0F, 0xFE, 0xE0, 0x3F, 0xC0, 0x01, 0xF8,
};

const GFXglyph RobotoMono_BoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 9, 26, 21, 6, -26 },
  { 31, 12, 9, 21, 6, -27 },
  { 45, 21, 26, 21, 0, -26 },
  { 114, 19, 34, 21, 2, -30 },
  { 195, 18, 26, 21, 2, -26 },
  { 254, 21, 26, 21, 0, -26 },
  { 323, 5, 10, 21, 9, -27 },
  { 330, 12, 37, 21, 6, -29 },
  { 386, 12, 36, 21, 3, -28 },
  { 440, 17, 19, 21, 3, -26 },
  { 481, 17, 18, 21, 2, -21 },
  { 520, 8, 11, 21, 3, -4 },
  { 531, 15, 4, 21, 5, -13 },
  { 539, 6, 6, 21, 6, -6 },
  { 544, 19, 28, 21, 1, -26 },
  { 611, 18, 26, 21, 2, -26 },
  { 670, 13, 26, 21, 4, -26 },
  { 713, 19, 26, 21, 0, -26 },
  { 775, 19, 26, 21, 1, -26 },
  { 837, 19, 26, 21, 0, -26 },
  { 899, 19, 26, 21, 1, -26 },
  { 961, 18, 26, 21, 1, -26 },
  { 1020, 19, 26, 21, 2, -26 },
  { 1082, 19, 26, 21, 1, -26 },
  { 1144, 17, 26, 21, 2, -26 },
  { 1200, 9, 21, 21, 6, -21 },
  { 1224, 11, 28, 21, 5, -21 },
  { 1263, 17, 17, 21, 2, -20 },
  { 1300, 18, 12, 21, 2, -17 },
  { 1327, 18, 17, 21, 1, -19 },
  { 1366, 16, 26, 21, 4, -26 },
  { 1418, 20, 25, 21, 1, -25 },
  { 1481, 20, 26, 21, -1, -26 },
  { 1546, 21, 26, 21, 0, -26 },
  { 1615, 20, 26, 21, 1, -26 },
  { 1680, 20, 26, 21, 0, -26 },
  { 1745, 21, 26, 21, 1, -26 },
  { 1814, 21, 26, 21, 1, -26 },
  { 1883, 20, 26, 21, 1, -26 },
  { 1948, 21, 26, 21, 0, -26 },
  { 2017, 19, 26, 21, 1, -26 },
  { 2079, 20, 26, 21, 1, -26 },
  { 2144, 24, 26, 21, 0, -26 },
  { 2222, 17, 26, 21, 1, -26 },
  { 2278, 22, 26, 21, 0, -26 },
  { 2350, 21, 26, 21, 0, -26 },
  { 2419, 19, 26, 21, 1, -26 },
  { 2481, 20, 26, 21, 1, -26 },
  { 2546, 20, 31, 21, 1, -26 },
  { 2624, 21, 26, 21, 0, -26 },
  { 2693, 20, 26, 21, 1, -26 },
  { 2758, 21, 26, 21, 2, -26 },
  { 2827, 19, 26, 21, 2, -26 },
  { 2889, 20, 26, 21, 3, -26 },
  { 2954, 21, 26, 21, 2, -26 },
  { 3023, 24, 26, 21, -1, -26 },
  { 3101, 21, 26, 21, 3, -26 },
  { 3170, 22, 26, 21, 0, -26 },
  { 3242, 13, 36, 21, 4, -30 },
  { 3301, 9, 28, 21, 7, -26 },
  { 3333, 13, 36, 21, 4, -30 },
  { 3392, 14, 14, 21, 4, -26 },
  { 3417, 16, 4, 21, 0, 0 },
  { 3425, 7, 5, 21, 10, -26 },
  { 3430, 17, 19, 21, 1, -19 },
  { 3471, 18, 27, 21, 1, -27 },
  { 3532, 17, 19, 21, 2, -19 },
  { 3573, 19, 27, 21, 2, -27 },
  { 3638, 18, 19, 21, 1, -19 },
  { 3681, 20, 28, 21, 3, -28 },
  { 3751, 20, 27, 21, 0, -19 },
  { 3819, 18, 27, 21, 1, -27 },
  { 3880, 16, 27, 21, 2, -27 },
  { 3934, 16, 35, 21, 1, -27 },
  { 4004, 20, 27, 21, 1, -27 },
  { 4072, 16, 27, 21, 2, -27 },
  { 4126, 21, 19, 21, -1, -19 },
  { 4176, 18, 19, 21, 1, -19 },
  { 4219, 18, 19, 21, 1, -19 },
  { 4262, 20, 26, 21, -1, -19 },
  { 4327, 18, 26, 21, 2, -19 },
  { 4386, 18, 19, 21, 3, -19 },
  { 4429, 18, 19, 21, 1, -19 },
  { 4472, 16, 24, 21, 3, -24 },
  { 4520, 18, 19, 21, 2, -19 },
  { 4563, 18, 19, 21, 3, -19 },
  { 4606, 20, 19, 21, 2, -19 },
  { 4654, 21, 19, 21, 0, -19 },
  { 4704, 23, 27, 21, 0, -19 },
  { 4782, 20, 19, 21, 0, -19 },
  { 4830, 14, 34, 21, 5, -28 },
  { 4890, 8, 33, 21, 6, -26 },
  { 4923, 14, 34, 21, 3, -28 },
  { 4983, 20, 8, 21, 0, -15 },
};

const GFXfont RobotoMono_BoldItalic36pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic36pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOMONO_BOLDITALIC36PT7B_H_
