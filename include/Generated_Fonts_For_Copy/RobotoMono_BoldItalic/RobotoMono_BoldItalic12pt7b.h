#ifndef _ROBOTOMONO_BOLDITALIC12PT7B_H_
#define _ROBOTOMONO_BOLDITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xB4, 0x86, 0xC0, 0xD9, 0xA0, 0x1A, 0x28, 0x53, 0xF2, 0x85,
  0x3F, 0x28, 0xD0, 0x10, 0xC7, 0xF3, 0x41, 0xC1, 0xA2, 0x9B, 0xC6, 0x00,
  0x42, 0xAA, 0xBC, 0x20, 0xE7, 0xEA, 0x38, 0x18, 0x78, 0xB1, 0xC3, 0x0E,
  0xF7, 0x66, 0x7C, 0xE8, 0x13, 0x64, 0xCC, 0x88, 0x88, 0x84, 0x40, 0x23,
  0x11, 0x11, 0x33, 0x26, 0xC8, 0x10, 0x4A, 0x5E, 0x73, 0x61, 0x00, 0x31,
  0xBF, 0xF6, 0x30, 0x6B, 0x00, 0xF8, 0xF0, 0x06, 0x08, 0x30, 0x41, 0x82,
  0x0C, 0x10, 0x61, 0x80, 0x31, 0xEC, 0xB3, 0xFB, 0x29, 0xA6, 0xF0, 0x0B,
  0xBC, 0x63, 0x18, 0x84, 0x60, 0x19, 0xF6, 0x41, 0x0C, 0x63, 0x10, 0xFC,
  0x18, 0x79, 0x98, 0x21, 0x85, 0x83, 0x66, 0x78, 0x04, 0x31, 0xCF, 0x6D,
  0x2F, 0xC6, 0x18, 0x3E, 0x7C, 0x83, 0xC7, 0xC1, 0xA3, 0x26, 0x78, 0x0C,
  0xF2, 0x1E, 0x7D, 0x14, 0x53, 0x78, 0xFF, 0xF0, 0x86, 0x30, 0x86, 0x10,
  0xC0, 0x18, 0x79, 0x93, 0x23, 0x8D, 0xB3, 0x66, 0x78, 0x33, 0xF3, 0x1D,
  0xFC, 0x66, 0xE0, 0x6C, 0x01, 0xB0, 0x6C, 0x00, 0x36, 0x80, 0x08, 0xFD,
  0x87, 0x0C, 0xFF, 0xE0, 0x3E, 0x60, 0xF0, 0xDE, 0xC0, 0x31, 0xFC, 0xC2,
  0x18, 0x80, 0x18, 0x60, 0x3C, 0xBD, 0xED, 0x5A, 0xB7, 0xB0, 0x38, 0x08,
  0x61, 0x8F, 0x2D, 0xB7, 0xF1, 0x84, 0x38, 0xFD, 0x9B, 0x37, 0xC8, 0x91,
  0xE6, 0xF8, 0x18, 0x79, 0x9A, 0x04, 0x18, 0x31, 0x26, 0x78, 0x30, 0xF9,
  0x93, 0x36, 0x68, 0x93, 0x6E, 0xF0, 0x3E, 0x7D, 0x83, 0x07, 0xC8, 0x10,
  0x60, 0xFC, 0x3E, 0x7D, 0x83, 0x07, 0xC8, 0x10, 0x60, 0xC0, 0x18, 0x7D,
  0x9A, 0x04, 0x2B, 0xB1, 0x26, 0x78, 0x26, 0xCD, 0x9B, 0x37, 0xC8, 0x93,
  0x66, 0xCC, 0x3E, 0x7C, 0x60, 0xC1, 0x02, 0x0C, 0x1A, 0xF8, 0x02, 0x0C,
  0x18, 0x30, 0x40, 0xB3, 0x26, 0x78, 0x23, 0x66, 0x6C, 0x78, 0x78, 0x78,
  0x48, 0xCC, 0xCE, 0x20, 0x86, 0x18, 0x61, 0x04, 0x30, 0xFC, 0x36, 0xED,
  0xFA, 0xF5, 0xEA, 0x91, 0x62, 0xCC, 0x26, 0xCD, 0xDB, 0xB5, 0x4A, 0x97,
  0x66, 0xCC, 0x18, 0x79, 0x9A, 0x34, 0x78, 0xF1, 0x26, 0x78, 0x38, 0x7D,
  0x9B, 0x36, 0xEF, 0x10, 0x60, 0xC0, 0x18, 0x79, 0x9A, 0x34, 0x78, 0xF1,
  0x26, 0x78, 0x18, 0x10, 0x38, 0xFD, 0x9B, 0x37, 0xCF, 0x12, 0x66, 0xCC,
  0x18, 0x7D, 0x9B, 0x03, 0x81, 0xB1, 0x26, 0x78, 0xFF, 0xFC, 0xC1, 0x82,
  0x04, 0x18, 0x30, 0x60, 0x47, 0x3C, 0xF3, 0xCA, 0x29, 0xA6, 0xF0, 0xC7,
  0x9B, 0x36, 0x45, 0x8A, 0x1C, 0x30, 0x60, 0x97, 0x6A, 0xD5, 0xEF, 0x9B,
  0x36, 0x6C, 0x90, 0x63, 0x66, 0x3C, 0x3C, 0x18, 0x38, 0x68, 0x6C, 0xCC,
  0xC7, 0x99, 0x33, 0xC7, 0x06, 0x08, 0x30, 0x60, 0x7E, 0xFC, 0x30, 0x41,
  0x86, 0x18, 0x60, 0xFC, 0x39, 0x88, 0x42, 0x31, 0x8C, 0x62, 0x11, 0xC0,
  0xD9, 0x24, 0xDB, 0x24, 0x38, 0xC4, 0x21, 0x18, 0xC6, 0x31, 0x09, 0xC0,
  0x11, 0x8C, 0x9C, 0x80, 0xF8, 0xCC, 0x7D, 0x93, 0xD3, 0xCD, 0xF0, 0x20,
  0x86, 0x1F, 0x65, 0x14, 0x73, 0xF8, 0x7E, 0x61, 0x09, 0xF8, 0x0C, 0x30,
  0xFE, 0xCA, 0x29, 0xA6, 0xF8, 0x3D, 0x97, 0xD0, 0x65, 0xE0, 0x1E, 0x60,
  0x87, 0xE6, 0x0C, 0x18, 0x30, 0x40, 0x3E, 0xC9, 0x12, 0x64, 0xCF, 0xA2,
  0x7C, 0x20, 0x21, 0x86, 0x1F, 0x65, 0x14, 0x73, 0xCC, 0x10, 0x81, 0xE3,
  0x18, 0x84, 0xF8, 0x0C, 0x30, 0x0E, 0x18, 0x61, 0x86, 0x10, 0x4F, 0x30,
  0x20, 0x41, 0x8B, 0x67, 0x8E, 0x1E, 0x64, 0xCC, 0x78, 0x8C, 0x63, 0x18,
  0x84, 0xF8, 0x7E, 0xAF, 0x56, 0xAF, 0x57, 0x80, 0x7D, 0x94, 0x51, 0xCF,
  0x30, 0x3D, 0x94, 0x71, 0x4D, 0xE0, 0x7D, 0x94, 0x51, 0xCF, 0xEC, 0x30,
  0xFF, 0x28, 0xA6, 0x9B, 0xE1, 0x04, 0x7D, 0x84, 0x30, 0xC3, 0x00, 0x7D,
  0x97, 0x87, 0xCD, 0xE0, 0x20, 0x9F, 0x98, 0x61, 0x86, 0x1E, 0xCF, 0x28,
  0xA6, 0x9B, 0xE0, 0xCF, 0x2D, 0x94, 0x71, 0x80, 0xAE, 0xBE, 0xB6, 0xDA,
  0x40, 0x66, 0x78, 0x61, 0xC6, 0x99, 0x80, 0x67, 0x64, 0x2C, 0x28, 0x38,
  0x30, 0x20, 0xE0, 0x80, 0x7E, 0x18, 0x61, 0x86, 0x1F, 0x80, 0x32, 0x22,
  0x68, 0x44, 0x44, 0x60, 0x25, 0x24, 0x92, 0x52, 0x00, 0x21, 0x8C, 0x63,
  0x0C, 0x8C, 0x63, 0x30, 0x67, 0xF8, 0x30,
};

const GFXglyph RobotoMono_BoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 4, 3, 7, 2, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 11, 7, 1, -10 },
  { 24, 6, 9, 7, 1, -9 },
  { 31, 7, 9, 7, 0, -9 },
  { 39, 2, 3, 7, 3, -9 },
  { 40, 4, 13, 7, 2, -10 },
  { 47, 4, 12, 7, 1, -9 },
  { 53, 6, 7, 7, 1, -9 },
  { 59, 5, 6, 7, 1, -7 },
  { 63, 3, 3, 7, 1, -1 },
  { 65, 5, 1, 7, 2, -4 },
  { 66, 2, 2, 7, 2, -2 },
  { 67, 7, 10, 7, 0, -9 },
  { 76, 6, 9, 7, 1, -9 },
  { 83, 5, 9, 7, 1, -9 },
  { 89, 6, 9, 7, 0, -9 },
  { 96, 7, 9, 7, 0, -9 },
  { 104, 6, 9, 7, 0, -9 },
  { 111, 7, 9, 7, 0, -9 },
  { 119, 6, 9, 7, 0, -9 },
  { 126, 6, 9, 7, 1, -9 },
  { 133, 7, 9, 7, 0, -9 },
  { 141, 5, 9, 7, 1, -9 },
  { 147, 3, 7, 7, 2, -7 },
  { 150, 3, 9, 7, 2, -7 },
  { 154, 5, 6, 7, 1, -7 },
  { 158, 6, 4, 7, 1, -6 },
  { 161, 6, 5, 7, 0, -6 },
  { 165, 6, 9, 7, 1, -9 },
  { 172, 7, 8, 7, 0, -8 },
  { 179, 6, 9, 7, 0, -9 },
  { 186, 7, 9, 7, 0, -9 },
  { 194, 7, 9, 7, 0, -9 },
  { 202, 7, 9, 7, 0, -9 },
  { 210, 7, 9, 7, 0, -9 },
  { 218, 7, 9, 7, 0, -9 },
  { 226, 7, 9, 7, 0, -9 },
  { 234, 7, 9, 7, 0, -9 },
  { 242, 7, 9, 7, 0, -9 },
  { 250, 7, 9, 7, 0, -9 },
  { 258, 8, 9, 7, 0, -9 },
  { 267, 6, 9, 7, 0, -9 },
  { 274, 7, 9, 7, 0, -9 },
  { 282, 7, 9, 7, 0, -9 },
  { 290, 7, 9, 7, 0, -9 },
  { 298, 7, 9, 7, 0, -9 },
  { 306, 7, 11, 7, 0, -9 },
  { 316, 7, 9, 7, 0, -9 },
  { 324, 7, 9, 7, 0, -9 },
  { 332, 7, 9, 7, 1, -9 },
  { 340, 6, 9, 7, 1, -9 },
  { 347, 7, 9, 7, 1, -9 },
  { 355, 7, 9, 7, 1, -9 },
  { 363, 8, 9, 7, 0, -9 },
  { 372, 7, 9, 7, 1, -9 },
  { 380, 7, 9, 7, 0, -9 },
  { 388, 5, 12, 7, 1, -10 },
  { 396, 3, 10, 7, 2, -9 },
  { 400, 5, 12, 7, 1, -10 },
  { 408, 5, 5, 7, 1, -9 },
  { 412, 5, 1, 7, 0, 0 },
  { 413, 3, 2, 7, 3, -9 },
  { 414, 6, 6, 7, 0, -6 },
  { 419, 6, 9, 7, 0, -9 },
  { 426, 5, 6, 7, 1, -6 },
  { 430, 6, 9, 7, 1, -9 },
  { 437, 6, 6, 7, 0, -6 },
  { 442, 7, 9, 7, 1, -9 },
  { 450, 7, 9, 7, 0, -6 },
  { 458, 6, 9, 7, 0, -9 },
  { 465, 5, 9, 7, 1, -9 },
  { 471, 6, 12, 7, 0, -9 },
  { 480, 7, 9, 7, 0, -9 },
  { 488, 5, 9, 7, 1, -9 },
  { 494, 7, 6, 7, 0, -6 },
  { 500, 6, 6, 7, 0, -6 },
  { 505, 6, 6, 7, 0, -6 },
  { 510, 6, 8, 7, 0, -6 },
  { 516, 6, 8, 7, 1, -6 },
  { 522, 6, 6, 7, 1, -6 },
  { 527, 6, 6, 7, 0, -6 },
  { 532, 6, 8, 7, 1, -8 },
  { 538, 6, 6, 7, 1, -6 },
  { 543, 6, 6, 7, 1, -6 },
  { 548, 6, 6, 7, 1, -6 },
  { 553, 7, 6, 7, 0, -6 },
  { 559, 8, 9, 7, 0, -6 },
  { 568, 7, 6, 7, 0, -6 },
  { 574, 4, 11, 7, 2, -9 },
  { 580, 3, 11, 7, 2, -9 },
  { 585, 5, 11, 7, 1, -9 },
  { 592, 7, 3, 7, 0, -5 },
};

const GFXfont RobotoMono_BoldItalic12pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic12pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOMONO_BOLDITALIC12PT7B_H_
