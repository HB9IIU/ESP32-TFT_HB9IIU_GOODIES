#ifndef _ROBOTOMONO_BOLDITALIC69PT7B_H_
#define _ROBOTOMONO_BOLDITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x3F, 0x81, 0xFC,
  0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0x8F,
  0xE0, 0x3F, 0x1F, 0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF9, 0xFC,
  0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x60, 0x7E, 0x07, 0xE0,
  0x3F, 0x3F, 0x81, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x07, 0xC3, 0xF8, 0x1F,
  0x83, 0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x3F, 0x83, 0xF8, 0xFC, 0x0F, 0xE0,
  0xFC, 0x3F, 0x03, 0xF8, 0x7F, 0x1F, 0x80, 0x7F, 0xFF, 0xCF, 0xC0, 0x1F,
  0xFF, 0xE3, 0xF0, 0x03, 0xFF, 0xF1, 0xF8, 0x00, 0x7F, 0xF8, 0xFC, 0x00,
  0x0F, 0xFC, 0x7E, 0x00, 0x00, 0x78, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0xFF, 0xC0, 0x00,
  0xFC, 0xFF, 0xF8, 0x00, 0x7E, 0x7F, 0xFF, 0x00, 0x3F, 0x3F, 0xFF, 0xE0,
  0x0F, 0xCF, 0xFF, 0xF8, 0x07, 0xE7, 0xF0, 0xFE, 0x03, 0xF1, 0xFC, 0x1F,
  0x80, 0xF8, 0x7E, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0,
  0x7E, 0x1F, 0x83, 0xF8, 0x1F, 0x83, 0xE0, 0xFE, 0x07, 0xE0, 0x30, 0x3F,
  0x81, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00,
  0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xF8,
  0x1F, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF,
  0xE0, 0x7F, 0x87, 0xFE, 0x7F, 0xC0, 0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE,
  0x3F, 0xF0, 0xFF, 0x87, 0xF8, 0xFF, 0xC1, 0xFF, 0x9F, 0xF1, 0xFF, 0x01,
  0xFF, 0xBF, 0xC3, 0xFE, 0x03, 0xFF, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xFF,
  0x1F, 0xF8, 0x03, 0xFF, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0xF0, 0x7F, 0xE0,
  0x07, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0xFC, 0x7F, 0xE0, 0x03,
  0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF1,
  0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x06, 0x00, 0x7E, 0x00, 0x21, 0xE0, 0x1F, 0x80, 0x78,
  0xFE, 0x07, 0xE0, 0x7E, 0x3F, 0xE1, 0xF0, 0x7F, 0x9F, 0xFE, 0x7C, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00,
  0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x40, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00,
  0xFE, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xE0, 0x0F, 0xFF,
  0x8F, 0xF8, 0x0F, 0xFF, 0xE3, 0xFE, 0x07, 0xFF, 0xF8, 0xFF, 0x87, 0xFF,
  0xFE, 0x3F, 0xE3, 0xFF, 0xFF, 0x9F, 0xFB, 0xFF, 0x7F, 0xC7, 0xFD, 0xFF,
  0x1F, 0xF1, 0xFF, 0xFF, 0x87, 0xFC, 0x7F, 0xFF, 0x81, 0xFF, 0x1F, 0xFF,
  0xC0, 0x7F, 0xC7, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF,
  0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFE,
  0x0F, 0xF8, 0xF0, 0x0F, 0xF8, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x7F,
  0xE0, 0x00, 0x40, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x0E, 0x00, 0x07, 0xFC, 0x7F, 0xF0, 0x03, 0xFE, 0xFF, 0xFC, 0x03,
  0xFE, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFE, 0x07, 0xFF,
  0x1F, 0xFC, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x1F,
  0xF7, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x1F, 0xF9, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xC0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xE0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x03, 0xFE, 0x3F,
  0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFE,
  0x0F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x07,
  0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03,
  0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFE, 0x7F, 0xE0, 0x1F, 0xFE, 0x7F, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC,
  0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF,
  0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xF0,
  0x1F, 0xC0, 0xFF, 0x83, 0xE0, 0x3F, 0x03, 0xFF, 0xC7, 0xC0, 0xFC, 0x1F,
  0xFF, 0xC7, 0xC1, 0xF8, 0x7F, 0xFF, 0x0F, 0x87, 0xE1, 0xFF, 0xFE, 0x1F,
  0x0F, 0xC3, 0xF8, 0x7C, 0x3E, 0x3F, 0x0F, 0xE0, 0xF8, 0x7C, 0x7E, 0x1F,
  0x83, 0xF0, 0xF8, 0xF8, 0x7E, 0x07, 0xC1, 0xF3, 0xF0, 0xFC, 0x0F, 0x83,
  0xE7, 0xE3, 0xF0, 0x1F, 0x0F, 0x8F, 0x87, 0xE0, 0x7E, 0x1F, 0x3F, 0x0F,
  0xC0, 0xF8, 0x3E, 0x7E, 0x1F, 0x01, 0xF0, 0x7C, 0xFC, 0x7E, 0x03, 0xE0,
  0xF9, 0xF0, 0xFC, 0x0F, 0xC1, 0xE3, 0xE1, 0xF8, 0x1F, 0x07, 0xC7, 0xC3,
  0xF0, 0x3E, 0x0F, 0x9F, 0x87, 0xE0, 0x7C, 0x1F, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7C, 0x7E, 0x1F, 0x83, 0xF0, 0xF8, 0xFC, 0x3F, 0x0F, 0xE3, 0xE1, 0xF8,
  0x7F, 0xFF, 0xCF, 0xC3, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xE0, 0xFF, 0xFF,
  0xFC, 0x07, 0xC0, 0xFF, 0xBF, 0xF0, 0x0F, 0xC1, 0xFC, 0x3F, 0xC0, 0x1F,
  0x80, 0xE0, 0x1E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0x80, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x07,
  0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0xF9, 0xFF, 0x80,
  0xFF, 0xFF, 0x8F, 0xF8, 0x07, 0xFF, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xE3,
  0xFE, 0x01, 0xFF, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xF8, 0xFF, 0x80, 0x80,
  0xFF, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xC3, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xE1,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF9, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xDF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0xE0, 0x0F, 0xFF, 0xEF,
  0xEF, 0xF0, 0x0F, 0xFF, 0xF7, 0xF7, 0xF8, 0x07, 0xF9, 0xFB, 0xF3, 0xFC,
  0x03, 0xFC, 0xFF, 0xFB, 0xFE, 0x01, 0xFE, 0x7F, 0xFD, 0xFE, 0x00, 0xFF,
  0x3F, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xFE, 0x7F, 0x80, 0x7F, 0xCF, 0xFE,
  0x3F, 0xC0, 0x3F, 0xC7, 0xFF, 0x3F, 0xE0, 0x1F, 0xE3, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF1, 0xFF, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x87, 0xF8, 0x03, 0xFC,
  0x3F, 0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xE1,
  0xFF, 0x00, 0xFF, 0x07, 0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xF0, 0x7F, 0x80,
  0x3F, 0xC1, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFC,
  0x01, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xBF, 0x83, 0xFE, 0x00, 0x7F,
  0xDF, 0xC1, 0xFF, 0x00, 0x7F, 0xEF, 0xE0, 0xFF, 0x80, 0x3F, 0xF7, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF1, 0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0xFE, 0x3F, 0xF0,
  0x07, 0xFC, 0x7F, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0x8F, 0xF8, 0x03, 0xFF,
  0x0F, 0xE7, 0xFC, 0x01, 0xFF, 0x87, 0xF3, 0xFE, 0x00, 0xFF, 0x83, 0xFB,
  0xFF, 0x00, 0x7F, 0xC1, 0xFD, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xFF, 0x80,
  0x1F, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFC,
  0x0F, 0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03,
  0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03,
  0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x03, 0xFF,
  0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFF, 0x3F,
  0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xFC,
  0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03,
  0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF8,
  0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00,
  0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xE3, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01,
  0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFE, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFC,
  0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00,
  0x3F, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0xFF,
  0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x7F, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0x01, 0xFF, 0x7F, 0xC0, 0xFF,
  0x01, 0xFE, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x03, 0xFE,
  0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x7F, 0x81,
  0xFF, 0x07, 0xFC, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x7F, 0x83, 0xFF, 0x07,
  0xF8, 0x7F, 0x83, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFF, 0x0F, 0xF8, 0x7F,
  0x87, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xFF,
  0x1F, 0xF0, 0x7F, 0x87, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xFF, 0x1F, 0xE0,
  0x7F, 0x8F, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xFF, 0x3F, 0xE0, 0x7F, 0x9F,
  0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xFE, 0x3F, 0xC0, 0x7F, 0x9F, 0xFE, 0x3F,
  0xC0, 0x7F, 0xBF, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0x7E, 0x7F, 0x80, 0x7F,
  0xBF, 0x7E, 0x7F, 0x80, 0x7F, 0xBF, 0x7E, 0xFF, 0x80, 0x7F, 0xFF, 0x7E,
  0xFF, 0x00, 0x7F, 0xFE, 0x7E, 0xFF, 0x00, 0x7F, 0xFE, 0x7E, 0xFF, 0x00,
  0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x7F, 0xFE, 0x00, 0x7F, 0xFC,
  0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x7F,
  0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFD, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F,
  0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F,
  0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC1, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xF1, 0xFF, 0xC0,
  0x0F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0xC0,
  0x03, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x80,
  0x3F, 0xF8, 0x7F, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x3F, 0xFC, 0x00, 0x7F,
  0xDF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF1, 0xFF,
  0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF3, 0xFF, 0xFE, 0x01, 0xFE,
  0x3F, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xBF, 0xFE, 0x0F, 0xFE, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0E, 0x3F, 0xE0, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF,
  0xFD, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF9,
  0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xDF, 0xE0, 0x00, 0x7F,
  0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xE1, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x07, 0xF8,
  0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F,
  0xF7, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x02, 0x01, 0xFF, 0x80, 0x01, 0xC0,
  0x7F, 0xF0, 0x01, 0xF8, 0x0F, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x0E, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x04, 0x00, 0x3F, 0xFE, 0x1F, 0xE0, 0x01,
  0xFF, 0xFE, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFC, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xDF, 0xF0, 0x00,
  0x7F, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x3C, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x08,
  0x00, 0x07, 0xFC, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x03, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xFE, 0x00, 0x3F, 0xE7, 0xFF,
  0xF0, 0x03, 0xFE, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF0,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xE0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x10, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0xC0,
  0x03, 0xFE, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xFC, 0x00, 0x0F, 0xF8,
  0xFF, 0xF0, 0x00, 0x1F, 0xF3, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFF, 0x00,
  0x00, 0xFF, 0xBF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xEF, 0xFC,
  0x00, 0x07, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03,
  0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x07, 0xF9, 0xFF, 0x1F, 0xF0, 0x0F, 0xF7, 0xFF, 0x7F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xF8,
  0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE,
  0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x1F,
  0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFC,
  0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0xE0, 0x03, 0xFC, 0x7F, 0xFF, 0x00, 0x3F,
  0xCF, 0xFF, 0xF8, 0x03, 0xFD, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFF,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFE, 0x7F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xFD,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xF8, 0x00,
  0x3F, 0xEF, 0xFF, 0xE0, 0x01, 0xFE, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0xFF, 0x00, 0x7F, 0xE7, 0xFF, 0xE0,
  0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC3, 0xFC, 0x03, 0xFF, 0xFC, 0xFF, 0x80,
  0xFF, 0xFF, 0xDF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0xFF, 0xFE, 0x1F, 0xFE, 0x03,
  0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF8,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xE0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F,
  0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF7, 0xFC, 0x00,
  0x1F, 0xF8, 0xFF, 0x80, 0x00, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0x8F, 0xFF, 0xF0, 0x3F,
  0xCF, 0xFF, 0xF0, 0x3F, 0xEF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8,
  0x7F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0xE7,
  0xF8, 0x03, 0xFF, 0xF8, 0xFF, 0x00, 0x3F, 0xFE, 0x3F, 0xE0, 0x03, 0xFF,
  0x87, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0xEF, 0xF0,
  0x3F, 0xC0, 0xFF, 0xBF, 0xC0, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0x0F,
  0xF3, 0xFC, 0x1F, 0xF0, 0x7F, 0xCF, 0xF0, 0x7F, 0xC1, 0xFE, 0x3F, 0xC1,
  0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0xF0, 0xFF,
  0x0F, 0xE0, 0xFF, 0xC3, 0xFC, 0x3F, 0x87, 0xFF, 0x1F, 0xE0, 0xFE, 0x1F,
  0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0xF1, 0xFE, 0x0F, 0xE3, 0xFF, 0xC7, 0xF0,
  0x3F, 0x8F, 0xBF, 0x3F, 0xC0, 0xFE, 0x7E, 0xFC, 0xFF, 0x03, 0xF9, 0xFB,
  0xF3, 0xF8, 0x0F, 0xE7, 0xCF, 0xDF, 0xE0, 0x3F, 0xBF, 0x3F, 0x7F, 0x80,
  0xFE, 0xFC, 0xFD, 0xFC, 0x03, 0xFB, 0xE3, 0xF7, 0xF0, 0x0F, 0xFF, 0x87,
  0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00,
  0x07, 0xFB, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x0B, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0x83, 0xFF, 0xFC, 0x00, 0x7F, 0x1F, 0xFF,
  0xF8, 0x01, 0xFC, 0xFF, 0xFF, 0xF0, 0x0F, 0xF3, 0xFF, 0xFF, 0xE0, 0x3F,
  0x9F, 0xFF, 0xFF, 0xF3, 0xFE, 0x7F, 0x83, 0xFF, 0xFF, 0xF9, 0xFC, 0x03,
  0xFF, 0xFF, 0xC7, 0xE0, 0x07, 0xFF, 0xFE, 0x3F, 0x80, 0x0F, 0xFF, 0xF8,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00,
};

const GFXglyph RobotoMono_BoldItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 18, 50, 41, 12, -49 },
  { 114, 23, 18, 41, 11, -52 },
  { 166, 40, 49, 41, 0, -49 },
  { 411, 37, 64, 41, 3, -57 },
  { 707, 34, 51, 41, 4, -50 },
  { 924, 39, 51, 41, 1, -50 },
  { 1173, 10, 19, 41, 17, -52 },
  { 1197, 23, 70, 41, 11, -55 },
  { 1399, 24, 70, 41, 5, -55 },
  { 1609, 34, 35, 41, 5, -49 },
  { 1758, 34, 36, 41, 3, -41 },
  { 1911, 15, 22, 41, 6, -8 },
  { 1953, 28, 7, 41, 9, -25 },
  { 1978, 13, 13, 41, 11, -12 },
  { 2000, 36, 53, 41, 3, -49 },
  { 2239, 34, 51, 41, 4, -50 },
  { 2456, 24, 49, 41, 8, -49 },
  { 2603, 37, 50, 41, 0, -50 },
  { 2835, 36, 51, 41, 2, -50 },
  { 3065, 35, 49, 41, 1, -49 },
  { 3280, 36, 50, 41, 3, -49 },
  { 3505, 33, 51, 41, 3, -50 },
  { 3716, 36, 49, 41, 4, -49 },
  { 3937, 35, 51, 41, 2, -50 },
  { 4161, 32, 50, 41, 5, -50 },
  { 4361, 17, 41, 41, 12, -40 },
  { 4449, 21, 54, 41, 9, -40 },
  { 4591, 32, 32, 41, 5, -37 },
  { 4719, 35, 22, 41, 3, -32 },
  { 4816, 32, 32, 41, 3, -37 },
  { 4944, 31, 51, 41, 8, -50 },
  { 5142, 39, 49, 41, 1, -49 },
  { 5381, 40, 49, 41, -3, -49 },
  { 5626, 39, 49, 41, 1, -49 },
  { 5865, 38, 51, 41, 2, -50 },
  { 6108, 38, 49, 41, 1, -49 },
  { 6341, 41, 49, 41, 1, -49 },
  { 6593, 41, 49, 41, 1, -49 },
  { 6845, 37, 51, 41, 3, -50 },
  { 7081, 41, 49, 41, 0, -49 },
  { 7333, 36, 49, 41, 3, -49 },
  { 7554, 39, 50, 41, 2, -49 },
  { 7798, 45, 49, 41, 1, -49 },
  { 8074, 33, 49, 41, 1, -49 },
  { 8277, 41, 49, 41, 1, -49 },
  { 8529, 41, 49, 41, 0, -49 },
  { 8781, 37, 51, 41, 2, -50 },
  { 9017, 40, 49, 41, 1, -49 },
  { 9262, 37, 59, 41, 2, -50 },
  { 9535, 39, 49, 41, 1, -49 },
  { 9774, 38, 51, 41, 2, -50 },
  { 10017, 39, 49, 41, 5, -49 },
  { 10256, 38, 50, 41, 3, -49 },
  { 10494, 38, 49, 41, 6, -49 },
  { 10727, 40, 49, 41, 4, -49 },
  { 10972, 46, 49, 41, -2, -49 },
  { 11254, 39, 49, 41, 6, -49 },
  { 11493, 42, 49, 41, 0, -49 },
  { 11751, 25, 68, 41, 8, -57 },
  { 11964, 17, 53, 41, 13, -49 },
  { 12077, 25, 68, 41, 8, -57 },
  { 12290, 28, 26, 41, 7, -49 },
  { 12381, 31, 7, 41, 0, 0 },
  { 12409, 14, 10, 41, 18, -50 },
  { 12427, 33, 38, 41, 2, -37 },
  { 12584, 35, 53, 41, 1, -52 },
  { 12816, 33, 38, 41, 3, -37 },
  { 12973, 38, 53, 41, 3, -52 },
  { 13225, 34, 38, 41, 3, -37 },
  { 13387, 37, 53, 41, 6, -53 },
  { 13633, 38, 51, 41, 1, -37 },
  { 13876, 36, 52, 41, 1, -52 },
  { 14110, 31, 51, 41, 3, -51 },
  { 14308, 31, 66, 41, 2, -51 },
  { 14564, 39, 52, 41, 1, -52 },
  { 14818, 31, 52, 41, 3, -52 },
  { 15020, 39, 37, 41, -1, -37 },
  { 15201, 36, 37, 41, 1, -37 },
  { 15368, 34, 38, 41, 3, -37 },
  { 15530, 37, 51, 41, -1, -37 },
  { 15766, 35, 51, 41, 3, -37 },
  { 15990, 33, 37, 41, 6, -37 },
  { 16143, 35, 38, 41, 2, -37 },
  { 16310, 31, 46, 41, 6, -45 },
  { 16489, 35, 37, 41, 4, -36 },
  { 16651, 36, 36, 41, 5, -36 },
  { 16813, 38, 36, 41, 4, -36 },
  { 16984, 42, 36, 41, -1, -36 },
  { 17173, 43, 51, 41, 0, -36 },
  { 17448, 38, 36, 41, 1, -36 },
  { 17619, 26, 66, 41, 10, -54 },
  { 17834, 16, 63, 41, 12, -49 },
  { 17960, 27, 66, 41, 6, -54 },
  { 18183, 38, 15, 41, 0, -28 },
};

const GFXfont RobotoMono_BoldItalic69pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic69pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _ROBOTOMONO_BOLDITALIC69PT7B_H_
