#ifndef _ROBOTOMONO_BOLDITALIC66PT7B_H_
#define _ROBOTOMONO_BOLDITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x08, 0x00, 0x3F, 0x81, 0xFC, 0xFE, 0x07,
  0xF3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3,
  0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x20, 0x7E, 0x0F, 0xC0, 0x70, 0xFE, 0x0F,
  0xC0, 0xFC, 0xFC, 0x0F, 0xC0, 0xF8, 0xFC, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F,
  0xC3, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x1F,
  0x8F, 0xC0, 0xFF, 0x3F, 0x8F, 0x80, 0x7F, 0xFF, 0x1F, 0x80, 0x7F, 0xFF,
  0x3F, 0x00, 0x3F, 0xFE, 0x7E, 0x00, 0x1F, 0xF8, 0x7C, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E,
  0x3F, 0xF8, 0x00, 0x7E, 0x7F, 0xFC, 0x00, 0xFC, 0xFF, 0xFE, 0x00, 0xF9,
  0xFF, 0xFE, 0x01, 0xF9, 0xFE, 0xFE, 0x03, 0xF3, 0xF8, 0x7F, 0x07, 0xE3,
  0xF0, 0x3F, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x83,
  0xF0, 0x3F, 0x1F, 0x03, 0xF0, 0x3F, 0x07, 0x03, 0xF0, 0x7E, 0x02, 0x03,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x07, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0xFE, 0x01, 0xFE, 0x1F,
  0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0x0F, 0xFD, 0xFF, 0x07,
  0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xCF, 0xFC, 0x3F, 0xE3, 0xFE, 0x7F, 0xC0,
  0xFF, 0x9F, 0xE3, 0xFE, 0x07, 0xFF, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0xF1,
  0xFF, 0x00, 0xFF, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0xF8, 0x7F, 0xC0, 0x0F,
  0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xF8,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x18, 0x01,
  0xF0, 0x06, 0x3E, 0x03, 0xF0, 0x1E, 0x3F, 0x83, 0xE0, 0x7E, 0x7F, 0xE3,
  0xE3, 0xFF, 0x7F, 0xFB, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x0B, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F,
  0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F,
  0x81, 0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x83, 0xFC,
  0x7F, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC,
  0x3F, 0x80, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF,
  0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF,
  0x3F, 0xE0, 0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF,
  0x3F, 0xE0, 0x3F, 0xFE, 0x3F, 0xC0, 0xFF, 0xFE, 0x7F, 0xC1, 0xFF, 0xFE,
  0x7F, 0xC7, 0xFF, 0xFE, 0x7F, 0xCF, 0xFB, 0xFE, 0x7F, 0xFF, 0xE3, 0xFE,
  0x7F, 0xFF, 0xC3, 0xFC, 0x7F, 0xFF, 0x03, 0xFC, 0x7F, 0xFE, 0x07, 0xFC,
  0xFF, 0xF8, 0x07, 0xFC, 0xFF, 0xF0, 0x07, 0xFC, 0xFF, 0xC0, 0x07, 0xFC,
  0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF8,
  0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0,
  0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFB, 0xFC, 0xFF, 0x0F, 0xF3, 0xE0, 0x7F, 0xCC, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F,
  0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0xBF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC1, 0xFF,
  0xE0, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0x02, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xCF, 0xFF, 0x80, 0xFF,
  0xBF, 0xFF, 0x81, 0xFE, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0,
  0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0xFF,
  0xCF, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE3, 0xFE, 0x00,
  0x7F, 0x9F, 0xF0, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xFD, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE7, 0xF8, 0x00, 0x7C, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFE, 0x01, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x3C, 0x07, 0xE0, 0x7F, 0xE1,
  0xF0, 0x7E, 0x0F, 0xFF, 0x8F, 0x83, 0xE0, 0xFF, 0xFC, 0x7C, 0x3F, 0x0F,
  0xFF, 0xE3, 0xE1, 0xF0, 0xFF, 0x1F, 0x1F, 0x1F, 0x87, 0xE0, 0xF8, 0xF8,
  0xF8, 0x7E, 0x0F, 0x87, 0xCF, 0xC3, 0xF0, 0x7C, 0x3E, 0x7E, 0x3F, 0x03,
  0xE1, 0xF3, 0xE1, 0xF8, 0x1F, 0x0F, 0x9F, 0x0F, 0x81, 0xF0, 0x7D, 0xF8,
  0xFC, 0x0F, 0x83, 0xCF, 0x87, 0xE0, 0x7C, 0x1E, 0x7C, 0x3E, 0x03, 0xE1,
  0xF3, 0xE1, 0xF0, 0x3E, 0x0F, 0x9F, 0x0F, 0x81, 0xF0, 0x7D, 0xF8, 0xFC,
  0x0F, 0x83, 0xCF, 0xC7, 0xE0, 0x7C, 0x3E, 0x7E, 0x3F, 0x07, 0xE1, 0xE3,
  0xF0, 0xF8, 0x3E, 0x1F, 0x1F, 0x87, 0xE3, 0xF0, 0xF8, 0xFC, 0x3F, 0xFF,
  0xFF, 0x87, 0xE1, 0xFF, 0xFF, 0xF8, 0x1F, 0x07, 0xFD, 0xFF, 0x80, 0xF8,
  0x3F, 0xC7, 0xF8, 0x07, 0xC0, 0x7C, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x02, 0x00, 0x00, 0xFF, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xE3,
  0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xFE,
  0x3F, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xE1, 0xFF, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F,
  0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xFC, 0x07,
  0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0xF3, 0xFE, 0x03,
  0xFF, 0xFE, 0x7F, 0xC0, 0x7F, 0xFF, 0xCF, 0xF8, 0x0F, 0xFF, 0xF1, 0xFF,
  0x01, 0xFF, 0xFE, 0x3F, 0xE0, 0x3F, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x08,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xFF, 0x00,
  0x00, 0x07, 0xFD, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xC0, 0x00,
  0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xE0, 0x1F, 0xFF,
  0x0F, 0xFF, 0xC0, 0x3F, 0xBE, 0x3F, 0xFF, 0x80, 0xFF, 0x7E, 0x7E, 0xFF,
  0x01, 0xFE, 0xFD, 0xFD, 0xFC, 0x03, 0xFD, 0xFB, 0xF7, 0xF8, 0x07, 0xFB,
  0xFF, 0xEF, 0xF0, 0x0F, 0xF7, 0xFF, 0x9F, 0xE0, 0x1F, 0xCF, 0xFF, 0x3F,
  0xC0, 0x7F, 0x9F, 0xFC, 0x7F, 0x00, 0xFF, 0x3F, 0xF9, 0xFE, 0x01, 0xFE,
  0x7F, 0xF3, 0xFC, 0x03, 0xFC, 0x7F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x8F,
  0xF0, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x7F, 0x80, 0x7F,
  0x87, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0x83,
  0xFC, 0x03, 0xFC, 0x3F, 0x07, 0xF8, 0x0F, 0xF8, 0x7C, 0x1F, 0xF0, 0x1F,
  0xE0, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xE0,
  0x07, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0xF8,
  0x03, 0xFF, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xE0, 0x1F, 0xF7,
  0xF0, 0x7F, 0xC0, 0x3F, 0xEF, 0xE0, 0xFF, 0x80, 0x7F, 0xCF, 0xC3, 0xFE,
  0x00, 0xFF, 0x9F, 0xC7, 0xFC, 0x01, 0xFF, 0x3F, 0x8F, 0xF8, 0x03, 0xFC,
  0x7F, 0x1F, 0xF0, 0x0F, 0xF8, 0x7E, 0x3F, 0xE0, 0x1F, 0xF0, 0xFE, 0x7F,
  0xC0, 0x3F, 0xE1, 0xFD, 0xFF, 0x00, 0x7F, 0xC3, 0xFB, 0xFE, 0x00, 0xFF,
  0x83, 0xF7, 0xFC, 0x01, 0xFE, 0x07, 0xEF, 0xF8, 0x07, 0xFC, 0x0F, 0xFF,
  0xF0, 0x0F, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xFF, 0x80, 0x3F,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F,
  0xF1, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x3F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x1F,
  0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFC,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFC,
  0x3F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFE,
  0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x80,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x03,
  0xFD, 0xFE, 0x03, 0xF8, 0x0F, 0xF7, 0xF8, 0x1F, 0xE0, 0x7F, 0x9F, 0xE0,
  0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFC, 0x07, 0xF9, 0xFE, 0x07, 0xF0, 0x3F,
  0xE7, 0xF8, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x7F, 0x83,
  0xFC, 0x0F, 0xF1, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC1, 0xFE,
  0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x1F, 0xE1, 0xFE, 0x3F,
  0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0xC3, 0xFC, 0x1F, 0xE3, 0xFF, 0x0F, 0xF0,
  0x7F, 0x1F, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0xF1, 0xFE, 0x07, 0xF1, 0xFF,
  0xC7, 0xF8, 0x1F, 0xCF, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x7C, 0xFF, 0x01,
  0xFC, 0xFD, 0xF3, 0xFC, 0x07, 0xF3, 0xF7, 0xCF, 0xF0, 0x1F, 0xDF, 0x9F,
  0x7F, 0x80, 0x7F, 0x7E, 0x7D, 0xFE, 0x01, 0xFD, 0xF9, 0xF7, 0xF8, 0x07,
  0xFF, 0xC7, 0xDF, 0xC0, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x7F,
  0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x3F,
  0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF,
  0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00,
  0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F,
  0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE7, 0xE0, 0x03, 0xF9, 0xF8, 0x01,
  0xFC, 0x7E, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0xFC,
  0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00,
  0xFE, 0x3F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xE7, 0xF8, 0x01, 0xFD, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x87, 0xFC,
  0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFE,
  0x0F, 0xF8, 0x03, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x1F, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x03, 0xFC,
  0x7F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0xC0, 0x07, 0xFC,
  0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF8,
  0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xEF, 0xF8, 0x0F, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0x0F, 0xF8,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x20, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x03, 0xFC, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F,
  0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03,
  0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC,
  0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFF, 0x01,
  0xFE, 0xFF, 0xFF, 0x80, 0xFF, 0x8F, 0xFF, 0xC0, 0x3F, 0xC1, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x01,
  0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x07,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xFD, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xFC,
  0xFF, 0x80, 0x1F, 0xFF, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xCF,
  0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x1F,
  0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x3F,
  0xE0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x7F, 0xC0, 0x00, 0xC0, 0x7F,
  0xE0, 0x01, 0xE0, 0x7F, 0xF0, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x0E, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0xFF, 0x00, 0x1F, 0xFF, 0x9F, 0xF0, 0x07, 0xFF, 0xFD, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xBF, 0xC0, 0x01, 0xFF, 0xF3, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xC0, 0x00,
  0x1F, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x80, 0x01, 0xFF, 0x80, 0x1C, 0x00, 0x1F, 0xF8, 0x03, 0xE0, 0x07,
  0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x10, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x03, 0xFC,
  0x7F, 0xFC, 0x00, 0xFF, 0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xFC,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01,
  0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x10,
  0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xF0,
  0x3F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x01, 0xFE, 0x0F, 0xFE, 0x00,
  0x07, 0xF8, 0x7F, 0xF0, 0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x00, 0xFF, 0x9F,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0xFF,
  0xC0, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x7F,
  0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x10, 0x01, 0x00, 0x0F, 0xF3, 0xF8, 0x3F, 0x80, 0x3F, 0x9F,
  0xF3, 0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFC, 0x7F, 0xC7, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83,
  0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F,
  0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF,
  0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F,
  0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC1,
  0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x07, 0xFE, 0x00,
  0x3F, 0xC7, 0xFF, 0xC0, 0x0F, 0xF3, 0xFF, 0xF8, 0x03, 0xFD, 0xFF, 0xFF,
  0x01, 0xFE, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0,
  0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xFC,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE,
  0x1F, 0xF8, 0x03, 0xFE, 0x3F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFC,
  0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xFD, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x00, 0xFF, 0x3F, 0xFE, 0x00, 0x0F, 0xF7, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xE7, 0xFF, 0xE0, 0x03, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xE0,
  0x3E, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0xC7, 0xF8, 0x07, 0xFF,
  0xF9, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC,
  0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFD,
  0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x38, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xFC, 0x0F, 0xFF, 0x07, 0xFC,
  0x3F, 0xFE, 0x07, 0xF8, 0xFF, 0xFE, 0x07, 0xF9, 0xFF, 0xFE, 0x07, 0xFB,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x7F, 0xE3, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x02, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF1, 0xFF,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F,
  0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xFC,
  0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F,
  0xFC, 0x3F, 0xE0, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF,
  0xDF, 0xE0, 0x3F, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0x8F, 0xF0, 0x01, 0xFF,
  0x87, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x07, 0xFC,
  0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xE0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0x01, 0xFE, 0xFE, 0x03, 0xF0,
  0x1F, 0xEF, 0xE0, 0x7F, 0x01, 0xFE, 0xFE, 0x07, 0xF0, 0x3F, 0xCF, 0xE0,
  0x7F, 0x03, 0xFC, 0xFE, 0x0F, 0xF0, 0x3F, 0xCF, 0xE0, 0xFF, 0x07, 0xF8,
  0xFE, 0x0F, 0xF0, 0x7F, 0x8F, 0xE1, 0xFF, 0x07, 0xF8, 0xFE, 0x1F, 0xF0,
  0x7F, 0x0F, 0xE1, 0xFF, 0x8F, 0xF0, 0xFE, 0x3F, 0xF8, 0xFE, 0x0F, 0xE3,
  0xFF, 0x8F, 0xE0, 0xFE, 0x3F, 0xF9, 0xFE, 0x0F, 0xE7, 0xDF, 0x9F, 0xC0,
  0xFE, 0x7D, 0xF9, 0xFC, 0x0F, 0xEF, 0xCF, 0xBF, 0xC0, 0xFE, 0xF8, 0xFB,
  0xF8, 0x0F, 0xCF, 0x8F, 0xBF, 0x80, 0xFD, 0xF8, 0xFB, 0xF8, 0x0F, 0xDF,
  0x0F, 0xFF, 0x00, 0xFD, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xC0, 0xFF,
  0xFE, 0x00, 0x3F, 0x1F, 0xFF, 0xF0, 0x03, 0xF3, 0xFF, 0xFF, 0x80, 0x7F,
  0x3F, 0xFF, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x83, 0xFF,
  0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xCF, 0xC0,
  0x03, 0xFF, 0xF8, 0x3C, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoMono_BoldItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 17, 48, 39, 11, -47 },
  { 103, 22, 18, 39, 11, -50 },
  { 153, 39, 47, 39, 0, -47 },
  { 383, 35, 61, 39, 3, -54 },
  { 650, 32, 49, 39, 4, -48 },
  { 846, 37, 49, 39, 1, -48 },
  { 1073, 10, 18, 39, 16, -50 },
  { 1096, 22, 67, 39, 10, -52 },
  { 1281, 23, 67, 39, 5, -52 },
  { 1474, 32, 33, 39, 5, -47 },
  { 1606, 33, 34, 39, 3, -39 },
  { 1747, 14, 21, 39, 6, -8 },
  { 1784, 28, 7, 39, 8, -24 },
  { 1809, 12, 12, 39, 11, -11 },
  { 1827, 34, 51, 39, 3, -47 },
  { 2044, 32, 49, 39, 4, -48 },
  { 2240, 22, 47, 39, 8, -47 },
  { 2370, 35, 48, 39, 0, -48 },
  { 2580, 34, 49, 39, 2, -48 },
  { 2789, 34, 47, 39, 1, -47 },
  { 2989, 36, 48, 39, 2, -47 },
  { 3205, 31, 48, 39, 3, -47 },
  { 3391, 34, 47, 39, 4, -47 },
  { 3591, 34, 49, 39, 2, -48 },
  { 3800, 30, 48, 39, 5, -48 },
  { 3980, 17, 39, 39, 11, -38 },
  { 4063, 20, 51, 39, 9, -38 },
  { 4191, 31, 31, 39, 4, -36 },
  { 4312, 33, 21, 39, 3, -30 },
  { 4399, 32, 31, 39, 2, -35 },
  { 4523, 29, 48, 39, 8, -48 },
  { 4697, 37, 47, 39, 1, -47 },
  { 4915, 38, 47, 39, -3, -47 },
  { 5139, 38, 47, 39, 1, -47 },
  { 5363, 36, 49, 39, 2, -48 },
  { 5584, 36, 47, 39, 1, -47 },
  { 5796, 39, 47, 39, 1, -47 },
  { 6026, 39, 47, 39, 1, -47 },
  { 6256, 35, 49, 39, 3, -48 },
  { 6471, 39, 47, 39, 0, -47 },
  { 6701, 34, 47, 39, 3, -47 },
  { 6901, 37, 48, 39, 2, -47 },
  { 7123, 43, 47, 39, 1, -47 },
  { 7376, 32, 47, 39, 1, -47 },
  { 7564, 39, 47, 39, 1, -47 },
  { 7794, 39, 47, 39, 0, -47 },
  { 8024, 35, 49, 39, 2, -48 },
  { 8239, 38, 47, 39, 1, -47 },
  { 8463, 36, 56, 39, 2, -48 },
  { 8715, 38, 47, 39, 1, -47 },
  { 8939, 37, 49, 39, 2, -48 },
  { 9166, 38, 47, 39, 4, -47 },
  { 9390, 36, 48, 39, 3, -47 },
  { 9606, 37, 47, 39, 5, -47 },
  { 9824, 38, 47, 39, 4, -47 },
  { 10048, 44, 47, 39, -2, -47 },
  { 10307, 37, 47, 39, 6, -47 },
  { 10525, 40, 47, 39, 0, -47 },
  { 10760, 24, 65, 39, 8, -54 },
  { 10955, 16, 51, 39, 12, -47 },
  { 11057, 24, 65, 39, 8, -54 },
  { 11252, 26, 25, 39, 7, -47 },
  { 11334, 30, 7, 39, 0, 0 },
  { 11361, 13, 9, 39, 18, -48 },
  { 11376, 32, 37, 39, 2, -36 },
  { 11524, 34, 51, 39, 1, -50 },
  { 11741, 32, 37, 39, 3, -36 },
  { 11889, 36, 51, 39, 3, -50 },
  { 12119, 32, 37, 39, 3, -36 },
  { 12267, 36, 51, 39, 5, -51 },
  { 12497, 36, 50, 39, 1, -36 },
  { 12722, 34, 50, 39, 1, -50 },
  { 12935, 29, 49, 39, 3, -49 },
  { 13113, 30, 63, 39, 2, -49 },
  { 13350, 38, 50, 39, 1, -50 },
  { 13588, 30, 50, 39, 3, -50 },
  { 13776, 38, 36, 39, -1, -36 },
  { 13947, 34, 36, 39, 1, -36 },
  { 14100, 32, 37, 39, 3, -36 },
  { 14248, 36, 49, 39, -1, -36 },
  { 14469, 34, 49, 39, 3, -36 },
  { 14678, 32, 36, 39, 6, -36 },
  { 14822, 33, 37, 39, 2, -36 },
  { 14975, 31, 44, 39, 5, -43 },
  { 15146, 33, 36, 39, 4, -35 },
  { 15295, 34, 35, 39, 5, -35 },
  { 15444, 36, 35, 39, 4, -35 },
  { 15602, 39, 35, 39, 0, -35 },
  { 15773, 41, 49, 39, 0, -35 },
  { 16025, 36, 35, 39, 1, -35 },
  { 16183, 26, 64, 39, 9, -52 },
  { 16391, 14, 60, 39, 12, -47 },
  { 16496, 26, 63, 39, 6, -51 },
  { 16701, 36, 15, 39, 0, -27 },
};

const GFXfont RobotoMono_BoldItalic66pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic66pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic66pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _ROBOTOMONO_BOLDITALIC66PT7B_H_
