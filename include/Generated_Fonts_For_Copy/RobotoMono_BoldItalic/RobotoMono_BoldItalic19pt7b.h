#ifndef _ROBOTOMONO_BOLDITALIC19PT7B_H_
#define _ROBOTOMONO_BOLDITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCE, 0x73, 0x18, 0xCE, 0x70, 0x00, 0xCE, 0x70, 0x6D, 0x3C,
  0xF3, 0xC8, 0x06, 0x60, 0xC8, 0x13, 0x06, 0x43, 0xFE, 0xFF, 0xC6, 0x40,
  0xD8, 0x13, 0x1F, 0xF8, 0xD8, 0x13, 0x06, 0x40, 0xD8, 0x00, 0x02, 0x00,
  0x80, 0x60, 0x7E, 0x3B, 0xDC, 0x77, 0x1D, 0xC0, 0x3C, 0x07, 0xC0, 0x78,
  0x0E, 0xC3, 0xB8, 0xE7, 0xF1, 0xF8, 0x18, 0x04, 0x00, 0x30, 0x3C, 0x32,
  0x79, 0x2D, 0xB3, 0xB0, 0x30, 0x10, 0x1B, 0x1B, 0xCB, 0x2D, 0x90, 0xD8,
  0x38, 0x07, 0x01, 0xF0, 0x76, 0x0C, 0xC1, 0x98, 0x3E, 0x07, 0x81, 0xE3,
  0x7E, 0xEC, 0xDB, 0x9F, 0x71, 0xC7, 0xF8, 0x7F, 0x80, 0xFF, 0x80, 0x04,
  0x31, 0x8C, 0x31, 0x86, 0x38, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x61,
  0x83, 0x00, 0x20, 0xC1, 0x86, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xC7, 0x18,
  0x63, 0x0C, 0x63, 0x08, 0x00, 0x06, 0x01, 0x80, 0x41, 0x12, 0xF7, 0xC7,
  0xC1, 0xC0, 0xD8, 0x63, 0x08, 0x80, 0x0E, 0x06, 0x03, 0x1F, 0xFF, 0xFF,
  0xFC, 0x60, 0x30, 0x18, 0x1C, 0x00, 0x77, 0x66, 0xC8, 0x7F, 0xFF, 0xEF,
  0xE0, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C,
  0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x00, 0x0E, 0x0F, 0x8E, 0xEE,
  0x36, 0x1B, 0x1D, 0x9F, 0xFF, 0xF3, 0xF1, 0xF8, 0xDC, 0xE7, 0xE1, 0xE0,
  0x02, 0x1D, 0xF7, 0xE8, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x87,
  0x00, 0x07, 0x07, 0xE3, 0xDC, 0xC7, 0x71, 0xC0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xFF, 0xBF, 0xE0, 0x07, 0x03, 0xF8, 0xF7, 0x1C,
  0x60, 0x0C, 0x03, 0x83, 0xE0, 0x7C, 0x01, 0x80, 0x39, 0x87, 0x31, 0xC7,
  0xF8, 0x7C, 0x00, 0x01, 0xC0, 0x70, 0x3C, 0x1E, 0x0F, 0x87, 0x61, 0xB8,
  0xCE, 0x63, 0xBF, 0xFF, 0xFC, 0x0C, 0x07, 0x01, 0xC0, 0x3F, 0xCF, 0xF3,
  0xF8, 0xC0, 0x70, 0x1B, 0x87, 0xF1, 0x8C, 0x03, 0x80, 0xEC, 0x33, 0x9C,
  0xFE, 0x1F, 0x00, 0x03, 0x07, 0x87, 0xC7, 0x07, 0x03, 0x73, 0xFD, 0xC7,
  0xC3, 0xE1, 0xF0, 0xFC, 0xE7, 0xE1, 0xE0, 0x7F, 0xDF, 0xF7, 0xFC, 0x0E,
  0x03, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38,
  0x00, 0x0E, 0x1F, 0x8E, 0xEE, 0x37, 0x1B, 0x9C, 0xFC, 0xFC, 0xE7, 0x61,
  0xB0, 0xD8, 0xEF, 0xF3, 0xE0, 0x0E, 0x1F, 0x9C, 0xEC, 0x7E, 0x1F, 0x0F,
  0x8E, 0xEF, 0x7F, 0x8D, 0x81, 0xC1, 0xC7, 0xC3, 0x80, 0x39, 0xCE, 0x00,
  0x00, 0x00, 0x67, 0xB8, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x08, 0xC3,
  0x0C, 0x71, 0x8C, 0x00, 0x01, 0x83, 0xCF, 0xCF, 0x0E, 0x03, 0xE0, 0x7C,
  0x0E, 0x01, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x60,
  0x3C, 0x0F, 0x81, 0xF0, 0x79, 0xFB, 0xE1, 0xC0, 0x80, 0x00, 0x1C, 0x3F,
  0x9D, 0xFC, 0x70, 0x38, 0x38, 0x38, 0x38, 0x18, 0x1C, 0x00, 0x06, 0x07,
  0x01, 0x80, 0x0F, 0xC3, 0x08, 0xC9, 0x97, 0xD6, 0xD2, 0xB2, 0xD6, 0x5E,
  0xDA, 0xDB, 0x5B, 0xF1, 0x00, 0x39, 0x03, 0xE0, 0x01, 0x80, 0x70, 0x0E,
  0x03, 0xE0, 0x6C, 0x1D, 0x83, 0x30, 0xE6, 0x18, 0xC7, 0xF8, 0xFF, 0xB8,
  0x77, 0x0F, 0xC1, 0xC0, 0x1E, 0x07, 0xF8, 0xFF, 0x9C, 0x73, 0x0E, 0x61,
  0xDF, 0xF3, 0xFC, 0x71, 0xCE, 0x19, 0x83, 0x30, 0xEF, 0xF9, 0xFE, 0x00,
  0x0E, 0x0F, 0xE3, 0xB9, 0xC7, 0x61, 0xF8, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x3B, 0x8C, 0x7F, 0x1F, 0x80, 0x3C, 0x07, 0xF0, 0xFF, 0x1C, 0xE3,
  0x0C, 0x61, 0xDC, 0x3B, 0x86, 0x70, 0xCC, 0x39, 0x87, 0x31, 0xCF, 0xF1,
  0xF8, 0x00, 0x1F, 0xF1, 0xFE, 0x3F, 0xE3, 0x80, 0x38, 0x03, 0x00, 0x3F,
  0xC7, 0xF8, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x7F, 0xCF, 0xF8, 0x1F,
  0xF1, 0xFE, 0x3F, 0xE3, 0x80, 0x38, 0x03, 0x00, 0x3F, 0xC7, 0xFC, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x0E, 0x07, 0xE3, 0xB9,
  0xC7, 0x61, 0xF8, 0x0E, 0x03, 0x9E, 0xCF, 0xB0, 0xEC, 0x3B, 0x8E, 0x7F,
  0x8F, 0x80, 0x38, 0x67, 0x0C, 0xE3, 0x98, 0x73, 0x0E, 0x61, 0x9F, 0xF3,
  0xFE, 0x71, 0xCC, 0x39, 0x86, 0x30, 0xCE, 0x19, 0xC7, 0x00, 0x3F, 0xCF,
  0xF3, 0xF8, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0x60, 0xFF, 0x3F, 0x80, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xEC, 0x3B, 0x9C, 0xFE, 0x1F, 0x00, 0x18, 0x79,
  0xC7, 0x8E, 0x38, 0x73, 0x83, 0x38, 0x1B, 0x81, 0xF8, 0x0F, 0xC0, 0x7F,
  0x03, 0x98, 0x18, 0xE0, 0xC7, 0x0E, 0x1C, 0x70, 0xE0, 0x18, 0x0C, 0x0E,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x07, 0xFF,
  0xFC, 0x1C, 0xE7, 0x9C, 0xF7, 0x9E, 0xF3, 0xF6, 0x7F, 0xDF, 0xB3, 0xB6,
  0x64, 0xCC, 0x99, 0x87, 0x30, 0xEE, 0x19, 0xC3, 0x00, 0x38, 0x67, 0x1C,
  0xE3, 0x9E, 0x73, 0xCE, 0x79, 0x9D, 0x33, 0xBE, 0x77, 0xCC, 0xF9, 0x8E,
  0x31, 0xCE, 0x39, 0xC7, 0x00, 0x0E, 0x0F, 0xE3, 0xB9, 0xC7, 0x61, 0xF8,
  0x7E, 0x1F, 0x06, 0xC1, 0xB0, 0x6C, 0x3B, 0x9C, 0x7E, 0x1F, 0x00, 0x1E,
  0x03, 0xF8, 0xFF, 0x9C, 0x73, 0x86, 0x61, 0xCC, 0x3B, 0xFE, 0x7F, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x00, 0x0E, 0x0F, 0xE3, 0xB9, 0xC7,
  0x61, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xB0, 0x6C, 0x3B, 0x9C, 0x7E, 0x0F,
  0xC0, 0x78, 0x0C, 0x1E, 0x07, 0xF8, 0xFF, 0x9C, 0x73, 0x0E, 0x61, 0xCC,
  0x73, 0xFC, 0x7F, 0x0E, 0x61, 0x8E, 0x31, 0xCE, 0x19, 0xC3, 0x80, 0x0E,
  0x0F, 0xE7, 0xBD, 0xC7, 0x60, 0x1C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x6C,
  0x1B, 0x8E, 0xFF, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x00, 0x30, 0xDC, 0x37, 0x1D, 0xC7, 0x61, 0xD8, 0x6E, 0x1B, 0x86, 0xE3,
  0xB8, 0xEE, 0x3B, 0x9C, 0x7F, 0x1F, 0x00, 0xC1, 0xF0, 0x7C, 0x3B, 0x8E,
  0xE3, 0x39, 0xCE, 0x61, 0xB8, 0x6C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1C,
  0x00, 0xE6, 0x7C, 0xDF, 0xBB, 0xF7, 0x6E, 0xED, 0xFF, 0xBF, 0xE6, 0xBC,
  0xF7, 0x9E, 0xF3, 0xDC, 0x73, 0x8E, 0x71, 0xCC, 0x00, 0x1C, 0x38, 0xE3,
  0xC7, 0x1C, 0x19, 0xC0, 0xEC, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x80,
  0x6C, 0x07, 0x70, 0x73, 0x87, 0x0C, 0x78, 0x70, 0xC0, 0xF8, 0x7E, 0x39,
  0x8E, 0x67, 0x1D, 0x87, 0xE0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30,
  0x1C, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0xFD, 0xFF, 0x80, 0x1E, 0x3C,
  0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x18, 0x30,
  0x61, 0xF3, 0xC0, 0xCC, 0xCC, 0xCE, 0x66, 0x66, 0x67, 0x33, 0x30, 0x1E,
  0x3C, 0x38, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x38, 0x70, 0xC1, 0x83, 0x06,
  0x1C, 0x39, 0xF3, 0xC0, 0x0C, 0x0C, 0x1C, 0x36, 0x36, 0x66, 0x66, 0xC3,
  0xFF, 0xFF, 0x80, 0xE6, 0x30, 0x3E, 0x3F, 0x98, 0xE0, 0x77, 0xF7, 0x9B,
  0x0D, 0x8E, 0xFF, 0x3F, 0x80, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x37, 0x8F,
  0xF3, 0x1D, 0xC7, 0x71, 0xDC, 0x76, 0x1D, 0xCE, 0x7F, 0xBB, 0xC0, 0x1F,
  0x3F, 0x98, 0xFC, 0x3E, 0x06, 0x03, 0x01, 0xC6, 0x7F, 0x1E, 0x00, 0x00,
  0xC0, 0x70, 0x1C, 0x07, 0x3D, 0x9F, 0xE6, 0x3B, 0x8E, 0xE3, 0xB0, 0xEC,
  0x33, 0x9C, 0xFF, 0x1E, 0xC0, 0x1F, 0x3F, 0xDC, 0xFC, 0x3F, 0xFF, 0xFF,
  0x01, 0xC2, 0x7F, 0x1F, 0x00, 0x03, 0x83, 0xF1, 0xE4, 0x60, 0x38, 0xBF,
  0xCF, 0xF0, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x00,
  0x1F, 0xE7, 0xF8, 0xE7, 0x38, 0x67, 0x1C, 0xC3, 0x98, 0x73, 0x8C, 0x7F,
  0x87, 0xB0, 0x0E, 0x23, 0x8F, 0xF0, 0x78, 0x00, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x37, 0x8F, 0xF3, 0x1D, 0xC3, 0x71, 0xDC, 0x76, 0x1D, 0x86, 0x61,
  0xB8, 0x60, 0x06, 0x07, 0x06, 0x00, 0x3E, 0x7E, 0x0E, 0x0C, 0x0C, 0x0C,
  0x1C, 0x1C, 0xFF, 0xFF, 0x01, 0x81, 0xC0, 0x60, 0x01, 0xF8, 0xF8, 0x0C,
  0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x7C, 0x7C,
  0x00, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x1E, 0x67, 0x8D, 0xC3, 0xF0,
  0x7E, 0x0F, 0xC1, 0xDC, 0x31, 0x86, 0x39, 0xC3, 0x80, 0x3F, 0x3E, 0x06,
  0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0xFF, 0xFF, 0x7F,
  0xCF, 0xFD, 0x9B, 0xB3, 0x66, 0xED, 0xD9, 0xBB, 0x36, 0x6E, 0xCD, 0xDB,
  0xB0, 0x37, 0x8F, 0xF3, 0x1D, 0xC3, 0x71, 0xDC, 0x76, 0x1D, 0x86, 0x61,
  0xB8, 0xE0, 0x3E, 0x3F, 0x98, 0xFC, 0x3C, 0x1E, 0x1F, 0x0F, 0xCE, 0x7F,
  0x3E, 0x00, 0x37, 0x8F, 0xF3, 0x1D, 0xC7, 0x71, 0xDC, 0x76, 0x1D, 0xCE,
  0x7F, 0xBF, 0xCE, 0x03, 0x80, 0xC0, 0x30, 0x00, 0x3D, 0xDF, 0xE6, 0x3B,
  0x8E, 0xE3, 0xB0, 0xEC, 0x33, 0x9C, 0xFF, 0x1F, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0x77, 0xB7, 0x9E, 0x4E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0,
  0x60, 0x00, 0x3F, 0x3F, 0xD8, 0x6C, 0x07, 0xE0, 0xF8, 0x0F, 0x87, 0xFF,
  0x3F, 0x00, 0x18, 0x38, 0x38, 0xFF, 0xFF, 0x30, 0x30, 0x70, 0x70, 0x70,
  0x70, 0x7E, 0x3E, 0x71, 0xD8, 0x66, 0x19, 0x86, 0xE3, 0xB8, 0xEE, 0x3B,
  0x9C, 0xFF, 0x1E, 0xC0, 0xE1, 0xD8, 0x66, 0x39, 0x8C, 0x77, 0x0D, 0x83,
  0xE0, 0xF0, 0x3C, 0x0E, 0x00, 0xCC, 0xF3, 0x3D, 0xDF, 0x76, 0xD5, 0xBD,
  0xEF, 0x73, 0x9C, 0xE6, 0x31, 0x80, 0x38, 0xE7, 0x38, 0x7E, 0x0F, 0x80,
  0xF0, 0x1C, 0x07, 0xC1, 0xD8, 0x73, 0x9C, 0x38, 0x70, 0x73, 0x0E, 0x30,
  0xC3, 0x9C, 0x39, 0x81, 0xB8, 0x1F, 0x01, 0xE0, 0x1E, 0x00, 0xC0, 0x1C,
  0x03, 0x80, 0xF0, 0x0E, 0x00, 0x3F, 0xE7, 0xF8, 0x0F, 0x03, 0xC0, 0xF0,
  0x38, 0x0E, 0x03, 0x80, 0xFF, 0xDF, 0xF0, 0x06, 0x1C, 0x70, 0xC1, 0x83,
  0x0E, 0x18, 0xF1, 0x81, 0x81, 0x83, 0x0E, 0x1C, 0x38, 0x30, 0x70, 0x18,
  0x84, 0x23, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x31, 0x08, 0x46, 0x00, 0x10,
  0x70, 0x60, 0xE1, 0x83, 0x06, 0x0C, 0x0E, 0x1C, 0x61, 0xC3, 0x06, 0x0C,
  0x38, 0x61, 0x80, 0x30, 0x1F, 0x1F, 0xFF, 0x1F, 0x01, 0x00,
};

const GFXglyph RobotoMono_BoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 14, 11, 3, -14 },
  { 10, 6, 5, 11, 3, -14 },
  { 14, 11, 14, 11, 0, -14 },
  { 34, 10, 18, 11, 1, -16 },
  { 57, 9, 14, 11, 1, -14 },
  { 73, 11, 14, 11, 0, -14 },
  { 93, 2, 5, 11, 5, -14 },
  { 95, 6, 19, 11, 3, -15 },
  { 110, 6, 19, 11, 2, -15 },
  { 125, 10, 10, 11, 1, -14 },
  { 138, 9, 10, 11, 1, -11 },
  { 150, 4, 6, 11, 2, -2 },
  { 153, 8, 2, 11, 2, -7 },
  { 155, 4, 3, 11, 3, -3 },
  { 157, 10, 15, 11, 1, -14 },
  { 176, 9, 14, 11, 1, -14 },
  { 192, 7, 14, 11, 2, -14 },
  { 205, 10, 14, 11, 0, -14 },
  { 223, 11, 14, 11, 0, -14 },
  { 243, 10, 14, 11, 0, -14 },
  { 261, 10, 14, 11, 1, -14 },
  { 279, 9, 14, 11, 1, -14 },
  { 295, 10, 14, 11, 1, -14 },
  { 313, 9, 14, 11, 1, -14 },
  { 329, 9, 14, 11, 1, -14 },
  { 345, 5, 11, 11, 3, -11 },
  { 352, 6, 15, 11, 2, -11 },
  { 364, 9, 9, 11, 1, -10 },
  { 375, 10, 6, 11, 1, -9 },
  { 383, 9, 9, 11, 1, -10 },
  { 394, 9, 14, 11, 2, -14 },
  { 410, 11, 13, 11, 0, -13 },
  { 428, 11, 14, 11, -1, -14 },
  { 448, 11, 14, 11, 0, -14 },
  { 468, 10, 14, 11, 1, -14 },
  { 486, 11, 14, 11, 0, -14 },
  { 506, 12, 14, 11, 0, -14 },
  { 527, 12, 14, 11, 0, -14 },
  { 548, 10, 14, 11, 1, -14 },
  { 566, 11, 14, 11, 0, -14 },
  { 586, 10, 14, 11, 1, -14 },
  { 604, 10, 14, 11, 1, -14 },
  { 622, 13, 14, 11, 0, -14 },
  { 645, 9, 14, 11, 0, -14 },
  { 661, 11, 14, 11, 0, -14 },
  { 681, 11, 14, 11, 0, -14 },
  { 701, 10, 14, 11, 1, -14 },
  { 719, 11, 14, 11, 0, -14 },
  { 739, 10, 16, 11, 1, -14 },
  { 759, 11, 14, 11, 0, -14 },
  { 779, 10, 14, 11, 1, -14 },
  { 797, 11, 14, 11, 1, -14 },
  { 817, 10, 14, 11, 1, -14 },
  { 835, 10, 14, 11, 2, -14 },
  { 853, 11, 14, 11, 1, -14 },
  { 873, 13, 14, 11, -1, -14 },
  { 896, 10, 14, 11, 2, -14 },
  { 914, 11, 14, 11, 0, -14 },
  { 934, 7, 19, 11, 2, -16 },
  { 951, 4, 15, 11, 4, -14 },
  { 959, 7, 19, 11, 2, -16 },
  { 976, 8, 8, 11, 2, -14 },
  { 984, 9, 2, 11, 0, 0 },
  { 987, 4, 3, 11, 5, -14 },
  { 989, 9, 10, 11, 1, -10 },
  { 1001, 10, 14, 11, 0, -14 },
  { 1019, 9, 10, 11, 1, -10 },
  { 1031, 10, 14, 11, 1, -14 },
  { 1049, 9, 10, 11, 1, -10 },
  { 1061, 10, 15, 11, 2, -15 },
  { 1080, 11, 14, 11, 0, -10 },
  { 1100, 10, 14, 11, 0, -14 },
  { 1118, 8, 14, 11, 1, -14 },
  { 1132, 9, 18, 11, 0, -14 },
  { 1153, 11, 14, 11, 0, -14 },
  { 1173, 8, 14, 11, 1, -14 },
  { 1187, 11, 10, 11, 0, -10 },
  { 1201, 10, 10, 11, 0, -10 },
  { 1214, 9, 10, 11, 1, -10 },
  { 1226, 10, 14, 11, 0, -10 },
  { 1244, 10, 14, 11, 1, -10 },
  { 1262, 9, 10, 11, 2, -10 },
  { 1274, 9, 10, 11, 1, -10 },
  { 1286, 8, 13, 11, 2, -13 },
  { 1299, 10, 10, 11, 1, -10 },
  { 1312, 10, 10, 11, 1, -10 },
  { 1325, 10, 10, 11, 1, -10 },
  { 1338, 11, 10, 11, 0, -10 },
  { 1352, 12, 14, 11, 0, -10 },
  { 1373, 11, 10, 11, 0, -10 },
  { 1387, 7, 18, 11, 3, -15 },
  { 1403, 5, 18, 11, 3, -14 },
  { 1415, 7, 18, 11, 2, -15 },
  { 1431, 10, 5, 11, 0, -8 },
};

const GFXfont RobotoMono_BoldItalic19pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic19pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOMONO_BOLDITALIC19PT7B_H_
