#ifndef _ROBOTOMONO_BOLDITALIC52PT7B_H_
#define _ROBOTOMONO_BOLDITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x07,
  0xE0, 0x00, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x0F, 0x8F, 0x83, 0xE3, 0xC0, 0xF9, 0xF0, 0x3C, 0x7C, 0x1F, 0x1F, 0x07,
  0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0xF8, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0,
  0x78, 0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x7C, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xE3, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x7F,
  0x87, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xE3, 0xE0, 0x41, 0xE0, 0xF0,
  0x39, 0xF0, 0x78, 0x3E, 0xF8, 0x3C, 0x3E, 0x7C, 0x1E, 0x1E, 0x3E, 0x1F,
  0x1E, 0x1F, 0x0F, 0x9F, 0x07, 0xDF, 0x9F, 0x03, 0xFF, 0xCF, 0x00, 0xFF,
  0xCF, 0x80, 0x3F, 0xCF, 0x80, 0x07, 0x87, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE1, 0xE0, 0x01, 0xE3, 0xFC, 0x01, 0xF7, 0xFF, 0x01, 0xF7, 0xFF,
  0x80, 0xF3, 0xF7, 0xE0, 0xF3, 0xE1, 0xF0, 0xF9, 0xF0, 0xF8, 0x78, 0xF8,
  0x7C, 0x78, 0x7C, 0x3E, 0x7C, 0x3E, 0x1F, 0x04, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF8,
  0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFE,
  0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0x87, 0xFF, 0xC0,
  0xFC, 0x7F, 0xFF, 0x0F, 0xC7, 0xFB, 0xF8, 0x7E, 0x7F, 0x9F, 0xE3, 0xF3,
  0xF8, 0x7F, 0x3F, 0xBF, 0xC1, 0xFF, 0xF9, 0xFC, 0x0F, 0xFF, 0xCF, 0xE0,
  0x3F, 0xFC, 0x7F, 0x01, 0xFF, 0xC3, 0xF8, 0x07, 0xFE, 0x1F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xF9, 0xFC, 0x03, 0xFF, 0x0F, 0xF0, 0x01,
  0x80, 0x00, 0x00, 0x3E, 0x7C, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E, 0x7D, 0xF3,
  0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x60, 0x3E, 0x02, 0x3C, 0x1E, 0x07, 0xBF, 0x8F, 0x1F, 0xDF,
  0xF7, 0xBF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF7, 0xC0,
  0x01, 0xF9, 0xE0, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x1F,
  0x01, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x0C, 0x01, 0xC0, 0x02, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0,
  0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE1,
  0xF8, 0x3E, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x0E, 0x0F, 0xE7, 0xF9,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFD, 0xFE, 0x3F, 0x03, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0,
  0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x7F,
  0x03, 0xFF, 0x3F, 0x03, 0xFF, 0xBF, 0x87, 0xFF, 0xDF, 0xC7, 0xFF, 0xEF,
  0xEF, 0xEF, 0xE7, 0xFF, 0xE7, 0xF3, 0xFF, 0xC3, 0xF9, 0xFF, 0xC1, 0xFD,
  0xFF, 0x80, 0xFE, 0xFF, 0x80, 0x7F, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x3F,
  0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE1, 0xF8, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xFE, 0x0F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xDF,
  0xCF, 0x87, 0xF3, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFE, 0x7F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xCF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x07,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC,
  0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFD,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0x78, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x01,
  0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x3C, 0x01, 0xFC, 0xFF, 0x80, 0xFE, 0xFF,
  0xF0, 0x7E, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xF8,
  0x7F, 0xCF, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xFD, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xBF,
  0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF1,
  0xFE, 0x07, 0xF8, 0x7F, 0x8F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xC7, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xE1, 0xFE, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xE3, 0xFC,
  0x07, 0xF8, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xE3, 0xFC, 0x3F, 0xC0,
  0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0x03,
  0xFE, 0x7F, 0xCF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFE,
  0xFC, 0x0F, 0xFD, 0xFC, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0xFC,
  0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFE, 0x07, 0xE0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xFC, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x20, 0x00, 0x00, 0x38,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0xBF, 0xC0,
  0x7F, 0x7F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0xFC,
  0x00, 0xF0, 0x0F, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0xC1, 0xF0,
  0x78, 0x7C, 0x3F, 0xE3, 0xC3, 0xC3, 0xFF, 0x9E, 0x3C, 0x3F, 0xFC, 0xF1,
  0xE3, 0xF1, 0xC7, 0x9E, 0x1E, 0x1E, 0x3C, 0xF1, 0xF0, 0xF1, 0xEF, 0x8F,
  0x07, 0x8F, 0x78, 0xF8, 0x38, 0x7B, 0xC7, 0x83, 0xC3, 0xDE, 0x3C, 0x1E,
  0x1D, 0xF1, 0xE0, 0xF1, 0xEF, 0x1F, 0x0F, 0x8F, 0x78, 0xF8, 0x78, 0x7B,
  0xC7, 0xC3, 0xC3, 0x9E, 0x3E, 0x1E, 0x3C, 0xF1, 0xF1, 0xF1, 0xC7, 0x87,
  0xFF, 0xFE, 0x3C, 0x3F, 0xFF, 0xE1, 0xF1, 0xFD, 0xFE, 0x07, 0x87, 0xC7,
  0xE0, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x3F, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0xFF, 0x00,
  0x03, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x1F, 0xC0, 0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F,
  0x80, 0x1F, 0xE1, 0xFC, 0x01, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0x80,
  0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC,
  0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8,
  0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0xC0, 0xFE,
  0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFC,
  0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F,
  0x1F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xFE, 0x7F,
  0x07, 0xFF, 0xCF, 0xE0, 0x7F, 0xFC, 0xFE, 0x07, 0xFF, 0xCF, 0xE0, 0x7F,
  0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xC3, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF0,
  0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80,
  0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0xFE, 0x00,
  0x7F, 0xC0, 0x3F, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xFC, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x1F,
  0xC0, 0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0xC0, 0x03, 0xF8, 0x3F, 0xE0, 0x00,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x8F, 0xFE, 0x07, 0xFF,
  0x1F, 0xFC, 0x0F, 0xFE, 0x7F, 0xF8, 0x1F, 0xBC, 0xFF, 0xF0, 0x3F, 0x7B,
  0xFF, 0xC0, 0x7E, 0xF7, 0xDF, 0x80, 0xFD, 0xEF, 0xBF, 0x03, 0xFB, 0xFE,
  0x7E, 0x07, 0xE7, 0xFD, 0xFC, 0x0F, 0xCF, 0xF3, 0xF8, 0x1F, 0x9F, 0xE7,
  0xE0, 0x3F, 0x3F, 0x8F, 0xC0, 0xFE, 0x7F, 0x1F, 0x81, 0xFC, 0x7C, 0x3F,
  0x03, 0xF0, 0xF8, 0xFE, 0x07, 0xE1, 0xE1, 0xF8, 0x0F, 0xC3, 0xC3, 0xF0,
  0x1F, 0x87, 0x87, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F,
  0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x7F,
  0xC0, 0x3F, 0x80, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0x01, 0xFC, 0x07, 0xFF,
  0x03, 0xF8, 0x0F, 0xFE, 0x07, 0xF0, 0x1F, 0xFC, 0x0F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xC0, 0x7F, 0xF8, 0x7F, 0x81, 0xFD, 0xF0, 0xFE, 0x03, 0xFB, 0xE1,
  0xFC, 0x07, 0xF7, 0xC3, 0xF8, 0x0F, 0xEF, 0xC7, 0xF0, 0x1F, 0xCF, 0x8F,
  0xE0, 0x3F, 0x9F, 0x3F, 0x80, 0xFE, 0x3E, 0x7F, 0x01, 0xFC, 0x7E, 0xFE,
  0x03, 0xF8, 0x7D, 0xFC, 0x07, 0xF0, 0xFB, 0xF8, 0x0F, 0xE1, 0xF7, 0xF0,
  0x1F, 0xC3, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0x01,
  0xFC, 0x0F, 0xFE, 0x03, 0xF8, 0x1F, 0xFC, 0x07, 0xF0, 0x1F, 0xF8, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0x80, 0xFE,
  0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x07, 0xFC, 0xFF, 0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xC7, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0x81, 0xFC,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x07, 0xFE, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07,
  0xF3, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC7, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC3,
  0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x01,
  0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x88, 0x00, 0x00,
  0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x3F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF8,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFC, 0xFE,
  0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xFC,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x83,
  0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03,
  0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0xFD, 0xF8, 0x3F, 0x07, 0xF7, 0xE0,
  0xFC, 0x1F, 0x9F, 0x83, 0xF0, 0x7E, 0x7E, 0x0F, 0xC3, 0xF9, 0xF8, 0x7F,
  0x0F, 0xE7, 0xE1, 0xFC, 0x3F, 0x1F, 0x87, 0xF0, 0xFC, 0x7E, 0x3F, 0xC7,
  0xF1, 0xF8, 0xFF, 0x1F, 0x87, 0xE3, 0xFC, 0x7E, 0x1F, 0x8F, 0xF1, 0xF8,
  0x7E, 0x7F, 0xCF, 0xE1, 0xF9, 0xFF, 0x3F, 0x07, 0xE7, 0xFC, 0xFC, 0x1F,
  0xBF, 0xF7, 0xF0, 0x7E, 0xFF, 0xDF, 0x81, 0xFB, 0xDF, 0x7E, 0x07, 0xFF,
  0x7D, 0xF8, 0x1F, 0xFD, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x01, 0xF7, 0x9F,
  0xFC, 0x07, 0xFE, 0x7F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xC7, 0xFE,
  0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00,
  0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F,
  0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xFE,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xBF,
  0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF,
  0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFD,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C,
  0x3F, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x3F, 0x01, 0xF1,
  0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xF8, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F,
  0x80, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0,
  0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x7F, 0xC7,
  0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xDF,
  0x81, 0xFF, 0xEF, 0xE0, 0x1F, 0xF1, 0xFC, 0x00, 0x40, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x87, 0xE0, 0x07, 0xE7, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC,
  0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3,
  0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE7, 0xF0, 0x03, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x1F, 0xF8,
  0x7F, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFE, 0xFF, 0xFC, 0x3F,
  0xBF, 0xFC, 0x0F, 0xC3, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x3F, 0x9F, 0xC0, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x4F, 0xE0, 0x0F, 0xC7,
  0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x1F, 0xC0,
  0x1F, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x7E, 0x00, 0x1F, 0xE3,
  0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0x1F, 0x8F, 0xE0,
  0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x18, 0x1F, 0xE0, 0x0F, 0x03, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x84, 0x00, 0x07, 0xFE, 0x7F,
  0x01, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x83, 0xFC, 0x0F, 0xF8, 0x3F, 0xE3,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0x7F, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0x20, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x10, 0x01, 0xFE, 0x03, 0x00, 0x3F, 0xC0, 0x7C, 0x07, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0xFE, 0x3F, 0xE0, 0x1F, 0xDF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFE, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0xC7, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xF8,
  0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F,
  0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x10, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x10, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x0F,
  0xF0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x1F, 0xF0, 0x0F, 0xE1, 0xFF, 0x00,
  0x7E, 0x1F, 0xF0, 0x07, 0xF1, 0xFF, 0x00, 0x3F, 0x9F, 0xF0, 0x01, 0xFD,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xE3, 0xC1, 0xE0, 0x1F, 0xBF, 0x9F,
  0xC0, 0x7D, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFE, 0x3F, 0x9F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE1, 0xF8, 0x7E, 0x3F, 0x8F,
  0xE3, 0xF8, 0x01, 0xE0, 0xFC, 0x01, 0xFC, 0x7F, 0xE0, 0x3F, 0xBF, 0xFE,
  0x07, 0xEF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7,
  0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0xFE,
  0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFE, 0x07, 0xF8,
  0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF0, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xEF, 0xE0,
  0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF,
  0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x7F,
  0x87, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x78, 0x7E, 0x00, 0x1F, 0x9F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFC, 0x0F,
  0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xBF, 0xFC, 0x03, 0xF8,
  0xFF, 0x80, 0x3F, 0x80, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF9, 0xFC,
  0x0F, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x87, 0xF8, 0x1F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xF1, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFB, 0xF0,
  0x03, 0xFC, 0xFE, 0x00, 0x0C, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x10, 0x7F, 0xC1, 0xF8, 0x7F, 0xE0,
  0x7E, 0x7F, 0xF8, 0x1F, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x04, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFC, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x7E,
  0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF3, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF,
  0xF0, 0x0F, 0xF1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x38, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0x9F, 0xC0, 0x0F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xF8,
  0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07,
  0xF8, 0xFE, 0x03, 0xFE, 0x3F, 0xE3, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFB, 0xF0, 0x3F, 0xFE, 0xFC, 0x0F, 0xFE, 0x7F, 0x00, 0xFF, 0x1F, 0xC0,
  0x02, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFB, 0xF8, 0x00,
  0xFF, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x3F,
  0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF3, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x1F, 0x03, 0xFF, 0xC1, 0xF0, 0x7F, 0xFC, 0x1F, 0x07,
  0xEF, 0xC3, 0xF0, 0x7E, 0xFC, 0x3F, 0x0F, 0xEF, 0xC3, 0xF0, 0xFC, 0xFC,
  0x7F, 0x0F, 0xCF, 0xC7, 0xF0, 0xFC, 0xFC, 0xFF, 0x1F, 0x8F, 0xCF, 0xF1,
  0xF8, 0xF8, 0xFF, 0x1F, 0x8F, 0x9F, 0xF3, 0xF0, 0xF9, 0xEF, 0x3F, 0x0F,
  0x9E, 0xF3, 0xE0, 0xFB, 0xCF, 0x7E, 0x0F, 0xBC, 0xF7, 0xE0, 0xFB, 0xCF,
  0x7C, 0x0F, 0xF8, 0xF7, 0xC0, 0xFF, 0x8F, 0xFC, 0x0F, 0xF8, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x03, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE,
  0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x00, 0xFF, 0x87, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x03, 0x80, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x04, 0x07, 0xFF, 0x80, 0x3E, 0x7F, 0xFE, 0x03, 0xE3, 0xFF, 0xF8,
  0x1F, 0x3F, 0xFF, 0xF3, 0xF9, 0xF8, 0x7F, 0xFF, 0x9F, 0x81, 0xFF, 0xFC,
  0xF8, 0x07, 0xFF, 0xC3, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
};

const GFXglyph RobotoMono_BoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 13, 37, 31, 9, -37 },
  { 62, 18, 13, 31, 8, -39 },
  { 92, 30, 37, 31, 0, -37 },
  { 231, 28, 48, 31, 2, -43 },
  { 399, 25, 39, 31, 3, -38 },
  { 521, 29, 39, 31, 1, -38 },
  { 663, 7, 14, 31, 13, -39 },
  { 676, 18, 53, 31, 8, -41 },
  { 796, 18, 53, 31, 4, -41 },
  { 916, 25, 26, 31, 4, -37 },
  { 998, 26, 27, 31, 2, -31 },
  { 1086, 11, 16, 31, 5, -6 },
  { 1108, 21, 6, 31, 7, -19 },
  { 1124, 10, 10, 31, 8, -9 },
  { 1137, 27, 40, 31, 2, -37 },
  { 1272, 25, 39, 31, 3, -38 },
  { 1394, 18, 37, 31, 6, -37 },
  { 1478, 28, 38, 31, 0, -38 },
  { 1611, 28, 39, 31, 1, -38 },
  { 1748, 27, 37, 31, 0, -37 },
  { 1873, 28, 38, 31, 2, -37 },
  { 2006, 25, 38, 31, 2, -37 },
  { 2125, 27, 37, 31, 3, -37 },
  { 2250, 26, 39, 31, 2, -38 },
  { 2377, 24, 38, 31, 4, -38 },
  { 2491, 13, 31, 31, 9, -30 },
  { 2542, 16, 40, 31, 7, -30 },
  { 2622, 25, 24, 31, 3, -28 },
  { 2697, 27, 17, 31, 2, -24 },
  { 2755, 25, 25, 31, 2, -28 },
  { 2834, 23, 38, 31, 6, -38 },
  { 2944, 29, 37, 31, 1, -37 },
  { 3079, 30, 37, 31, -2, -37 },
  { 3218, 29, 37, 31, 1, -37 },
  { 3353, 28, 39, 31, 2, -38 },
  { 3490, 29, 37, 31, 0, -37 },
  { 3625, 31, 37, 31, 1, -37 },
  { 3769, 31, 37, 31, 1, -37 },
  { 3913, 28, 39, 31, 2, -38 },
  { 4050, 31, 37, 31, 0, -37 },
  { 4194, 27, 37, 31, 2, -37 },
  { 4319, 29, 38, 31, 2, -37 },
  { 4457, 34, 37, 31, 1, -37 },
  { 4615, 25, 37, 31, 1, -37 },
  { 4731, 31, 37, 31, 0, -37 },
  { 4875, 31, 37, 31, 0, -37 },
  { 5019, 28, 39, 31, 2, -38 },
  { 5156, 30, 37, 31, 1, -37 },
  { 5295, 28, 45, 31, 2, -38 },
  { 5453, 29, 37, 31, 1, -37 },
  { 5588, 30, 39, 31, 1, -38 },
  { 5735, 30, 37, 31, 3, -37 },
  { 5874, 29, 38, 31, 2, -37 },
  { 6012, 29, 37, 31, 4, -37 },
  { 6147, 30, 37, 31, 3, -37 },
  { 6286, 35, 37, 31, -2, -37 },
  { 6448, 29, 37, 31, 5, -37 },
  { 6583, 31, 37, 31, 0, -37 },
  { 6727, 19, 52, 31, 6, -43 },
  { 6851, 12, 40, 31, 10, -37 },
  { 6911, 19, 52, 31, 6, -43 },
  { 7035, 21, 20, 31, 5, -37 },
  { 7088, 24, 6, 31, 0, 0 },
  { 7106, 10, 8, 31, 14, -38 },
  { 7116, 26, 29, 31, 1, -28 },
  { 7211, 26, 40, 31, 1, -39 },
  { 7341, 25, 29, 31, 2, -28 },
  { 7432, 29, 40, 31, 2, -39 },
  { 7577, 26, 29, 31, 2, -28 },
  { 7672, 29, 40, 31, 4, -40 },
  { 7817, 28, 39, 31, 1, -28 },
  { 7954, 27, 39, 31, 1, -39 },
  { 8086, 22, 38, 31, 3, -38 },
  { 8191, 24, 49, 31, 1, -38 },
  { 8338, 29, 39, 31, 1, -39 },
  { 8480, 24, 39, 31, 2, -39 },
  { 8597, 30, 28, 31, -1, -28 },
  { 8702, 27, 28, 31, 1, -28 },
  { 8797, 26, 29, 31, 2, -28 },
  { 8892, 28, 39, 31, -1, -28 },
  { 9029, 27, 39, 31, 2, -28 },
  { 9161, 26, 28, 31, 4, -28 },
  { 9252, 26, 29, 31, 2, -28 },
  { 9347, 24, 35, 31, 4, -34 },
  { 9452, 26, 28, 31, 3, -27 },
  { 9543, 27, 28, 31, 4, -28 },
  { 9638, 28, 27, 31, 3, -27 },
  { 9733, 31, 27, 31, 0, -27 },
  { 9838, 33, 38, 31, 0, -27 },
  { 9995, 28, 27, 31, 1, -27 },
  { 10090, 20, 50, 31, 7, -41 },
  { 10215, 12, 47, 31, 9, -37 },
  { 10286, 20, 50, 31, 5, -41 },
  { 10411, 29, 11, 31, 0, -21 },
};

const GFXfont RobotoMono_BoldItalic52pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic52pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOMONO_BOLDITALIC52PT7B_H_
