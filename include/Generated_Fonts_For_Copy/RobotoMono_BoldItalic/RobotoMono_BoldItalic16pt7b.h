#ifndef _ROBOTOMONO_BOLDITALIC16PT7B_H_
#define _ROBOTOMONO_BOLDITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x37, 0x66, 0x66, 0x60, 0x0C, 0xC0, 0xDE, 0xE5, 0x20, 0x0D, 0x84,
  0x82, 0xCF, 0xF1, 0x20, 0xB3, 0xFD, 0xFE, 0x2C, 0x34, 0x12, 0x00, 0x04,
  0x0C, 0x3E, 0x73, 0x63, 0x60, 0x78, 0x3C, 0x0E, 0xC6, 0xC6, 0xFE, 0x7C,
  0x10, 0x30, 0x20, 0xF0, 0xD2, 0x96, 0xFC, 0x08, 0x10, 0x3E, 0x2B, 0x5B,
  0x1B, 0x0E, 0x04, 0x0F, 0x0E, 0xC6, 0x63, 0x60, 0xE0, 0xE6, 0xDB, 0xED,
  0xE3, 0xBF, 0xCF, 0xF0, 0x7F, 0x04, 0x31, 0x8C, 0x31, 0x86, 0x18, 0x43,
  0x0C, 0x10, 0x41, 0x86, 0x0C, 0x10, 0x10, 0xC1, 0x82, 0x0C, 0x30, 0xC3,
  0x0C, 0x21, 0x86, 0x10, 0xC6, 0x30, 0x80, 0x0C, 0x08, 0x6B, 0xFF, 0x18,
  0x2C, 0x66, 0x44, 0x18, 0x18, 0x19, 0xFE, 0xFE, 0x30, 0x30, 0x30, 0x33,
  0x66, 0xC0, 0xFF, 0xF8, 0xDF, 0x00, 0x07, 0x06, 0x0E, 0x0C, 0x18, 0x18,
  0x30, 0x30, 0x60, 0x60, 0xC0, 0xC0, 0x08, 0x3E, 0x76, 0x63, 0x63, 0xEF,
  0xDE, 0xE6, 0xC6, 0xC6, 0xFC, 0x78, 0x1F, 0xF6, 0x33, 0x98, 0xC6, 0x31,
  0x9C, 0x04, 0x1F, 0x8C, 0xCC, 0x60, 0x30, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x3F, 0xDF, 0xE0, 0x04, 0x0F, 0x8C, 0xE6, 0x30, 0x38, 0x78, 0x78, 0x06,
  0x03, 0x71, 0x9F, 0x87, 0x80, 0x07, 0x07, 0x0F, 0x1B, 0x37, 0x36, 0x66,
  0xFF, 0xFF, 0x06, 0x0E, 0x3F, 0x60, 0x60, 0x60, 0x7C, 0xC6, 0x06, 0x06,
  0xC6, 0xFC, 0x78, 0x1E, 0x71, 0x87, 0x4F, 0xFC, 0xF1, 0xE3, 0xC7, 0xF9,
  0xE0, 0xFF, 0x03, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x70, 0x60, 0xE0,
  0x04, 0x0F, 0x8E, 0xE6, 0x33, 0x31, 0xF8, 0xF8, 0xC6, 0x63, 0x31, 0x9F,
  0x87, 0x80, 0x08, 0x3E, 0x66, 0xE6, 0xC6, 0xC6, 0xEE, 0x7E, 0x06, 0x0C,
  0x78, 0x70, 0x27, 0x70, 0x00, 0xCE, 0xC0, 0x11, 0xCE, 0x00, 0x00, 0x0E,
  0x63, 0x19, 0x80, 0x01, 0x06, 0x3E, 0xF0, 0xE0, 0x7C, 0x1E, 0x04, 0xFF,
  0x00, 0x00, 0xFE, 0xFE, 0x80, 0xC1, 0xF0, 0xF0, 0xEF, 0xB8, 0x40, 0x10,
  0xFB, 0x9E, 0x30, 0xE3, 0x8E, 0x18, 0x30, 0x01, 0x83, 0x00, 0x1F, 0x18,
  0xCB, 0xAB, 0x55, 0x2E, 0x97, 0x53, 0xBE, 0x52, 0x32, 0x0F, 0x00, 0x03,
  0x03, 0x81, 0xC1, 0xA0, 0xD8, 0xCC, 0x66, 0x7F, 0x3F, 0xB0, 0xF8, 0x60,
  0x3F, 0x19, 0xCC, 0x6E, 0x37, 0xF3, 0xF9, 0x8E, 0xC3, 0x63, 0xFF, 0xBF,
  0x80, 0x08, 0x3E, 0x77, 0xE3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC6, 0xC6, 0xFE,
  0x78, 0x3E, 0x1B, 0x8C, 0xEE, 0x36, 0x1B, 0x0D, 0x8E, 0xC6, 0x67, 0x7F,
  0x3E, 0x00, 0x3F, 0xCC, 0x03, 0x00, 0xC0, 0x7F, 0x1F, 0xC6, 0x01, 0x80,
  0x60, 0x1F, 0xCF, 0xF0, 0x3F, 0xCC, 0x03, 0x00, 0xC0, 0x7F, 0x1F, 0xC6,
  0x01, 0x80, 0x60, 0x18, 0x0E, 0x00, 0x08, 0x3E, 0x73, 0x63, 0xC0, 0xC0,
  0xCF, 0xCF, 0xC6, 0xC6, 0xFE, 0x7C, 0x31, 0x98, 0xCC, 0x6E, 0x37, 0xFB,
  0xF9, 0x8C, 0xC6, 0x63, 0x71, 0xB1, 0xC0, 0x7F, 0x1C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x38, 0x30, 0xFC, 0xFC, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x38, 0x18, 0x0C, 0xC6, 0x7E, 0x1E, 0x00, 0x31, 0xE6, 0x70, 0xDC, 0x3F,
  0x06, 0xC0, 0xF8, 0x1F, 0x83, 0x30, 0x67, 0x1C, 0x63, 0x0E, 0x00, 0x30,
  0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0x7F, 0xFF, 0x39, 0xCE,
  0xE3, 0xB9, 0xBE, 0x6D, 0x9B, 0x66, 0x91, 0x8C, 0x63, 0x30, 0xCC, 0x30,
  0x31, 0x9C, 0xCE, 0x6F, 0x36, 0xBB, 0x79, 0xBC, 0xCE, 0x67, 0x73, 0xB1,
  0xC0, 0x08, 0x3E, 0x67, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xFC,
  0x78, 0x3F, 0x19, 0xCC, 0x66, 0x37, 0x1B, 0xF9, 0xF8, 0xC0, 0x60, 0x30,
  0x38, 0x00, 0x08, 0x3E, 0x77, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xC6,
  0xFC, 0x7C, 0x0E, 0x04, 0x3F, 0x19, 0xCC, 0x6E, 0x36, 0x3B, 0xF9, 0xF8,
  0xCC, 0x67, 0x71, 0xB0, 0xC0, 0x04, 0x0F, 0x8E, 0x66, 0x33, 0x01, 0xE0,
  0x7C, 0x06, 0xE3, 0xB1, 0x9F, 0xC7, 0xC0, 0xFF, 0x8E, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x00, 0x63, 0xB1, 0x98, 0xDC,
  0x6C, 0x36, 0x3B, 0x19, 0x8C, 0xC6, 0x7E, 0x1E, 0x00, 0xE3, 0xB1, 0x98,
  0xCC, 0xC6, 0x63, 0x71, 0xB0, 0xD8, 0x38, 0x1C, 0x0C, 0x00, 0xC9, 0xEC,
  0xF6, 0xDB, 0x6F, 0xB7, 0xDB, 0xB9, 0xDC, 0xEE, 0x66, 0x33, 0x00, 0x38,
  0xE3, 0x38, 0x36, 0x07, 0xC0, 0xF0, 0x1C, 0x03, 0xC0, 0xD8, 0x3B, 0x86,
  0x33, 0x87, 0x00, 0xE1, 0xD8, 0xC6, 0x70, 0xD8, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0x3F, 0xD0, 0x60, 0x30, 0x18, 0x0E, 0x07,
  0x01, 0x80, 0xC0, 0x60, 0x3F, 0xCF, 0xF0, 0x3C, 0xC3, 0x0C, 0x31, 0xC6,
  0x18, 0x61, 0x86, 0x18, 0xC3, 0x0F, 0x38, 0xCC, 0xC6, 0x66, 0x66, 0x63,
  0x33, 0x3C, 0x71, 0x86, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x0C, 0x30, 0xCE,
  0x38, 0x18, 0xE6, 0x9B, 0xCF, 0x30, 0xFF, 0xFC, 0xCC, 0x80, 0x0C, 0x3F,
  0x73, 0x03, 0x3F, 0x63, 0xE3, 0x7E, 0x7F, 0x38, 0x30, 0x30, 0x36, 0x3F,
  0x73, 0x63, 0x63, 0x63, 0x63, 0x7E, 0xDE, 0x18, 0xFD, 0x9E, 0x3C, 0x18,
  0x31, 0xFE, 0x78, 0x03, 0x03, 0x03, 0x13, 0x7F, 0xE7, 0xC6, 0xC6, 0xC6,
  0xC6, 0xFE, 0x7C, 0x18, 0x7E, 0x66, 0xC3, 0xFF, 0xC0, 0xC4, 0xFE, 0x7C,
  0x0F, 0x8E, 0x46, 0x03, 0x0F, 0xF1, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x0E, 0x00, 0x0C, 0x1F, 0xDC, 0xEC, 0x66, 0x33, 0x19, 0x8C, 0xFE, 0x3B,
  0x03, 0x33, 0x8F, 0x80, 0x30, 0x18, 0x0C, 0x06, 0xC3, 0xF3, 0x99, 0x8C,
  0xC6, 0x63, 0x31, 0x98, 0xD8, 0xE0, 0x0C, 0x18, 0x10, 0x07, 0xC3, 0x06,
  0x0C, 0x18, 0x33, 0xFF, 0xF0, 0x02, 0x07, 0x02, 0x00, 0x1E, 0x06, 0x06,
  0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0xF8, 0x30, 0x18, 0x0C, 0x06,
  0x13, 0x33, 0xB1, 0xB0, 0xF8, 0x7C, 0x33, 0x19, 0x98, 0xE0, 0x3C, 0xF8,
  0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x33, 0xFF, 0xF0, 0x09, 0x3F, 0xDB,
  0x6D, 0xB4, 0xDE, 0xCB, 0x6D, 0xB6, 0xDB, 0x00, 0x06, 0x1F, 0x9C, 0xCC,
  0x66, 0x33, 0x19, 0x8C, 0xC6, 0xC7, 0x00, 0x18, 0x7E, 0xE6, 0xC6, 0xC6,
  0xC6, 0xC6, 0xFC, 0x78, 0x06, 0x3F, 0x73, 0x63, 0x63, 0x63, 0x63, 0x7E,
  0xFE, 0xC0, 0xC0, 0xC0, 0x10, 0x7F, 0xE7, 0xC6, 0xC6, 0xC6, 0xC6, 0xFE,
  0x7C, 0x0C, 0x0C, 0x0C, 0x03, 0x3F, 0x7F, 0x70, 0x60, 0x60, 0x60, 0x60,
  0xE0, 0x18, 0x7E, 0xE7, 0xE0, 0x7C, 0x1E, 0xC6, 0xEE, 0x7C, 0x18, 0x18,
  0x39, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3E, 0x3E, 0x63, 0xE3, 0xC6,
  0xC6, 0xC6, 0xC6, 0xFE, 0x76, 0xC3, 0x66, 0x66, 0x6C, 0x6C, 0x78, 0x38,
  0x30, 0xDB, 0xED, 0xBE, 0xDD, 0xCE, 0xE7, 0x73, 0x31, 0x98, 0x73, 0xCE,
  0xC1, 0xE0, 0x70, 0x1C, 0x0D, 0x87, 0x63, 0x8C, 0x71, 0xCC, 0x63, 0x30,
  0xDC, 0x36, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x0E, 0x00, 0x7F, 0x81,
  0x81, 0x81, 0x83, 0x83, 0x83, 0xFD, 0xFE, 0x04, 0x31, 0x86, 0x18, 0x63,
  0x3C, 0xE0, 0xC3, 0x0C, 0x30, 0xC3, 0x04, 0x24, 0xB6, 0xD2, 0x4B, 0x69,
  0x00, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0xC7, 0x31, 0x86, 0x18, 0x63, 0x08,
  0x00, 0x79, 0xEF, 0x91, 0xC0,
};

const GFXglyph RobotoMono_BoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 11, 9, 3, -11 },
  { 7, 5, 4, 9, 3, -12 },
  { 10, 9, 11, 9, 0, -11 },
  { 23, 8, 15, 9, 1, -13 },
  { 38, 8, 12, 9, 1, -12 },
  { 50, 9, 12, 9, 0, -12 },
  { 64, 2, 4, 9, 4, -12 },
  { 65, 6, 17, 9, 2, -13 },
  { 78, 6, 17, 9, 1, -13 },
  { 91, 8, 8, 9, 1, -11 },
  { 99, 8, 8, 9, 1, -9 },
  { 107, 4, 5, 9, 1, -2 },
  { 110, 7, 2, 9, 2, -6 },
  { 112, 3, 3, 9, 3, -3 },
  { 114, 8, 12, 9, 1, -11 },
  { 126, 8, 12, 9, 1, -12 },
  { 138, 5, 11, 9, 2, -11 },
  { 145, 9, 12, 9, 0, -12 },
  { 159, 9, 12, 9, 0, -12 },
  { 173, 8, 11, 9, 0, -11 },
  { 184, 8, 11, 9, 1, -11 },
  { 195, 7, 11, 9, 1, -11 },
  { 205, 8, 11, 9, 1, -11 },
  { 216, 9, 12, 9, 0, -12 },
  { 230, 8, 12, 9, 1, -12 },
  { 242, 4, 9, 9, 3, -9 },
  { 247, 5, 12, 9, 2, -9 },
  { 255, 8, 8, 9, 1, -9 },
  { 263, 8, 5, 9, 1, -7 },
  { 268, 7, 8, 9, 1, -9 },
  { 275, 7, 12, 9, 2, -12 },
  { 286, 9, 11, 9, 0, -11 },
  { 299, 9, 11, 9, -1, -11 },
  { 312, 9, 11, 9, 0, -11 },
  { 325, 8, 12, 9, 1, -12 },
  { 337, 9, 11, 9, 0, -11 },
  { 350, 10, 11, 9, 0, -11 },
  { 364, 10, 11, 9, 0, -11 },
  { 378, 8, 12, 9, 1, -12 },
  { 390, 9, 11, 9, 0, -11 },
  { 403, 8, 11, 9, 1, -11 },
  { 414, 9, 11, 9, 1, -11 },
  { 427, 11, 11, 9, 0, -11 },
  { 443, 8, 11, 9, 0, -11 },
  { 454, 10, 11, 9, 0, -11 },
  { 468, 9, 11, 9, 0, -11 },
  { 481, 8, 12, 9, 1, -12 },
  { 493, 9, 11, 9, 0, -11 },
  { 506, 8, 14, 9, 1, -12 },
  { 520, 9, 11, 9, 0, -11 },
  { 533, 9, 12, 9, 0, -12 },
  { 547, 9, 11, 9, 1, -11 },
  { 560, 9, 11, 9, 1, -11 },
  { 573, 9, 11, 9, 1, -11 },
  { 586, 9, 11, 9, 1, -11 },
  { 599, 11, 11, 9, -1, -11 },
  { 615, 10, 11, 9, 1, -11 },
  { 629, 10, 11, 9, 0, -11 },
  { 643, 6, 16, 9, 2, -13 },
  { 655, 4, 12, 9, 3, -11 },
  { 661, 6, 16, 9, 2, -13 },
  { 673, 6, 6, 9, 2, -11 },
  { 678, 7, 2, 9, 0, 0 },
  { 680, 3, 3, 9, 4, -12 },
  { 682, 8, 9, 9, 0, -9 },
  { 691, 8, 12, 9, 0, -12 },
  { 703, 7, 9, 9, 1, -9 },
  { 711, 8, 12, 9, 1, -12 },
  { 723, 8, 9, 9, 1, -9 },
  { 732, 9, 12, 9, 1, -12 },
  { 746, 9, 12, 9, 0, -9 },
  { 760, 9, 12, 9, 0, -12 },
  { 774, 7, 12, 9, 1, -12 },
  { 785, 8, 15, 9, 0, -12 },
  { 800, 9, 12, 9, 0, -12 },
  { 814, 7, 12, 9, 1, -12 },
  { 825, 9, 9, 9, 0, -9 },
  { 836, 9, 9, 9, 0, -9 },
  { 847, 8, 9, 9, 1, -9 },
  { 856, 8, 12, 9, 0, -9 },
  { 868, 8, 12, 9, 1, -9 },
  { 880, 8, 9, 9, 1, -9 },
  { 889, 8, 9, 9, 1, -9 },
  { 898, 8, 11, 9, 1, -11 },
  { 909, 8, 8, 9, 1, -8 },
  { 917, 8, 8, 9, 1, -8 },
  { 925, 9, 8, 9, 1, -8 },
  { 934, 10, 8, 9, 0, -8 },
  { 944, 10, 11, 9, 0, -8 },
  { 958, 9, 8, 9, 0, -8 },
  { 967, 6, 16, 9, 2, -13 },
  { 979, 3, 14, 9, 3, -11 },
  { 985, 6, 15, 9, 2, -12 },
  { 997, 9, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_BoldItalic16pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic16pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOMONO_BOLDITALIC16PT7B_H_
