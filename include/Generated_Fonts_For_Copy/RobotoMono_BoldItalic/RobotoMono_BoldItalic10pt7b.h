#ifndef _ROBOTOMONO_BOLDITALIC10PT7B_H_
#define _ROBOTOMONO_BOLDITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x57, 0x88, 0xB6, 0x80, 0x1C, 0xA7, 0xCC, 0xF9, 0x4E, 0x00, 0x10,
  0xE6, 0xD8, 0x38, 0x2C, 0x9E, 0x20, 0xCD, 0xE2, 0x7B, 0x30, 0x39, 0xA7,
  0x18, 0xFF, 0x67, 0x80, 0x5C, 0x2B, 0x49, 0x24, 0x98, 0x44, 0x92, 0x4B,
  0x50, 0x25, 0x5C, 0xC9, 0x00, 0x11, 0x9F, 0x42, 0x00, 0x78, 0xF0, 0xC0,
  0x0C, 0x21, 0x0C, 0x21, 0x84, 0x30, 0x7D, 0x9F, 0x9B, 0xE0, 0x3E, 0x22,
  0x66, 0x40, 0x7A, 0x42, 0x22, 0x23, 0xE0, 0x39, 0x20, 0x8C, 0x0B, 0x27,
  0x00, 0x18, 0xCE, 0xBF, 0x88, 0x40, 0x3D, 0x87, 0x16, 0x0B, 0x67, 0x00,
  0x3B, 0x1C, 0xBC, 0xAD, 0xC0, 0xF8, 0x8C, 0x46, 0x22, 0x00, 0x3A, 0x52,
  0xEC, 0xED, 0xC0, 0x79, 0x9B, 0x52, 0xC0, 0x70, 0xB0, 0x24, 0x00, 0x94,
  0x3C, 0xC3, 0x7D, 0xE7, 0xBE, 0x60, 0xCF, 0x80, 0x76, 0xC4, 0x46, 0x01,
  0x00, 0x39, 0x56, 0xED, 0xBA, 0xA7, 0x00, 0x11, 0xCE, 0xD7, 0xFE, 0x20,
  0x79, 0x34, 0xDE, 0x4B, 0x2F, 0x80, 0x39, 0x34, 0x30, 0xC3, 0x27, 0x00,
  0x79, 0x24, 0xD3, 0x4B, 0x6F, 0x00, 0x7D, 0x04, 0x1E, 0x43, 0x0F, 0x80,
  0x7D, 0x04, 0x1E, 0x43, 0x0C, 0x00, 0x39, 0x34, 0x16, 0xC9, 0x27, 0x80,
  0x6D, 0x34, 0x9E, 0x4B, 0x29, 0x80, 0x7C, 0x43, 0x0C, 0x20, 0x8F, 0x80,
  0x0C, 0x30, 0x82, 0x0B, 0x67, 0x00, 0x6E, 0x91, 0x43, 0x85, 0x1B, 0x32,
  0x00, 0x63, 0x10, 0x84, 0x63, 0xE0, 0x6D, 0xB7, 0xDE, 0x6B, 0x28, 0x80,
  0x6D, 0xB6, 0x96, 0x5B, 0x6D, 0x80, 0x39, 0x34, 0xF3, 0xCB, 0x27, 0x00,
  0x79, 0x34, 0xDE, 0x43, 0x0C, 0x00, 0x39, 0x34, 0xD3, 0xCB, 0x27, 0x02,
  0x79, 0x34, 0xDE, 0x53, 0x6C, 0x80, 0x39, 0x36, 0x0E, 0x0B, 0x27, 0x80,
  0xF9, 0x18, 0xC4, 0x21, 0x00, 0x65, 0x34, 0x92, 0xC9, 0x67, 0x00, 0x8C,
  0xE5, 0xEE, 0x31, 0x00, 0xAD, 0x7F, 0xEF, 0x5A, 0x80, 0x6C, 0xA3, 0x8C,
  0x71, 0x6C, 0x80, 0x8F, 0x67, 0x18, 0x61, 0x04, 0x00, 0x7C, 0x21, 0x8C,
  0x61, 0x0F, 0x80, 0x36, 0x64, 0x44, 0x44, 0xCC, 0xAB, 0x55, 0x33, 0x22,
  0x22, 0x66, 0x4C, 0x25, 0x59, 0xF8, 0xC0, 0x78, 0x5F, 0xB7, 0x80, 0x63,
  0x10, 0xF4, 0xA7, 0x3E, 0x7A, 0x70, 0x97, 0x00, 0x04, 0x30, 0xDE, 0x4B,
  0x25, 0x9E, 0x7A, 0x7E, 0x97, 0x80, 0x19, 0x1B, 0xE4, 0x21, 0x18, 0x7D,
  0x2C, 0x92, 0x7A, 0x6F, 0x00, 0x63, 0x10, 0xF4, 0xA7, 0x3B, 0x30, 0xE2,
  0x66, 0xF0, 0x18, 0x4C, 0x21, 0x08, 0xC4, 0xE0, 0x61, 0x84, 0x56, 0x71,
  0xCD, 0x36, 0x39, 0x84, 0x21, 0x18, 0xDF, 0x7F, 0xEA, 0xAA, 0xA8, 0x7A,
  0x53, 0x9D, 0x80, 0x7A, 0x73, 0x97, 0x00, 0x7A, 0x53, 0x9F, 0x42, 0x00,
  0x7D, 0x2C, 0x92, 0x78, 0x61, 0x00, 0x7E, 0x31, 0x08, 0x00, 0x7A, 0x0F,
  0x97, 0x80, 0x66, 0xF4, 0x44, 0x70, 0x9C, 0xA5, 0x2F, 0x00, 0x9C, 0xA8,
  0xC4, 0x00, 0xAF, 0xBD, 0x6A, 0x00, 0x6C, 0xE3, 0x1C, 0xC8, 0x4D, 0x27,
  0x8C, 0x21, 0x8C, 0x00, 0x7C, 0x63, 0x18, 0xF8, 0x12, 0x22, 0x6C, 0x64,
  0x42, 0x55, 0xAA, 0x80, 0x42, 0x22, 0x32, 0x44, 0x48, 0x66, 0xE0,
};

const GFXglyph RobotoMono_BoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -8 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 9, 6, 0, -8 },
  { 18, 4, 7, 6, 1, -7 },
  { 22, 6, 7, 6, 0, -7 },
  { 28, 2, 3, 6, 2, -8 },
  { 29, 3, 10, 6, 2, -8 },
  { 33, 3, 10, 6, 1, -8 },
  { 37, 5, 5, 6, 1, -7 },
  { 41, 5, 5, 6, 0, -6 },
  { 45, 2, 3, 6, 1, -1 },
  { 46, 4, 1, 6, 1, -4 },
  { 47, 1, 2, 6, 2, -2 },
  { 48, 6, 8, 6, 0, -7 },
  { 54, 4, 7, 6, 1, -7 },
  { 58, 4, 7, 6, 1, -7 },
  { 62, 5, 7, 6, 0, -7 },
  { 67, 6, 7, 6, 0, -7 },
  { 73, 5, 7, 6, 0, -7 },
  { 78, 6, 7, 6, 0, -7 },
  { 84, 5, 7, 6, 0, -7 },
  { 89, 5, 7, 6, 1, -7 },
  { 94, 5, 7, 6, 0, -7 },
  { 99, 4, 7, 6, 1, -7 },
  { 103, 2, 6, 6, 2, -6 },
  { 105, 3, 8, 6, 1, -6 },
  { 108, 4, 4, 6, 1, -5 },
  { 110, 6, 4, 6, 0, -5 },
  { 113, 5, 4, 6, 0, -5 },
  { 116, 5, 7, 6, 1, -7 },
  { 121, 6, 7, 6, 0, -7 },
  { 127, 5, 7, 6, 0, -7 },
  { 132, 6, 7, 6, 0, -7 },
  { 138, 6, 7, 6, 0, -7 },
  { 144, 6, 7, 6, 0, -7 },
  { 150, 6, 7, 6, 0, -7 },
  { 156, 6, 7, 6, 0, -7 },
  { 162, 6, 7, 6, 0, -7 },
  { 168, 6, 7, 6, 0, -7 },
  { 174, 6, 7, 6, 0, -7 },
  { 180, 6, 7, 6, 0, -7 },
  { 186, 7, 7, 6, 0, -7 },
  { 193, 5, 7, 6, 0, -7 },
  { 198, 6, 7, 6, 0, -7 },
  { 204, 6, 7, 6, 0, -7 },
  { 210, 6, 7, 6, 0, -7 },
  { 216, 6, 7, 6, 0, -7 },
  { 222, 6, 8, 6, 0, -7 },
  { 228, 6, 7, 6, 0, -7 },
  { 234, 6, 7, 6, 0, -7 },
  { 240, 5, 7, 6, 1, -7 },
  { 245, 6, 7, 6, 0, -7 },
  { 251, 5, 7, 6, 1, -7 },
  { 256, 5, 7, 6, 1, -7 },
  { 261, 6, 7, 6, 0, -7 },
  { 267, 6, 7, 6, 1, -7 },
  { 273, 6, 7, 6, 0, -7 },
  { 279, 4, 10, 6, 1, -8 },
  { 284, 2, 8, 6, 2, -7 },
  { 286, 4, 10, 6, 1, -8 },
  { 291, 4, 4, 6, 1, -7 },
  { 293, 5, 1, 6, 0, 0 },
  { 294, 2, 1, 6, 3, -7 },
  { 295, 5, 5, 6, 0, -5 },
  { 299, 5, 8, 6, 0, -8 },
  { 304, 5, 5, 6, 0, -5 },
  { 308, 6, 8, 6, 0, -8 },
  { 314, 5, 5, 6, 0, -5 },
  { 318, 5, 8, 6, 1, -8 },
  { 323, 6, 7, 6, 0, -5 },
  { 329, 5, 8, 6, 0, -8 },
  { 334, 4, 7, 6, 1, -7 },
  { 338, 5, 9, 6, 0, -7 },
  { 344, 6, 8, 6, 0, -8 },
  { 350, 5, 8, 6, 0, -8 },
  { 355, 6, 5, 6, 0, -5 },
  { 359, 5, 5, 6, 0, -5 },
  { 363, 5, 5, 6, 0, -5 },
  { 367, 5, 7, 6, 0, -5 },
  { 372, 6, 7, 6, 0, -5 },
  { 378, 5, 5, 6, 1, -5 },
  { 382, 5, 5, 6, 0, -5 },
  { 386, 4, 7, 6, 1, -7 },
  { 390, 5, 5, 6, 1, -5 },
  { 394, 5, 5, 6, 1, -5 },
  { 398, 5, 5, 6, 1, -5 },
  { 402, 6, 5, 6, 0, -5 },
  { 406, 6, 7, 6, 0, -5 },
  { 412, 6, 5, 6, 0, -5 },
  { 416, 4, 10, 6, 1, -8 },
  { 421, 2, 9, 6, 2, -7 },
  { 424, 4, 10, 6, 1, -8 },
  { 429, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_BoldItalic10pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic10pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOMONO_BOLDITALIC10PT7B_H_
