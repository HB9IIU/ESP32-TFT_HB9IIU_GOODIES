#ifndef _ROBOTOMONO_BOLDITALIC68PT7B_H_
#define _ROBOTOMONO_BOLDITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xC0,
  0xFE, 0x3F, 0x01, 0xFC, 0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8,
  0xFE, 0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF8,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x40, 0xFC, 0x0F, 0xC0, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x7F,
  0x03, 0xF0, 0x3E, 0x3F, 0x01, 0xF8, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x0F,
  0xC0, 0xFE, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x83, 0xF8, 0x3F, 0x1F, 0x80,
  0xFE, 0x7F, 0x9F, 0x80, 0x7F, 0xFF, 0x8F, 0x80, 0x3F, 0xFF, 0x8F, 0xC0,
  0x0F, 0xFF, 0x8F, 0xC0, 0x03, 0xFF, 0x8F, 0xC0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x08, 0x00, 0x01, 0xF8,
  0x7F, 0xC0, 0x00, 0xFC, 0xFF, 0xF0, 0x00, 0xFC, 0xFF, 0xFC, 0x00, 0xFC,
  0xFF, 0xFF, 0x00, 0x7C, 0x7F, 0xFF, 0x80, 0x7E, 0x7F, 0x0F, 0xE0, 0x7E,
  0x3F, 0x07, 0xF0, 0x3E, 0x1F, 0x81, 0xF8, 0x3F, 0x1F, 0xC0, 0xFC, 0x3F,
  0x0F, 0xE0, 0x7E, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0x83, 0xF0, 0x3F, 0x81,
  0x81, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFE,
  0x7F, 0xE0, 0x00, 0x07, 0xFB, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF,
  0x80, 0xFF, 0x0F, 0xFF, 0xFE, 0x03, 0xFC, 0x7F, 0xFF, 0xFC, 0x1F, 0xE3,
  0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x7F, 0xE0, 0xFF,
  0x8F, 0xF1, 0xFF, 0x01, 0xFF, 0x7F, 0xC7, 0xFC, 0x07, 0xFF, 0xFF, 0x3F,
  0xF0, 0x0F, 0xFF, 0xF8, 0xFF, 0x80, 0x3F, 0xFF, 0xE3, 0xFE, 0x00, 0x7F,
  0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF,
  0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x1F,
  0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F,
  0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0xFC,
  0x01, 0x8F, 0x80, 0x7C, 0x03, 0xC7, 0xF0, 0x3E, 0x0F, 0xF7, 0xFE, 0x1F,
  0x1F, 0xFB, 0xFF, 0xCF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03,
  0xFC, 0x7E, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x03,
  0xFC, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3E, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x01,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xC1, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFE, 0x7F, 0xF3, 0xFF, 0x0F, 0xF0, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x9F, 0xFE, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x03,
  0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xE7, 0xFC, 0x01, 0xFF, 0xF3, 0xFE, 0x01,
  0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0x83, 0xFF, 0xFC, 0xFF, 0xC7,
  0xFF, 0xFE, 0x7F, 0xC7, 0xFD, 0xFF, 0x3F, 0xEF, 0xF8, 0xFF, 0x9F, 0xFF,
  0xF8, 0x7F, 0xCF, 0xFF, 0xF0, 0x7F, 0xC7, 0xFF, 0xF0, 0x3F, 0xE3, 0xFF,
  0xE0, 0x1F, 0xF3, 0xFF, 0xE0, 0x0F, 0xF9, 0xFF, 0xC0, 0x07, 0xFC, 0xFF,
  0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0x7F,
  0xCF, 0xF0, 0xFF, 0x9F, 0x01, 0xFF, 0x38, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF1, 0xFF,
  0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xE1,
  0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x78, 0x00, 0x00, 0xFF, 0xBF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xFE, 0x00, 0x0E, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF3, 0xFF,
  0xC0, 0x3F, 0xEF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F,
  0xFE, 0x7F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F,
  0xFC, 0x7F, 0xE0, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC4, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x3F,
  0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xFC, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x07, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF,
  0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xBF, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF,
  0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF7, 0xF8,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE,
  0x01, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x20, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0x7F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x07,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xFF, 0xC3, 0xE0, 0x7E, 0x07, 0xFF,
  0xC7, 0xC0, 0xFC, 0x3F, 0xFF, 0x8F, 0x83, 0xF0, 0x7F, 0xFF, 0x1F, 0x07,
  0xE1, 0xFE, 0x3E, 0x3E, 0x1F, 0x87, 0xF0, 0xF8, 0x7C, 0x3F, 0x0F, 0xC1,
  0xF0, 0xF8, 0x7C, 0x3F, 0x03, 0xE1, 0xF1, 0xF8, 0x7E, 0x07, 0xC3, 0xE3,
  0xF1, 0xF8, 0x1F, 0x07, 0xC7, 0xC3, 0xF0, 0x3E, 0x0F, 0x9F, 0x87, 0xC0,
  0x7C, 0x1F, 0x3F, 0x1F, 0x80, 0xF8, 0x3C, 0x7C, 0x3F, 0x03, 0xF0, 0xF8,
  0xF8, 0x7E, 0x07, 0xC1, 0xF1, 0xF0, 0xFC, 0x0F, 0x83, 0xE3, 0xE1, 0xF0,
  0x1F, 0x07, 0x8F, 0xC3, 0xE0, 0x7E, 0x1F, 0x1F, 0x87, 0xC0, 0xF8, 0x3E,
  0x3F, 0x0F, 0x81, 0xF0, 0x78, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F,
  0xBF, 0xC7, 0xC1, 0xF8, 0x7F, 0xFF, 0xFF, 0x81, 0xF0, 0x7F, 0xFF, 0xFE,
  0x03, 0xE0, 0xFF, 0xDF, 0xF8, 0x07, 0xC0, 0xFE, 0x1F, 0xE0, 0x0F, 0xC0,
  0x78, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x02, 0x00, 0x00, 0x7F,
  0xC0, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x00,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x80,
  0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0xFF, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC,
  0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x07, 0xFF,
  0x80, 0x7F, 0xC3, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF3, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xFC, 0xFF,
  0x80, 0x7F, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xFF,
  0xCF, 0xF8, 0x07, 0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0x8F, 0xF8, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC7, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xDF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xBF, 0xE0,
  0x00, 0x01, 0xFF, 0xF3, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x03,
  0xFF, 0xF1, 0xFF, 0xFC, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0x03, 0xFF, 0xF3,
  0xFB, 0xFC, 0x07, 0xFB, 0xF3, 0xFF, 0xF8, 0x07, 0xFB, 0xF7, 0xF7, 0xF8,
  0x07, 0xFB, 0xF7, 0xF7, 0xF8, 0x07, 0xFB, 0xF7, 0xE7, 0xF8, 0x07, 0xF9,
  0xFF, 0xE7, 0xF8, 0x07, 0xF9, 0xFF, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0xCF,
  0xF0, 0x0F, 0xF1, 0xFF, 0x8F, 0xF0, 0x0F, 0xF1, 0xFF, 0x8F, 0xF0, 0x0F,
  0xF1, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFF,
  0x1F, 0xF0, 0x1F, 0xF1, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0,
  0x1F, 0xE0, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0,
  0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xF8,
  0x03, 0xFF, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xF8, 0x03, 0xFE,
  0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0xFE, 0x1F,
  0xF0, 0x07, 0xFC, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x7E, 0x1F, 0xF0, 0x07,
  0xFC, 0x7F, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F,
  0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xBF, 0xE0,
  0x0F, 0xF8, 0x3F, 0xBF, 0xE0, 0x0F, 0xF8, 0x3F, 0xBF, 0xE0, 0x0F, 0xF8,
  0x1F, 0xBF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xE0,
  0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFE,
  0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0x00,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xE7,
  0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00,
  0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF,
  0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x1C, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x03,
  0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFE, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F,
  0xC0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x01, 0xFE, 0x7F,
  0xC0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x7E, 0x01, 0xFE, 0xFF, 0x01, 0xFC,
  0x07, 0xFD, 0xFE, 0x03, 0xF8, 0x0F, 0xFB, 0xFC, 0x07, 0xF0, 0x1F, 0xE7,
  0xF8, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F, 0xC0, 0xFF, 0x9F, 0xE0, 0x7F,
  0x81, 0xFE, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x7F, 0x83, 0xFE, 0x07, 0xF8,
  0xFF, 0x07, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F,
  0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0xC3, 0xFC,
  0x1F, 0xE3, 0xFF, 0x87, 0xF8, 0x3F, 0xC7, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F,
  0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0xF8, 0xFF,
  0x03, 0xFC, 0xFF, 0xF3, 0xFE, 0x07, 0xF9, 0xFF, 0xE7, 0xF8, 0x0F, 0xF7,
  0xFF, 0xCF, 0xF0, 0x1F, 0xEF, 0xDF, 0x9F, 0xE0, 0x3F, 0xDF, 0xBF, 0x7F,
  0x80, 0x7F, 0xFF, 0x7E, 0xFF, 0x00, 0xFE, 0xFC, 0xFD, 0xFE, 0x01, 0xFD,
  0xF9, 0xFB, 0xFC, 0x03, 0xFB, 0xF3, 0xFF, 0xF0, 0x07, 0xFF, 0xC7, 0xFF,
  0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF,
  0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F,
  0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x00, 0x0F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x1F,
  0xE3, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0x0F, 0xF0,
  0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0x8F, 0xE0, 0x03, 0xFB,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE,
  0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F,
  0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x80,
  0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0,
  0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xC0,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xC0, 0x00, 0x1F, 0xF1,
  0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF,
  0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x9F,
  0xFF, 0xF0, 0x0F, 0xF1, 0xFF, 0xF8, 0x03, 0xFE, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0x7F, 0xC7, 0xFE, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00,
  0x07, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0E,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xFE, 0x7F, 0xC0,
  0x07, 0xFF, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF7, 0xF8, 0x00, 0x3F, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xE3, 0xFC,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x07, 0xF9, 0xFF, 0x00,
  0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x02,
  0x01, 0xFF, 0x80, 0x01, 0x80, 0x7F, 0xF0, 0x01, 0xF0, 0x0F, 0xFE, 0x01,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x20, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x3F, 0xC0, 0x07, 0xFF, 0xF3, 0xFE, 0x00, 0x7F, 0xFF, 0xDF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0x80,
  0x03, 0xFF, 0xF7, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0x81,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x08,
  0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x00, 0x1F, 0xF0, 0x7F, 0xE0,
  0x03, 0xFE, 0x3F, 0xFE, 0x00, 0x7F, 0xCF, 0xFF, 0xE0, 0x0F, 0xF7, 0xFF,
  0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF,
  0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x80, 0x7F, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFE,
  0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0xE0,
  0x00, 0x3F, 0xE7, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xCF, 0xFC, 0x00, 0x0F,
  0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x08,
  0x01, 0x80, 0x07, 0xF8, 0xFE, 0x0F, 0xE0, 0x0F, 0xF7, 0xFE, 0x7F, 0xE0,
  0x1F, 0xDF, 0xFD, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFC, 0x7F, 0xE3, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x07,
  0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F,
  0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0xF8, 0x01,
  0xFE, 0x7F, 0xFF, 0x80, 0x3F, 0xDF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xE3, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFC, 0x00,
  0x7F, 0xC7, 0xFE, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFC,
  0x7F, 0xE0, 0x00, 0x3F, 0xC7, 0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0xFE, 0x00, 0x7F,
  0xE7, 0xFF, 0xE0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0xF8, 0xFF, 0x00, 0x7F, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xC0,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x07, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xE7, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0x00, 0x00, 0x78, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x01, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0x8F,
  0xFF, 0xE0, 0x7F, 0xCF, 0xFF, 0xF0, 0x3F, 0xEF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x81, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x18, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xFC,
  0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xEF, 0xF8,
  0x07, 0xFF, 0xF3, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0x1F, 0xF8, 0x3F,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF,
  0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFE, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x01, 0xF8, 0x0F,
  0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0xBF, 0xC0, 0xFE, 0x03, 0xFD, 0xFE, 0x07,
  0xF0, 0x1F, 0xEF, 0xF0, 0x3F, 0x81, 0xFE, 0x7F, 0x83, 0xFC, 0x0F, 0xF3,
  0xF8, 0x1F, 0xE0, 0x7F, 0x9F, 0xC0, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC7, 0xF0, 0x7F, 0xC1, 0xFE, 0x3F, 0x87, 0xFE, 0x1F, 0xE1, 0xFC,
  0x3F, 0xF0, 0xFF, 0x0F, 0xE1, 0xFF, 0x87, 0xF8, 0x7F, 0x1F, 0xFC, 0x3F,
  0x83, 0xF8, 0xFF, 0xE3, 0xFC, 0x1F, 0xC7, 0xDF, 0x1F, 0xE0, 0xFE, 0x7E,
  0xF8, 0xFE, 0x07, 0xF3, 0xE7, 0xCF, 0xF0, 0x3F, 0x9F, 0x3E, 0x7F, 0x81,
  0xFD, 0xF9, 0xF3, 0xF8, 0x0F, 0xEF, 0x8F, 0xBF, 0xC0, 0x7F, 0x7C, 0x7D,
  0xFE, 0x03, 0xFF, 0xE3, 0xEF, 0xE0, 0x1F, 0xFE, 0x1F, 0x7F, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFC,
  0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x81, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0,
  0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x08, 0x03, 0xFF, 0xF8, 0x00,
  0x7E, 0x3F, 0xFF, 0xE0, 0x03, 0xF1, 0xFF, 0xFF, 0x80, 0x3F, 0x9F, 0xFF,
  0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0x3F, 0xEF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x7F, 0x01, 0xFF, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0xFF, 0x3F, 0x80, 0x1F,
  0xFF, 0xF1, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x40, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
};

const GFXglyph RobotoMono_BoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 17, 49, 40, 12, -48 },
  { 106, 23, 18, 40, 11, -51 },
  { 158, 40, 48, 40, 0, -48 },
  { 398, 36, 63, 40, 3, -56 },
  { 682, 33, 50, 40, 4, -49 },
  { 889, 38, 50, 40, 1, -49 },
  { 1127, 10, 18, 40, 17, -51 },
  { 1150, 23, 69, 40, 10, -54 },
  { 1349, 24, 69, 40, 5, -54 },
  { 1556, 33, 34, 40, 5, -48 },
  { 1697, 34, 35, 40, 3, -40 },
  { 1846, 15, 21, 40, 6, -8 },
  { 1886, 28, 7, 40, 9, -25 },
  { 1911, 13, 12, 40, 11, -11 },
  { 1931, 35, 52, 40, 3, -48 },
  { 2159, 33, 50, 40, 4, -49 },
  { 2366, 23, 48, 40, 8, -48 },
  { 2504, 36, 49, 40, 0, -49 },
  { 2725, 36, 50, 40, 2, -49 },
  { 2950, 35, 48, 40, 1, -48 },
  { 3160, 36, 49, 40, 3, -48 },
  { 3381, 32, 50, 40, 3, -49 },
  { 3581, 36, 48, 40, 4, -48 },
  { 3797, 35, 50, 40, 2, -49 },
  { 4016, 31, 49, 40, 5, -49 },
  { 4206, 17, 39, 40, 12, -38 },
  { 4289, 21, 51, 40, 9, -38 },
  { 4423, 31, 32, 40, 5, -37 },
  { 4547, 35, 22, 40, 3, -31 },
  { 4644, 33, 31, 40, 2, -36 },
  { 4772, 31, 50, 40, 8, -49 },
  { 4966, 39, 48, 40, 1, -48 },
  { 5200, 39, 48, 40, -3, -48 },
  { 5434, 39, 48, 40, 1, -48 },
  { 5668, 37, 50, 40, 2, -49 },
  { 5900, 37, 48, 40, 1, -48 },
  { 6122, 40, 48, 40, 1, -48 },
  { 6362, 40, 48, 40, 1, -48 },
  { 6602, 36, 50, 40, 3, -49 },
  { 6827, 40, 48, 40, 0, -48 },
  { 7067, 35, 48, 40, 3, -48 },
  { 7277, 38, 49, 40, 2, -48 },
  { 7510, 44, 48, 40, 1, -48 },
  { 7774, 33, 48, 40, 1, -48 },
  { 7972, 40, 48, 40, 1, -48 },
  { 8212, 40, 48, 40, 0, -48 },
  { 8452, 37, 50, 40, 2, -49 },
  { 8684, 39, 48, 40, 1, -48 },
  { 8918, 37, 58, 40, 2, -49 },
  { 9187, 39, 48, 40, 1, -48 },
  { 9421, 38, 50, 40, 2, -49 },
  { 9659, 40, 48, 40, 4, -48 },
  { 9899, 37, 49, 40, 3, -48 },
  { 10126, 37, 48, 40, 6, -48 },
  { 10348, 39, 48, 40, 4, -48 },
  { 10582, 46, 48, 40, -2, -48 },
  { 10858, 39, 48, 40, 6, -48 },
  { 11092, 41, 48, 40, 0, -48 },
  { 11338, 25, 67, 40, 8, -56 },
  { 11548, 16, 52, 40, 13, -48 },
  { 11652, 25, 67, 40, 8, -56 },
  { 11862, 27, 25, 40, 7, -48 },
  { 11947, 31, 7, 40, 0, 0 },
  { 11975, 14, 9, 40, 18, -49 },
  { 11991, 33, 38, 40, 2, -37 },
  { 12148, 35, 52, 40, 1, -51 },
  { 12376, 33, 38, 40, 3, -37 },
  { 12533, 37, 52, 40, 3, -51 },
  { 12774, 34, 38, 40, 3, -37 },
  { 12936, 37, 53, 40, 6, -53 },
  { 13182, 37, 51, 40, 1, -37 },
  { 13418, 35, 51, 40, 1, -51 },
  { 13642, 30, 50, 40, 3, -50 },
  { 13830, 31, 65, 40, 2, -50 },
  { 14082, 39, 51, 40, 1, -51 },
  { 14331, 31, 51, 40, 3, -51 },
  { 14529, 39, 37, 40, -1, -37 },
  { 14710, 35, 37, 40, 1, -37 },
  { 14872, 33, 38, 40, 3, -37 },
  { 15029, 37, 51, 40, -1, -37 },
  { 15265, 35, 51, 40, 3, -37 },
  { 15489, 33, 37, 40, 6, -37 },
  { 15642, 35, 38, 40, 2, -37 },
  { 15809, 31, 46, 40, 6, -45 },
  { 15988, 34, 37, 40, 4, -36 },
  { 16146, 35, 36, 40, 5, -36 },
  { 16304, 37, 36, 40, 4, -36 },
  { 16471, 42, 36, 40, -1, -36 },
  { 16660, 43, 51, 40, 0, -36 },
  { 16935, 37, 36, 40, 1, -36 },
  { 17102, 26, 65, 40, 10, -53 },
  { 17314, 15, 62, 40, 12, -48 },
  { 17431, 27, 65, 40, 6, -53 },
  { 17651, 37, 15, 40, 0, -27 },
};

const GFXfont RobotoMono_BoldItalic68pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic68pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _ROBOTOMONO_BOLDITALIC68PT7B_H_
