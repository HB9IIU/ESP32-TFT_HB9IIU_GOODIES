#ifndef _ROBOTOMONO_BOLDITALIC27PT7B_H_
#define _ROBOTOMONO_BOLDITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0xF1, 0xE3, 0x80,
  0x00, 0x00, 0x30, 0xF1, 0xE3, 0x80, 0x71, 0xB8, 0xDC, 0xEC, 0x76, 0x33,
  0x1B, 0x8C, 0x01, 0xCE, 0x01, 0xCC, 0x01, 0x8C, 0x03, 0x9C, 0x03, 0x18,
  0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x06, 0x30, 0x0E, 0x70, 0x0C, 0x60,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x18, 0xC0, 0x39, 0xC0, 0x31, 0x80,
  0x33, 0x80, 0x73, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x3F, 0x80,
  0xFF, 0x83, 0xFF, 0x87, 0x0F, 0x1E, 0x0E, 0x3C, 0x1C, 0x78, 0x00, 0x7C,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3C, 0xF0, 0x39,
  0xE0, 0xF1, 0xC1, 0xE3, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x81, 0x8C, 0x4C, 0x67, 0x67,
  0x73, 0x3B, 0x1F, 0xB0, 0x7B, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xDE,
  0x0D, 0xF8, 0xCC, 0xEE, 0xE7, 0x67, 0x38, 0x39, 0x80, 0xFC, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0xE3, 0x81, 0xC7, 0x03,
  0x9E, 0x07, 0x78, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x01, 0xFC, 0x77, 0xFC,
  0xEF, 0x3F, 0xDC, 0x7F, 0x78, 0x7E, 0x70, 0xF8, 0xFF, 0xF1, 0xFF, 0xF0,
  0xFD, 0xE0, 0x7E, 0xEE, 0xEC, 0xC0, 0x01, 0x81, 0xC1, 0xC1, 0xC1, 0xE0,
  0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x0E, 0x02,
  0x00, 0x0C, 0x07, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC1, 0xE0,
  0xE0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x30, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x86, 0x17, 0x33, 0xFF, 0xFC, 0xFF, 0xC0, 0xE0, 0x0F, 0x80, 0xEC,
  0x0E, 0x70, 0xE3, 0xC2, 0x0C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x81, 0xFF, 0xF7, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x73, 0xCF, 0x38, 0xE7,
  0x38, 0x7F, 0xF7, 0xFE, 0xFF, 0xE0, 0x23, 0xFF, 0xF7, 0x80, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x07, 0xFC, 0x7F, 0xE7, 0x87, 0x3C, 0x3D, 0xC1, 0xEE, 0x0F,
  0xF1, 0xFF, 0x9F, 0xBF, 0xDD, 0xF9, 0xEF, 0x8F, 0x70, 0x7B, 0x83, 0x9C,
  0x1C, 0xF1, 0xE7, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x01, 0x87, 0xDF, 0xEF,
  0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF,
  0x0F, 0x3C, 0x1C, 0xE0, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xE3, 0xFF, 0x8F, 0x0F, 0x38,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x3E, 0x07, 0xF0, 0x1F, 0x80, 0xFF, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xEE, 0x07, 0x3C, 0x3C, 0xFF, 0xF1, 0xFF, 0x83,
  0xF8, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0E,
  0xE0, 0x77, 0x83, 0xDE, 0x0E, 0x78, 0x71, 0xC3, 0x87, 0x1E, 0x1C, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x98,
  0x0F, 0xF8, 0x3F, 0xF1, 0xE3, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xEF, 0x07, 0x3C, 0x3C, 0x7F, 0xE1, 0xFF, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x3F, 0x83, 0xFC, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE7, 0x0F, 0xFC, 0x7F,
  0xF3, 0xE7, 0xBC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xCE, 0x1E,
  0x7F, 0xE1, 0xFE, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0xE1, 0xFF, 0x8F, 0x0F, 0x3C, 0x3C,
  0xE0, 0xE3, 0xC7, 0x8F, 0x3C, 0x1F, 0xE0, 0x7F, 0x83, 0xFF, 0x1E, 0x3C,
  0xF0, 0x73, 0xC1, 0xCF, 0x07, 0x3C, 0x3C, 0xFF, 0xE1, 0xFF, 0x83, 0xF8,
  0x00, 0x1F, 0xC3, 0xFE, 0x7F, 0xF7, 0x8F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0xFF, 0x1F, 0x7F, 0xF7, 0xFE, 0x1C, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x7F, 0x07, 0xE0, 0x78, 0x00, 0x10, 0xF7, 0xCF, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x08, 0xF3, 0xEF, 0x3C, 0x02, 0x07, 0xC3, 0xE1, 0xF0, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x78,
  0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x00, 0x00, 0x10, 0x03, 0x01, 0xF0, 0x7F,
  0x3F, 0xCF, 0xF0, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xE0, 0x1E,
  0x00, 0x40, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xE7, 0xFF, 0xBF, 0xFE, 0x30, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0x3C, 0x07, 0xE1, 0xFE, 0x7F, 0x87, 0xF0, 0x3C, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x3F, 0xE7, 0xFF, 0xF0, 0xFF, 0x07, 0x00, 0xF0, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x03, 0xF0, 0x0F, 0xF0, 0x78, 0x70,
  0xC0, 0x63, 0x1E, 0xCE, 0xFC, 0xD9, 0x99, 0xF7, 0x33, 0xCC, 0x6D, 0xB9,
  0x9B, 0x73, 0x36, 0xE6, 0x6D, 0xDD, 0x99, 0xFF, 0x33, 0xB8, 0x60, 0x00,
  0x60, 0x80, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xEF, 0x01, 0xDE, 0x07, 0x9C, 0x0E,
  0x38, 0x3C, 0x70, 0x70, 0xE1, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0x9C, 0x0F,
  0x78, 0x1E, 0xF0, 0x3F, 0xC0, 0x38, 0x1F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE,
  0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0E, 0x3C, 0x3E, 0x3F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xFC, 0x38, 0x1C, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C,
  0x78, 0x3C, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xC7, 0x03, 0x9E, 0x07, 0xB8, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x1E,
  0x78, 0x3C, 0xF0, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE1, 0xC1, 0xE3, 0x83, 0xCF, 0x07, 0x9E,
  0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xE0, 0x79, 0xC0, 0xE7, 0x83, 0xCF, 0x07,
  0x9E, 0x1E, 0x38, 0x7C, 0x7F, 0xF1, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFF, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF8,
  0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF9, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x0F, 0x38, 0x1D, 0xE0, 0x77, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0xC7, 0xFF, 0x1F, 0xFC, 0x7E, 0xF0, 0x3B, 0xC1,
  0xEF, 0x07, 0x9E, 0x1E, 0x7F, 0xF8, 0xFF, 0xC1, 0xFC, 0x00, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x78, 0x3C, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x38, 0x70, 0x38, 0x70, 0x78, 0xF0, 0x78, 0xF0, 0x78,
  0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x7F, 0xE3, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x9E, 0x0F,
  0x3C, 0x1C, 0x78, 0x78, 0x7F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x1E, 0x07,
  0xC7, 0x83, 0xC1, 0xE1, 0xE0, 0x78, 0xF8, 0x1C, 0x7C, 0x07, 0x3E, 0x03,
  0xDF, 0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x7C, 0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x70, 0x3C,
  0x1C, 0x0F, 0x0F, 0x03, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x1F, 0x3E, 0x1F, 0x7E, 0x3F, 0x6E,
  0x3B, 0xEE, 0x3B, 0xCE, 0x3B, 0xDE, 0x3B, 0xDC, 0x39, 0x9C, 0x79, 0x9C,
  0x78, 0x1C, 0x70, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0xF0, 0x38, 0xF0, 0x38,
  0x1E, 0x0F, 0x1F, 0x0F, 0x1F, 0x0E, 0x1F, 0x0E, 0x1F, 0x1E, 0x1F, 0x1E,
  0x3F, 0x9E, 0x3F, 0x9E, 0x3F, 0x9C, 0x39, 0x9C, 0x39, 0xFC, 0x79, 0xFC,
  0x79, 0xFC, 0x78, 0xFC, 0x78, 0xF8, 0x70, 0xF8, 0x70, 0xF8, 0xF0, 0x78,
  0xF0, 0x78, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F, 0x38, 0x3D, 0xE0,
  0x77, 0x01, 0xDC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3B, 0xC1, 0xEF, 0x07, 0xBC, 0x3C, 0x7F, 0xE0, 0xFF, 0x01, 0xF8, 0x00,
  0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE0, 0xF3, 0xC1, 0xE7, 0x03, 0xCE,
  0x07, 0x9C, 0x0E, 0x78, 0x7C, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F, 0x38, 0x1D, 0xE0, 0x77, 0x81,
  0xDC, 0x07, 0x70, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xEF, 0x07, 0xBC, 0x3C, 0x7F, 0xE0, 0xFF, 0x01, 0xFE, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1F, 0x1C,
  0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x3F,
  0xF0, 0x3F, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x70,
  0x78, 0x70, 0x3C, 0xF0, 0x3C, 0x07, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE0,
  0xF3, 0x81, 0xE7, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xC0, 0x03, 0xC0, 0x03, 0x9C, 0x07, 0x3C, 0x0E, 0x78, 0x3C, 0x7F,
  0xF8, 0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0,
  0xE3, 0x81, 0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x71,
  0xC0, 0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1C, 0x38, 0x78, 0x7F,
  0xE0, 0x7F, 0xC0, 0x7E, 0x00, 0xF0, 0x1F, 0xE0, 0x79, 0xC0, 0xF3, 0x81,
  0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xE0, 0x73, 0xC0,
  0xE7, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE3, 0x8F, 0xC7, 0x3F, 0x9E, 0x77, 0x3C,
  0xEE, 0x79, 0xDC, 0xF7, 0xBB, 0xEE, 0x77, 0xDC, 0xEF, 0xF9, 0xFF, 0xE3,
  0xFF, 0xC7, 0xDF, 0x8F, 0xBF, 0x1F, 0x7C, 0x3C, 0xF8, 0x79, 0xF0, 0xF3,
  0xC1, 0xC7, 0x83, 0x8F, 0x00, 0x1F, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0,
  0x1E, 0x3C, 0x07, 0x9E, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xDE,
  0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x1E, 0x07, 0x8F, 0x81, 0xE0,
  0xF0, 0x1F, 0x78, 0x1E, 0x78, 0x3C, 0x38, 0x78, 0x38, 0x78, 0x3C, 0xF0,
  0x3C, 0xE0, 0x1D, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xC3, 0xF0, 0xFC, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0,
  0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xFC, 0x3F,
  0x00, 0xE1, 0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x78, 0x70, 0xE1, 0xC3,
  0x87, 0x8F, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE0, 0x0F, 0xC3, 0xF0, 0xFC,
  0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x70, 0xFC, 0x3F, 0x00, 0x07, 0x00, 0xF0, 0x3E, 0x06, 0xC1, 0xD8,
  0x73, 0x8E, 0x73, 0x8E, 0x70, 0xDC, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0xE3, 0xC0, 0x03, 0x00, 0xFF, 0x0F, 0xFC, 0x79, 0xF7, 0x87, 0x80,
  0x3C, 0x1F, 0xE7, 0xFE, 0x7E, 0x77, 0x83, 0xBC, 0x3D, 0xC1, 0xEF, 0xFF,
  0x7F, 0xF8, 0xFB, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x79, 0x01, 0xDF, 0x87, 0xFE, 0x1F, 0x7C, 0xF0, 0xF3, 0xC1, 0xCF,
  0x07, 0x38, 0x1C, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x79, 0xFF, 0xE7,
  0xFF, 0x3D, 0xF8, 0x01, 0x00, 0x7F, 0x07, 0xFC, 0x7D, 0xF7, 0x87, 0xBC,
  0x1D, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x1C, 0xE1, 0xE7, 0xFE,
  0x1F, 0xF0, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x47, 0x87, 0xEF, 0x1F, 0xFE, 0x3E, 0xF8, 0xF0, 0xF1, 0xE0,
  0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1C, 0x78, 0x38, 0xF0, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC1, 0xF7, 0x80, 0x01, 0x00, 0x3F, 0x81, 0xFF, 0x0F,
  0xBE, 0x78, 0x39, 0xE0, 0xE7, 0x03, 0xBF, 0xFE, 0xFF, 0xFB, 0xC0, 0x0F,
  0x00, 0x1E, 0x08, 0x7F, 0xF0, 0xFF, 0xC1, 0xFC, 0x00, 0x00, 0x7E, 0x03,
  0xFC, 0x0F, 0xF8, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x3F, 0xFC,
  0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x01, 0x00, 0x0F, 0xDC, 0x7F, 0xF8, 0xFB, 0xF3, 0xC1, 0xC7, 0x83,
  0x8E, 0x07, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xE1, 0xC3, 0xC3,
  0xFF, 0x87, 0xFF, 0x07, 0xDE, 0x00, 0x3C, 0x20, 0xF0, 0xE3, 0xE3, 0xFF,
  0x81, 0xFE, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x71, 0x81, 0xDF, 0x87, 0xFF, 0x3F, 0x7C, 0xF0, 0xF3, 0xC1,
  0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x39, 0xC0,
  0xE7, 0x03, 0xBC, 0x1E, 0x00, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x00,
  0x00, 0x1F, 0xC1, 0xFC, 0x3F, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x87, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x60,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x1F, 0x0F, 0xE0, 0xFC, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x01, 0x1C, 0x3E, 0x1C, 0x7C, 0x3C, 0xF8, 0x3D, 0xF0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7D, 0xE0, 0x79, 0xE0, 0x78, 0xF0, 0x70,
  0xF0, 0x70, 0x78, 0xF0, 0x7C, 0x0F, 0xE1, 0xFE, 0x1F, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0x08, 0x7F, 0xF8, 0xFF, 0xF9, 0xFF, 0xF7, 0x9C, 0xEE, 0x79, 0xDC, 0xF7,
  0xB9, 0xCF, 0x73, 0x9C, 0xE7, 0x3B, 0xCE, 0x77, 0x3C, 0xEE, 0x73, 0xDC,
  0xE7, 0xB9, 0xCE, 0x00, 0x00, 0x20, 0x77, 0xE1, 0xFF, 0xCF, 0xDF, 0x3C,
  0x3C, 0xF0, 0x73, 0xC1, 0xCE, 0x0F, 0x38, 0x3D, 0xE0, 0xF7, 0x83, 0xDE,
  0x0E, 0x70, 0x39, 0xC1, 0xEF, 0x07, 0x80, 0x01, 0x00, 0x7F, 0x07, 0xFC,
  0x7D, 0xF7, 0x87, 0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC,
  0x1F, 0xE1, 0xE7, 0xFE, 0x1F, 0xF0, 0x7E, 0x00, 0x00, 0x40, 0x77, 0xE1,
  0xFF, 0x8F, 0xDF, 0x3C, 0x3C, 0xF0, 0x73, 0xC1, 0xCE, 0x07, 0x38, 0x3D,
  0xE0, 0xF7, 0x83, 0x9E, 0x1E, 0x7F, 0xF9, 0xFF, 0xC7, 0x7E, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x02, 0x00, 0x7F, 0xF3, 0xFF,
  0xCF, 0xBE, 0x78, 0x79, 0xE0, 0xE7, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1,
  0xCF, 0x07, 0x3C, 0x3C, 0x7F, 0xF1, 0xFF, 0xC3, 0xEF, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x20, 0xEF, 0xCF, 0xFE, 0x7F,
  0xF3, 0xF0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x3F, 0xC3, 0xFF,
  0x8F, 0x1E, 0x78, 0x39, 0xE0, 0x13, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xCE, 0x07, 0xBC, 0x1C, 0xF9, 0xF1, 0xFF, 0x81, 0xFC, 0x00, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x07, 0xFF, 0xFF, 0xF8, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x00, 0x3C, 0x3C, 0xE0, 0xF3, 0x83, 0xDE, 0x0F, 0x78,
  0x39, 0xE0, 0xE7, 0x07, 0x9C, 0x1E, 0x70, 0x79, 0xC1, 0xC7, 0x0F, 0x1F,
  0xFC, 0x7F, 0x70, 0xFB, 0xC0, 0xF0, 0x3F, 0xC1, 0xE7, 0x07, 0x1C, 0x3C,
  0x70, 0xE1, 0xC7, 0x87, 0x9C, 0x0E, 0xF0, 0x3B, 0x80, 0xEE, 0x03, 0xF0,
  0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xF3, 0x8F, 0xE7, 0x3F, 0xCE, 0x77,
  0x3C, 0xEE, 0x7B, 0xDC, 0xF7, 0x3B, 0x6E, 0x76, 0xDC, 0xED, 0xF1, 0xF3,
  0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x38, 0x00, 0x3C, 0x1F, 0x1E,
  0x1E, 0x0E, 0x3C, 0x0F, 0x78, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3C, 0x78, 0x78, 0x78, 0xF0,
  0x3C, 0x3C, 0x0F, 0x9E, 0x07, 0x87, 0x07, 0x83, 0x83, 0xC1, 0xE3, 0xC0,
  0xF1, 0xC0, 0x39, 0xE0, 0x1C, 0xE0, 0x0E, 0xF0, 0x07, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xFC,
  0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x00, 0x00,
  0xC0, 0xF0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xC3, 0xF0, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0x70, 0x1E, 0x01, 0x00, 0x1C, 0x71, 0x86, 0x18,
  0x61, 0x8E, 0x30, 0xC3, 0x0C, 0x31, 0xC7, 0x18, 0x61, 0x86, 0x38, 0xE3,
  0x0C, 0x30, 0x1C, 0x07, 0x80, 0xE0, 0x18, 0x07, 0x03, 0xC0, 0xF0, 0x38,
  0x0E, 0x03, 0x80, 0xF0, 0x1F, 0x03, 0xC1, 0xF0, 0xF0, 0x78, 0x1C, 0x07,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x83, 0xC0, 0xE0, 0x20, 0x00, 0x1C,
  0x00, 0xFE, 0x1D, 0xFE, 0x3F, 0x1F, 0xEE, 0x1F, 0xC0, 0x1F, 0x00,
};

const GFXglyph RobotoMono_BoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 7, 19, 16, 5, -19 },
  { 18, 9, 7, 16, 4, -20 },
  { 26, 16, 19, 16, 0, -19 },
  { 64, 15, 25, 16, 1, -22 },
  { 111, 13, 20, 16, 2, -20 },
  { 144, 15, 20, 16, 0, -20 },
  { 182, 4, 7, 16, 7, -20 },
  { 186, 9, 27, 16, 4, -21 },
  { 217, 9, 27, 16, 2, -21 },
  { 248, 13, 13, 16, 2, -19 },
  { 270, 14, 14, 16, 1, -16 },
  { 295, 6, 8, 16, 2, -3 },
  { 301, 12, 3, 16, 3, -10 },
  { 306, 5, 5, 16, 4, -5 },
  { 310, 14, 21, 16, 1, -19 },
  { 347, 13, 20, 16, 2, -20 },
  { 380, 9, 19, 16, 3, -19 },
  { 402, 14, 19, 16, 0, -19 },
  { 436, 14, 19, 16, 1, -19 },
  { 470, 14, 19, 16, 0, -19 },
  { 504, 14, 19, 16, 1, -19 },
  { 538, 13, 19, 16, 1, -19 },
  { 569, 14, 19, 16, 2, -19 },
  { 603, 14, 19, 16, 1, -19 },
  { 637, 12, 19, 16, 2, -19 },
  { 666, 6, 16, 16, 5, -16 },
  { 678, 9, 21, 16, 3, -16 },
  { 702, 12, 13, 16, 2, -15 },
  { 722, 14, 8, 16, 1, -12 },
  { 736, 13, 12, 16, 1, -14 },
  { 756, 12, 20, 16, 3, -20 },
  { 786, 15, 19, 16, 1, -19 },
  { 822, 15, 19, 16, -1, -19 },
  { 858, 16, 19, 16, 0, -19 },
  { 896, 15, 20, 16, 1, -20 },
  { 934, 15, 19, 16, 0, -19 },
  { 970, 16, 19, 16, 0, -19 },
  { 1008, 15, 19, 16, 1, -19 },
  { 1044, 14, 19, 16, 1, -19 },
  { 1078, 16, 19, 16, 0, -19 },
  { 1116, 14, 19, 16, 1, -19 },
  { 1150, 15, 19, 16, 1, -19 },
  { 1186, 18, 19, 16, 0, -19 },
  { 1229, 12, 19, 16, 1, -19 },
  { 1258, 16, 19, 16, 0, -19 },
  { 1296, 16, 19, 16, 0, -19 },
  { 1334, 14, 19, 16, 1, -19 },
  { 1368, 15, 19, 16, 1, -19 },
  { 1404, 14, 22, 16, 1, -19 },
  { 1443, 16, 19, 16, 0, -19 },
  { 1481, 15, 19, 16, 1, -19 },
  { 1517, 15, 19, 16, 2, -19 },
  { 1553, 15, 19, 16, 1, -19 },
  { 1589, 15, 19, 16, 2, -19 },
  { 1625, 15, 19, 16, 2, -19 },
  { 1661, 18, 19, 16, -1, -19 },
  { 1704, 16, 19, 16, 2, -19 },
  { 1742, 16, 19, 16, 0, -19 },
  { 1780, 10, 26, 16, 3, -22 },
  { 1813, 7, 21, 16, 5, -19 },
  { 1832, 10, 26, 16, 3, -22 },
  { 1865, 11, 10, 16, 3, -19 },
  { 1879, 12, 3, 16, 0, 0 },
  { 1884, 6, 3, 16, 7, -19 },
  { 1887, 13, 15, 16, 1, -15 },
  { 1912, 14, 20, 16, 0, -20 },
  { 1947, 13, 15, 16, 1, -15 },
  { 1972, 15, 20, 16, 1, -20 },
  { 2010, 14, 15, 16, 1, -15 },
  { 2037, 15, 21, 16, 2, -21 },
  { 2077, 15, 21, 16, 0, -15 },
  { 2117, 14, 20, 16, 0, -20 },
  { 2152, 12, 20, 16, 1, -20 },
  { 2182, 12, 26, 16, 1, -20 },
  { 2221, 16, 20, 16, 0, -20 },
  { 2261, 12, 20, 16, 1, -20 },
  { 2291, 15, 15, 16, 0, -15 },
  { 2320, 14, 15, 16, 0, -15 },
  { 2347, 13, 15, 16, 1, -15 },
  { 2372, 14, 20, 16, 0, -15 },
  { 2407, 14, 20, 16, 1, -15 },
  { 2442, 13, 15, 16, 2, -15 },
  { 2467, 14, 15, 16, 1, -15 },
  { 2494, 13, 18, 16, 2, -18 },
  { 2524, 14, 14, 16, 1, -14 },
  { 2549, 14, 14, 16, 2, -14 },
  { 2574, 15, 14, 16, 1, -14 },
  { 2601, 16, 14, 16, 0, -14 },
  { 2629, 17, 20, 16, 0, -14 },
  { 2672, 15, 14, 16, 0, -14 },
  { 2699, 10, 26, 16, 4, -21 },
  { 2732, 6, 24, 16, 5, -19 },
  { 2750, 10, 26, 16, 3, -21 },
  { 2783, 15, 6, 16, 0, -11 },
};

const GFXfont RobotoMono_BoldItalic27pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic27pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOMONO_BOLDITALIC27PT7B_H_
