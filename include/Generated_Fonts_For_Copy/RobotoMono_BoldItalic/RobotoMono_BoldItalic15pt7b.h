#ifndef _ROBOTOMONO_BOLDITALIC15PT7B_H_
#define _ROBOTOMONO_BOLDITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xB0, 0x1B, 0x00, 0x6A, 0x53, 0xB0, 0x0D, 0x04, 0x82,
  0xCF, 0xF7, 0xF8, 0xB0, 0x91, 0xFE, 0x68, 0x24, 0x16, 0x00, 0x0C, 0x1C,
  0x7E, 0x66, 0x63, 0x70, 0x38, 0x0C, 0x06, 0xC6, 0xFC, 0x78, 0x20, 0x20,
  0x61, 0xA2, 0x5D, 0xE6, 0x82, 0x0D, 0x1F, 0x52, 0xA4, 0x70, 0x0C, 0x0F,
  0x0C, 0x86, 0xC3, 0xC1, 0xC1, 0xE7, 0xDE, 0xCF, 0x77, 0x1E, 0xC0, 0xFA,
  0x08, 0xCC, 0x46, 0x31, 0x18, 0xC6, 0x31, 0x84, 0x30, 0x80, 0x20, 0x86,
  0x30, 0x84, 0x23, 0x18, 0xC6, 0x63, 0x33, 0x00, 0x08, 0x12, 0x6F, 0xF1,
  0x85, 0x3B, 0x24, 0x18, 0x30, 0x67, 0xFF, 0xE6, 0x0C, 0x18, 0x32, 0x66,
  0xC0, 0xFF, 0xF0, 0x5D, 0x80, 0x06, 0x0C, 0x30, 0x61, 0x83, 0x0C, 0x18,
  0x60, 0xC3, 0x06, 0x00, 0x1C, 0xFD, 0x9B, 0x3C, 0xFB, 0xF9, 0xE3, 0xCD,
  0xF9, 0xE0, 0x0B, 0xFF, 0x63, 0x18, 0xC6, 0x33, 0x18, 0x1C, 0x3F, 0x63,
  0x63, 0x07, 0x06, 0x1C, 0x38, 0x70, 0xFE, 0xFE, 0x1E, 0x3F, 0x73, 0x03,
  0x07, 0x1C, 0x06, 0x03, 0xC6, 0x7E, 0x7C, 0x03, 0x07, 0x0E, 0x1E, 0x16,
  0x36, 0x66, 0xFF, 0xFF, 0x0C, 0x0C, 0x3F, 0x7E, 0x60, 0x60, 0x7C, 0xFC,
  0x06, 0x06, 0xCC, 0xFC, 0x78, 0x0C, 0x79, 0xC3, 0x0F, 0xDF, 0xB1, 0xE3,
  0xCD, 0xF9, 0xE0, 0xFF, 0xFF, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x70,
  0x60, 0xC0, 0x0E, 0x3F, 0x33, 0x33, 0x37, 0x1C, 0x76, 0x62, 0x66, 0x7E,
  0x3C, 0x38, 0xFB, 0x9E, 0x3C, 0x79, 0xDF, 0x96, 0x0C, 0xF1, 0x80, 0x4D,
  0x80, 0x26, 0xC0, 0x11, 0xCC, 0x00, 0x00, 0x0C, 0x63, 0x31, 0x80, 0x06,
  0x3F, 0xE6, 0x07, 0x83, 0x81, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x41,
  0xE0, 0xF0, 0x77, 0xDC, 0x20, 0x00, 0x39, 0xFB, 0x30, 0x60, 0xC7, 0x0C,
  0x30, 0x00, 0xC1, 0x80, 0x04, 0x0F, 0x88, 0x4D, 0xD5, 0x2A, 0xAB, 0xD5,
  0x7A, 0xD6, 0x20, 0x0F, 0x00, 0x02, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0xD8,
  0x6C, 0x7E, 0x3F, 0xB0, 0xF8, 0x60, 0x3E, 0x1F, 0x8C, 0x6C, 0x36, 0x33,
  0xF1, 0x8C, 0xC6, 0x63, 0x7F, 0xBF, 0x00, 0x1C, 0x7E, 0x66, 0xC3, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC6, 0xFC, 0x78, 0x3C, 0x3E, 0x33, 0x63, 0x63, 0x63,
  0x63, 0x63, 0x66, 0xFE, 0xF8, 0x3F, 0x9F, 0xCC, 0x06, 0x06, 0x03, 0xF9,
  0x80, 0xC0, 0x60, 0x3F, 0xBF, 0x80, 0x3F, 0x9F, 0xCC, 0x06, 0x06, 0x03,
  0xF9, 0xFC, 0xC0, 0x60, 0x30, 0x30, 0x00, 0x1C, 0x7E, 0x66, 0xC3, 0xC0,
  0xC0, 0xDE, 0xC6, 0xC6, 0xFE, 0x7C, 0x31, 0x98, 0xCC, 0xCC, 0x66, 0x33,
  0xF9, 0x8C, 0xC6, 0x66, 0x63, 0x31, 0x80, 0x7E, 0xFC, 0x60, 0xC1, 0x83,
  0x0C, 0x18, 0x31, 0xFB, 0xF0, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06,
  0x06, 0xCC, 0xFC, 0x78, 0x31, 0xCC, 0xE3, 0x71, 0x98, 0x6C, 0x1F, 0x07,
  0xC1, 0xB8, 0x66, 0x31, 0x8C, 0x30, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18,
  0x30, 0x60, 0xFF, 0xF8, 0x33, 0x9D, 0xCE, 0xEF, 0xE7, 0xD3, 0x79, 0xAC,
  0xC6, 0x43, 0x61, 0x31, 0x80, 0x31, 0x98, 0xCC, 0xCF, 0x67, 0xB3, 0x59,
  0xAC, 0xDE, 0x6E, 0x63, 0x31, 0x80, 0x1C, 0x7E, 0x66, 0xC6, 0xC6, 0xC6,
  0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x3E, 0x1F, 0x8C, 0x66, 0x36, 0x3B, 0xF9,
  0xF8, 0xC0, 0x60, 0x30, 0x30, 0x00, 0x1C, 0x7E, 0x66, 0xC3, 0xC3, 0xC6,
  0xC6, 0xC6, 0xC6, 0xFC, 0x7C, 0x0E, 0x04, 0x3E, 0x1F, 0x8C, 0xEC, 0x36,
  0x33, 0xF9, 0xF0, 0xCC, 0x66, 0x63, 0x30, 0xC0, 0x0E, 0x1F, 0x8C, 0x6C,
  0x03, 0x00, 0xF0, 0x3C, 0x06, 0xE3, 0x3F, 0x8F, 0x80, 0xFF, 0xFF, 0x86,
  0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x63, 0x63,
  0x63, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0xCC, 0xFC, 0x78, 0xC3, 0xF1, 0x99,
  0xCC, 0xC6, 0x63, 0x61, 0xB0, 0xF0, 0x78, 0x38, 0x0C, 0x00, 0xC9, 0xED,
  0xB6, 0xDB, 0x6F, 0xA7, 0x73, 0xB9, 0xD8, 0xEC, 0x66, 0x33, 0x00, 0x38,
  0xE3, 0x38, 0x66, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xD8, 0x3B, 0x06,
  0x63, 0x86, 0x00, 0xE3, 0xB1, 0x99, 0x8C, 0xC2, 0xC1, 0xE0, 0xE0, 0x60,
  0x30, 0x18, 0x0C, 0x00, 0x3F, 0xBF, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60,
  0x60, 0x60, 0x7F, 0xBF, 0xC0, 0x39, 0x8C, 0xC6, 0x31, 0x8C, 0x63, 0x31,
  0x8C, 0x70, 0xDB, 0x6C, 0x9B, 0x6D, 0x90, 0x38, 0xC6, 0x31, 0x98, 0xC6,
  0x31, 0x8C, 0xC6, 0x70, 0x10, 0xE3, 0x9A, 0xCB, 0x30, 0xFF, 0xFC, 0xCC,
  0x3E, 0x76, 0x03, 0x3E, 0x76, 0xE6, 0x6E, 0x7E, 0x30, 0x30, 0x30, 0x2E,
  0x7F, 0x63, 0x63, 0x63, 0x67, 0x7E, 0xDC, 0x3C, 0xFF, 0x1E, 0x0C, 0x19,
  0xBF, 0x3C, 0x03, 0x03, 0x06, 0x7E, 0x7E, 0xC6, 0xC6, 0xC6, 0xCC, 0xFC,
  0x7C, 0x3C, 0xFF, 0x1F, 0xFF, 0xF8, 0x3B, 0x3E, 0x03, 0x0F, 0x18, 0x18,
  0xFE, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x1F, 0x3F, 0x63, 0x63,
  0x63, 0x66, 0x7E, 0x3E, 0x06, 0xFC, 0x78, 0x30, 0x30, 0x30, 0x2E, 0x7F,
  0x63, 0x63, 0x63, 0x63, 0xC6, 0xC6, 0x0C, 0x30, 0x1E, 0x78, 0x61, 0x86,
  0x33, 0xFF, 0xC0, 0x06, 0x0C, 0x00, 0xF3, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x60, 0xCB, 0x9E, 0x00, 0x30, 0x18, 0x0C, 0x06, 0x76, 0x63, 0x61, 0xE0,
  0xF8, 0x6C, 0x33, 0x31, 0xC0, 0x7C, 0x31, 0x86, 0x18, 0x61, 0x86, 0x33,
  0xFF, 0xC0, 0x7B, 0x7F, 0x69, 0x5B, 0xDB, 0xDB, 0xDB, 0xDA, 0x2E, 0x7F,
  0x63, 0x63, 0x63, 0x63, 0xC6, 0xC6, 0x3C, 0xFF, 0x1E, 0x3C, 0x79, 0xFF,
  0x3C, 0x2E, 0x7F, 0x63, 0x63, 0x63, 0x66, 0x7E, 0xDC, 0xC0, 0xC0, 0xC0,
  0x7E, 0xFF, 0x1E, 0x3C, 0x79, 0xBF, 0x3E, 0x0C, 0x18, 0x60, 0x3F, 0x7E,
  0x70, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x3C, 0xDF, 0x03, 0x83, 0xD0, 0xF3,
  0x3C, 0x18, 0x63, 0xFF, 0xF3, 0x06, 0x0C, 0x30, 0x7C, 0x78, 0x67, 0x8F,
  0x1E, 0x3C, 0x79, 0xBF, 0x3E, 0xC7, 0xC6, 0x46, 0x6C, 0x68, 0x78, 0x70,
  0x30, 0xDB, 0xDB, 0xBE, 0xBE, 0xBC, 0xDC, 0xCC, 0xC8, 0x73, 0x99, 0x87,
  0x83, 0x81, 0xC1, 0xE1, 0x99, 0xCE, 0x61, 0xB1, 0xCC, 0xC6, 0xC3, 0x61,
  0xE0, 0x70, 0x30, 0x30, 0x38, 0x38, 0x00, 0x7F, 0x7F, 0x06, 0x0C, 0x18,
  0x30, 0x7F, 0xFE, 0x04, 0x71, 0x84, 0x30, 0xC7, 0x30, 0x60, 0x82, 0x18,
  0x60, 0xC1, 0x00, 0x25, 0xB4, 0x92, 0xDA, 0x49, 0x00, 0x10, 0xE1, 0x86,
  0x18, 0x61, 0x83, 0x18, 0xC3, 0x0C, 0x23, 0x88, 0x00, 0x71, 0xFB, 0x8E,
};

const GFXglyph RobotoMono_BoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 4, 9, 2, -11 },
  { 9, 9, 11, 9, 0, -11 },
  { 22, 8, 14, 9, 1, -12 },
  { 36, 7, 11, 9, 1, -11 },
  { 46, 9, 11, 9, 0, -11 },
  { 59, 2, 4, 9, 4, -11 },
  { 60, 5, 15, 9, 2, -12 },
  { 70, 5, 15, 9, 1, -12 },
  { 80, 7, 8, 9, 1, -11 },
  { 87, 7, 8, 9, 1, -9 },
  { 94, 4, 5, 9, 1, -2 },
  { 97, 6, 2, 9, 2, -6 },
  { 99, 3, 3, 9, 2, -3 },
  { 101, 7, 12, 9, 1, -11 },
  { 112, 7, 11, 9, 1, -11 },
  { 122, 5, 11, 9, 2, -11 },
  { 129, 8, 11, 9, 0, -11 },
  { 140, 8, 11, 9, 0, -11 },
  { 151, 8, 11, 9, 0, -11 },
  { 162, 8, 11, 9, 1, -11 },
  { 173, 7, 11, 9, 1, -11 },
  { 183, 8, 11, 9, 1, -11 },
  { 194, 8, 11, 9, 0, -11 },
  { 205, 7, 11, 9, 1, -11 },
  { 215, 3, 9, 9, 3, -9 },
  { 219, 5, 12, 9, 2, -9 },
  { 227, 7, 7, 9, 1, -8 },
  { 234, 7, 5, 9, 1, -7 },
  { 239, 7, 7, 9, 1, -8 },
  { 246, 7, 11, 9, 2, -11 },
  { 256, 9, 11, 9, 0, -11 },
  { 269, 9, 11, 9, -1, -11 },
  { 282, 9, 11, 9, 0, -11 },
  { 295, 8, 11, 9, 1, -11 },
  { 306, 8, 11, 9, 0, -11 },
  { 317, 9, 11, 9, 0, -11 },
  { 330, 9, 11, 9, 0, -11 },
  { 343, 8, 11, 9, 1, -11 },
  { 354, 9, 11, 9, 0, -11 },
  { 367, 7, 11, 9, 1, -11 },
  { 377, 8, 11, 9, 1, -11 },
  { 388, 10, 11, 9, 0, -11 },
  { 402, 7, 11, 9, 0, -11 },
  { 412, 9, 11, 9, 0, -11 },
  { 425, 9, 11, 9, 0, -11 },
  { 438, 8, 11, 9, 1, -11 },
  { 449, 9, 11, 9, 0, -11 },
  { 462, 8, 13, 9, 1, -11 },
  { 475, 9, 11, 9, 0, -11 },
  { 488, 9, 11, 9, 0, -11 },
  { 501, 9, 11, 9, 1, -11 },
  { 514, 8, 11, 9, 1, -11 },
  { 525, 9, 11, 9, 1, -11 },
  { 538, 9, 11, 9, 1, -11 },
  { 551, 11, 11, 9, -1, -11 },
  { 567, 9, 11, 9, 1, -11 },
  { 580, 9, 11, 9, 0, -11 },
  { 593, 5, 14, 9, 2, -12 },
  { 602, 3, 12, 9, 3, -11 },
  { 607, 5, 14, 9, 2, -12 },
  { 616, 6, 6, 9, 2, -11 },
  { 621, 7, 2, 9, 0, 0 },
  { 623, 3, 2, 9, 4, -11 },
  { 624, 8, 8, 9, 0, -8 },
  { 632, 8, 11, 9, 0, -11 },
  { 643, 7, 8, 9, 1, -8 },
  { 650, 8, 11, 9, 1, -11 },
  { 661, 7, 8, 9, 1, -8 },
  { 668, 8, 12, 9, 1, -12 },
  { 680, 8, 11, 9, 0, -8 },
  { 691, 8, 11, 9, 0, -11 },
  { 702, 6, 11, 9, 1, -11 },
  { 711, 7, 14, 9, 0, -11 },
  { 724, 9, 11, 9, 0, -11 },
  { 737, 6, 11, 9, 1, -11 },
  { 746, 8, 8, 9, 0, -8 },
  { 754, 8, 8, 9, 0, -8 },
  { 762, 7, 8, 9, 1, -8 },
  { 769, 8, 11, 9, 0, -8 },
  { 780, 7, 11, 9, 1, -8 },
  { 790, 8, 8, 9, 1, -8 },
  { 798, 7, 8, 9, 1, -8 },
  { 805, 7, 10, 9, 1, -10 },
  { 814, 7, 8, 9, 1, -8 },
  { 821, 8, 8, 9, 1, -8 },
  { 829, 8, 8, 9, 1, -8 },
  { 837, 9, 8, 9, 0, -8 },
  { 846, 9, 11, 9, 0, -8 },
  { 859, 8, 8, 9, 0, -8 },
  { 867, 6, 15, 9, 2, -12 },
  { 879, 3, 14, 9, 3, -11 },
  { 885, 6, 15, 9, 1, -12 },
  { 897, 8, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_BoldItalic15pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic15pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOMONO_BOLDITALIC15PT7B_H_
