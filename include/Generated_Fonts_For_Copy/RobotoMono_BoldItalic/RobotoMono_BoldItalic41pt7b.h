#ifndef _ROBOTOMONO_BOLDITALIC41PT7B_H_
#define _ROBOTOMONO_BOLDITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-BoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_BoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x7C, 0x1F,
  0x83, 0xF0, 0x7E, 0x07, 0x80, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7,
  0x87, 0xB8, 0x3B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x07, 0x38, 0x38, 0x00,
  0x0E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x38, 0x00,
  0x3C, 0x38, 0x00, 0x38, 0x78, 0x00, 0x78, 0x70, 0x00, 0x78, 0xF0, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x01,
  0xE1, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xC3, 0xC0, 0x03, 0xC3, 0x80, 0x03,
  0xC7, 0x80, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x1E,
  0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x38,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0x87, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x80, 0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x3F,
  0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x02,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x78, 0xF0, 0x87,
  0x8F, 0x0E, 0x70, 0xF1, 0xE7, 0x0F, 0x3C, 0xF0, 0xE3, 0x87, 0x9E, 0x70,
  0x7F, 0xEF, 0x03, 0xFD, 0xE0, 0x1F, 0x9C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xCF, 0xC0, 0x39,
  0xFE, 0x07, 0xBF, 0xF0, 0xF7, 0xCF, 0x0E, 0x78, 0xF1, 0xE7, 0x8F, 0x3C,
  0x78, 0xF0, 0x87, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xF1, 0xF0, 0x03, 0xE1, 0xF0, 0x03,
  0xC1, 0xF0, 0x03, 0xC1, 0xF0, 0x03, 0xC3, 0xE0, 0x03, 0xE7, 0xE0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x01, 0x0F, 0xFC, 0x1E, 0x1F, 0xFC, 0x1E, 0x3F, 0xFE, 0x3E, 0x3F,
  0x3F, 0x3E, 0x7E, 0x3F, 0x7C, 0x7E, 0x1F, 0xFC, 0x7C, 0x0F, 0xF8, 0x7C,
  0x0F, 0xF8, 0x7E, 0x07, 0xF0, 0x7E, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xF8, 0xFC, 0x3C, 0xF7, 0xDE, 0x79,
  0xE7, 0x9E, 0xF3, 0xCF, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x1C, 0x00, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x02, 0x07, 0x01, 0x78, 0x70, 0xF7, 0xE7,
  0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0x03,
  0xF8, 0x00, 0x7B, 0x80, 0x0F, 0x3C, 0x01, 0xF1, 0xE0, 0x3E, 0x1E, 0x07,
  0xC1, 0xF0, 0x3C, 0x0E, 0x00, 0x80, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E,
  0x1E, 0x06, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x1F, 0x81,
  0xF1, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0,
  0x3F, 0x3E, 0x0F, 0xF7, 0xE1, 0xFF, 0x7E, 0x7F, 0xF7, 0xEF, 0xBF, 0x7F,
  0xF3, 0xE7, 0xFC, 0x3E, 0x7F, 0x83, 0xE7, 0xE0, 0x3E, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xE1, 0xF8,
  0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0C,
  0x01, 0xF0, 0x3F, 0x87, 0xFE, 0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0xBE, 0x7E,
  0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F,
  0x00, 0xFC, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x7F, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7D, 0xF0,
  0x03, 0xE7, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x1F,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F,
  0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xBF, 0x80,
  0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFC, 0x7F, 0x00, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0xFE, 0x1F,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xC0,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xFB, 0xFC, 0x3E, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xC3, 0xF7,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xF7, 0xE0, 0x7E, 0x7E, 0x3F, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF0, 0xFC, 0x3F, 0x07, 0xE1,
  0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x1F, 0x07,
  0xE0, 0xFC, 0x7F, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC1, 0xFC, 0x7E, 0x0F, 0xC1, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3E,
  0x7E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0xFC, 0x7C, 0x07, 0xE3, 0xF8,
  0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7E, 0x1F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xF7,
  0xF0, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xF7, 0xC0,
  0x11, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0x03, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE1, 0xF0, 0x00, 0xE0, 0x1F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x8F, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xF8,
  0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x7F,
  0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0x87, 0xC0, 0x7C, 0x03, 0xC1, 0xE0, 0x03, 0x83, 0x83, 0x87, 0x0F,
  0x1F, 0xEE, 0x3C, 0x7F, 0xCE, 0x71, 0xF7, 0x1D, 0xE7, 0x8E, 0x3B, 0x8E,
  0x1C, 0x77, 0x3C, 0x39, 0xDE, 0x78, 0xF3, 0xBC, 0xE1, 0xC7, 0x71, 0xC3,
  0x8E, 0xE3, 0x87, 0x1D, 0xCF, 0x1E, 0x73, 0x9E, 0x38, 0xE7, 0x1C, 0xF3,
  0x8E, 0x3F, 0xFF, 0x1C, 0x7E, 0xFC, 0x3C, 0x38, 0xE0, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x18, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C,
  0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xC1, 0xFE, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC,
  0x3E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81,
  0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7E,
  0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x8F, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0x7E, 0x1F, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x7C, 0xFF, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x0F,
  0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00,
  0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x87, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x07, 0xF0, 0x7F, 0x7F, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8,
  0x1F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00, 0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xFC, 0xFC, 0x3F, 0xF3, 0xE0, 0xFF, 0xCF, 0x83, 0xFF, 0x3E, 0x00,
  0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3F, 0x01, 0xF8,
  0xFC, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x3F, 0x07,
  0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F,
  0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x0F,
  0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3F,
  0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x7E,
  0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0x1F,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x03,
  0xE0, 0x3F, 0x80, 0x7C, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0xFE,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x3E,
  0x7F, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFE, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F,
  0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xF7,
  0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xDF, 0xEF, 0x83, 0xEF,
  0xF7, 0xC1, 0xF3, 0xF3, 0xE0, 0xF9, 0xFB, 0xE0, 0x7C, 0xF9, 0xF0, 0x3E,
  0x7C, 0xF8, 0x1F, 0x3C, 0x7C, 0x1F, 0x1E, 0x3E, 0x0F, 0x8E, 0x3F, 0x07,
  0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3E, 0x0F, 0xF0,
  0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF8, 0x7E, 0x0F, 0xF8, 0x7E, 0x0F, 0xF8,
  0x7E, 0x0F, 0xF8, 0x7C, 0x1F, 0xFC, 0x7C, 0x1F, 0xBC, 0xFC, 0x1F, 0xBC,
  0xFC, 0x1F, 0x3C, 0xFC, 0x1F, 0x3E, 0xF8, 0x3F, 0x1E, 0xF8, 0x3F, 0x1E,
  0xF8, 0x3F, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F,
  0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x07, 0xF0, 0x7C, 0x07,
  0xF0, 0x7C, 0x07, 0xF0, 0x7C, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0x8F, 0xE0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF8, 0x03,
  0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF0, 0x07, 0xC7, 0xC0,
  0x3F, 0x1F, 0x00, 0xFC, 0x7E, 0x07, 0xE0, 0xFC, 0x7F, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFC, 0x3F, 0xC1,
  0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x1F, 0x80, 0x3E, 0x3F,
  0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x0F, 0xC7, 0xE0,
  0x7F, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0x87, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0x7C, 0xFC, 0x01,
  0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7D, 0xF8, 0x01, 0xF7,
  0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0xFC, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x1F,
  0x1F, 0x00, 0xFC, 0x7E, 0x07, 0xE0, 0xFC, 0x7F, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xC1,
  0xFE, 0x07, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80,
  0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0xFE, 0x1F, 0x87, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07,
  0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x03,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x0F,
  0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0x8F,
  0xC0, 0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x9F, 0x80,
  0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC,
  0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xFC,
  0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0x7E, 0x3F,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x3E,
  0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xE0,
  0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0x3F,
  0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x7C, 0x3F, 0xF0, 0xF0, 0x7F, 0xE1, 0xE1, 0xF7, 0xC7, 0xC3, 0xEF,
  0x8F, 0x87, 0xDF, 0x1F, 0x0F, 0xBE, 0x3E, 0x3E, 0x7C, 0xFC, 0x7C, 0xF9,
  0xF8, 0xF9, 0xF3, 0xF3, 0xE3, 0xEF, 0xE7, 0xC7, 0xDF, 0xCF, 0x8F, 0xBF,
  0x9E, 0x1F, 0x77, 0x7C, 0x3F, 0xEE, 0xF8, 0x7F, 0xDD, 0xF0, 0xF7, 0x3F,
  0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x00,
  0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x80,
  0x07, 0xC7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x0F,
  0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xE3, 0xE0,
  0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x07,
  0xE0, 0x3F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x80, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07,
  0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xE0, 0x47, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0x78, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1E, 0xE0,
  0x1F, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0x8F, 0x07, 0x87, 0xC7, 0xC1,
  0xE3, 0xC0, 0xF3, 0xE0, 0x7B, 0xE0, 0x3E, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xFC, 0x7C, 0x7E, 0x3E, 0x1E, 0x0F, 0x00,
  0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x87, 0xF1,
  0xF0, 0x3F, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0xFF,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x83, 0xE7, 0xE0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0x3F, 0xF7, 0xC1, 0xFE, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0xF8, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7E, 0x0F, 0xC7, 0xE0, 0x3E,
  0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xF3, 0xE0,
  0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x7E, 0x7C, 0x03, 0xE3,
  0xF0, 0x3F, 0x1F, 0xC3, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7D, 0xFF,
  0x83, 0xE7, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFD, 0xFE, 0x7E, 0x0F, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0xFC, 0x0F, 0xCF, 0xC3, 0xF1, 0xFF,
  0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xC7,
  0xE0, 0x7F, 0xDF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0x7F, 0xC3,
  0xF0, 0x7F, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0,
  0x3E, 0x3F, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xE3, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFC, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xCF, 0xE3,
  0xF0, 0x3E, 0x7E, 0x03, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x10, 0xFC, 0x03, 0x07, 0xF0, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x20, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x7C, 0x0F, 0xF9, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xE7, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x3E, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C,
  0x03, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x80, 0xF8, 0x7E, 0x07,
  0xE0, 0xFC, 0x3F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x1F, 0x9F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x20, 0x1F, 0x81, 0xC0,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x7C, 0x07, 0xCF, 0xF8, 0x3E, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01,
  0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x3F,
  0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F,
  0x3F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x7E, 0x7C, 0x03, 0xF3, 0xE0,
  0x1F, 0x80, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x01, 0xFC,
  0x7E, 0x07, 0xF0, 0xFC, 0x1F, 0xC1, 0xF0, 0x7F, 0x03, 0xE1, 0xFC, 0x07,
  0xC7, 0xF0, 0x1F, 0x9F, 0xC0, 0x3F, 0x7F, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0x9F, 0x80, 0x7C, 0x3F, 0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x7F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xFC,
  0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0x9E, 0x3C, 0x0F, 0xFF, 0x7E, 0x0F, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0x1F, 0x0F, 0x80, 0xF9, 0xFF, 0x07, 0xDF,
  0xFC, 0x3F, 0xFF, 0xE1, 0xFE, 0xFF, 0x0F, 0xC0, 0xFC, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0x3E, 0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0xFC, 0x03,
  0xE7, 0xE0, 0x1F, 0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0x7C,
  0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E,
  0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF,
  0xFC, 0x3F, 0xDF, 0xE3, 0xF0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xFC, 0x0F, 0xC7, 0xE1, 0xF8,
  0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xC7,
  0xC0, 0x0F, 0xBF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xBF,
  0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x7E,
  0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xC3,
  0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7C, 0x1F, 0x81, 0xF8, 0x3F,
  0x87, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xCF,
  0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0xF8, 0x3F, 0xEF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3,
  0xFC, 0xFF, 0x1F, 0x81, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0x7C, 0x03,
  0xE7, 0xE0, 0x1F, 0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xF0, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xE7, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0x87, 0xF0, 0xF9,
  0xFF, 0x0F, 0xBF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xDE, 0x1F,
  0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE1, 0xF8, 0x3F, 0x8F, 0x80, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x7E, 0x7C, 0x03, 0xF3,
  0xF0, 0x3F, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x40, 0x7F, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xF8,
  0xFC, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xEF, 0x83, 0xFE,
  0x7C, 0x0F, 0xE7, 0xC0, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0xFC,
  0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x07, 0xC1,
  0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x01,
  0xE3, 0xE0, 0x0F, 0x3E, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x78, 0x3F, 0xF0, 0xF0, 0xFB, 0xE1, 0xE1, 0xF7, 0xC7,
  0xC3, 0xEF, 0x8F, 0x8F, 0x9F, 0x1F, 0x1F, 0x3E, 0x7E, 0x3E, 0x7C, 0xFC,
  0xF8, 0xF9, 0xF9, 0xF1, 0xF7, 0xF3, 0xE3, 0xEE, 0xE7, 0x87, 0xDD, 0xDF,
  0x0F, 0xFB, 0xBC, 0x1E, 0xE7, 0x78, 0x3D, 0xCF, 0xF0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x7F,
  0x07, 0xC0, 0xFE, 0x07, 0xE0, 0xFC, 0x03, 0xE1, 0xF8, 0x03, 0xF3, 0xF0,
  0x01, 0xF7, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x0F, 0xC7, 0xC0, 0x1F, 0xC7, 0xE0,
  0x1F, 0x83, 0xE0, 0x3F, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0xFC, 0x01, 0xF8,
  0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x3E, 0x00,
  0xFC, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x1F,
  0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0x9F, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07,
  0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83,
  0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x00, 0x03, 0x00, 0x03,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3E, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x7B,
  0xFF, 0xC1, 0xE7, 0xFF, 0xC7, 0xCF, 0x1F, 0xFF, 0xBC, 0x0F, 0xFE, 0x78,
  0x0F, 0xF8, 0x00, 0x0F, 0xE0,
};

const GFXglyph RobotoMono_BoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 11, 29, 24, 7, -29 },
  { 41, 13, 11, 24, 7, -31 },
  { 59, 24, 29, 24, 0, -29 },
  { 146, 22, 38, 24, 2, -34 },
  { 251, 20, 30, 24, 2, -30 },
  { 326, 24, 30, 24, 0, -30 },
  { 416, 6, 11, 24, 10, -31 },
  { 425, 14, 41, 24, 6, -32 },
  { 497, 14, 41, 24, 3, -32 },
  { 569, 20, 20, 24, 3, -29 },
  { 619, 20, 21, 24, 2, -24 },
  { 672, 9, 13, 24, 4, -5 },
  { 687, 17, 4, 24, 5, -15 },
  { 696, 7, 7, 24, 7, -7 },
  { 703, 21, 32, 24, 2, -29 },
  { 787, 20, 30, 24, 2, -30 },
  { 862, 14, 29, 24, 5, -29 },
  { 913, 22, 30, 24, 0, -30 },
  { 996, 22, 30, 24, 1, -30 },
  { 1079, 22, 29, 24, 0, -29 },
  { 1159, 21, 29, 24, 2, -29 },
  { 1236, 19, 29, 24, 2, -29 },
  { 1305, 22, 29, 24, 2, -29 },
  { 1385, 21, 30, 24, 1, -30 },
  { 1464, 19, 30, 24, 3, -30 },
  { 1536, 10, 24, 24, 7, -24 },
  { 1566, 13, 32, 24, 5, -24 },
  { 1618, 19, 19, 24, 3, -22 },
  { 1664, 21, 13, 24, 2, -19 },
  { 1699, 20, 19, 24, 1, -22 },
  { 1747, 18, 30, 24, 5, -30 },
  { 1815, 23, 29, 24, 1, -29 },
  { 1899, 24, 29, 24, -2, -29 },
  { 1986, 24, 29, 24, 0, -29 },
  { 2073, 23, 30, 24, 1, -30 },
  { 2160, 23, 29, 24, 0, -29 },
  { 2244, 24, 29, 24, 1, -29 },
  { 2331, 24, 29, 24, 1, -29 },
  { 2418, 22, 30, 24, 2, -30 },
  { 2501, 24, 29, 24, 0, -29 },
  { 2588, 21, 29, 24, 2, -29 },
  { 2665, 23, 29, 24, 1, -29 },
  { 2749, 27, 29, 24, 0, -29 },
  { 2847, 19, 29, 24, 1, -29 },
  { 2916, 25, 29, 24, 0, -29 },
  { 3007, 24, 29, 24, 0, -29 },
  { 3094, 22, 30, 24, 1, -30 },
  { 3177, 23, 29, 24, 1, -29 },
  { 3261, 22, 35, 24, 1, -30 },
  { 3358, 24, 29, 24, 0, -29 },
  { 3445, 23, 30, 24, 1, -30 },
  { 3532, 23, 29, 24, 3, -29 },
  { 3616, 22, 29, 24, 2, -29 },
  { 3696, 23, 29, 24, 3, -29 },
  { 3780, 23, 29, 24, 3, -29 },
  { 3864, 27, 29, 24, -1, -29 },
  { 3962, 23, 29, 24, 4, -29 },
  { 4046, 25, 29, 24, 0, -29 },
  { 4137, 15, 41, 24, 5, -34 },
  { 4214, 10, 32, 24, 8, -29 },
  { 4254, 15, 41, 24, 5, -34 },
  { 4331, 17, 15, 24, 4, -29 },
  { 4363, 19, 4, 24, 0, 0 },
  { 4373, 8, 6, 24, 11, -30 },
  { 4379, 20, 22, 24, 1, -22 },
  { 4434, 21, 31, 24, 1, -31 },
  { 4516, 19, 22, 24, 2, -22 },
  { 4569, 22, 31, 24, 2, -31 },
  { 4655, 20, 22, 24, 2, -22 },
  { 4710, 23, 32, 24, 3, -32 },
  { 4802, 22, 31, 24, 1, -22 },
  { 4888, 21, 31, 24, 1, -31 },
  { 4970, 18, 30, 24, 2, -30 },
  { 5038, 19, 39, 24, 1, -30 },
  { 5131, 23, 31, 24, 1, -31 },
  { 5221, 18, 31, 24, 2, -31 },
  { 5291, 24, 22, 24, -1, -22 },
  { 5357, 21, 22, 24, 1, -22 },
  { 5415, 20, 22, 24, 2, -22 },
  { 5470, 23, 30, 24, -1, -22 },
  { 5557, 21, 30, 24, 2, -22 },
  { 5636, 20, 22, 24, 3, -22 },
  { 5691, 21, 22, 24, 1, -22 },
  { 5749, 19, 27, 24, 3, -27 },
  { 5814, 21, 22, 24, 2, -22 },
  { 5872, 21, 22, 24, 3, -22 },
  { 5930, 23, 22, 24, 2, -22 },
  { 5994, 24, 22, 24, 0, -22 },
  { 6060, 26, 31, 24, 0, -22 },
  { 6161, 23, 22, 24, 0, -22 },
  { 6225, 16, 39, 24, 6, -32 },
  { 6303, 9, 37, 24, 7, -29 },
  { 6345, 16, 39, 24, 4, -32 },
  { 6423, 23, 9, 24, 0, -17 },
};

const GFXfont RobotoMono_BoldItalic41pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_BoldItalic41pt7bBitmaps,
  (GFXglyph *)RobotoMono_BoldItalic41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOMONO_BOLDITALIC41PT7B_H_
