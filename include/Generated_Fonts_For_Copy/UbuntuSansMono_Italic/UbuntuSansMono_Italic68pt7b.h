#ifndef _UBUNTUSANSMONO_ITALIC68PT7B_H_
#define _UBUNTUSANSMONO_ITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x1F, 0x01, 0xE3, 0xC0, 0x3C,
  0x78, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C,
  0x01, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x00, 0x0F,
  0xC0, 0x00, 0x20, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x03, 0x00, 0x00,
  0x3F, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x00,
  0x1F, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x78, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x0F,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x3E, 0x00, 0x00, 0x3C, 0x07, 0xC3,
  0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x1F, 0x00, 0x00, 0x0F, 0x03, 0xE1, 0xF0,
  0x00, 0x00, 0x7C, 0x1E, 0x1F, 0x00, 0x00, 0x03, 0xF1, 0xF1, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xF1, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x80, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x18, 0x00, 0x00, 0x00,
  0x0F, 0x87, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0x87, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x7C, 0x7C, 0x00, 0x00, 0x07, 0xC7,
  0xC1, 0xE0, 0x00, 0x00, 0x7C, 0x3C, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xE0,
  0x7C, 0x00, 0x00, 0x7C, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x78, 0x07, 0xC0,
  0x00, 0x3E, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x00, 0x3E,
  0x00, 0x3C, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x3E, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0x01, 0xFF, 0xC0, 0x3E,
  0x03, 0xFF, 0xE0, 0x3E, 0x07, 0xF3, 0xE0, 0x3E, 0x0F, 0xC3, 0xF0, 0x7C,
  0x1F, 0x81, 0xF8, 0x7C, 0x1F, 0x01, 0xF8, 0x7C, 0x3E, 0x00, 0xFC, 0xF8,
  0x7E, 0x00, 0x7C, 0xF8, 0x7E, 0x00, 0x7F, 0xF0, 0x7C, 0x00, 0x3F, 0xF0,
  0xFC, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0xFF, 0xF0,
  0x7F, 0x87, 0xFB, 0xF0, 0x7F, 0xFF, 0xF1, 0xF0, 0x3F, 0xFF, 0xE1, 0xF8,
  0x1F, 0xFF, 0x81, 0xF8, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F,
  0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x04, 0x01, 0xF0, 0x04,
  0x7C, 0x0F, 0x81, 0xE3, 0xF8, 0x78, 0x3F, 0x9F, 0xF1, 0xC7, 0xFD, 0xFF,
  0xEE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x01,
  0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x7C,
  0x00, 0x60, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xEF,
  0xFF, 0xF0, 0x1F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xC3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xC7, 0xE0, 0x7C, 0x03, 0xE3, 0xF0, 0x7F,
  0x01, 0xF1, 0xF8, 0x7F, 0xC1, 0xF8, 0xF8, 0x3F, 0xE0, 0xFC, 0xFC, 0x1F,
  0xF0, 0x7E, 0x7E, 0x0F, 0xF8, 0x3E, 0x3E, 0x07, 0xFC, 0x1F, 0x1F, 0x03,
  0xFC, 0x1F, 0x9F, 0x80, 0xFC, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFB, 0xE0, 0x07, 0xFC, 0x7C, 0x00,
  0xFE, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x01, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x7F, 0x00,
  0x20, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xC0, 0x0F, 0xE0, 0x00, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x03,
  0x00, 0x00, 0xFF, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0x00, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xE0,
  0x07, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFF,
  0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xE1,
  0xFC, 0x00, 0x07, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xE7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xBF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xE3, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03,
  0xE0, 0x3F, 0x80, 0x80, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x00, 0xBE, 0x0F, 0xC0, 0x03, 0xFF, 0xF0, 0x7E, 0x00, 0x7F,
  0xFF, 0x87, 0xE0, 0x0F, 0xFF, 0xFC, 0x3F, 0x00, 0xFF, 0xFF, 0xC1, 0xF8,
  0x0F, 0xE0, 0x3E, 0x1F, 0x80, 0xFC, 0x01, 0xF0, 0xFC, 0x0F, 0xC0, 0x1F,
  0x87, 0xC0, 0xFC, 0x00, 0xF8, 0x7E, 0x07, 0xE0, 0x07, 0xC3, 0xF0, 0x7E,
  0x00, 0x3E, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xF8, 0x1F, 0x00, 0x1F, 0x0F,
  0xC0, 0xF8, 0x00, 0xF8, 0x7E, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x7E, 0x00,
  0x7E, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0xF8, 0x00, 0xF8, 0x3E, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x3F, 0x00, 0x7E,
  0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x1F, 0x01, 0xFC, 0x0F, 0xC0, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0x00, 0x7F, 0xFF, 0x01, 0xF8, 0x00, 0xFF,
  0xF0, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x07, 0xFE,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x0F, 0xF8, 0x07, 0xC0,
  0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x01,
  0xF8, 0x00, 0xFF, 0x00, 0x01, 0x80, 0x0F, 0xE0, 0x00, 0x04, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0x00, 0x0F,
  0xF0, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x3F,
  0x80, 0x3E, 0x00, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0x00,
  0x1F, 0xF8, 0x00, 0xFE, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xC0,
  0x00, 0xC0, 0x07, 0xF0, 0x00, 0x04, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x03, 0xF8,
  0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x30, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x00, 0x7F,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00,
  0x01, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x7C,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE7,
  0xF0, 0x00, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x0E, 0xF8, 0x03, 0xFE, 0x00, 0x1E, 0xF8,
  0x03, 0xDE, 0x00, 0x1E, 0xF8, 0x07, 0x9E, 0x00, 0x1E, 0xF8, 0x07, 0x9E,
  0x00, 0x3C, 0xF8, 0x0F, 0x3E, 0x00, 0x3C, 0x78, 0x0F, 0x3E, 0x00, 0x3C,
  0x78, 0x1E, 0x3C, 0x00, 0x7C, 0x78, 0x3E, 0x3C, 0x00, 0x78, 0x78, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x78, 0x7C, 0x00, 0xF8, 0x78, 0x78, 0x7C, 0x00,
  0xF8, 0x78, 0xF0, 0x7C, 0x00, 0xF0, 0x78, 0xF0, 0x78, 0x01, 0xF0, 0x7D,
  0xE0, 0x78, 0x01, 0xF0, 0x7F, 0xE0, 0xF8, 0x01, 0xE0, 0x3F, 0xC0, 0xF8,
  0x03, 0xE0, 0x3F, 0x80, 0xF8, 0x03, 0xE0, 0x3F, 0x80, 0xF8, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x3F,
  0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x00,
  0x3E, 0x00, 0x7F, 0xC0, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00,
  0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x7B, 0xE0, 0x00, 0x7C, 0x00, 0xF9, 0xF0,
  0x00, 0x7C, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xF8,
  0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x03,
  0xE0, 0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x07, 0xC0,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x1F,
  0x00, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x07, 0x9F, 0x00, 0x1E, 0x00, 0x07,
  0x9F, 0x00, 0x3E, 0x00, 0x07, 0x9F, 0x00, 0x3E, 0x00, 0x07, 0xDE, 0x00,
  0x3E, 0x00, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0x03, 0xFE, 0x00, 0x7C, 0x00,
  0x03, 0xFE, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x03, 0xFC,
  0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x03, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x7E,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFA, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x03,
  0xFE, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x07, 0xE0,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x01, 0x00, 0x00, 0x1F, 0xC0,
  0x0E, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x80,
  0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x78, 0x0F, 0xE0, 0x3E, 0x00,
  0x3C, 0x0F, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xBC, 0x0F, 0x80, 0x1F, 0x07,
  0xDE, 0x07, 0x80, 0x0F, 0x83, 0xCF, 0x07, 0xC0, 0x07, 0x83, 0xE7, 0x83,
  0xE0, 0x03, 0xC1, 0xE3, 0xC1, 0xE0, 0x01, 0xE1, 0xF1, 0xE0, 0xF0, 0x01,
  0xF0, 0xF0, 0xF0, 0xF8, 0x00, 0xF8, 0xF0, 0x78, 0x78, 0x00, 0x78, 0xF8,
  0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x1E, 0x3E, 0x00, 0x1E, 0x7C, 0x0F, 0x1E,
  0x00, 0x0F, 0x3C, 0x07, 0xCF, 0x00, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x07,
  0x9E, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00,
  0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFD, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x3E,
  0x00, 0x00, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x87, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x01,
  0xF0, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x07, 0xCE,
  0x00, 0x00, 0x1E, 0x10, 0x00, 0x00, 0x20, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x08, 0x03, 0x80, 0x7C, 0x0F, 0xC0, 0x7E,
  0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01,
  0xE0, 0x08, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF7, 0xF0, 0x07,
  0xFE, 0x00, 0xF8, 0x07, 0xF8, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFD, 0xF0, 0x03, 0xFF,
  0xF8, 0xF8, 0x00, 0xFF, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x3F,
  0xC0, 0x00, 0x7E, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0xFF, 0x01, 0xF0, 0x00, 0xFF,
  0x01, 0xF8, 0x01, 0xFF, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x3F, 0x00, 0x3F, 0xE0, 0x00, 0xC0, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x7F, 0x80, 0x03, 0xFF, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x03,
  0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x03, 0xF8, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0xC0,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0xF8, 0x00, 0x1F, 0xFF, 0xC7, 0xC0, 0x00, 0x7F, 0xFC, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7C, 0x00, 0x03, 0xFC, 0xFC, 0x00,
  0x1F, 0xF8, 0xFC, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xE0, 0x3F, 0xE0,
  0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x40, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x3E, 0x00,
  0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0xF8, 0x00, 0x00,
  0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x03, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xE7, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x01,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x3F, 0xC0, 0x01, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0xFE, 0x00,
  0x00, 0x3E, 0x3F, 0xC0, 0x00, 0x03, 0xE7, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x9F, 0xE0, 0x00,
  0x00, 0xF8, 0x7F, 0x00, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x80,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x23, 0xF8,
  0x06, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x07, 0xFF, 0xE7, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E,
  0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF8,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xC0,
  0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x03, 0xF8, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0xC1,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80,
  0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x0F, 0xE0,
  0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x07,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xF3, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xE0, 0x0F,
  0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xBF, 0x00, 0x00, 0xFF, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x0C, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x3F, 0xC0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x02, 0x01, 0xFC, 0x01, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF7, 0xC0, 0x1F, 0xFF, 0xC3, 0xE0, 0x0F, 0xFF, 0x83, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8,
  0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x00,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x3E,
  0x03, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0xC0, 0x7C, 0x0F, 0x81, 0xFE, 0x07,
  0xC0, 0x7C, 0x1F, 0xF0, 0x3E, 0x07, 0xC0, 0xF7, 0x81, 0xF0, 0x3E, 0x0F,
  0xBE, 0x1F, 0x01, 0xF0, 0x79, 0xF0, 0xF8, 0x0F, 0x87, 0x8F, 0x8F, 0x80,
  0x7C, 0x7C, 0x7C, 0x7C, 0x03, 0xE3, 0xC1, 0xE3, 0xE0, 0x1F, 0x3E, 0x0F,
  0x3E, 0x00, 0xF9, 0xE0, 0x79, 0xF0, 0x07, 0xDE, 0x03, 0xDF, 0x00, 0x3F,
  0xF0, 0x1E, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0xF8, 0x00, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xE1,
  0xF0, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x0F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x00, 0x7C, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x02, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF4, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x06, 0x01, 0xFF, 0x80, 0x03, 0xC3,
  0xFF, 0xE0, 0x03, 0xE3, 0xFF, 0xFC, 0x01, 0xE1, 0xF9, 0xFF, 0x01, 0xF1,
  0xF0, 0x1F, 0xE3, 0xF1, 0xF0, 0x07, 0xFF, 0xF0, 0xF8, 0x01, 0xFF, 0xF0,
  0xF8, 0x00, 0x3F, 0xF0, 0x08, 0x00, 0x0F, 0xE0, 0x00,
};

const GFXglyph UbuntuSansMono_Italic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 17, 48, 38, 11, -47 },
  { 103, 19, 18, 38, 15, -52 },
  { 146, 40, 47, 38, 0, -47 },
  { 381, 35, 60, 38, 3, -53 },
  { 644, 45, 49, 38, -2, -48 },
  { 920, 32, 49, 38, 2, -48 },
  { 1116, 10, 20, 38, 20, -52 },
  { 1141, 28, 66, 38, 9, -53 },
  { 1372, 28, 66, 38, 2, -53 },
  { 1603, 29, 27, 38, 8, -47 },
  { 1701, 31, 34, 38, 4, -37 },
  { 1833, 16, 21, 38, 5, -10 },
  { 1875, 17, 5, 38, 11, -22 },
  { 1886, 10, 11, 38, 11, -10 },
  { 1900, 43, 66, 38, -4, -53 },
  { 2255, 33, 49, 38, 4, -48 },
  { 2458, 27, 47, 38, 5, -47 },
  { 2617, 34, 48, 38, 3, -48 },
  { 2821, 34, 49, 38, 2, -48 },
  { 3030, 34, 47, 38, 1, -47 },
  { 3230, 37, 48, 38, 2, -47 },
  { 3452, 34, 48, 38, 5, -47 },
  { 3656, 34, 47, 38, 8, -47 },
  { 3856, 34, 49, 38, 4, -48 },
  { 4065, 35, 48, 38, 3, -48 },
  { 4275, 16, 36, 38, 11, -35 },
  { 4347, 22, 46, 38, 5, -35 },
  { 4474, 33, 30, 38, 3, -34 },
  { 4598, 35, 20, 38, 2, -30 },
  { 4686, 33, 30, 38, 2, -34 },
  { 4810, 26, 49, 38, 10, -48 },
  { 4970, 37, 58, 38, 3, -48 },
  { 5239, 37, 47, 38, -4, -47 },
  { 5457, 36, 48, 38, 1, -48 },
  { 5673, 37, 49, 38, 4, -48 },
  { 5900, 37, 48, 38, 0, -48 },
  { 6122, 37, 47, 38, 3, -47 },
  { 6340, 37, 47, 38, 3, -47 },
  { 6558, 36, 49, 38, 3, -48 },
  { 6779, 41, 47, 38, 0, -47 },
  { 7020, 35, 47, 38, 3, -47 },
  { 7226, 36, 48, 38, 3, -47 },
  { 7442, 41, 47, 38, 1, -47 },
  { 7683, 28, 47, 38, 1, -47 },
  { 7848, 40, 47, 38, -1, -47 },
  { 8083, 40, 47, 38, 1, -47 },
  { 8318, 34, 49, 38, 4, -48 },
  { 8527, 36, 48, 38, 2, -48 },
  { 8743, 34, 60, 38, 4, -48 },
  { 8998, 36, 48, 38, 1, -48 },
  { 9214, 37, 49, 38, 2, -48 },
  { 9441, 33, 47, 38, 9, -47 },
  { 9635, 37, 48, 38, 4, -47 },
  { 9857, 37, 47, 38, 7, -47 },
  { 10075, 41, 47, 38, 2, -47 },
  { 10316, 45, 47, 38, -2, -47 },
  { 10581, 37, 47, 38, 8, -47 },
  { 10799, 41, 47, 38, 0, -47 },
  { 11040, 33, 66, 38, 5, -53 },
  { 11313, 11, 66, 38, 14, -53 },
  { 11404, 34, 66, 38, -1, -53 },
  { 11685, 30, 25, 38, 6, -47 },
  { 11779, 35, 5, 38, -5, 8 },
  { 11801, 12, 14, 38, 18, -53 },
  { 11822, 33, 37, 38, 3, -36 },
  { 11975, 33, 54, 38, 3, -53 },
  { 12198, 34, 37, 38, 2, -36 },
  { 12356, 37, 54, 38, 4, -53 },
  { 12606, 32, 37, 38, 3, -36 },
  { 12754, 44, 66, 38, -1, -53 },
  { 13117, 39, 49, 38, -1, -36 },
  { 13356, 32, 53, 38, 1, -53 },
  { 13568, 21, 52, 38, 8, -52 },
  { 13705, 37, 65, 38, -1, -52 },
  { 14006, 36, 53, 38, 2, -53 },
  { 14245, 20, 53, 38, 11, -52 },
  { 14378, 37, 36, 38, 0, -36 },
  { 14545, 33, 36, 38, 2, -36 },
  { 14694, 32, 37, 38, 4, -36 },
  { 14842, 37, 49, 38, -1, -36 },
  { 15069, 34, 49, 38, 3, -36 },
  { 15278, 33, 36, 38, 4, -36 },
  { 15427, 31, 37, 38, 4, -36 },
  { 15571, 28, 47, 38, 8, -46 },
  { 15736, 32, 36, 38, 4, -35 },
  { 15880, 29, 35, 38, 8, -35 },
  { 16007, 37, 35, 38, 4, -35 },
  { 16169, 39, 35, 38, -1, -35 },
  { 16340, 42, 48, 38, -4, -35 },
  { 16592, 33, 35, 38, 2, -35 },
  { 16737, 37, 66, 38, 4, -53 },
  { 17043, 21, 66, 38, 9, -53 },
  { 17217, 37, 66, 38, -3, -53 },
  { 17523, 33, 10, 38, 3, -25 },
};

const GFXfont UbuntuSansMono_Italic68pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic68pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic68pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _UBUNTUSANSMONO_ITALIC68PT7B_H_
