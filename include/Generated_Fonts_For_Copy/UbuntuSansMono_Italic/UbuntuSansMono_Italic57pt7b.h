#ifndef _UBUNTUSANSMONO_ITALIC57PT7B_H_
#define _UBUNTUSANSMONO_ITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x30,
  0x00, 0x1E, 0x07, 0x8F, 0x03, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1,
  0xE0, 0x70, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x38, 0x0E, 0x1C, 0x07,
  0x0E, 0x03, 0x86, 0x01, 0x87, 0x01, 0xC3, 0x80, 0xE0, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xE0, 0x7C, 0x01, 0xF8, 0x00, 0x40, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x04, 0x00, 0x03,
  0xE0, 0x38, 0x00, 0x3F, 0x01, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x07,
  0xFF, 0x00, 0x0F, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0xF0, 0x03,
  0xE0, 0x07, 0x81, 0xC0, 0x1F, 0x00, 0x1E, 0x07, 0x00, 0x78, 0x00, 0x70,
  0x1C, 0x03, 0xC0, 0x01, 0xC0, 0x70, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0xF0,
  0x00, 0x3C, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x3E, 0x00, 0x03, 0xC0,
  0xF1, 0xF0, 0x00, 0x0F, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x1E, 0x3C, 0x00,
  0x00, 0xF0, 0xF1, 0xE0, 0x00, 0x01, 0xFF, 0x8F, 0x00, 0x00, 0x07, 0xFC,
  0x78, 0x00, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x1E,
  0x3F, 0xC0, 0x00, 0x00, 0xF1, 0xFF, 0x80, 0x00, 0x07, 0x8F, 0x9E, 0x00,
  0x00, 0x3E, 0x38, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0xF0, 0x00, 0x07, 0x87,
  0x03, 0xC0, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x3C, 0x00,
  0x0F, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x0E, 0x03, 0xC0, 0x03, 0xE0, 0x38,
  0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x03, 0x81, 0xE0, 0x03,
  0xC0, 0x0E, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x00, 0xF1,
  0xE0, 0x07, 0x80, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F,
  0x80, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x01, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xF0,
  0x1F, 0xF0, 0x1E, 0x0F, 0xDF, 0x07, 0xC3, 0xF3, 0xE0, 0xF0, 0x78, 0x3E,
  0x1E, 0x1F, 0x03, 0xC7, 0x87, 0xC0, 0x7C, 0xF0, 0xF0, 0x07, 0xDE, 0x3E,
  0x00, 0xFF, 0x87, 0xC0, 0x0F, 0xF0, 0xF8, 0x01, 0xFC, 0x1E, 0x00, 0x1F,
  0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0xC1, 0xF0,
  0x07, 0xF8, 0x3F, 0x01, 0xFF, 0x83, 0xFF, 0xFD, 0xF0, 0x7F, 0xFF, 0x1F,
  0x07, 0xFF, 0xC3, 0xE0, 0x7F, 0xC0, 0x7C, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x70,
  0xF0, 0xF0, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x3C, 0x02,
  0x70, 0x3C, 0x0E, 0x7C, 0x38, 0x7E, 0xFF, 0x39, 0xFE, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xEF, 0x00, 0x03, 0xE7, 0x80, 0x07, 0xC7, 0xC0, 0x0F, 0xC3, 0xE0,
  0x0F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x01, 0xF0, 0x06, 0x00, 0xC0,
  0x02, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x80, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC3, 0xFE, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0x08, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE,
  0x7E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xE0, 0x60, 0x1F, 0x3E,
  0x1F, 0x81, 0xE3, 0xE1, 0xFC, 0x1E, 0x3C, 0x3F, 0xC3, 0xE7, 0xC3, 0xFC,
  0x3E, 0x7C, 0x3F, 0xC3, 0xE7, 0xC1, 0xFC, 0x3C, 0x7C, 0x1F, 0x87, 0xC7,
  0x80, 0x40, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x07, 0x80,
  0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x9F, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xFE, 0xF8, 0x07, 0xF9, 0xE0, 0x0F, 0x83, 0xC0, 0x1C,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x01, 0xF8, 0x07, 0xE0, 0x0E, 0x00, 0x3E, 0x00, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x38, 0x03, 0xF0,
  0x02, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x07, 0x00, 0x0F, 0xE0,
  0x7F, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F,
  0x07, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x1E,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x78, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x3E,
  0x03, 0xE0, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x03, 0x00,
  0x0F, 0xF0, 0x07, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x3C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0x1F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x03,
  0xE0, 0x3C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x0F,
  0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0xDF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0xF8,
  0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7C, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x07, 0xC0, 0x3F, 0x81, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x03, 0xF0, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x03, 0xE0, 0x1F, 0xC0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x01, 0xF8, 0x03, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7F,
  0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xF0, 0x7F, 0x04, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x07, 0xC0, 0x0F, 0xE0,
  0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x1E, 0x07, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x01, 0xE1, 0xF0, 0x03, 0xFF, 0xC3, 0xE0, 0x1F, 0xFF,
  0x8F, 0x80, 0xFF, 0xFE, 0x1F, 0x03, 0xFE, 0xFC, 0x7C, 0x0F, 0xC0, 0xF8,
  0xF8, 0x3F, 0x01, 0xF1, 0xF0, 0x7C, 0x03, 0xC3, 0xC1, 0xF0, 0x07, 0x8F,
  0x83, 0xE0, 0x1F, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x1F, 0x00, 0x78, 0x78,
  0x3E, 0x00, 0xF0, 0xF0, 0x78, 0x03, 0xE3, 0xE0, 0xF0, 0x07, 0xC7, 0xC1,
  0xE0, 0x0F, 0x0F, 0x83, 0xC0, 0x1E, 0x1F, 0x07, 0x80, 0x7C, 0x3E, 0x0F,
  0x80, 0xF8, 0x7C, 0x1F, 0x01, 0xE0, 0xF8, 0x1F, 0x03, 0xC1, 0xF0, 0x3F,
  0xFF, 0x81, 0xE0, 0x3F, 0xFF, 0x03, 0xC0, 0x3F, 0xFE, 0x07, 0xC0, 0x0F,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x3C,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x7C,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xC0, 0x07,
  0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C,
  0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x07, 0x80, 0x0F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3C, 0x01, 0xFE,
  0x00, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x78, 0x3E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3F, 0x07, 0x80, 0x01,
  0xF8, 0x3E, 0x00, 0x1F, 0xC0, 0xFF, 0xBF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xF8, 0x03, 0xC0, 0x1F, 0xC0, 0x01, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x08, 0x01,
  0xFC, 0x00, 0x60, 0x01, 0xFE, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0x80, 0xFF, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x78,
  0x3E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x1E,
  0x00, 0x07, 0xE0, 0x3C, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x01, 0xF0,
  0x03, 0xF8, 0x03, 0xC0, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x78, 0x03, 0xF0, 0x00, 0x40,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x78, 0x07, 0xE0, 0x03, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x01,
  0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x3E,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x3C, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x80, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0x01, 0xF0,
  0x01, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x03,
  0xF0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00,
  0x7E, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00,
  0x3C, 0x7E, 0x00, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00,
  0xF0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0x3B, 0xC0, 0x7F, 0x80,
  0x1E, 0xF0, 0x1D, 0xE0, 0x07, 0x3C, 0x0F, 0x78, 0x01, 0xCF, 0x07, 0x9E,
  0x00, 0xF3, 0xC1, 0xC7, 0x00, 0x3C, 0xF0, 0xF1, 0xC0, 0x0E, 0x3C, 0x38,
  0xF0, 0x07, 0x8F, 0x1E, 0x3C, 0x01, 0xE1, 0xC7, 0x0F, 0x00, 0x78, 0x73,
  0xC3, 0xC0, 0x3C, 0x1C, 0xE1, 0xE0, 0x0F, 0x07, 0x70, 0x78, 0x03, 0xC1,
  0xFC, 0x1E, 0x01, 0xE0, 0x7E, 0x07, 0x80, 0x78, 0x1F, 0x81, 0xE0, 0x1E,
  0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x3C,
  0x01, 0xFC, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x01,
  0xE0, 0x07, 0xF0, 0x00, 0x78, 0x03, 0xDE, 0x00, 0x1E, 0x00, 0xF7, 0x80,
  0x0F, 0x80, 0x3D, 0xE0, 0x03, 0xC0, 0x0F, 0x3C, 0x00, 0xF0, 0x07, 0x8F,
  0x00, 0x3C, 0x01, 0xE3, 0xC0, 0x1F, 0x00, 0x78, 0xF0, 0x07, 0x80, 0x1E,
  0x1E, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x78, 0x03, 0xC1, 0xE0, 0x3E, 0x00,
  0xF0, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0xF0,
  0x07, 0x80, 0xF0, 0x3C, 0x01, 0xE0, 0x1C, 0x1E, 0x00, 0x78, 0x07, 0x87,
  0x80, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC0, 0x1E,
  0x3C, 0x00, 0xF0, 0x03, 0x8F, 0x00, 0x7C, 0x00, 0xF3, 0xC0, 0x1E, 0x00,
  0x3C, 0xF0, 0x07, 0x80, 0x0F, 0x78, 0x01, 0xE0, 0x03, 0xDE, 0x00, 0xF8,
  0x00, 0x77, 0x80, 0x3C, 0x00, 0x1F, 0xE0, 0x0F, 0x00, 0x07, 0xF8, 0x03,
  0xC0, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x78, 0x00, 0x0F, 0xC0,
  0x1E, 0x00, 0x03, 0xF0, 0x07, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xBF, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x07,
  0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0x80,
  0x3F, 0xC0, 0x0F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x78,
  0x07, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0x00,
  0x78, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF1, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0x8F, 0x80,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xF8,
  0x03, 0xF8, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x80,
  0x07, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x78, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x00,
  0x80, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x80, 0x00, 0x7E, 0x01, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x3E,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x07, 0xC0, 0x78, 0x07, 0x81, 0xF0,
  0x1E, 0x01, 0xE0, 0xFC, 0x0F, 0x00, 0x78, 0x3F, 0x03, 0xC0, 0x3C, 0x1F,
  0xE0, 0xF0, 0x0F, 0x07, 0x78, 0x38, 0x03, 0xC3, 0xDE, 0x1E, 0x00, 0xF0,
  0xE3, 0x87, 0x80, 0x38, 0x78, 0xE1, 0xC0, 0x0E, 0x3C, 0x38, 0xF0, 0x07,
  0x8F, 0x0E, 0x3C, 0x01, 0xE7, 0x83, 0x8E, 0x00, 0x79, 0xC0, 0xE3, 0x80,
  0x1C, 0xF0, 0x39, 0xE0, 0x07, 0x38, 0x0E, 0x70, 0x01, 0xDE, 0x03, 0xDC,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x1E, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x1F,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x03, 0xC0,
  0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0x78, 0x01,
  0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x07, 0x9F, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xF0, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0xF9, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x1E, 0x00,
  0x7C, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x3E, 0x00, 0xF0,
  0x3E, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x07,
  0x9F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x70, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x10, 0x1E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x38, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFE, 0x01, 0xE0, 0x3F, 0x80, 0x1E,
  0x07, 0xE0, 0x01, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC1, 0xF0,
  0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0x78,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0x03,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x9E, 0x00, 0x7F, 0xE1, 0xF0,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE3, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3E,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01,
  0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF8, 0x3C, 0x00,
  0x3F, 0x07, 0xC0, 0x07, 0xE0, 0x78, 0x00, 0xFC, 0x07, 0x80, 0x3F, 0x80,
  0x7C, 0x7F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFE, 0xFE, 0x03, 0xFC, 0x00, 0x40,
  0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x60, 0x3F, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x01, 0xE0, 0x03,
  0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xC0, 0x0F,
  0x80, 0x03, 0xC0, 0x1F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x7F,
  0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xDE, 0x00, 0x1F, 0xFF, 0x9E, 0x00, 0x07,
  0xFE, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x7E,
  0x0F, 0xE0, 0x07, 0xC3, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x1F, 0x00,
  0x01, 0xE7, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xFC, 0xF8, 0x00, 0xFF, 0x1E, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xC0, 0xFF,
  0x83, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFC, 0x02, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x10, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xE0, 0x1F, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x7F, 0x00, 0x1E, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3C, 0x01,
  0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x0F,
  0x80, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFB, 0xC0, 0x00,
  0x3F, 0xC7, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x30, 0x00, 0x7E, 0x00, 0x7C, 0x03, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF7, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xF0, 0x0F, 0xE0, 0x3E, 0x00,
  0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3E,
  0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x7C, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x08, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x60, 0x03, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x7E, 0x03, 0xE0, 0x03,
  0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0xC0,
  0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x78, 0x3F, 0x00, 0x01,
  0xE1, 0xF8, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x00, 0xFC, 0x00,
  0x3C, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1E,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x01, 0x7E, 0x0E, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFE, 0x01, 0xC0,
  0x00, 0x7F, 0x83, 0xF0, 0x03, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3C, 0x1F, 0x87, 0xE0, 0x78, 0x1E, 0x07, 0xC1,
  0xF0, 0x3C, 0x0F, 0x83, 0xC0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x3C, 0x0F,
  0x03, 0xE0, 0x78, 0x3E, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x03, 0xE0, 0xF0,
  0x3E, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0x1E, 0x0F, 0x81,
  0xE0, 0x7C, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x1E,
  0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3E,
  0x00, 0xFC, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0,
  0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x0F, 0x83,
  0xF0, 0x00, 0xF0, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xF0,
  0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1E,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x00, 0x1F,
  0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x7F, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFE, 0x01, 0xE0, 0x3F, 0x00, 0x3E,
  0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x3C, 0x1F, 0x80, 0x03, 0xC1, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF0, 0xF8,
  0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0x03,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0x80,
  0x00, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xF8,
  0x01, 0x80, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x3F, 0x07, 0xE0, 0x3F,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x80, 0xFC, 0x1E, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x01,
  0xE1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF0,
  0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E,
  0x1E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x78, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3E,
  0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x3F,
  0x81, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xDE, 0x01, 0xFF, 0xF3, 0xE0, 0x1F,
  0xF8, 0x3C, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C,
  0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x78, 0x03, 0xE0,
  0x78, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x7C, 0x0F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x7C, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3C, 0x7C, 0x07, 0x80, 0xF8, 0xF0,
  0x0F, 0x01, 0xE1, 0xE0, 0x3E, 0x03, 0xC3, 0xC0, 0x7C, 0x0F, 0x07, 0x81,
  0xF8, 0x1E, 0x0F, 0x07, 0xF0, 0x3C, 0x1E, 0x0F, 0xE0, 0xF0, 0x3C, 0x3D,
  0xC1, 0xE0, 0x78, 0x73, 0xC7, 0x80, 0xF1, 0xE7, 0x8F, 0x03, 0xE3, 0x8F,
  0x1E, 0x07, 0xCF, 0x1E, 0x78, 0x0F, 0xBC, 0x3C, 0xF0, 0x1E, 0x70, 0x3B,
  0xC0, 0x3D, 0xE0, 0x77, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFC,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x07, 0xE0, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x1E, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x06, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x81,
  0xFF, 0x00, 0x1C, 0x7F, 0xF8, 0x07, 0x9F, 0xFF, 0x81, 0xE7, 0xC1, 0xFC,
  0x7C, 0xF0, 0x1F, 0xFF, 0x3C, 0x01, 0xFF, 0xC3, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x20, 0x00,
};

const GFXglyph UbuntuSansMono_Italic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 14, 41, 32, 9, -40 },
  { 73, 17, 15, 32, 12, -43 },
  { 105, 34, 40, 32, 0, -40 },
  { 275, 29, 50, 32, 3, -44 },
  { 457, 38, 41, 32, -2, -40 },
  { 652, 27, 41, 32, 1, -40 },
  { 791, 8, 16, 32, 17, -43 },
  { 807, 24, 56, 32, 7, -45 },
  { 975, 24, 56, 32, 1, -45 },
  { 1143, 24, 24, 32, 7, -40 },
  { 1215, 27, 28, 32, 3, -31 },
  { 1310, 14, 17, 32, 4, -8 },
  { 1340, 14, 4, 32, 10, -18 },
  { 1347, 9, 10, 32, 9, -9 },
  { 1359, 36, 56, 32, -4, -45 },
  { 1611, 28, 41, 32, 3, -40 },
  { 1755, 23, 40, 32, 4, -40 },
  { 1870, 28, 40, 32, 3, -40 },
  { 2010, 28, 41, 32, 2, -40 },
  { 2154, 29, 40, 32, 1, -40 },
  { 2299, 31, 41, 32, 2, -40 },
  { 2458, 29, 41, 32, 4, -40 },
  { 2607, 28, 40, 32, 7, -40 },
  { 2747, 29, 41, 32, 3, -40 },
  { 2896, 29, 40, 32, 3, -40 },
  { 3041, 14, 31, 32, 9, -30 },
  { 3096, 19, 39, 32, 4, -30 },
  { 3189, 27, 25, 32, 3, -29 },
  { 3274, 29, 16, 32, 2, -25 },
  { 3332, 27, 25, 32, 2, -29 },
  { 3417, 22, 41, 32, 8, -40 },
  { 3530, 31, 48, 32, 2, -40 },
  { 3716, 30, 40, 32, -3, -40 },
  { 3866, 30, 40, 32, 1, -40 },
  { 4016, 31, 41, 32, 3, -40 },
  { 4175, 31, 40, 32, 0, -40 },
  { 4330, 31, 40, 32, 3, -40 },
  { 4485, 32, 40, 32, 2, -40 },
  { 4645, 30, 41, 32, 3, -40 },
  { 4799, 34, 40, 32, 0, -40 },
  { 4969, 28, 40, 32, 3, -40 },
  { 5109, 31, 41, 32, 2, -40 },
  { 5268, 34, 40, 32, 1, -40 },
  { 5438, 23, 40, 32, 1, -40 },
  { 5553, 34, 40, 32, -1, -40 },
  { 5723, 34, 40, 32, 0, -40 },
  { 5893, 29, 41, 32, 3, -40 },
  { 6042, 31, 40, 32, 1, -40 },
  { 6197, 29, 50, 32, 3, -40 },
  { 6379, 30, 40, 32, 1, -40 },
  { 6529, 31, 41, 32, 1, -40 },
  { 6688, 27, 40, 32, 8, -40 },
  { 6823, 31, 41, 32, 3, -40 },
  { 6982, 31, 40, 32, 6, -40 },
  { 7137, 34, 40, 32, 2, -40 },
  { 7307, 38, 40, 32, -2, -40 },
  { 7497, 30, 40, 32, 7, -40 },
  { 7647, 34, 40, 32, 0, -40 },
  { 7817, 28, 56, 32, 4, -45 },
  { 8013, 9, 56, 32, 12, -45 },
  { 8076, 28, 56, 32, -1, -45 },
  { 8272, 25, 21, 32, 5, -40 },
  { 8338, 29, 4, 32, -4, 7 },
  { 8353, 10, 11, 32, 15, -44 },
  { 8367, 28, 31, 32, 2, -30 },
  { 8476, 28, 45, 32, 2, -44 },
  { 8634, 28, 31, 32, 2, -30 },
  { 8743, 32, 45, 32, 3, -44 },
  { 8923, 27, 31, 32, 2, -30 },
  { 9028, 37, 55, 32, -1, -44 },
  { 9283, 32, 41, 32, -1, -30 },
  { 9447, 28, 44, 32, 0, -44 },
  { 9601, 17, 44, 32, 7, -44 },
  { 9695, 31, 55, 32, -1, -44 },
  { 9909, 30, 44, 32, 2, -44 },
  { 10074, 16, 45, 32, 10, -44 },
  { 10164, 31, 30, 32, 0, -30 },
  { 10281, 27, 30, 32, 2, -30 },
  { 10383, 27, 31, 32, 3, -30 },
  { 10488, 31, 41, 32, -1, -30 },
  { 10647, 28, 41, 32, 3, -30 },
  { 10791, 27, 30, 32, 4, -30 },
  { 10893, 26, 31, 32, 3, -30 },
  { 10994, 23, 40, 32, 7, -39 },
  { 11109, 27, 31, 32, 3, -30 },
  { 11214, 24, 30, 32, 7, -30 },
  { 11304, 31, 30, 32, 3, -30 },
  { 11421, 33, 30, 32, -1, -30 },
  { 11545, 35, 41, 32, -3, -30 },
  { 11725, 29, 30, 32, 1, -30 },
  { 11834, 31, 56, 32, 3, -45 },
  { 12051, 17, 56, 32, 8, -45 },
  { 12170, 30, 56, 32, -2, -45 },
  { 12380, 27, 9, 32, 3, -21 },
};

const GFXfont UbuntuSansMono_Italic57pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic57pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic57pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _UBUNTUSANSMONO_ITALIC57PT7B_H_
