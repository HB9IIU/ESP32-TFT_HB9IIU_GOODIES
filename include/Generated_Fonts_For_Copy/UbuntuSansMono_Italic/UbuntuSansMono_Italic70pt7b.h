#ifndef _UBUNTUSANSMONO_ITALIC70PT7B_H_
#define _UBUNTUSANSMONO_ITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0xF1, 0xF0, 0x1F, 0x1F,
  0x01, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3,
  0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0x80, 0x78,
  0x78, 0x07, 0x87, 0x80, 0x78, 0x70, 0x07, 0x0F, 0x00, 0x70, 0xF0, 0x07,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1C,
  0x00, 0x3F, 0x80, 0x00, 0x40, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x03, 0x80, 0x00, 0x3F, 0x80,
  0x3E, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xBF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x3F, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0xF0, 0x07, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x78, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x03, 0xE3, 0xF0,
  0x00, 0x00, 0x7C, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0xF8, 0x7C, 0x00,
  0x00, 0x03, 0xFF, 0xE3, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC3, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x87, 0xCF, 0xC0, 0x00, 0x00,
  0x7E, 0x3E, 0x0F, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x3E, 0x00, 0x00, 0x0F,
  0x87, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x1F, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x1E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x07, 0xC3, 0xF8, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0x80, 0x7F, 0xE0, 0x0F, 0x80, 0x7F, 0xF8, 0x07, 0xC0, 0x7F, 0x7E,
  0x03, 0xE0, 0x7E, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x03,
  0xF0, 0xF8, 0x7E, 0x01, 0xF8, 0xF8, 0x3F, 0x00, 0x7E, 0x7C, 0x3F, 0x00,
  0x3F, 0x7E, 0x1F, 0x80, 0x0F, 0xFE, 0x0F, 0x80, 0x03, 0xFF, 0x0F, 0xC0,
  0x01, 0xFF, 0x07, 0xE0, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x07, 0xFC, 0x1F, 0xC0, 0x0F, 0xFE, 0x07, 0xF0, 0x0F, 0xFF, 0x83,
  0xFE, 0x3F, 0xEF, 0xC0, 0xFF, 0xFF, 0xE7, 0xE0, 0x7F, 0xFF, 0xC1, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFC, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F,
  0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x30, 0x07, 0x80, 0x30,
  0xF0, 0x1E, 0x03, 0xE7, 0xF0, 0x78, 0x3F, 0x9F, 0xF9, 0xE7, 0xFE, 0x7F,
  0xFF, 0xBF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x80, 0x04, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF,
  0x00, 0xFC, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF0, 0x3F, 0x8F, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xC0,
  0x03, 0xFC, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F,
  0x83, 0xF0, 0x0F, 0x8F, 0xC1, 0xFE, 0x03, 0xE3, 0xF0, 0x7F, 0xC1, 0xF8,
  0xFC, 0x3F, 0xF0, 0x7E, 0x7E, 0x0F, 0xFC, 0x1F, 0x9F, 0x83, 0xFF, 0x07,
  0xE7, 0xE0, 0xFF, 0xC1, 0xF1, 0xF8, 0x1F, 0xE0, 0xFC, 0x7C, 0x07, 0xF0,
  0x3F, 0x3F, 0x00, 0x78, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xCF, 0x80, 0x1F, 0xF9, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0x01, 0xF8,
  0x00, 0xC0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xE0,
  0x00, 0x7E, 0x00, 0x18, 0x00, 0x0F, 0xE0, 0x02, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x80, 0x03, 0xC0, 0x07,
  0xF0, 0x00, 0x20, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x10, 0x00, 0x01, 0xFE, 0x03, 0x80, 0x00, 0xFF, 0x80, 0x7E,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0x03, 0xF9, 0xF0, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0xE1, 0xF0, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03,
  0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x0C, 0x00, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x38, 0x00, 0x00, 0xFC, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x1F, 0xF8,
  0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xC7, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF9, 0xF8,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0x80,
  0x3F, 0xC0, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x07, 0xFF, 0xE0,
  0xFC, 0x00, 0x7F, 0xFF, 0x83, 0xF0, 0x07, 0xFF, 0xFE, 0x1F, 0x80, 0x7F,
  0xFF, 0xF8, 0x7E, 0x03, 0xFE, 0x07, 0xC3, 0xF8, 0x1F, 0xC0, 0x1F, 0x0F,
  0xC0, 0x7E, 0x00, 0xFC, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x0F, 0xC0,
  0x0F, 0x87, 0xE0, 0x7E, 0x00, 0x3E, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x7E,
  0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0xF8, 0x00,
  0x7C, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0xFC, 0x0F, 0x80, 0x0F, 0xC3, 0xF0,
  0x7E, 0x00, 0x3E, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0xFC, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0xC0, 0xF8, 0x0F, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0x00,
  0x7F, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0xFF, 0xE0,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x20, 0x00, 0x01, 0xFF, 0xEF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0x00, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x07,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x00,
  0x0C, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x08, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x1F,
  0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x80,
  0x3E, 0x00, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x00,
  0xFF, 0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x8F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0x08, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x03, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x0C, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x00, 0x00,
  0xF8, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x00, 0x01, 0xF7, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x01,
  0xE7, 0x80, 0x7C, 0xF0, 0x00, 0xF3, 0xE0, 0x3C, 0xF8, 0x00, 0xF9, 0xF0,
  0x3E, 0x7C, 0x00, 0x78, 0xF8, 0x1E, 0x3E, 0x00, 0x3C, 0x7C, 0x1E, 0x1E,
  0x00, 0x3E, 0x3E, 0x0F, 0x0F, 0x00, 0x1E, 0x1F, 0x0F, 0x0F, 0x80, 0x0F,
  0x07, 0x8F, 0x87, 0xC0, 0x0F, 0x83, 0xC7, 0x83, 0xE0, 0x07, 0xC1, 0xE7,
  0xC1, 0xF0, 0x03, 0xC0, 0xF3, 0xC0, 0xF0, 0x03, 0xE0, 0x7B, 0xC0, 0xF8,
  0x01, 0xF0, 0x3D, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0xE0, 0x3E, 0x00, 0xF8,
  0x0F, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xF8,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0x03,
  0xE0, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x01,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0xC0,
  0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x3E, 0x00, 0x07, 0xC0, 0x0F,
  0x8F, 0x80, 0x07, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE0, 0x03, 0xE3, 0xE0,
  0x01, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x01, 0xF0,
  0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x0F, 0x80,
  0x03, 0xE7, 0xC0, 0x07, 0xC0, 0x01, 0xF3, 0xE0, 0x03, 0xE0, 0x00, 0xF9,
  0xF0, 0x01, 0xF0, 0x00, 0x3C, 0xF8, 0x01, 0xF0, 0x00, 0x1E, 0xF8, 0x00,
  0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x07,
  0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x00, 0xF8, 0x00,
  0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0x80, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x7C,
  0x00, 0x0F, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x00,
  0x04, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x08,
  0x00, 0x00, 0x7F, 0x00, 0x38, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7E, 0x01, 0xF0,
  0x03, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0xF8, 0x0F, 0xE0, 0x3E, 0x00, 0x3E,
  0x07, 0xF8, 0x0F, 0x80, 0x0F, 0x01, 0xFE, 0x03, 0xE0, 0x07, 0xC0, 0xFF,
  0x80, 0xF0, 0x01, 0xF0, 0x7D, 0xE0, 0x7C, 0x00, 0x7C, 0x1E, 0x78, 0x1F,
  0x00, 0x1F, 0x0F, 0x8F, 0x07, 0x80, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0x01,
  0xE1, 0xF0, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x3C, 0x3C, 0x00, 0x3E, 0x3E,
  0x0F, 0x0F, 0x00, 0x0F, 0x1F, 0x03, 0xC7, 0xC0, 0x03, 0xC7, 0x80, 0xF1,
  0xE0, 0x00, 0xF3, 0xE0, 0x3C, 0x78, 0x00, 0x3C, 0xF0, 0x0F, 0x1E, 0x00,
  0x1F, 0x7C, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0xFB, 0xC0, 0x01, 0xEF,
  0x80, 0x3E, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xBE, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFD, 0xE0, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7E, 0x0F,
  0x80, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xF8,
  0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x0F, 0x7F,
  0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3E, 0x30, 0x00, 0x00, 0x20, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x08, 0x01,
  0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0E, 0x00, 0x20, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xE0, 0x0F,
  0xF0, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0x01,
  0xFC, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x9F, 0x00, 0x3F, 0xFF, 0xC7, 0xC0, 0x07, 0xFF, 0xC1, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0xF0, 0x00, 0x0F, 0xBF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xF0, 0x3E, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0xFF, 0x01, 0xF0,
  0x00, 0xFF, 0x80, 0x7C, 0x00, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0x00, 0x7F, 0xE0, 0x00, 0xC0, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0x01, 0xFE, 0x00, 0x01,
  0x80, 0x3F, 0xE0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x7C, 0x00, 0x0F, 0xFF,
  0xF1, 0xF0, 0x00, 0x1F, 0xFF, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0x7C, 0x00, 0x07, 0xFC, 0x7E,
  0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x40, 0xFF, 0x00, 0x00,
  0xC0, 0x3F, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x10,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x7E, 0x00, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x3E, 0x00, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x30, 0x00, 0x07, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE7, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xF0, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0x80,
  0x00, 0x7C, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0x0F,
  0xF0, 0x00, 0x01, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0x00,
  0x7D, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFD,
  0xFE, 0x00, 0x00, 0x07, 0xE7, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0xE0, 0x00,
  0x01, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF,
  0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x23, 0xF0, 0x0E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFC, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xC0, 0x03, 0xFF, 0xF9,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F,
  0xF0, 0x07, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x0F, 0x87, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE3, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7E,
  0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00,
  0x3F, 0x80, 0x3E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x1F,
  0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0xFE, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xE0, 0x1F, 0xF0,
  0x01, 0xF8, 0x0F, 0xF0, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xCF, 0x80, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x10, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0x00, 0x1E, 0x00, 0xFC, 0x00, 0x04, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x20, 0x00, 0x07, 0xE0, 0x30, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x04, 0x01, 0xFC, 0x03, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF9, 0xF0, 0x07, 0xFF,
  0xF8, 0xF8, 0x00, 0xFF, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0x7E,
  0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x3E,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x03, 0xC0,
  0x0F, 0x87, 0xC0, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x7C,
  0x03, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0xE0, 0x3E, 0x07, 0xC0, 0x7F, 0x80,
  0xF8, 0x1F, 0x01, 0xFE, 0x07, 0xE0, 0x7C, 0x0F, 0xF8, 0x1F, 0x01, 0xF0,
  0x3D, 0xE0, 0x7C, 0x07, 0xC1, 0xF7, 0x83, 0xE0, 0x3F, 0x0F, 0x9E, 0x0F,
  0x80, 0xFC, 0x3C, 0x78, 0x7E, 0x03, 0xE1, 0xF1, 0xF1, 0xF0, 0x0F, 0x87,
  0x87, 0xC7, 0xC0, 0x3E, 0x3E, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x7C, 0xF8,
  0x03, 0xE7, 0x80, 0xF7, 0xC0, 0x0F, 0xBE, 0x03, 0xDF, 0x00, 0x3E, 0xF0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x3F,
  0x81, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x10, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x02, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x7F, 0xFC, 0x00, 0x7C,
  0x3F, 0xFF, 0x80, 0x1F, 0x1F, 0xFF, 0xF0, 0x0F, 0x8F, 0xC0, 0xFF, 0x07,
  0xC3, 0xE0, 0x1F, 0xFF, 0xF1, 0xF0, 0x03, 0xFF, 0xF8, 0x78, 0x00, 0x3F,
  0xFC, 0x2E, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00,
};

const GFXglyph UbuntuSansMono_Italic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 18, 50, 39, 11, -49 },
  { 114, 20, 18, 39, 15, -53 },
  { 159, 42, 49, 39, 0, -49 },
  { 417, 36, 62, 39, 3, -54 },
  { 696, 46, 51, 39, -2, -50 },
  { 990, 33, 51, 39, 2, -50 },
  { 1201, 9, 20, 39, 21, -53 },
  { 1224, 29, 68, 39, 9, -55 },
  { 1471, 29, 68, 39, 2, -55 },
  { 1718, 30, 29, 39, 8, -49 },
  { 1827, 32, 35, 39, 4, -38 },
  { 1967, 16, 21, 39, 6, -10 },
  { 2009, 17, 5, 39, 12, -22 },
  { 2020, 11, 11, 39, 11, -10 },
  { 2036, 44, 68, 39, -4, -55 },
  { 2410, 34, 51, 39, 4, -50 },
  { 2627, 28, 49, 39, 5, -49 },
  { 2799, 35, 50, 39, 3, -50 },
  { 3018, 35, 51, 39, 2, -50 },
  { 3242, 35, 49, 39, 1, -49 },
  { 3457, 38, 50, 39, 2, -49 },
  { 3695, 35, 50, 39, 5, -49 },
  { 3914, 35, 49, 39, 8, -49 },
  { 4129, 35, 51, 39, 4, -50 },
  { 4353, 36, 50, 39, 3, -50 },
  { 4578, 17, 37, 39, 11, -36 },
  { 4657, 22, 47, 39, 6, -36 },
  { 4787, 34, 30, 39, 3, -35 },
  { 4915, 36, 19, 39, 2, -30 },
  { 5001, 34, 30, 39, 2, -35 },
  { 5129, 27, 51, 39, 10, -50 },
  { 5302, 38, 60, 39, 3, -50 },
  { 5587, 38, 49, 39, -4, -49 },
  { 5820, 37, 49, 39, 1, -49 },
  { 6047, 38, 51, 39, 4, -50 },
  { 6290, 38, 49, 39, 0, -49 },
  { 6523, 39, 49, 39, 3, -49 },
  { 6762, 39, 49, 39, 3, -49 },
  { 7001, 38, 51, 39, 3, -50 },
  { 7244, 42, 49, 39, 0, -49 },
  { 7502, 36, 49, 39, 3, -49 },
  { 7723, 37, 50, 39, 3, -49 },
  { 7955, 42, 49, 39, 1, -49 },
  { 8213, 28, 49, 39, 1, -49 },
  { 8385, 41, 49, 39, -1, -49 },
  { 8637, 41, 49, 39, 1, -49 },
  { 8889, 35, 51, 39, 4, -50 },
  { 9113, 37, 49, 39, 2, -49 },
  { 9340, 36, 63, 39, 4, -50 },
  { 9624, 37, 49, 39, 1, -49 },
  { 9851, 38, 51, 39, 2, -50 },
  { 10094, 33, 49, 39, 10, -49 },
  { 10297, 38, 50, 39, 4, -49 },
  { 10535, 37, 49, 39, 8, -49 },
  { 10762, 42, 49, 39, 2, -49 },
  { 11020, 47, 49, 39, -2, -49 },
  { 11308, 37, 49, 39, 9, -49 },
  { 11535, 42, 49, 39, 0, -49 },
  { 11793, 34, 68, 39, 5, -55 },
  { 12082, 11, 68, 39, 14, -55 },
  { 12176, 35, 68, 39, -1, -55 },
  { 12474, 31, 26, 39, 6, -49 },
  { 12575, 36, 5, 39, -5, 8 },
  { 12598, 13, 14, 39, 18, -54 },
  { 12621, 34, 38, 39, 3, -37 },
  { 12783, 34, 55, 39, 3, -54 },
  { 13017, 34, 38, 39, 3, -37 },
  { 13179, 38, 55, 39, 4, -54 },
  { 13441, 33, 38, 39, 3, -37 },
  { 13598, 45, 67, 39, -1, -54 },
  { 13975, 40, 50, 39, -1, -37 },
  { 14225, 33, 54, 39, 1, -54 },
  { 14448, 22, 54, 39, 8, -54 },
  { 14597, 38, 67, 39, -1, -54 },
  { 14916, 37, 54, 39, 2, -54 },
  { 15166, 20, 55, 39, 12, -54 },
  { 15304, 38, 37, 39, 0, -37 },
  { 15480, 33, 37, 39, 3, -37 },
  { 15633, 33, 38, 39, 4, -37 },
  { 15790, 38, 50, 39, -1, -37 },
  { 16028, 34, 50, 39, 4, -37 },
  { 16241, 33, 37, 39, 5, -37 },
  { 16394, 32, 38, 39, 4, -37 },
  { 16546, 28, 49, 39, 9, -48 },
  { 16718, 33, 37, 39, 4, -36 },
  { 16871, 30, 36, 39, 8, -36 },
  { 17006, 38, 36, 39, 4, -36 },
  { 17177, 40, 36, 39, -1, -36 },
  { 17357, 43, 49, 39, -4, -36 },
  { 17621, 34, 36, 39, 2, -36 },
  { 17774, 38, 68, 39, 4, -55 },
  { 18097, 21, 68, 39, 10, -55 },
  { 18276, 38, 68, 39, -3, -55 },
  { 18599, 34, 11, 39, 3, -26 },
};

const GFXfont UbuntuSansMono_Italic70pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic70pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic70pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _UBUNTUSANSMONO_ITALIC70PT7B_H_
