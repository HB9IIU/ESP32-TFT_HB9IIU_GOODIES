#ifndef _UBUNTUSANSMONO_ITALIC62PT7B_H_
#define _UBUNTUSANSMONO_ITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x38, 0x00, 0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C,
  0x78, 0x1F, 0x3E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x38,
  0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x03,
  0x86, 0x01, 0xC3, 0x80, 0x70, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x7C,
  0x00, 0x7E, 0x00, 0x0C, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x30, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7F, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x07, 0x8F, 0x00, 0x07,
  0xC0, 0x07, 0x87, 0xC0, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x78, 0x03, 0xE0, 0x01, 0xE0, 0x3C,
  0x03, 0xE0, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x03, 0xE0,
  0x00, 0x38, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0x81, 0xE0, 0x00, 0x1E,
  0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0x81, 0xF1,
  0xF0, 0x00, 0x01, 0xE0, 0xF1, 0xF0, 0x00, 0x00, 0xF0, 0xF1, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x10, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0x00,
  0x00, 0x00, 0x78, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0xFF, 0xF0, 0x00, 0x00,
  0x7C, 0x78, 0x78, 0x00, 0x00, 0x7C, 0x78, 0x3C, 0x00, 0x00, 0x7C, 0x3C,
  0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x07, 0xC0,
  0x00, 0x3C, 0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x01, 0xE0, 0x00, 0x3E,
  0x07, 0x80, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x78, 0x00, 0x3E, 0x01, 0xE0,
  0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x00, 0x78, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x00,
  0x07, 0xCF, 0x80, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xF8,
  0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xE0,
  0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x7C, 0x07, 0xFC, 0x03, 0xC0, 0xFF, 0xF0, 0x1E, 0x0F, 0xCF,
  0x81, 0xF0, 0xFC, 0x3E, 0x0F, 0x07, 0xC1, 0xF8, 0x78, 0x7C, 0x07, 0xC7,
  0xC7, 0xC0, 0x1F, 0x3C, 0x3E, 0x00, 0xFF, 0xE1, 0xF0, 0x03, 0xFE, 0x1F,
  0x00, 0x1F, 0xF0, 0xF8, 0x00, 0x7F, 0x07, 0xC0, 0x03, 0xF8, 0x3E, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xF0, 0x7C, 0x00, 0x7F,
  0x83, 0xF0, 0x07, 0xFE, 0x1F, 0xC0, 0xFF, 0xF0, 0x7F, 0xFF, 0xCF, 0xC1,
  0xFF, 0xFC, 0x3E, 0x07, 0xFF, 0xC1, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x0C,
  0x00, 0x00, 0x00, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C,
  0x78, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x01, 0x80, 0xF0, 0x0C, 0x7E, 0x0E, 0x0F, 0xCF, 0xF1, 0xC7, 0xF9, 0xFF,
  0xBB, 0xFF, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0x7E, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF,
  0x03, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x01,
  0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFE, 0x01, 0xF8, 0x03, 0x00, 0x00, 0x7F,
  0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x3E, 0x3F, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xF0,
  0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x07, 0x80, 0xF8,
  0x7C, 0x1F, 0x81, 0xF1, 0xF8, 0x7F, 0x83, 0xE3, 0xE0, 0xFF, 0x07, 0xC7,
  0xC3, 0xFE, 0x1F, 0x8F, 0x87, 0xFC, 0x3E, 0x3F, 0x07, 0xF8, 0x7C, 0x7C,
  0x0F, 0xE0, 0xF8, 0xF8, 0x0F, 0x83, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03,
  0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xBE, 0x00, 0xFF, 0x9F, 0x00, 0x7F, 0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x18,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x04, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0x80,
  0x1C, 0x00, 0x3F, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03,
  0x80, 0x1F, 0x80, 0x04, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x08, 0x00, 0x07, 0xF0, 0x3C, 0x00,
  0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xBC, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80,
  0x0F, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x10, 0x00,
  0x0F, 0xE0, 0x07, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x7F, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0x80, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x9F, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0xE0,
  0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x81, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xFC, 0x03, 0xFE, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xE1, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x03,
  0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x03, 0x80, 0x7E, 0x04, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xFC, 0x3F, 0x00,
  0x3F, 0xFF, 0x0F, 0xC0, 0x3F, 0xFF, 0x83, 0xE0, 0x1F, 0xFF, 0xE1, 0xF8,
  0x1F, 0xF1, 0xF8, 0x7C, 0x0F, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0x0F, 0x0F,
  0xC1, 0xF8, 0x07, 0xC3, 0xE0, 0x7C, 0x01, 0xF0, 0xF8, 0x3E, 0x00, 0x7C,
  0x7E, 0x0F, 0x80, 0x1E, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC1, 0xF0, 0x03,
  0xE1, 0xF0, 0x7C, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x3C, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x1F,
  0x00, 0x7C, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0xC1, 0xF8, 0x0F, 0x81, 0xF0,
  0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xE0, 0xF8, 0x1F, 0x01, 0xFF, 0xFC, 0x07,
  0xC0, 0x3F, 0xFF, 0x01, 0xF0, 0x07, 0xFF, 0xC0, 0x7C, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x18, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x1F, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7C, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0xFC, 0x03, 0xC0, 0x03, 0xF8, 0x07, 0xC1, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x07, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x1F, 0xE0, 0x78, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xDF, 0xF8, 0x03, 0xFC, 0x00, 0x78,
  0x03, 0xF8, 0x00, 0x08, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x0C, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x1F, 0xF9, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7C,
  0x03, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0xF0, 0x00,
  0x3F, 0x80, 0x7C, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x1F, 0xE0, 0x07, 0xC0,
  0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x87, 0xF0, 0x01,
  0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00, 0x08, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x1F,
  0xF8, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x02, 0x00, 0x03, 0xE0, 0x03, 0x80,
  0x03, 0xF0, 0x01, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0x87, 0xF0,
  0x00, 0x00, 0x7C, 0x7F, 0x00, 0x00, 0x03, 0xE7, 0xF0, 0x00, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x00, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03,
  0xBC, 0x01, 0xFE, 0x00, 0x1D, 0xE0, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x0F, 0x3C, 0x00, 0x73, 0xC0, 0x7B, 0xC0, 0x07, 0x9E,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x38, 0xF0, 0x03, 0xC7, 0x83, 0xC7, 0x80,
  0x1E, 0x1C, 0x3C, 0x3C, 0x00, 0xF0, 0xF1, 0xE3, 0xE0, 0x0F, 0x87, 0x9E,
  0x1E, 0x00, 0x78, 0x3C, 0xF0, 0xF0, 0x03, 0xC1, 0xEF, 0x07, 0x80, 0x3E,
  0x0F, 0x70, 0x3C, 0x01, 0xF0, 0x7F, 0x83, 0xE0, 0x0F, 0x03, 0xF8, 0x1F,
  0x00, 0x78, 0x1F, 0xC0, 0xF0, 0x07, 0xC0, 0xFC, 0x07, 0x80, 0x3C, 0x07,
  0xE0, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x0F, 0xE0, 0x00, 0x3E, 0x00,
  0x7F, 0x00, 0x01, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x00,
  0x78, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0x0F, 0x78, 0x00, 0x3E, 0x00, 0x7B,
  0xC0, 0x01, 0xE0, 0x03, 0xDF, 0x00, 0x0F, 0x00, 0x3E, 0x78, 0x00, 0xF8,
  0x01, 0xE3, 0xC0, 0x07, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0xF8,
  0x01, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x01,
  0xE0, 0xF8, 0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x1E, 0x01,
  0xE0, 0x07, 0xC0, 0xF0, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0xF8, 0x01, 0xE0,
  0x1E, 0x07, 0x80, 0x1F, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x07, 0x83, 0xE0,
  0x07, 0x80, 0x3E, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xE0, 0x07,
  0x87, 0x80, 0x1F, 0x00, 0x3C, 0x7C, 0x00, 0xF0, 0x01, 0xE3, 0xE0, 0x07,
  0x80, 0x0F, 0x9E, 0x00, 0x7C, 0x00, 0x3C, 0xF0, 0x03, 0xE0, 0x01, 0xE7,
  0x80, 0x1E, 0x00, 0x0F, 0x7C, 0x00, 0xF0, 0x00, 0x7B, 0xC0, 0x07, 0x80,
  0x03, 0xDE, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0x7F, 0x80,
  0x1E, 0x00, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xE3, 0xFC,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F,
  0x1E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x7C,
  0x78, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0xC7, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0xF0, 0x03, 0xE0, 0x01, 0xF8,
  0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x3F, 0x80, 0x3E, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x07,
  0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xCF, 0xF0, 0x01, 0xFC, 0x00, 0x30, 0x01, 0xF8,
  0x00, 0x08, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x80, 0x00,
  0x3F, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0xFC, 0x07, 0x80, 0x3E, 0x07, 0xE0, 0x3C, 0x01, 0xE0,
  0x7F, 0x01, 0xE0, 0x0F, 0x03, 0xF8, 0x1E, 0x00, 0x78, 0x3D, 0xC0, 0xF0,
  0x03, 0xC3, 0xCF, 0x07, 0x80, 0x3C, 0x1E, 0x78, 0x78, 0x01, 0xE1, 0xE3,
  0xC3, 0xC0, 0x0F, 0x0F, 0x1E, 0x1E, 0x00, 0x78, 0xF0, 0xF0, 0xF0, 0x03,
  0xC7, 0x87, 0x8F, 0x00, 0x1C, 0x78, 0x3C, 0x78, 0x01, 0xE7, 0xC0, 0xE3,
  0x80, 0x0F, 0x3C, 0x07, 0x3C, 0x00, 0x7B, 0xC0, 0x39, 0xE0, 0x03, 0xDE,
  0x01, 0xCE, 0x00, 0x1D, 0xE0, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xCF,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x83, 0xC0, 0x03,
  0xE0, 0x78, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x0F, 0xC0, 0x1E,
  0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0xF9, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3E,
  0xE0, 0x00, 0x03, 0x84, 0x00, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x18,
  0x07, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x07,
  0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x7F, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x3C,
  0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x7F,
  0xF0, 0x07, 0xFF, 0xFD, 0xE0, 0x07, 0xFF, 0xF3, 0xE0, 0x07, 0xFF, 0x87,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x7F, 0x00, 0x01, 0xF3, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0xC1, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8,
  0x1F, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x7F, 0x01,
  0xF0, 0x03, 0xFC, 0x03, 0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x78, 0x07, 0xF8,
  0x00, 0x20, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x20,
  0x3F, 0x80, 0x03, 0x80, 0x7F, 0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x3E, 0x00, 0x0F, 0xF0, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xEF, 0x00, 0x03, 0xFF, 0xF9, 0xE0,
  0x00, 0x3F, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xC3, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x07,
  0xC1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x0F, 0xE7, 0xC0, 0x00, 0xFF, 0x1F, 0x00, 0x3F, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x20, 0x3F, 0xC0, 0x07, 0x80, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x07, 0xF0, 0x01,
  0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x1F, 0xC0,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x7C, 0x00, 0x00, 0xFF,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x08, 0x00, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0xCF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x20, 0x00, 0xFC, 0x00,
  0x0E, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x80, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0x1E, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0xFE,
  0x00, 0x07, 0xC0, 0xFE, 0x00, 0x03, 0xC0, 0xFE, 0x00, 0x03, 0xE1, 0xFC,
  0x00, 0x01, 0xF1, 0xFC, 0x00, 0x00, 0xFB, 0xFC, 0x00, 0x00, 0x7B, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F,
  0x80, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0x3F,
  0x87, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x7C, 0x00, 0x7F, 0xF9, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x9F, 0xFB, 0xF8, 0x1F, 0x03, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x7C, 0x0F,
  0x83, 0xE0, 0x3E, 0x07, 0xC1, 0xF0, 0x1E, 0x03, 0xE0, 0xF8, 0x1F, 0x01,
  0xF0, 0x78, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xC0,
  0x7C, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0x1E, 0x0F, 0x80, 0xF8,
  0x1F, 0x07, 0xC0, 0x78, 0x0F, 0x83, 0xE0, 0x7C, 0x07, 0xC1, 0xE0, 0x3E,
  0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xC0, 0x0F, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F,
  0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x1F, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xE0, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0xF8, 0x03, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xC0, 0x1F, 0xC0,
  0x0F, 0x80, 0xFF, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0,
  0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xBE, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x3F, 0x00,
  0x7E, 0x00, 0x10, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x40, 0x00, 0x3E, 0x03, 0x80,
  0x07, 0xF0, 0x3F, 0xC3, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0x80, 0x7F, 0xBF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1E,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x7C, 0x07, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xCF, 0xFF,
  0x00, 0xFF, 0xFF, 0xBE, 0x01, 0xFF, 0xFC, 0xF8, 0x01, 0xFF, 0xC1, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F,
  0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF1, 0xF0,
  0x00, 0x1E, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x7C, 0x07, 0xC0,
  0xF0, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xF0, 0x1E, 0x07, 0xC0, 0x7E, 0x07,
  0xC0, 0xF8, 0x1F, 0xC0, 0xF8, 0x1F, 0x07, 0xF8, 0x1E, 0x03, 0xE0, 0xFF,
  0x07, 0xC0, 0x7C, 0x3D, 0xE0, 0xF0, 0x0F, 0x87, 0xBC, 0x3E, 0x01, 0xE1,
  0xE3, 0xC7, 0x80, 0x3C, 0x7C, 0x78, 0xF0, 0x07, 0x8F, 0x0F, 0x3E, 0x00,
  0xF3, 0xC1, 0xE7, 0x80, 0x1E, 0x78, 0x3D, 0xF0, 0x03, 0xDE, 0x07, 0xBC,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x8F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x20, 0x1F, 0xF0, 0x00,
  0xF0, 0xFF, 0xF0, 0x03, 0xC7, 0xFF, 0xE0, 0x1E, 0x3E, 0x1F, 0xC0, 0xF9,
  0xF0, 0x1F, 0xFF, 0xC7, 0x80, 0x3F, 0xFE, 0x3E, 0x00, 0x7F, 0xF0, 0x70,
  0x00, 0x7F, 0x80,
};

const GFXglyph UbuntuSansMono_Italic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 16, 44, 35, 10, -43 },
  { 89, 18, 16, 35, 13, -47 },
  { 125, 37, 43, 35, 0, -43 },
  { 324, 32, 55, 35, 3, -48 },
  { 544, 41, 45, 35, -2, -44 },
  { 775, 29, 45, 35, 2, -44 },
  { 939, 8, 18, 35, 19, -47 },
  { 957, 25, 60, 35, 8, -48 },
  { 1145, 25, 60, 35, 2, -48 },
  { 1333, 27, 25, 35, 7, -43 },
  { 1418, 28, 30, 35, 4, -33 },
  { 1523, 15, 19, 35, 5, -9 },
  { 1559, 16, 5, 35, 10, -20 },
  { 1569, 9, 10, 35, 10, -9 },
  { 1581, 39, 60, 35, -4, -49 },
  { 1874, 31, 45, 35, 3, -44 },
  { 2049, 25, 43, 35, 4, -43 },
  { 2184, 31, 44, 35, 3, -44 },
  { 2355, 31, 45, 35, 2, -44 },
  { 2530, 31, 43, 35, 1, -43 },
  { 2697, 34, 44, 35, 2, -43 },
  { 2884, 30, 44, 35, 5, -43 },
  { 3049, 31, 43, 35, 7, -43 },
  { 3216, 32, 45, 35, 3, -44 },
  { 3396, 32, 44, 35, 3, -44 },
  { 3572, 15, 33, 35, 10, -32 },
  { 3634, 20, 42, 35, 5, -32 },
  { 3739, 30, 27, 35, 3, -31 },
  { 3841, 32, 17, 35, 2, -27 },
  { 3909, 30, 27, 35, 2, -31 },
  { 4011, 24, 45, 35, 9, -44 },
  { 4146, 34, 53, 35, 2, -44 },
  { 4372, 34, 43, 35, -4, -43 },
  { 4555, 32, 43, 35, 1, -43 },
  { 4727, 33, 45, 35, 4, -44 },
  { 4913, 34, 43, 35, 0, -43 },
  { 5096, 34, 43, 35, 3, -43 },
  { 5279, 34, 43, 35, 3, -43 },
  { 5462, 33, 45, 35, 3, -44 },
  { 5648, 37, 43, 35, 0, -43 },
  { 5847, 31, 43, 35, 3, -43 },
  { 6014, 33, 44, 35, 3, -43 },
  { 6196, 37, 43, 35, 1, -43 },
  { 6395, 25, 43, 35, 1, -43 },
  { 6530, 37, 43, 35, -1, -43 },
  { 6729, 37, 43, 35, 0, -43 },
  { 6928, 32, 45, 35, 3, -44 },
  { 7108, 34, 43, 35, 1, -43 },
  { 7291, 32, 55, 35, 3, -44 },
  { 7511, 33, 43, 35, 1, -43 },
  { 7689, 33, 45, 35, 2, -44 },
  { 7875, 30, 43, 35, 8, -43 },
  { 8037, 34, 44, 35, 3, -43 },
  { 8224, 33, 43, 35, 7, -43 },
  { 8402, 37, 43, 35, 2, -43 },
  { 8601, 42, 43, 35, -2, -43 },
  { 8827, 33, 43, 35, 8, -43 },
  { 9005, 37, 43, 35, 0, -43 },
  { 9204, 31, 60, 35, 4, -49 },
  { 9437, 10, 60, 35, 13, -49 },
  { 9512, 31, 60, 35, -1, -49 },
  { 9745, 27, 23, 35, 6, -43 },
  { 9823, 32, 4, 35, -4, 7 },
  { 9839, 11, 13, 35, 16, -48 },
  { 9857, 31, 34, 35, 2, -33 },
  { 9989, 31, 49, 35, 2, -48 },
  { 10179, 30, 34, 35, 2, -33 },
  { 10307, 35, 49, 35, 3, -48 },
  { 10522, 30, 34, 35, 2, -33 },
  { 10650, 40, 60, 35, -1, -48 },
  { 10950, 35, 45, 35, -1, -33 },
  { 11147, 30, 48, 35, 0, -48 },
  { 11327, 19, 47, 35, 7, -47 },
  { 11439, 34, 59, 35, -1, -47 },
  { 11690, 33, 48, 35, 2, -48 },
  { 11888, 18, 49, 35, 10, -48 },
  { 11999, 33, 33, 35, 0, -33 },
  { 12136, 30, 33, 35, 2, -33 },
  { 12260, 29, 34, 35, 3, -33 },
  { 12384, 33, 44, 35, -1, -33 },
  { 12566, 31, 44, 35, 3, -33 },
  { 12737, 29, 33, 35, 4, -33 },
  { 12857, 29, 34, 35, 3, -33 },
  { 12981, 25, 43, 35, 8, -42 },
  { 13116, 30, 33, 35, 3, -32 },
  { 13240, 27, 32, 35, 7, -32 },
  { 13348, 35, 32, 35, 3, -32 },
  { 13488, 36, 32, 35, -1, -32 },
  { 13632, 37, 44, 35, -3, -32 },
  { 13836, 30, 32, 35, 2, -32 },
  { 13956, 34, 60, 35, 3, -49 },
  { 14211, 19, 60, 35, 9, -49 },
  { 14354, 34, 60, 35, -3, -49 },
  { 14609, 30, 9, 35, 3, -23 },
};

const GFXfont UbuntuSansMono_Italic62pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic62pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic62pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _UBUNTUSANSMONO_ITALIC62PT7B_H_
