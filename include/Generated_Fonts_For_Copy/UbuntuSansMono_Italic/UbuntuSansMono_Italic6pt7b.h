#ifndef _UBUNTUSANSMONO_ITALIC6PT7B_H_
#define _UBUNTUSANSMONO_ITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xF0, 0x5E, 0xEC, 0x2D, 0x1E, 0x80, 0xDE, 0x6E, 0x6A, 0xF0,
  0xC0, 0x6A, 0xA0, 0x44, 0x95, 0x00, 0xF0, 0x5D, 0x00, 0x70, 0x80, 0x80,
  0x25, 0x29, 0x00, 0x7E, 0xF0, 0x65, 0x70, 0x65, 0x70, 0x6C, 0xF0, 0x2E,
  0xA0, 0x68, 0xF0, 0x6A, 0xF0, 0xEA, 0x40, 0x6E, 0xF0, 0x75, 0xE0, 0xA0,
  0x47, 0x38, 0x80, 0x7C, 0x4E, 0x00, 0xDA, 0x7A, 0xEA, 0x40, 0x2F, 0xD0,
  0x7E, 0xF0, 0x78, 0x8E, 0x76, 0xE0, 0x76, 0x8E, 0x76, 0x88, 0x72, 0xF0,
  0x5E, 0xAA, 0x69, 0x60, 0x64, 0xF0, 0x74, 0xCA, 0x52, 0x70, 0x6E, 0xD0,
  0x5D, 0xAA, 0x76, 0xF0, 0x77, 0x40, 0x76, 0xD6, 0x77, 0xD0, 0x68, 0xF0,
  0xF2, 0x40, 0x5A, 0xAE, 0xBA, 0x40, 0x9D, 0xAA, 0x52, 0x4A, 0xBA, 0x40,
  0x72, 0x4E, 0x29, 0x25, 0x80, 0xFC, 0x64, 0xA5, 0x80, 0x70, 0xE0, 0xC0,
  0x77, 0x80, 0x49, 0xDE, 0x73, 0x80, 0x11, 0x6A, 0xE0, 0x7F, 0x80, 0x34,
  0x64, 0x4C, 0x76, 0xF0, 0x4A, 0xDA, 0x4A, 0xC0, 0x21, 0x93, 0x80, 0x49,
  0xAA, 0xAA, 0xC0, 0xFE, 0x80, 0x76, 0x80, 0x77, 0x80, 0x77, 0xC0, 0x77,
  0x90, 0x72, 0x00, 0x6B, 0x80, 0xBB, 0xB7, 0x80, 0xF8, 0x9E, 0xA0, 0x6A,
  0x80, 0xAD, 0x60, 0x6B, 0x80, 0x34, 0x4C, 0x4C, 0x5A, 0xA0, 0x44, 0xA5,
  0x80, 0xE0,
};

const GFXglyph UbuntuSansMono_Italic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 4, 3, 1, -4 },
  { 2, 2, 2, 3, 1, -5 },
  { 3, 4, 4, 3, 0, -4 },
  { 5, 3, 6, 3, 0, -5 },
  { 8, 4, 4, 3, 0, -4 },
  { 10, 3, 4, 3, 0, -4 },
  { 12, 1, 2, 3, 2, -5 },
  { 13, 2, 6, 3, 1, -5 },
  { 15, 3, 6, 3, 0, -5 },
  { 18, 2, 2, 3, 1, -4 },
  { 19, 3, 3, 3, 0, -3 },
  { 21, 2, 2, 3, 0, -1 },
  { 22, 1, 1, 3, 1, -2 },
  { 23, 1, 1, 3, 1, -1 },
  { 24, 3, 6, 3, 0, -5 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 1, -4 },
  { 43, 3, 4, 3, 0, -4 },
  { 45, 3, 4, 3, 0, -4 },
  { 47, 1, 3, 3, 1, -3 },
  { 48, 2, 4, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -3 },
  { 51, 3, 2, 3, 0, -3 },
  { 52, 3, 3, 3, 0, -3 },
  { 54, 2, 4, 3, 1, -4 },
  { 55, 4, 5, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 4, 4, 3, 0, -4 },
  { 64, 3, 4, 3, 0, -4 },
  { 66, 4, 4, 3, 0, -4 },
  { 68, 4, 4, 3, 0, -4 },
  { 70, 3, 4, 3, 0, -4 },
  { 72, 4, 4, 3, 0, -4 },
  { 74, 3, 4, 3, 0, -4 },
  { 76, 3, 4, 3, 0, -4 },
  { 78, 4, 4, 3, 0, -4 },
  { 80, 3, 4, 3, 0, -4 },
  { 82, 3, 4, 3, 0, -4 },
  { 84, 4, 4, 3, 0, -4 },
  { 86, 3, 4, 3, 0, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 3, 5, 3, 0, -4 },
  { 92, 3, 4, 3, 0, -4 },
  { 94, 3, 4, 3, 0, -4 },
  { 96, 3, 4, 3, 1, -4 },
  { 98, 4, 4, 3, 0, -4 },
  { 100, 3, 4, 3, 1, -4 },
  { 102, 4, 4, 3, 0, -4 },
  { 104, 4, 4, 3, 0, -4 },
  { 106, 3, 4, 3, 1, -4 },
  { 108, 4, 4, 3, 0, -4 },
  { 110, 3, 6, 3, 0, -5 },
  { 113, 1, 6, 3, 1, -5 },
  { 114, 3, 6, 3, 0, -5 },
  { 117, 2, 2, 3, 1, -4 },
  { 118, 3, 1, 3, 0, 0 },
  { 119, 1, 2, 3, 2, -5 },
  { 120, 3, 3, 3, 0, -3 },
  { 122, 3, 5, 3, 0, -5 },
  { 124, 3, 3, 3, 0, -3 },
  { 126, 4, 5, 3, 0, -5 },
  { 129, 3, 3, 3, 0, -3 },
  { 131, 4, 6, 3, 0, -5 },
  { 134, 3, 4, 3, 0, -3 },
  { 136, 3, 5, 3, 0, -5 },
  { 138, 2, 5, 3, 1, -5 },
  { 140, 3, 6, 3, 0, -5 },
  { 143, 3, 5, 3, 0, -5 },
  { 145, 2, 5, 3, 1, -5 },
  { 147, 3, 3, 3, 0, -3 },
  { 149, 3, 3, 3, 0, -3 },
  { 151, 3, 3, 3, 0, -3 },
  { 153, 3, 4, 3, 0, -3 },
  { 155, 3, 4, 3, 0, -3 },
  { 157, 3, 3, 3, 0, -3 },
  { 159, 3, 3, 3, 0, -3 },
  { 161, 2, 4, 3, 1, -4 },
  { 162, 3, 3, 3, 0, -3 },
  { 164, 2, 3, 3, 1, -3 },
  { 165, 4, 3, 3, 0, -3 },
  { 167, 3, 3, 3, 0, -3 },
  { 169, 3, 4, 3, 0, -3 },
  { 171, 3, 3, 3, 0, -3 },
  { 173, 4, 6, 3, 0, -5 },
  { 176, 2, 6, 3, 1, -5 },
  { 178, 3, 6, 3, 0, -5 },
  { 181, 3, 1, 3, 0, -2 },
};

const GFXfont UbuntuSansMono_Italic6pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic6pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _UBUNTUSANSMONO_ITALIC6PT7B_H_
