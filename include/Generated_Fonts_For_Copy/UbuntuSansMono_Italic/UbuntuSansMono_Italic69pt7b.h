#ifndef _UBUNTUSANSMONO_ITALIC69PT7B_H_
#define _UBUNTUSANSMONO_ITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x01,
  0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x78, 0x78,
  0x07, 0x87, 0x80, 0x78, 0x70, 0x07, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0E,
  0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0x80, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x03,
  0x00, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xC0,
  0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x3C, 0x01,
  0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x3E,
  0x00, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x0F, 0x80,
  0x00, 0x1E, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x07, 0x83, 0xE0, 0x00,
  0x01, 0xE0, 0x3E, 0x1F, 0x80, 0x00, 0x07, 0x80, 0xF0, 0xFC, 0x00, 0x00,
  0x1F, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x7C, 0x1E, 0x1F, 0x00, 0x00, 0x00,
  0xFD, 0xF8, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC7, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x87, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xE1, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x8F,
  0x87, 0xC0, 0x00, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x00, 0x03, 0xE1, 0xE0,
  0x3C, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0xF8, 0x3C, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x3C,
  0x00, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x07, 0xC0,
  0x00, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x00,
  0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x7C, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3E, 0x3F, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x18, 0x00, 0x7F, 0xC0, 0x1F, 0x01, 0xFF, 0xE0, 0x1F,
  0x03, 0xFF, 0xE0, 0x3E, 0x07, 0xE3, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E,
  0x1F, 0x81, 0xF8, 0x7C, 0x1F, 0x00, 0xFC, 0x7C, 0x3E, 0x00, 0xFC, 0x7C,
  0x7E, 0x00, 0x7E, 0xF8, 0x7E, 0x00, 0x3E, 0xF8, 0x7C, 0x00, 0x3F, 0xF0,
  0xFC, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xE0,
  0xFC, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0xF0, 0xFE, 0x00, 0xFF, 0xF0,
  0x7F, 0xC7, 0xF9, 0xF0, 0x3F, 0xFF, 0xF1, 0xF8, 0x3F, 0xFF, 0xE1, 0xF8,
  0x1F, 0xFF, 0x81, 0xF8, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0xC0, 0x00, 0x00,
  0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x04, 0x01, 0xF0, 0x02, 0x38, 0x07, 0x80, 0x73, 0xF0, 0x3C, 0x1F,
  0x9F, 0xE1, 0xE3, 0xFC, 0xFF, 0xCF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0xF0,
  0x03, 0x80, 0x01, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x3F, 0x0F, 0xF1, 0xFF, 0x7F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0x8F, 0xE0, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x3C, 0x03, 0xF3, 0xF0, 0x7F,
  0x01, 0xF9, 0xF8, 0x3F, 0xC0, 0xFC, 0xFC, 0x3F, 0xE0, 0x7E, 0x7C, 0x1F,
  0xF8, 0x3E, 0x7E, 0x0F, 0xFC, 0x3F, 0x3F, 0x07, 0xFC, 0x1F, 0x9F, 0x83,
  0xFE, 0x0F, 0xCF, 0x80, 0xFE, 0x07, 0xCF, 0xC0, 0x3E, 0x07, 0xE7, 0xE0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFD, 0xF0,
  0x07, 0xFE, 0x7E, 0x00, 0xFF, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xC0,
  0x3E, 0x00, 0x40, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xE0,
  0x01, 0xFC, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x10, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0x80, 0x7F, 0x80, 0x03, 0x80, 0x07, 0xF0, 0x00, 0x40, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x1C, 0x00, 0x07,
  0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x07, 0xC0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x1F, 0xF8, 0x00, 0x1F, 0xBF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03,
  0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xF3, 0xFF, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0xC0,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFB, 0xF8,
  0x00, 0x0F, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7F, 0xF8,
  0x7E, 0x00, 0x3F, 0xFF, 0xC3, 0xF0, 0x07, 0xFF, 0xFC, 0x3F, 0x00, 0x7F,
  0xFF, 0xE1, 0xF8, 0x07, 0xFE, 0xFF, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0xFC,
  0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x7E, 0x00, 0x7C, 0x3F, 0x07, 0xE0, 0x07,
  0xE3, 0xF0, 0x3F, 0x00, 0x3F, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0xFC, 0x1F,
  0x80, 0x0F, 0x87, 0xC0, 0xFC, 0x00, 0xFC, 0x7E, 0x07, 0xC0, 0x07, 0xE3,
  0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0xFC, 0x1F, 0x80,
  0x0F, 0x87, 0xE0, 0xFC, 0x00, 0xFC, 0x3E, 0x07, 0xE0, 0x07, 0xC1, 0xF0,
  0x3F, 0x00, 0x3E, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x1F,
  0x83, 0xE0, 0x3F, 0x00, 0xFC, 0x1F, 0x01, 0xFC, 0x07, 0xC0, 0xFC, 0x07,
  0xF0, 0x3E, 0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0x81,
  0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x07, 0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFE,
  0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x0F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x0F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x00, 0x08, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x02, 0x00, 0x07, 0xF0, 0x00, 0x38,
  0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x03, 0xF8, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x00, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x3E,
  0x00, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0x00, 0x1F, 0xF8,
  0x00, 0xFE, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x07, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0x80, 0x07, 0xF0, 0x00,
  0x04, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x20, 0x00, 0x0F,
  0xE0, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00,
  0x3F, 0x80, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x00,
  0x7C, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x07, 0xFC, 0x01, 0xF7,
  0x80, 0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x03, 0xCF, 0x00, 0xFB, 0xC0, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x3C, 0x78, 0x00, 0x78, 0xF0, 0x3C, 0x7C, 0x00, 0x7C, 0x78, 0x1E, 0x3E,
  0x00, 0x3C, 0x3E, 0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x1F, 0x0F, 0x00, 0x1F,
  0x0F, 0x8F, 0x07, 0x80, 0x0F, 0x87, 0xCF, 0x07, 0xC0, 0x07, 0x81, 0xE7,
  0x83, 0xE0, 0x07, 0xC0, 0xF7, 0x81, 0xF0, 0x03, 0xE0, 0x7B, 0xC0, 0xF8,
  0x01, 0xF0, 0x3F, 0xC0, 0x78, 0x01, 0xF0, 0x1F, 0xE0, 0x7C, 0x00, 0xF8,
  0x0F, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xE0,
  0x03, 0xFC, 0x00, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x00,
  0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x00,
  0x1F, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0x9F, 0x00, 0x07, 0xC0, 0x07, 0xC7,
  0xC0, 0x07, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x00, 0x07, 0x8F, 0x80, 0x0F, 0x80, 0x03, 0xC7, 0xC0, 0x07, 0xC0, 0x01,
  0xF3, 0xC0, 0x03, 0xC0, 0x00, 0xFB, 0xE0, 0x03, 0xE0, 0x00, 0x7D, 0xF0,
  0x01, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x7C,
  0x00, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x3F, 0x80,
  0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xE0,
  0x00, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x0F, 0xFE, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00,
  0xFC, 0x7C, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x0F,
  0xFE, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xFE,
  0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x01, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x08, 0x00,
  0x00, 0xFE, 0x00, 0x70, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x0F, 0xE0, 0x3E, 0x00, 0x7C,
  0x07, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xF8, 0x0F, 0x80, 0x1E, 0x03, 0xFC,
  0x07, 0x80, 0x1F, 0x03, 0xDE, 0x07, 0xC0, 0x0F, 0x83, 0xEF, 0x03, 0xE0,
  0x07, 0xC1, 0xE7, 0x81, 0xE0, 0x03, 0xC1, 0xF3, 0xC1, 0xF0, 0x01, 0xE0,
  0xF1, 0xE0, 0xF8, 0x00, 0xF0, 0xF8, 0xF0, 0x78, 0x00, 0xF8, 0x78, 0x78,
  0x3C, 0x00, 0x7C, 0x78, 0x1E, 0x3E, 0x00, 0x3C, 0x7C, 0x0F, 0x1E, 0x00,
  0x1E, 0x3C, 0x07, 0x8F, 0x00, 0x0F, 0x3E, 0x03, 0xCF, 0x80, 0x07, 0x9E,
  0x01, 0xE7, 0x80, 0x07, 0xDF, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x79,
  0xE0, 0x01, 0xEF, 0x80, 0x3D, 0xE0, 0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x00,
  0x7F, 0x80, 0x0F, 0x78, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x83, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0,
  0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x18,
  0x00, 0x00, 0x38, 0x10, 0x00, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x18, 0x07, 0xC0, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x00, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xE0, 0x0F, 0xF8, 0x01, 0xF0, 0x07, 0xF8, 0x00,
  0x7C, 0x03, 0xF8, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xE0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xBF, 0x00, 0x3F, 0xFF, 0xC7, 0xC0,
  0x07, 0xFF, 0xC1, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x0E, 0x00, 0x00,
  0x3E, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3F, 0x83, 0xE0, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x3F, 0x80, 0xF8,
  0x00, 0x7F, 0x80, 0x7C, 0x00, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xE0, 0x0F, 0xF0,
  0x00, 0x10, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xC0,
  0x1F, 0xF0, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0xF8, 0x00, 0x0F, 0xFF, 0xF1,
  0xF0, 0x00, 0x1F, 0xFF, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F,
  0x0F, 0xE0, 0x00, 0x1F, 0x1F, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F,
  0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0xFE, 0x7C, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x3F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x60, 0x3F, 0xE0, 0x07, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x04, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0x80, 0x01,
  0xFF, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0xF8, 0x00, 0x00, 0x3F, 0x81, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x80,
  0x00, 0x7F, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x08, 0x00, 0x00, 0xF9, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0x8F, 0xFE, 0x01, 0xF0, 0x00, 0xFE, 0x01, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00,
  0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x0F, 0xE0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x00,
  0x7C, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x01, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0x00, 0x7C,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x01,
  0xF0, 0x7F, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x01, 0x7F, 0x00, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x01,
  0xFF, 0xE1, 0xFE, 0x00, 0x3F, 0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0xF1, 0xFC, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x7E, 0x03,
  0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x7C, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x3F, 0xF8, 0x03,
  0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x3F, 0x80, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x3F, 0xC0, 0x7F, 0xC3, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x7C, 0x00, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0x00,
  0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x3F, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xF8, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xDF, 0x80, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0x30, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0x80,
  0x7C, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x20, 0x00, 0x07, 0xC0, 0x30, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x20,
  0x0F, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF9, 0xF0, 0x07, 0xFF, 0xF8, 0xF8, 0x01, 0xFF, 0xF0,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x07, 0xC0,
  0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x03, 0xE1, 0xF0, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x7F, 0x01, 0xF8, 0x1F, 0x01, 0xFC, 0x07,
  0xC0, 0x7C, 0x0F, 0xF8, 0x1F, 0x01, 0xF0, 0x7F, 0xE0, 0xF8, 0x0F, 0xC1,
  0xEF, 0x83, 0xE0, 0x3F, 0x0F, 0xBE, 0x0F, 0x80, 0xF8, 0x3C, 0x78, 0x7C,
  0x03, 0xE1, 0xF1, 0xE1, 0xF0, 0x0F, 0x8F, 0x87, 0x8F, 0x80, 0x3E, 0x3C,
  0x1E, 0x3E, 0x00, 0xF9, 0xF0, 0x7D, 0xF0, 0x03, 0xE7, 0x81, 0xF7, 0xC0,
  0x0F, 0xBC, 0x07, 0xDF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x7F,
  0x01, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x80, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xC0, 0x7F, 0xF8, 0x00, 0x7C, 0x3F, 0xFF, 0x00, 0x1E,
  0x1F, 0xFF, 0xF0, 0x0F, 0x8F, 0xC1, 0xFE, 0x07, 0xC3, 0xE0, 0x3F, 0xFF,
  0xE1, 0xF0, 0x03, 0xFF, 0xF8, 0x7C, 0x00, 0x7F, 0xFC, 0x3E, 0x00, 0x07,
  0xFC, 0x00, 0x80, 0x00, 0xFC, 0x00,
};

const GFXglyph UbuntuSansMono_Italic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 17, 49, 39, 11, -48 },
  { 106, 20, 18, 39, 15, -52 },
  { 151, 41, 48, 39, 0, -48 },
  { 397, 36, 62, 39, 3, -54 },
  { 676, 46, 50, 39, -2, -49 },
  { 964, 32, 50, 39, 2, -49 },
  { 1164, 9, 19, 39, 21, -52 },
  { 1186, 28, 67, 39, 9, -54 },
  { 1421, 28, 67, 39, 2, -54 },
  { 1656, 29, 28, 39, 8, -48 },
  { 1758, 32, 34, 39, 4, -37 },
  { 1894, 17, 21, 39, 5, -10 },
  { 1939, 17, 5, 39, 12, -22 },
  { 1950, 11, 11, 39, 11, -10 },
  { 1966, 43, 67, 39, -4, -54 },
  { 2327, 33, 50, 39, 4, -49 },
  { 2534, 27, 48, 39, 5, -48 },
  { 2696, 34, 49, 39, 3, -49 },
  { 2905, 35, 50, 39, 2, -49 },
  { 3124, 35, 48, 39, 1, -48 },
  { 3334, 38, 49, 39, 2, -48 },
  { 3567, 34, 49, 39, 5, -48 },
  { 3776, 35, 48, 39, 8, -48 },
  { 3986, 35, 50, 39, 4, -49 },
  { 4205, 35, 49, 39, 3, -49 },
  { 4420, 17, 36, 39, 11, -35 },
  { 4497, 23, 46, 39, 5, -35 },
  { 4630, 34, 30, 39, 3, -35 },
  { 4758, 36, 19, 39, 2, -30 },
  { 4844, 34, 30, 39, 2, -35 },
  { 4972, 27, 50, 39, 10, -49 },
  { 5141, 37, 59, 39, 3, -49 },
  { 5414, 37, 48, 39, -4, -48 },
  { 5636, 36, 48, 39, 1, -48 },
  { 5852, 38, 50, 39, 4, -49 },
  { 6090, 37, 48, 39, 0, -48 },
  { 6312, 38, 48, 39, 3, -48 },
  { 6540, 38, 48, 39, 3, -48 },
  { 6768, 37, 50, 39, 3, -49 },
  { 7000, 41, 48, 39, 0, -48 },
  { 7246, 35, 48, 39, 3, -48 },
  { 7456, 37, 49, 39, 3, -48 },
  { 7683, 41, 48, 39, 1, -48 },
  { 7929, 28, 48, 39, 1, -48 },
  { 8097, 41, 48, 39, -1, -48 },
  { 8343, 41, 48, 39, 1, -48 },
  { 8589, 35, 50, 39, 4, -49 },
  { 8808, 37, 48, 39, 2, -48 },
  { 9030, 35, 62, 39, 4, -49 },
  { 9302, 37, 48, 39, 1, -48 },
  { 9524, 37, 50, 39, 2, -49 },
  { 9756, 33, 48, 39, 9, -48 },
  { 9954, 38, 49, 39, 4, -48 },
  { 10187, 36, 48, 39, 8, -48 },
  { 10403, 41, 48, 39, 2, -48 },
  { 10649, 46, 48, 39, -2, -48 },
  { 10925, 36, 48, 39, 9, -48 },
  { 11141, 41, 48, 39, 0, -48 },
  { 11387, 34, 67, 39, 5, -54 },
  { 11672, 11, 67, 39, 14, -54 },
  { 11765, 34, 67, 39, -1, -54 },
  { 12050, 31, 26, 39, 6, -48 },
  { 12151, 36, 5, 39, -5, 8 },
  { 12174, 12, 14, 39, 18, -53 },
  { 12195, 34, 38, 39, 3, -37 },
  { 12357, 33, 55, 39, 3, -54 },
  { 12584, 34, 38, 39, 2, -37 },
  { 12746, 38, 55, 39, 4, -54 },
  { 13008, 32, 38, 39, 3, -37 },
  { 13160, 44, 67, 39, -1, -54 },
  { 13529, 39, 50, 39, -1, -37 },
  { 13773, 32, 54, 39, 1, -54 },
  { 13989, 21, 53, 39, 8, -53 },
  { 14129, 37, 66, 39, -1, -53 },
  { 14435, 37, 54, 39, 2, -54 },
  { 14685, 19, 54, 39, 12, -53 },
  { 14814, 37, 37, 39, 0, -37 },
  { 14986, 33, 37, 39, 2, -37 },
  { 15139, 32, 38, 39, 4, -37 },
  { 15291, 37, 50, 39, -1, -37 },
  { 15523, 34, 50, 39, 4, -37 },
  { 15736, 33, 37, 39, 4, -37 },
  { 15889, 32, 38, 39, 4, -37 },
  { 16041, 28, 48, 39, 8, -47 },
  { 16209, 33, 37, 39, 4, -36 },
  { 16362, 30, 36, 39, 8, -36 },
  { 16497, 38, 36, 39, 4, -36 },
  { 16668, 40, 36, 39, -1, -36 },
  { 16848, 42, 49, 39, -4, -36 },
  { 17106, 34, 36, 39, 2, -36 },
  { 17259, 37, 67, 39, 4, -54 },
  { 17569, 21, 67, 39, 10, -54 },
  { 17745, 37, 67, 39, -3, -54 },
  { 18055, 34, 11, 39, 3, -26 },
};

const GFXfont UbuntuSansMono_Italic69pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic69pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic69pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _UBUNTUSANSMONO_ITALIC69PT7B_H_
