#ifndef _UBUNTUSANSMONO_ITALIC42PT7B_H_
#define _UBUNTUSANSMONO_ITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF0, 0x08, 0x00, 0x38, 0x73, 0x87, 0x30, 0x77, 0x06, 0x70, 0xE7, 0x0E,
  0x60, 0xE6, 0x0C, 0xE0, 0xCC, 0x0C, 0xC1, 0x80, 0x00, 0x07, 0x03, 0x80,
  0x07, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0xE0,
  0x00, 0xE0, 0xF0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x0F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x80, 0x3C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x0E,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x80, 0x07, 0x03, 0x80, 0x03, 0x83,
  0xC0, 0x03, 0x81, 0xC0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC0, 0xF0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x38,
  0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFF,
  0x03, 0xF0, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x80, 0x0F, 0x07, 0x00, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x10, 0x1F,
  0xC0, 0x0E, 0x03, 0xDC, 0x01, 0xC0, 0x30, 0xC0, 0x38, 0x07, 0x0E, 0x07,
  0x00, 0x60, 0xE0, 0xF0, 0x0E, 0x0C, 0x0E, 0x00, 0xE0, 0xC1, 0xC0, 0x0E,
  0x1C, 0x38, 0x00, 0xE1, 0xC7, 0x00, 0x0E, 0x1C, 0xE0, 0x00, 0xE3, 0x9C,
  0x00, 0x0F, 0x7B, 0xC0, 0x00, 0x7F, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x9F, 0xC0, 0x00, 0x73,
  0xCE, 0x00, 0x0F, 0x38, 0xE0, 0x00, 0xE7, 0x0E, 0x00, 0x1C, 0x70, 0xE0,
  0x03, 0x86, 0x0E, 0x00, 0x70, 0x60, 0xE0, 0x0E, 0x0E, 0x0E, 0x01, 0xC0,
  0xE0, 0xC0, 0x3C, 0x0E, 0x1C, 0x03, 0x80, 0x71, 0xC0, 0x70, 0x07, 0xF8,
  0x0E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xC0, 0x1E, 0x1E, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x81, 0xE0, 0x38, 0x1C, 0x07, 0x83, 0xC0, 0x78, 0x38, 0x03, 0x87, 0x80,
  0x38, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x40, 0x7E, 0x07,
  0x0F, 0xF0, 0xE1, 0xC7, 0x8E, 0x38, 0x38, 0xE7, 0x83, 0xDC, 0x70, 0x1D,
  0xCF, 0x01, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01,
  0xF8, 0xF8, 0x3F, 0x87, 0xFF, 0xBC, 0x3F, 0xF3, 0xC1, 0xFC, 0x1C, 0x39,
  0xDE, 0xE7, 0x3B, 0xDC, 0xE7, 0x31, 0x80, 0x00, 0x00, 0x80, 0x00, 0xE0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x41, 0xC0,
  0x9C, 0x30, 0xEF, 0xCD, 0xFB, 0xFF, 0xFF, 0x1F, 0xFE, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x1D, 0xE0, 0x0F, 0x3C, 0x07, 0x8F, 0x83, 0xE1, 0xE0, 0x70,
  0x30, 0x08, 0x08, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0x3C, 0x1E, 0x0F, 0x0F, 0x8F, 0xC1, 0xE0, 0x40, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7B, 0xFF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xE3, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x38, 0x1E, 0x01, 0xE1, 0xE0,
  0x0F, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x78, 0x00, 0xF3,
  0x87, 0x87, 0x1C, 0x7C, 0x39, 0xE3, 0xF1, 0xCF, 0x1F, 0x1E, 0x70, 0xF8,
  0xF3, 0x83, 0x87, 0x1C, 0x00, 0x39, 0xE0, 0x03, 0xCF, 0x00, 0x1C, 0x78,
  0x01, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x03, 0x80, 0x78,
  0x1E, 0x0F, 0x80, 0xFD, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x0F,
  0xF0, 0x3F, 0xF0, 0x3F, 0x38, 0x0E, 0x3C, 0x04, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x1F, 0xFF, 0xDF,
  0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xC3, 0xE0, 0x30, 0x07, 0x01, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xC1, 0xF0, 0x08, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x08, 0x01, 0xF0, 0xFD, 0xFF,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0x70, 0x00, 0xF3, 0x80, 0x0F, 0x1C, 0x00, 0xF1, 0xE0, 0x0F, 0x0E, 0x00,
  0xF0, 0x70, 0x07, 0x03, 0x80, 0x70, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0E,
  0x03, 0x80, 0x70, 0x38, 0x03, 0x83, 0xC0, 0x3C, 0x1C, 0x01, 0xC1, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x80, 0x1F, 0x01, 0xF3, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xFE, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0xF8,
  0x03, 0xBF, 0xF0, 0x3F, 0xFF, 0xC1, 0xF8, 0x1F, 0x0F, 0x00, 0x78, 0x70,
  0x01, 0xC7, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xE0, 0x03, 0x8E, 0x00, 0x1C,
  0x70, 0x00, 0xE3, 0x80, 0x0F, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x83, 0x80,
  0x78, 0x1E, 0x0F, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x78, 0x3E, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0xE0, 0x70, 0x03,
  0xC1, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xF0, 0x07, 0x81,
  0xC0, 0x3C, 0x07, 0x81, 0xE0, 0x1F, 0x0F, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0x9F, 0x80, 0x78, 0x1F, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0x78,
  0x70, 0x01, 0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xF0,
  0x01, 0xC3, 0xC0, 0x0F, 0x07, 0x00, 0x78, 0x1F, 0x07, 0xC0, 0x3F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xFC, 0x07, 0xC1, 0xE0, 0x78, 0x07, 0x83, 0xC0, 0x1C, 0x3C,
  0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x0E,
  0x38, 0x00, 0x71, 0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x38, 0x03, 0xE1, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xF7, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0x83, 0xE0, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xF8, 0x08, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x03, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x03, 0xF0, 0x07, 0x80, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x30, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x08, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x20, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0,
  0x0F, 0xC3, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x03, 0x81, 0xE0, 0x07, 0x07,
  0x80, 0x0F, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0xF0, 0x0F, 0xF1, 0xE0,
  0xFF, 0xE3, 0x83, 0xFF, 0xCF, 0x0F, 0x07, 0x1E, 0x3C, 0x0E, 0x38, 0x70,
  0x1C, 0xF1, 0xE0, 0x79, 0xE3, 0xC0, 0xE3, 0xC7, 0x01, 0xC7, 0x0E, 0x03,
  0x8E, 0x1C, 0x0F, 0x1C, 0x38, 0x1E, 0x38, 0x70, 0x38, 0x70, 0xF0, 0x70,
  0xE1, 0xE1, 0xE1, 0xC1, 0xFF, 0xC3, 0x81, 0xFF, 0x07, 0x80, 0xF8, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0x78, 0x00, 0x39, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x03,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x03, 0x80, 0x3C, 0x0E, 0x00,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x70, 0x00, 0x71,
  0xC0, 0x01, 0xCF, 0x00, 0x07, 0x38, 0x00, 0x1D, 0xE0, 0x00, 0x77, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x07, 0x8F, 0xF0, 0x1E, 0x01, 0xE0, 0x38, 0x01, 0xE0, 0x70, 0x03,
  0xC0, 0xE0, 0x07, 0x83, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x78,
  0x1C, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x07, 0x01, 0xF8, 0x1E, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x70,
  0x01, 0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xE0, 0x0F, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xE1, 0xF0, 0x1E, 0x00, 0x40, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x06,
  0x00, 0xF8, 0x7C, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xBF, 0xC0, 0x1C, 0x07,
  0xC0, 0x38, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0F,
  0x07, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xF0,
  0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x78, 0xF0, 0x00, 0xE1, 0xC0, 0x03, 0xC3, 0x80,
  0x07, 0x07, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x38, 0x01, 0xE0, 0x70, 0x07,
  0xC0, 0xE0, 0x3F, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7E, 0x0F,
  0x03, 0xE0, 0x08, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0xF3,
  0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80,
  0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xE0, 0x0E,
  0x07, 0xC0, 0x38, 0x0F, 0xC3, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0xF0, 0x01,
  0xE0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x1E, 0x00,
  0x3C, 0x0F, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x03, 0xC0,
  0x07, 0x81, 0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07,
  0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x40, 0x0F, 0x01,
  0x80, 0x78, 0x0F, 0xC7, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x0F, 0x81, 0xC0, 0x0F, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x0F, 0x00,
  0x0E, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x9F, 0x00, 0x03, 0x9E, 0x00,
  0x01, 0xDE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x03, 0xC0, 0x70, 0x01, 0xC0,
  0x3C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x78, 0x01, 0xC0, 0x38,
  0x00, 0xF0, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0xEC, 0x03, 0x30, 0x66,
  0x03, 0x98, 0x77, 0x01, 0xCC, 0x33, 0x80, 0xE6, 0x39, 0xC0, 0xE3, 0x98,
  0xE0, 0x71, 0xDC, 0x70, 0x38, 0xFC, 0x70, 0x38, 0x7C, 0x38, 0x1C, 0x3E,
  0x1C, 0x0E, 0x1E, 0x0E, 0x07, 0x0F, 0x07, 0x07, 0x00, 0x07, 0x03, 0x80,
  0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70,
  0x00, 0x78, 0x78, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x03, 0x80, 0xF0, 0x01,
  0xC0, 0x7C, 0x00, 0xE0, 0x7E, 0x00, 0xF0, 0x3F, 0x00, 0x70, 0x1F, 0x80,
  0x38, 0x0E, 0xE0, 0x1C, 0x06, 0x70, 0x0E, 0x07, 0x38, 0x0E, 0x03, 0x8E,
  0x07, 0x01, 0xC7, 0x03, 0x80, 0xE3, 0x81, 0xC0, 0xE1, 0xC1, 0xC0, 0x70,
  0x70, 0xE0, 0x38, 0x38, 0x70, 0x1C, 0x1C, 0x38, 0x1C, 0x0E, 0x38, 0x0E,
  0x03, 0x1C, 0x07, 0x01, 0xCE, 0x03, 0x80, 0xE7, 0x03, 0x80, 0x77, 0x01,
  0xC0, 0x1B, 0x80, 0xE0, 0x0D, 0xC0, 0x70, 0x07, 0xE0, 0x70, 0x03, 0xE0,
  0x38, 0x01, 0xF0, 0x1C, 0x00, 0xF8, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7C, 0x3C,
  0x03, 0xC0, 0x78, 0x1E, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x0F, 0x1E,
  0x00, 0x3C, 0x70, 0x00, 0xF3, 0xC0, 0x03, 0xCE, 0x00, 0x0F, 0x38, 0x00,
  0x39, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x79,
  0xC0, 0x01, 0xCF, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0xE3, 0xC0,
  0x03, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xF0, 0x03, 0x81, 0xC0, 0x1E,
  0x07, 0x80, 0xF0, 0x0F, 0x8F, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3E, 0x3F, 0x80,
  0xE0, 0x0F, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0,
  0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xF0, 0x03, 0xC3, 0x80, 0x0E,
  0x0E, 0x00, 0x78, 0x38, 0x03, 0xC1, 0xE0, 0x3E, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7C, 0x3C, 0x03, 0xC0,
  0x78, 0x1E, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x0F, 0x1E, 0x00, 0x3C,
  0x70, 0x00, 0xF3, 0xC0, 0x03, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x3D, 0xE0,
  0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0xE3, 0xC0, 0x03, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0x70, 0xF0, 0x03, 0x81, 0xC0, 0x1E, 0x07, 0x80,
  0xF0, 0x0F, 0x8F, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xD0, 0x00,
  0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x07, 0xC7, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x70,
  0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0E, 0x00,
  0x3C, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xF0, 0x03, 0x81, 0xE0, 0x1E,
  0x03, 0x87, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3C, 0x1C, 0x00,
  0x70, 0x3C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x38, 0x01, 0xC0, 0xF0, 0x03, 0x81, 0xC0,
  0x07, 0x83, 0x80, 0x0F, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xC1, 0xE0, 0x1E, 0x00, 0x40, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x81, 0x80,
  0x1F, 0x03, 0xE1, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x01, 0x70,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x3C, 0x00,
  0x78, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x80, 0x0F,
  0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xC0,
  0x70, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0xF0, 0xFC, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xEE,
  0x00, 0x07, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0x8E, 0x00,
  0x1E, 0x38, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x70,
  0x38, 0x01, 0xC0, 0xF0, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x3C,
  0x0F, 0x00, 0xF0, 0x38, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00,
  0x77, 0x80, 0x01, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x07,
  0x03, 0x83, 0x83, 0x81, 0xC3, 0xC1, 0xC1, 0xC3, 0xE1, 0xC0, 0xE1, 0xF0,
  0xE0, 0x71, 0xD8, 0x70, 0x38, 0xCC, 0x30, 0x1C, 0xE6, 0x38, 0x0C, 0x63,
  0x1C, 0x0E, 0x71, 0xCC, 0x07, 0x70, 0xEE, 0x03, 0xB8, 0x77, 0x01, 0xB8,
  0x3B, 0x00, 0xD8, 0x1D, 0x80, 0x7C, 0x0F, 0xC0, 0x3C, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x01,
  0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00,
  0x38, 0x07, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C,
  0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x03, 0x80, 0xF0,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x79, 0xC0, 0x01, 0xE3,
  0x80, 0x03, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0xF0, 0x1C,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x1E, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0xE0, 0x01, 0xC3, 0x80, 0x01, 0xCF, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xE3, 0x8E,
  0x38, 0xE3, 0xCF, 0x3C, 0xF3, 0xCF, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x3C, 0xF3,
  0xCF, 0x3C, 0x71, 0xC7, 0x1C, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xEE, 0x00,
  0xF1, 0xC0, 0x38, 0x70, 0x1C, 0x1C, 0x0F, 0x07, 0x07, 0x80, 0xE3, 0xC0,
  0x38, 0xE0, 0x0E, 0x70, 0x01, 0xFC, 0x00, 0x76, 0x00, 0x1C, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x20, 0xC3, 0xC3, 0xC3, 0x87,
  0x87, 0x87, 0x04, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C,
  0x0F, 0x0F, 0x00, 0xE1, 0xE0, 0x0E, 0x3C, 0x00, 0xE7, 0x80, 0x1E, 0x78,
  0x01, 0xC7, 0x00, 0x1C, 0xF0, 0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0x8E,
  0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xF0, 0x0F, 0x07, 0x87, 0xF0, 0x3F, 0xFB, 0x81, 0xFE, 0x38, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0x01, 0xE0, 0xE0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x07, 0x1C, 0x00,
  0x71, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x0F, 0x38, 0x00, 0xE3, 0x80,
  0x0E, 0x78, 0x01, 0xE7, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x78, 0xF0,
  0x0F, 0x0E, 0x03, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0xFB, 0xE0, 0xF8, 0x02, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x01, 0x07,
  0xE0, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xC0, 0x70, 0x0F, 0x80, 0x70, 0x1E, 0x00,
  0xF0, 0x1C, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x78, 0x01,
  0xE0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0xF0, 0x03,
  0xC0, 0xF0, 0x03, 0x80, 0xF0, 0x03, 0x80, 0xF0, 0x03, 0x80, 0xF0, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0x7C, 0x3F, 0x80, 0x3F, 0xFB, 0x80, 0x1F, 0xF3,
  0xC0, 0x01, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0,
  0xF8, 0x0E, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x00, 0xE7, 0x80, 0x0E,
  0x70, 0x01, 0xEF, 0x00, 0x7C, 0xE3, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x01, 0x07, 0xF3, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFC, 0x20, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x07, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xC0, 0xF0, 0x3E, 0x01, 0xC0,
  0xF8, 0x03, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x3C,
  0x00, 0x70, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x80,
  0x0E, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x3C, 0x07,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xDC, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x81, 0x00, 0x1E, 0x03,
  0x80, 0x7C, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0x00, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x1E, 0x00, 0x71, 0xC0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x0E,
  0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0x80, 0x1C, 0x78, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0xF0, 0x03, 0x80, 0x00,
  0xE0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x78, 0x03, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x01, 0xF0, 0x78, 0x07, 0x80, 0xE0, 0x1E, 0x01, 0xC0, 0x78,
  0x03, 0x83, 0xE0, 0x0F, 0x0F, 0x00, 0x1C, 0x7C, 0x00, 0x39, 0xF0, 0x00,
  0x77, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x78, 0x00, 0x0E,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x70, 0x78, 0x00, 0xE0, 0x78, 0x01, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x38, 0x01,
  0xE0, 0xF0, 0x01, 0xC0, 0x7F, 0xCF, 0xFC, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x17,
  0xC7, 0x3F, 0xF1, 0xFF, 0x02, 0x00, 0x03, 0xF9, 0xF8, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x70, 0xF0, 0xF0, 0xE0, 0xE1, 0xE1, 0xC1, 0xC3, 0xC3,
  0x87, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70,
  0xF0, 0xE1, 0xE1, 0xC1, 0xC3, 0x83, 0x83, 0x87, 0x07, 0x0F, 0x0E, 0x00,
  0x1C, 0x3C, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xE1, 0xC0, 0x03,
  0x87, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0x00, 0xF0, 0xE0, 0x0E, 0x3C, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x03,
  0x9C, 0x00, 0xF3, 0x80, 0x1C, 0x70, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x1E,
  0x70, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0x79,
  0xC0, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8,
  0x1E, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0x73, 0x80, 0x07, 0x78,
  0x00, 0x77, 0x80, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78,
  0x78, 0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x01,
  0xE0, 0x78, 0x03, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x0E,
  0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xF0, 0xF0, 0x01, 0xC1,
  0xE0, 0x07, 0x83, 0x80, 0x0E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0xF0, 0x3C,
  0x03, 0xE0, 0x70, 0x1F, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x0E, 0x40, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0x80, 0xE0,
  0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x78, 0x00,
  0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x78,
  0x01, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x80, 0x3C,
  0x1E, 0x03, 0xC0, 0xF8, 0x7E, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x04,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x78,
  0x02, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x60, 0x07, 0x07, 0x83, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x9F, 0x03, 0xFF,
  0x80, 0xFF, 0x80, 0x08, 0x00, 0x1E, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00,
  0x71, 0xC0, 0x0F, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80,
  0x1E, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x70,
  0x03, 0x8F, 0x00, 0x38, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0x70, 0x70, 0x1F, 0x07, 0xC7, 0xF8, 0x3F, 0xFB, 0x81, 0xFE, 0x38,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0x3C,
  0x01, 0xCF, 0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x1E, 0x1C, 0x07, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x70, 0x1C, 0x3C, 0x07, 0x0E, 0x01, 0xE7, 0x00,
  0x7B, 0xC0, 0x0E, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x7B, 0xC0,
  0x00, 0xE7, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x9C, 0x0E, 0x0E, 0x38, 0x3C,
  0x1C, 0x70, 0x78, 0x70, 0xE1, 0xF0, 0xE1, 0xC3, 0xE1, 0xC3, 0x8F, 0xC7,
  0x07, 0x39, 0x8E, 0x0E, 0x63, 0x38, 0x1D, 0xC6, 0x70, 0x7B, 0x0F, 0xE0,
  0xEE, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x1C, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x03, 0x87,
  0x80, 0x01, 0xE7, 0x80, 0x00, 0x77, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xC3, 0xC0, 0x03,
  0xC0, 0xE0, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x0F, 0x07,
  0xC0, 0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x01,
  0xE0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0x70, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x3C, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x01,
  0xC3, 0xC0, 0x00, 0xF1, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x10, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x02, 0x00, 0x01, 0xFC, 0x03, 0x3F, 0xE0, 0x77, 0x8F, 0x8E,
  0x70, 0x7F, 0xEE, 0x03, 0xFC, 0x20, 0x0F, 0x00,
};

const GFXglyph UbuntuSansMono_Italic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 10, 30, 24, 7, -29 },
  { 39, 12, 11, 24, 9, -32 },
  { 56, 25, 29, 24, 0, -29 },
  { 147, 21, 38, 24, 2, -33 },
  { 247, 28, 31, 24, -1, -30 },
  { 356, 20, 30, 24, 1, -30 },
  { 431, 5, 12, 24, 13, -32 },
  { 439, 18, 41, 24, 5, -33 },
  { 532, 18, 41, 24, 1, -33 },
  { 625, 18, 17, 24, 5, -29 },
  { 664, 19, 21, 24, 3, -23 },
  { 714, 10, 13, 24, 3, -6 },
  { 731, 10, 3, 24, 7, -13 },
  { 735, 6, 7, 24, 7, -6 },
  { 741, 27, 41, 24, -3, -33 },
  { 880, 21, 31, 24, 2, -30 },
  { 962, 17, 29, 24, 3, -29 },
  { 1024, 21, 30, 24, 2, -30 },
  { 1103, 21, 31, 24, 1, -30 },
  { 1185, 21, 29, 24, 1, -29 },
  { 1262, 23, 30, 24, 1, -29 },
  { 1349, 21, 30, 24, 3, -29 },
  { 1428, 21, 29, 24, 5, -29 },
  { 1505, 22, 31, 24, 2, -30 },
  { 1591, 21, 30, 24, 2, -30 },
  { 1670, 10, 22, 24, 7, -21 },
  { 1698, 14, 28, 24, 3, -21 },
  { 1747, 20, 18, 24, 2, -21 },
  { 1792, 22, 12, 24, 1, -18 },
  { 1825, 21, 18, 24, 1, -21 },
  { 1873, 16, 31, 24, 6, -30 },
  { 1935, 23, 36, 24, 2, -30 },
  { 2039, 22, 29, 24, -2, -29 },
  { 2119, 23, 29, 24, 0, -29 },
  { 2203, 23, 31, 24, 2, -30 },
  { 2293, 23, 29, 24, 0, -29 },
  { 2377, 23, 29, 24, 2, -29 },
  { 2461, 23, 29, 24, 2, -29 },
  { 2545, 22, 31, 24, 2, -30 },
  { 2631, 25, 29, 24, 0, -29 },
  { 2722, 21, 29, 24, 2, -29 },
  { 2799, 22, 30, 24, 2, -29 },
  { 2882, 25, 29, 24, 1, -29 },
  { 2973, 17, 29, 24, 1, -29 },
  { 3035, 25, 29, 24, -1, -29 },
  { 3126, 25, 29, 24, 0, -29 },
  { 3217, 22, 31, 24, 2, -30 },
  { 3303, 22, 29, 24, 1, -29 },
  { 3383, 22, 38, 24, 2, -30 },
  { 3488, 23, 29, 24, 0, -29 },
  { 3572, 23, 31, 24, 1, -30 },
  { 3662, 20, 29, 24, 6, -29 },
  { 3735, 23, 30, 24, 2, -29 },
  { 3822, 22, 29, 24, 5, -29 },
  { 3902, 25, 29, 24, 1, -29 },
  { 3993, 28, 29, 24, -1, -29 },
  { 4095, 23, 29, 24, 5, -29 },
  { 4179, 25, 29, 24, 0, -29 },
  { 4270, 21, 41, 24, 3, -33 },
  { 4378, 6, 41, 24, 9, -33 },
  { 4409, 20, 41, 24, 0, -33 },
  { 4512, 18, 15, 24, 4, -29 },
  { 4546, 22, 3, 24, -3, 5 },
  { 4555, 7, 9, 24, 11, -33 },
  { 4563, 20, 23, 24, 2, -22 },
  { 4621, 20, 33, 24, 2, -33 },
  { 4704, 20, 23, 24, 2, -22 },
  { 4762, 24, 34, 24, 2, -33 },
  { 4864, 20, 23, 24, 2, -22 },
  { 4922, 27, 41, 24, -1, -33 },
  { 5061, 23, 30, 24, 0, -22 },
  { 5148, 20, 33, 24, 0, -33 },
  { 5231, 13, 32, 24, 5, -32 },
  { 5283, 22, 40, 24, 0, -32 },
  { 5393, 23, 33, 24, 1, -33 },
  { 5488, 12, 33, 24, 7, -32 },
  { 5538, 23, 22, 24, 0, -22 },
  { 5602, 19, 22, 24, 2, -22 },
  { 5655, 20, 22, 24, 2, -22 },
  { 5710, 23, 30, 24, -1, -22 },
  { 5797, 21, 30, 24, 2, -22 },
  { 5876, 20, 22, 24, 3, -22 },
  { 5931, 20, 23, 24, 2, -22 },
  { 5989, 17, 30, 24, 5, -29 },
  { 6053, 20, 22, 24, 2, -22 },
  { 6108, 18, 22, 24, 5, -22 },
  { 6158, 23, 22, 24, 2, -22 },
  { 6222, 25, 22, 24, -1, -22 },
  { 6291, 25, 30, 24, -2, -22 },
  { 6385, 21, 22, 24, 1, -22 },
  { 6443, 23, 41, 24, 2, -33 },
  { 6561, 13, 41, 24, 6, -33 },
  { 6628, 23, 41, 24, -2, -33 },
  { 6746, 20, 7, 24, 2, -16 },
};

const GFXfont UbuntuSansMono_Italic42pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic42pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic42pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _UBUNTUSANSMONO_ITALIC42PT7B_H_
