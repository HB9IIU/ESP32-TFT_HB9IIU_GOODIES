#ifndef _UBUNTUSANSMONO_ITALIC37PT7B_H_
#define _UBUNTUSANSMONO_ITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07,
  0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x03, 0xE1, 0xF0, 0xF8, 0x78, 0x00, 0x30, 0xEE, 0x19, 0xC3, 0x30,
  0xE6, 0x1C, 0xC3, 0x38, 0x66, 0x0C, 0xC1, 0x10, 0x60, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x70, 0x01,
  0xC1, 0xC0, 0x07, 0x06, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE0, 0x1C, 0x1C, 0x00, 0x60, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00,
  0x70, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x0E, 0x01, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x07, 0x07, 0x00, 0x18, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x60, 0x03, 0x83, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0x80,
  0xFF, 0xF8, 0x3E, 0x06, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x40, 0x1E, 0x1F, 0x3F, 0x83, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x07, 0x03, 0xF0, 0x06, 0x07, 0x38,
  0x0E, 0x06, 0x18, 0x1C, 0x0E, 0x18, 0x38, 0x0C, 0x38, 0x70, 0x0C, 0x38,
  0xE0, 0x0C, 0x39, 0xC0, 0x0C, 0x31, 0x80, 0x0C, 0x73, 0x80, 0x0E, 0xE7,
  0x00, 0x0F, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x33,
  0xE0, 0x00, 0x67, 0xF0, 0x00, 0xEE, 0x30, 0x01, 0xCC, 0x30, 0x03, 0x8C,
  0x30, 0x07, 0x1C, 0x30, 0x0E, 0x1C, 0x30, 0x0C, 0x18, 0x30, 0x18, 0x18,
  0x70, 0x38, 0x1C, 0x60, 0x70, 0x1C, 0xE0, 0xE0, 0x0F, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0xF1, 0xC0, 0x70, 0x60, 0x70, 0x30,
  0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x8E, 0x01, 0xDE,
  0x00, 0x7E, 0x00, 0x7C, 0x18, 0x7E, 0x1C, 0x73, 0x8E, 0x71, 0xC6, 0x70,
  0x77, 0x38, 0x3F, 0xB8, 0x0F, 0x9C, 0x03, 0xCE, 0x01, 0xC7, 0x01, 0xF3,
  0xC1, 0xF8, 0xF1, 0xFC, 0x7F, 0xEF, 0x1F, 0xC3, 0x80, 0x39, 0xDC, 0xE7,
  0x39, 0x8C, 0xE6, 0x30, 0x00, 0x04, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0x80, 0x02, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x41, 0x82, 0x71, 0x8E, 0x7F, 0xBF, 0xFF, 0xFE,
  0x03, 0xC0, 0x03, 0xE0, 0x07, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x3C, 0x3C,
  0x08, 0x18, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x0F, 0x87, 0xE3, 0xF1, 0xF0, 0x38,
  0x3C, 0x3C, 0xFC, 0x78, 0x30, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x21, 0xEF,
  0xBF, 0xFB, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0xC0, 0x3E, 0xF8, 0x1E, 0x0E, 0x0F, 0x01, 0xC3, 0x80,
  0x71, 0xC0, 0x1C, 0x70, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x77, 0x8E, 0x1D,
  0xC7, 0xC7, 0x71, 0xF3, 0x9C, 0x7C, 0xEF, 0x1E, 0x3B, 0x80, 0x0E, 0xE0,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x0F,
  0x0F, 0x03, 0x81, 0xE3, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x3F, 0x03, 0xF8, 0x3F, 0xE0, 0xF3,
  0x83, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0xFF, 0xE0, 0xFC, 0xF8, 0x18, 0x0F, 0x04, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0x1F, 0x00, 0x80, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC3, 0x81, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x1E, 0xE0, 0x0F, 0x38, 0x07, 0x8C, 0x01, 0xC7, 0x00, 0xE1,
  0xC0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x80, 0xE1,
  0xC0, 0x38, 0x70, 0x1C, 0x3F, 0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x06, 0x07,
  0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x07, 0xF0, 0x07, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x8E, 0x01, 0xDF, 0xF0,
  0x7F, 0xFE, 0x1E, 0x07, 0x8E, 0x00, 0xF3, 0x80, 0x1C, 0xE0, 0x07, 0x38,
  0x01, 0xCE, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x01,
  0xC3, 0xC1, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x60, 0x00, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0x0F, 0x03, 0xC0, 0xE0, 0xF0, 0x0E,
  0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x78,
  0x3C, 0x1E, 0x03, 0xC7, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x07, 0x8F, 0x81,
  0xC0, 0x78, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E,
  0x00, 0x71, 0xC0, 0x1E, 0x38, 0x03, 0x87, 0x81, 0xE0, 0x7F, 0xF8, 0x07,
  0xFE, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0x0F,
  0x07, 0x80, 0xE0, 0xE0, 0x1C, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07,
  0x1C, 0x00, 0xE7, 0x00, 0x38, 0xF0, 0x07, 0x0E, 0x00, 0xE1, 0xE0, 0x3C,
  0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0x9C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x02, 0x07, 0x87, 0xE3, 0xF1,
  0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0xF0, 0xF8, 0x7E, 0x3E, 0x1F, 0x00, 0x00, 0x40, 0x1E, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF0,
  0x07, 0x00, 0xF0, 0x1E, 0x0F, 0xC0, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x70, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x04, 0x00,
  0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xF0,
  0x08, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x03, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x30, 0xF0, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x7E, 0x7C,
  0x07, 0xC0, 0xE0, 0x38, 0x07, 0x03, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0,
  0x07, 0x1C, 0x03, 0xF0, 0xE0, 0xFF, 0x8E, 0x0F, 0xFC, 0x70, 0xE0, 0xE3,
  0x8E, 0x0E, 0x38, 0xF0, 0x71, 0xC7, 0x03, 0x8E, 0x38, 0x1C, 0x71, 0xC0,
  0xC3, 0x8E, 0x0E, 0x3C, 0x70, 0x71, 0xC3, 0x83, 0x8E, 0x1C, 0x18, 0x38,
  0xF1, 0xC1, 0xC3, 0xFE, 0x0E, 0x07, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x80, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0C, 0xC0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70,
  0xE0, 0x06, 0x0E, 0x00, 0xE0, 0xE0, 0x0C, 0x0E, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x06, 0x00, 0x60, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE1, 0xC0, 0x06, 0x18, 0x00, 0x73, 0x80, 0x07, 0x30, 0x00, 0x77,
  0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0x01, 0xFF, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x38, 0x0F, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00,
  0x70, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x03, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1C, 0x03, 0xC1, 0xC0, 0x1C, 0x18,
  0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x30, 0x01, 0xC7,
  0x00, 0x38, 0x70, 0x07, 0x87, 0x03, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xF9, 0xF0, 0x3C, 0x02, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x02, 0x03, 0xC0, 0xE0,
  0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0xC0, 0x70, 0x3C, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x06,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x18, 0x00, 0x63, 0x80, 0x0E,
  0x38, 0x00, 0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x38, 0x70, 0x07,
  0x87, 0x00, 0xF0, 0x70, 0x1E, 0x0F, 0x1F, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x1F, 0xFC, 0x0F, 0xC7, 0x83, 0xC0, 0x20, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE7, 0x00,
  0x1C, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0xE1, 0xE0, 0x1C, 0x1E, 0x03, 0x83, 0xE0, 0x70, 0x3F, 0xFC, 0x01, 0xFF,
  0x80, 0x04, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01,
  0xC1, 0xC0, 0x06, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x83,
  0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xC0, 0x0E, 0x06, 0x00, 0x38,
  0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0C, 0x00, 0x70, 0x70,
  0x01, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x03,
  0x03, 0x80, 0x1C, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xFF, 0xF8,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x10, 0x0F, 0x07, 0x03, 0xC0,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x07,
  0x00, 0x78, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x70, 0x01, 0xC1, 0xC0, 0x03, 0x8F, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xF0,
  0x00, 0x3B, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x30, 0x70, 0x00,
  0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x06, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x07, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFF, 0xFD, 0xFF, 0xF8,
  0x00, 0xE0, 0x0C, 0x03, 0x80, 0x70, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x01,
  0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x37, 0x0D, 0xC0, 0xDC, 0x36, 0x03, 0x31,
  0x98, 0x1C, 0xCE, 0x60, 0x63, 0x31, 0x81, 0x8D, 0xCE, 0x0E, 0x36, 0x38,
  0x38, 0xF0, 0xC0, 0xC3, 0xC3, 0x07, 0x0E, 0x1C, 0x1C, 0x00, 0x70, 0x60,
  0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x38, 0x00, 0xE0, 0xC0, 0x03,
  0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xC3, 0x80, 0x07, 0x00,
  0x03, 0xC0, 0x0C, 0x0F, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0xF0, 0x07, 0x07,
  0xE0, 0x18, 0x1F, 0x80, 0xE0, 0x76, 0x03, 0x81, 0x9C, 0x0E, 0x0E, 0x70,
  0x30, 0x38, 0xC1, 0xC0, 0xE3, 0x07, 0x03, 0x0E, 0x1C, 0x0C, 0x38, 0x60,
  0x70, 0x61, 0x81, 0xC1, 0x8E, 0x06, 0x07, 0x38, 0x18, 0x1C, 0xC0, 0xE0,
  0x33, 0x03, 0x80, 0xDC, 0x0E, 0x03, 0x70, 0x30, 0x0F, 0xC1, 0xC0, 0x3E,
  0x07, 0x00, 0xF8, 0x1C, 0x01, 0xE0, 0x60, 0x07, 0x83, 0x80, 0x1C, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0x1F, 0x03, 0xC0, 0xE0, 0xE0, 0x1C,
  0x1C, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1D,
  0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0D, 0xC0, 0x03, 0xB8, 0x00, 0x77,
  0x00, 0x0E, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0x8E,
  0x00, 0xF1, 0xC0, 0x1C, 0x1C, 0x07, 0x03, 0xC3, 0xC0, 0x3F, 0xF0, 0x03,
  0xFC, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0x70, 0x1E, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x60, 0xE0, 0x0E, 0x0C, 0x00, 0xE1, 0xC0, 0x1C, 0x1C,
  0x03, 0x81, 0xC3, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0xF0, 0x0F, 0x1F, 0x03, 0xC0, 0xE0, 0xE0, 0x1C, 0x1C, 0x01,
  0xC7, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1D, 0xC0, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x0D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E,
  0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0x8E, 0x00, 0xF1,
  0xC0, 0x1C, 0x1C, 0x07, 0x03, 0xC3, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x38, 0x0F, 0x03, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70,
  0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x0E,
  0x03, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1C, 0x1C, 0x03,
  0x81, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0x70,
  0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x8E, 0x00, 0x38, 0x00, 0x7F,
  0xC0, 0x1F, 0xFF, 0x03, 0xFB, 0xE0, 0x38, 0x02, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x40, 0x0F, 0x07, 0x03, 0xE0, 0xFF, 0xFC,
  0x07, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00,
  0x71, 0xC0, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0x80,
  0x0E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x70,
  0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x03, 0x0E,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x00, 0xE0,
  0x70, 0x1C, 0x07, 0x83, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x02, 0x00,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0,
  0x01, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0xE0, 0x60, 0x0C, 0x06, 0x01, 0xC0, 0x70, 0x38, 0x07, 0x03, 0x80,
  0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xC0,
  0x07, 0x18, 0x00, 0x73, 0x80, 0x07, 0x70, 0x00, 0x77, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0,
  0x03, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x60, 0x01, 0xC3, 0x87, 0x06,
  0x0E, 0x1C, 0x38, 0x38, 0xF0, 0xE0, 0xC7, 0xC3, 0x03, 0x1B, 0x1C, 0x0C,
  0xEE, 0x70, 0x73, 0x39, 0x81, 0xDC, 0x66, 0x06, 0x61, 0xB8, 0x1B, 0x86,
  0xC0, 0x6C, 0x1B, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x80, 0xF0, 0x07,
  0x80, 0x38, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x03, 0x83,
  0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x1D,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x1C, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x78, 0x00, 0xE0,
  0x78, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x70,
  0x01, 0xCE, 0x00, 0x78, 0xC0, 0x0E, 0x1C, 0x03, 0x83, 0x80, 0xE0, 0x70,
  0x3C, 0x06, 0x07, 0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x01, 0x8C, 0x00, 0x3B,
  0x80, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x10, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x79, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x70, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1D, 0xC0, 0x1C, 0x60,
  0x1C, 0x38, 0x1E, 0x1C, 0x0E, 0x06, 0x0E, 0x03, 0x8E, 0x01, 0xCE, 0x00,
  0x6F, 0x00, 0x39, 0x00, 0x10, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x43, 0x8E, 0x1C, 0x38, 0xE1, 0xC2, 0x00, 0x07, 0x00, 0x1F, 0xFC,
  0x0F, 0xFF, 0x03, 0xE0, 0xE0, 0xF0, 0x1C, 0x3C, 0x03, 0x8F, 0x00, 0xE1,
  0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x03, 0x86,
  0x00, 0x71, 0xC0, 0x0E, 0x18, 0x01, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0F,
  0x07, 0xC0, 0xFF, 0xD8, 0x0F, 0xF3, 0x80, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xCE, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0x03,
  0xC3, 0x80, 0x70, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71,
  0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0xC0,
  0x1C, 0x70, 0x0F, 0x1C, 0x0F, 0x87, 0x0F, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x3E, 0x01, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x01, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0x81, 0x81, 0xF0, 0x38, 0x1C, 0x03, 0x83,
  0x80, 0x38, 0x78, 0x03, 0x87, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E,
  0x0F, 0x01, 0xE0, 0x78, 0x7E, 0x07, 0xFF, 0xE0, 0x1F, 0xCE, 0x00, 0x00,
  0x18, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3E, 0x0F, 0x1E, 0x01, 0xC7, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x70, 0x07, 0x9C, 0x0F, 0xC7, 0xFF, 0xE3,
  0xFF, 0xC0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x83, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0x07, 0x03, 0xC0, 0x70, 0x78, 0x0E, 0x0F,
  0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x18, 0x01, 0xC3,
  0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x18, 0x38, 0x03, 0x83, 0x80, 0x38,
  0x1E, 0x1F, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x0C, 0x03, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xCC, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0x07, 0x83, 0x80, 0xF0,
  0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70,
  0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1C, 0x70, 0x07,
  0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x38, 0xE0, 0x0E, 0x00, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0xFF, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xF9, 0x07, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x04, 0x07, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x01, 0x06, 0x01, 0xE0,
  0xE0, 0x3C, 0x0E, 0x07, 0x80, 0xE0, 0xF0, 0x0E, 0x3C, 0x01, 0xC7, 0x80,
  0x1D, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xBC, 0x00, 0x39, 0xE0,
  0x03, 0x8F, 0x00, 0x38, 0x70, 0x07, 0x03, 0x80, 0x70, 0x3C, 0x07, 0x01,
  0xC0, 0x70, 0x0E, 0x06, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x7F, 0x8F, 0xF3,
  0xFE, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE1, 0x1F, 0xF3,
  0xFE, 0x00, 0xC0, 0x80, 0xFF, 0x7E, 0x0F, 0xFF, 0xF0, 0xE3, 0xC7, 0x0C,
  0x38, 0x71, 0xC3, 0x87, 0x1C, 0x38, 0x71, 0xC3, 0x06, 0x18, 0x70, 0xE3,
  0x87, 0x0E, 0x38, 0x70, 0xE3, 0x87, 0x0C, 0x30, 0xE1, 0xC7, 0x00, 0x1C,
  0x70, 0x01, 0xC7, 0x00, 0x18, 0x60, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03,
  0x8E, 0x00, 0x30, 0x00, 0x30, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x38, 0x1E,
  0x0E, 0x03, 0xC3, 0x80, 0x70, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0x71, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80,
  0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x38,
  0x00, 0x30, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xE0, 0xF1, 0xE0, 0x39, 0xE0,
  0x1C, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x3D, 0xC0, 0x3C, 0xF0, 0x3C,
  0x3C, 0x7E, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0xE0, 0x38, 0x0F, 0x03, 0x80, 0x70, 0x30, 0x07, 0x07, 0x00,
  0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x01, 0xC1, 0xC0, 0x3C, 0x1C,
  0x07, 0x81, 0xC3, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0x3E, 0x07,
  0x1E, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x0E, 0x70, 0x07, 0x1C,
  0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x38, 0xF0, 0x1C, 0x1C, 0x1F, 0x07, 0xFF, 0xC0, 0xFF, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0xE0, 0x20, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x40,
  0x1C, 0x38, 0x1E, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x7F, 0xFF, 0x7F, 0xFE, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1E, 0x0C, 0x1F, 0xF8, 0x1F, 0xE0, 0x1C, 0x01, 0xCE, 0x00, 0xE3,
  0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8C, 0x01, 0xC7, 0x00, 0x71, 0xC0,
  0x1C, 0x70, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E,
  0x38, 0x03, 0x0E, 0x00, 0xC3, 0x80, 0xF0, 0x70, 0x7C, 0x1F, 0xFB, 0x03,
  0xFC, 0xE0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0x70, 0x0C,
  0x70, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x70, 0x30, 0x70, 0x70, 0x70, 0xE0,
  0x70, 0xE0, 0x71, 0xC0, 0x31, 0x80, 0x3B, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x67,
  0x00, 0x0E, 0x70, 0x00, 0xE7, 0x0E, 0x0C, 0x60, 0xE1, 0xC6, 0x1E, 0x1C,
  0xE1, 0xE3, 0x8E, 0x3E, 0x38, 0xE7, 0x63, 0x0E, 0x67, 0x70, 0xEE, 0x77,
  0x0E, 0xC7, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x00, 0x07, 0x80, 0x3C, 0x0F, 0x01, 0xC0, 0x1C, 0x0F,
  0x00, 0x78, 0x78, 0x00, 0xE3, 0xC0, 0x03, 0xDE, 0x00, 0x07, 0x70, 0x00,
  0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3B,
  0x80, 0x01, 0xCE, 0x00, 0x0E, 0x3C, 0x00, 0x70, 0x70, 0x03, 0x81, 0xC0,
  0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x0F, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1E,
  0x07, 0x00, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x01,
  0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0C,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x02, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x87, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0x0C, 0x01, 0x0F,
  0xE0, 0x77, 0xFC, 0x39, 0x87, 0xFE, 0xE0, 0x7F, 0x10, 0x0F, 0x00,
};

const GFXglyph UbuntuSansMono_Italic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 9, 26, 21, 6, -26 },
  { 31, 11, 10, 21, 8, -28 },
  { 45, 22, 26, 21, 0, -26 },
  { 117, 19, 33, 21, 2, -29 },
  { 196, 24, 27, 21, -1, -26 },
  { 277, 17, 26, 21, 1, -26 },
  { 333, 5, 11, 21, 11, -28 },
  { 340, 15, 36, 21, 5, -29 },
  { 408, 15, 36, 21, 1, -29 },
  { 476, 16, 15, 21, 4, -26 },
  { 506, 17, 18, 21, 2, -20 },
  { 545, 9, 11, 21, 3, -5 },
  { 558, 9, 3, 21, 6, -12 },
  { 562, 6, 6, 21, 6, -6 },
  { 567, 23, 36, 21, -2, -29 },
  { 671, 18, 27, 21, 2, -26 },
  { 732, 14, 26, 21, 3, -26 },
  { 778, 18, 26, 21, 2, -26 },
  { 837, 19, 27, 21, 1, -26 },
  { 902, 18, 26, 21, 1, -26 },
  { 961, 20, 27, 21, 1, -26 },
  { 1029, 18, 27, 21, 3, -26 },
  { 1090, 19, 26, 21, 4, -26 },
  { 1152, 19, 27, 21, 2, -26 },
  { 1217, 19, 26, 21, 2, -26 },
  { 1279, 9, 20, 21, 6, -20 },
  { 1302, 12, 26, 21, 3, -20 },
  { 1341, 18, 17, 21, 2, -19 },
  { 1380, 19, 10, 21, 1, -16 },
  { 1404, 18, 17, 21, 1, -19 },
  { 1443, 15, 26, 21, 5, -26 },
  { 1492, 21, 31, 21, 1, -26 },
  { 1574, 20, 26, 21, -2, -26 },
  { 1639, 20, 26, 21, 0, -26 },
  { 1704, 20, 27, 21, 2, -26 },
  { 1772, 20, 26, 21, 0, -26 },
  { 1837, 20, 26, 21, 2, -26 },
  { 1902, 20, 26, 21, 2, -26 },
  { 1967, 19, 27, 21, 2, -26 },
  { 2032, 22, 26, 21, 0, -26 },
  { 2104, 18, 26, 21, 2, -26 },
  { 2163, 19, 27, 21, 2, -26 },
  { 2228, 23, 26, 21, 0, -26 },
  { 2303, 15, 26, 21, 1, -26 },
  { 2352, 22, 26, 21, -1, -26 },
  { 2424, 22, 26, 21, 0, -26 },
  { 2496, 19, 27, 21, 2, -26 },
  { 2561, 20, 26, 21, 1, -26 },
  { 2626, 19, 33, 21, 2, -26 },
  { 2705, 20, 26, 21, 0, -26 },
  { 2770, 20, 27, 21, 1, -26 },
  { 2838, 18, 26, 21, 5, -26 },
  { 2897, 20, 27, 21, 2, -26 },
  { 2965, 20, 26, 21, 4, -26 },
  { 3030, 22, 26, 21, 1, -26 },
  { 3102, 25, 26, 21, -1, -26 },
  { 3184, 19, 26, 21, 5, -26 },
  { 3246, 22, 26, 21, 0, -26 },
  { 3318, 18, 36, 21, 3, -29 },
  { 3399, 5, 36, 21, 8, -29 },
  { 3422, 18, 36, 21, 0, -29 },
  { 3503, 17, 14, 21, 3, -26 },
  { 3533, 20, 3, 21, -3, 4 },
  { 3541, 6, 8, 21, 10, -29 },
  { 3547, 19, 20, 21, 1, -20 },
  { 3595, 18, 29, 21, 1, -29 },
  { 3661, 18, 20, 21, 1, -20 },
  { 3706, 20, 29, 21, 2, -29 },
  { 3779, 18, 20, 21, 1, -20 },
  { 3824, 24, 36, 21, -1, -29 },
  { 3932, 20, 27, 21, 0, -20 },
  { 4000, 18, 29, 21, 0, -29 },
  { 4066, 12, 28, 21, 4, -28 },
  { 4108, 20, 35, 21, 0, -28 },
  { 4196, 20, 29, 21, 1, -29 },
  { 4269, 11, 29, 21, 6, -29 },
  { 4309, 20, 20, 21, 0, -20 },
  { 4359, 18, 20, 21, 1, -20 },
  { 4404, 17, 20, 21, 2, -20 },
  { 4447, 20, 27, 21, -1, -20 },
  { 4515, 18, 27, 21, 2, -20 },
  { 4576, 18, 20, 21, 2, -20 },
  { 4621, 17, 20, 21, 2, -20 },
  { 4664, 15, 25, 21, 5, -25 },
  { 4711, 18, 19, 21, 2, -19 },
  { 4754, 16, 19, 21, 4, -19 },
  { 4792, 20, 19, 21, 2, -19 },
  { 4840, 22, 19, 21, -1, -19 },
  { 4893, 23, 26, 21, -2, -19 },
  { 4968, 18, 19, 21, 1, -19 },
  { 5011, 20, 36, 21, 2, -29 },
  { 5101, 11, 36, 21, 5, -29 },
  { 5151, 20, 36, 21, -2, -29 },
  { 5241, 18, 6, 21, 2, -14 },
};

const GFXfont UbuntuSansMono_Italic37pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic37pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic37pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _UBUNTUSANSMONO_ITALIC37PT7B_H_
