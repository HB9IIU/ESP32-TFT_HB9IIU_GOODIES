#ifndef _UBUNTUSANSMONO_ITALIC20PT7B_H_
#define _UBUNTUSANSMONO_ITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC6, 0x21, 0x18, 0xC4, 0x20, 0x00, 0x8E, 0x70, 0x65, 0x34,
  0x92, 0x88, 0x03, 0x30, 0x22, 0x06, 0x60, 0x44, 0x3F, 0xF4, 0x8C, 0x18,
  0x81, 0x18, 0x11, 0x2F, 0xFC, 0x22, 0x06, 0x60, 0x44, 0x0C, 0xC0, 0x01,
  0x00, 0xC0, 0x30, 0x3F, 0x18, 0x4C, 0x03, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x30, 0x06, 0x01, 0xA0, 0xCF, 0xE0, 0x60, 0x10, 0x0C, 0x00, 0x0E, 0x0C,
  0x48, 0x41, 0x23, 0x0C, 0x98, 0x32, 0xC0, 0x5A, 0x01, 0xD0, 0x00, 0x90,
  0x05, 0xA0, 0x34, 0xC1, 0x92, 0x0C, 0xC8, 0x23, 0x23, 0x07, 0x00, 0x0F,
  0x0C, 0x8C, 0x46, 0x23, 0x31, 0xB0, 0x60, 0xF3, 0xCD, 0x63, 0xA1, 0x90,
  0xCC, 0xF7, 0xD8, 0x6B, 0x69, 0x00, 0x01, 0x07, 0x0E, 0x18, 0x30, 0x30,
  0x60, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x60,
  0x70, 0x20, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x02, 0x02, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x80, 0x08, 0x04,
  0x12, 0x5F, 0xF1, 0xC0, 0xA0, 0xD8, 0xC6, 0x06, 0x02, 0x01, 0x01, 0x87,
  0xFF, 0xFC, 0x20, 0x10, 0x18, 0x0C, 0x00, 0x37, 0x73, 0x6C, 0xF8, 0x7F,
  0x80, 0x00, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x0F, 0x86, 0x63, 0x0C, 0xC3,
  0x60, 0xDB, 0x34, 0xCF, 0x32, 0xC1, 0xB0, 0x6C, 0x33, 0x0C, 0xC6, 0x1F,
  0x00, 0x01, 0x03, 0x0F, 0x1B, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C,
  0x0C, 0x08, 0xFF, 0x0F, 0x8E, 0x71, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x3F, 0xC0, 0x1F, 0x84, 0x60,
  0x0C, 0x03, 0x00, 0x80, 0xE0, 0xE0, 0x4C, 0x01, 0x80, 0x60, 0x18, 0x0C,
  0x87, 0x3F, 0x80, 0x00, 0xC0, 0x70, 0x3C, 0x1B, 0x0C, 0x86, 0x23, 0x18,
  0x86, 0x61, 0x3F, 0xF0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x0F, 0xC2, 0x00,
  0x80, 0x60, 0x10, 0x04, 0x03, 0xE0, 0x0C, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x87, 0x3F, 0x00, 0x01, 0xC1, 0xF0, 0xC0, 0x60, 0x30, 0x08, 0x07, 0xF1,
  0x86, 0x40, 0xB0, 0x2C, 0x19, 0x06, 0x63, 0x0F, 0x80, 0x3F, 0xC0, 0x30,
  0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x00, 0x0F, 0x86, 0x33, 0x04, 0xC1, 0x30, 0xCC, 0x61, 0xF0,
  0xDC, 0x61, 0xB0, 0x6C, 0x1B, 0x06, 0xC3, 0x1F, 0x80, 0x0F, 0x86, 0x33,
  0x0C, 0x81, 0x60, 0x58, 0x32, 0x0C, 0xFF, 0x09, 0x80, 0x60, 0x30, 0x18,
  0x3C, 0x3C, 0x00, 0x39, 0xCE, 0x00, 0x00, 0x0C, 0xE7, 0x00, 0x1C, 0x71,
  0xC0, 0x00, 0x00, 0x0C, 0x71, 0xC3, 0x18, 0xC0, 0x00, 0xC0, 0xE1, 0xE1,
  0xC0, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x18, 0x78, 0xE1,
  0xC0, 0x80, 0x00, 0x3E, 0x43, 0x03, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x20,
  0x40, 0x00, 0x40, 0xE0, 0xC0, 0x07, 0xC3, 0x98, 0xC1, 0x98, 0x36, 0x1E,
  0xCF, 0xB3, 0x16, 0x46, 0xD8, 0xD3, 0x12, 0x62, 0x46, 0xCC, 0x79, 0x80,
  0x18, 0x03, 0xA0, 0x3C, 0x00, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0x60, 0x44,
  0x18, 0x82, 0x10, 0xC2, 0x10, 0x47, 0xF8, 0x81, 0x30, 0x34, 0x07, 0x80,
  0xC0, 0x1F, 0x83, 0x1C, 0x41, 0x88, 0x33, 0x04, 0x61, 0x8F, 0xC1, 0x1C,
  0x60, 0xCC, 0x19, 0x83, 0x20, 0x44, 0x39, 0xFC, 0x00, 0x07, 0xE3, 0x8C,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x06, 0x10, 0x7E, 0x00, 0x1F, 0x02, 0x38, 0x43, 0x18, 0x33, 0x06,
  0x60, 0xC8, 0x1B, 0x03, 0x60, 0x4C, 0x19, 0x02, 0x20, 0xCC, 0x71, 0xF8,
  0x00, 0x1F, 0xE2, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x0F, 0xE3, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0xFE, 0x00, 0x1F, 0xE2, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x40, 0x0F, 0xE3, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x00, 0x07, 0xE3, 0x88, 0xC0, 0x10, 0x06, 0x00,
  0x80, 0x30, 0x06, 0x04, 0xC1, 0x98, 0x33, 0x04, 0x60, 0x86, 0x30, 0x7E,
  0x00, 0x18, 0x31, 0x83, 0x10, 0x21, 0x02, 0x30, 0x63, 0x06, 0x3F, 0xC2,
  0x04, 0x60, 0xC6, 0x0C, 0x40, 0xC4, 0x08, 0xC1, 0x8C, 0x18, 0x1F, 0xC0,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x10, 0x3F, 0x80, 0x0F, 0xE0, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x8C, 0x61, 0xF8, 0x00,
  0x18, 0x31, 0x86, 0x18, 0xC1, 0x18, 0x13, 0x03, 0x60, 0x38, 0x02, 0xC0,
  0x26, 0x06, 0x60, 0x63, 0x04, 0x10, 0x41, 0x8C, 0x0C, 0x08, 0x18, 0x18,
  0x18, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0xFF, 0x0C,
  0x30, 0xC6, 0x1C, 0x61, 0x4A, 0x14, 0xA3, 0x56, 0x27, 0x62, 0x64, 0x66,
  0x44, 0x04, 0x40, 0xCC, 0x0C, 0xC0, 0xC8, 0x08, 0x18, 0x11, 0xC3, 0x1C,
  0x31, 0x42, 0x34, 0x23, 0x66, 0x22, 0x62, 0x24, 0x62, 0x46, 0x3C, 0x43,
  0xC4, 0x18, 0x41, 0x8C, 0x18, 0x0F, 0x86, 0x33, 0x0C, 0x81, 0x60, 0x50,
  0x14, 0x07, 0x03, 0xC0, 0xF0, 0x2C, 0x1B, 0x0C, 0x66, 0x1F, 0x00, 0x0F,
  0xC3, 0x1C, 0x61, 0x8C, 0x11, 0x02, 0x60, 0xCC, 0x31, 0xFC, 0x3E, 0x04,
  0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x00, 0x0F, 0x86, 0x33, 0x0C, 0x81,
  0x60, 0x50, 0x14, 0x07, 0x03, 0xC0, 0xF0, 0x2C, 0x1B, 0x0C, 0x66, 0x1F,
  0x03, 0x00, 0x60, 0x1E, 0x00, 0x80, 0x1F, 0x83, 0x18, 0x61, 0x88, 0x31,
  0x06, 0x60, 0x8C, 0x31, 0xFC, 0x22, 0x0C, 0x61, 0x84, 0x20, 0x84, 0x19,
  0x83, 0x00, 0x0F, 0xC6, 0x13, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0x00, 0x60, 0x18, 0x04, 0x87, 0x3F, 0x80, 0xFF, 0x84, 0x06, 0x03,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x00,
  0x30, 0x66, 0x0C, 0x81, 0x10, 0x26, 0x0C, 0xC1, 0x90, 0x32, 0x04, 0xC1,
  0x98, 0x33, 0x06, 0x61, 0x84, 0x30, 0xFC, 0x00, 0xC0, 0x78, 0x1B, 0x03,
  0x60, 0x4C, 0x19, 0x86, 0x10, 0x82, 0x30, 0x44, 0x09, 0x81, 0x20, 0x2C,
  0x05, 0x00, 0xE0, 0x00, 0x20, 0x32, 0x02, 0x60, 0x66, 0x06, 0x60, 0x44,
  0x44, 0x4C, 0xC5, 0xC8, 0xD4, 0x8B, 0x58, 0xA7, 0x0C, 0x70, 0xC7, 0x08,
  0x20, 0x0C, 0x0C, 0x18, 0x60, 0x63, 0x01, 0x98, 0x03, 0x40, 0x0F, 0x00,
  0x18, 0x00, 0xE0, 0x07, 0x80, 0x32, 0x01, 0x8C, 0x04, 0x30, 0x30, 0x43,
  0x81, 0x80, 0xC0, 0x68, 0x09, 0x03, 0x30, 0xC6, 0x30, 0x44, 0x0D, 0x01,
  0xE0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x00, 0x0F, 0xF1,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x0F, 0xF8, 0x07, 0xC1, 0xF0, 0x40, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x10, 0x07, 0xC3, 0xF0, 0xDB, 0x6C, 0x92, 0x49,
  0xB6, 0xDB, 0x6C, 0x90, 0x0F, 0xC3, 0xE0, 0x08, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30,
  0x0C, 0x02, 0x0F, 0x83, 0xE0, 0x06, 0x07, 0x06, 0x86, 0x62, 0x33, 0x0B,
  0x06, 0x02, 0xFF, 0xFF, 0xF0, 0xC6, 0x32, 0x03, 0x07, 0xF3, 0x09, 0x86,
  0xC1, 0xB0, 0x48, 0x12, 0x0C, 0xC3, 0x31, 0xC7, 0xF0, 0x08, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0D, 0x83, 0xF8, 0x86, 0x60, 0xD8, 0x24, 0x09, 0x06,
  0xC1, 0xB0, 0xCC, 0xE3, 0xF0, 0x07, 0x0F, 0xCC, 0x0C, 0x0C, 0x06, 0x02,
  0x01, 0x00, 0xC0, 0x70, 0x9F, 0xC0, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x07, 0x87, 0xF1, 0x84, 0x60, 0x88, 0x33, 0x06, 0x60, 0x8C, 0x11,
  0x82, 0x31, 0xC3, 0xE8, 0x06, 0x0F, 0xDC, 0x2C, 0x1C, 0x1E, 0x7B, 0xF1,
  0x00, 0xC0, 0x70, 0x9F, 0xC0, 0x00, 0x28, 0x0F, 0x80, 0x40, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x7F, 0x80, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x3C, 0x01,
  0xC0, 0x00, 0x01, 0xC1, 0xFC, 0x61, 0x98, 0x23, 0x04, 0xC1, 0x98, 0x33,
  0x04, 0x61, 0x87, 0xF0, 0x76, 0x00, 0x80, 0x31, 0xFC, 0x1E, 0x00, 0x04,
  0x02, 0x01, 0x80, 0x60, 0x10, 0x05, 0x83, 0xF8, 0xC3, 0x30, 0xC8, 0x36,
  0x09, 0x82, 0x61, 0x90, 0x64, 0x13, 0x04, 0x1C, 0x38, 0x20, 0x00, 0x1F,
  0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83, 0x06, 0x47, 0x00, 0x00, 0xE0, 0x18,
  0x01, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x1F, 0x81, 0xC0, 0x00,
  0x08, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x12, 0x18, 0x8C, 0x66, 0x1E,
  0x07, 0x01, 0x60, 0xCC, 0x31, 0x8C, 0x32, 0x0C, 0xF8, 0x61, 0x84, 0x10,
  0xC3, 0x08, 0x21, 0x86, 0x10, 0x41, 0x97, 0xC0, 0x0C, 0xC7, 0xFC, 0x89,
  0x93, 0x36, 0x64, 0xC8, 0x91, 0x32, 0x06, 0x40, 0x98, 0x13, 0x06, 0x00,
  0x06, 0x1F, 0xC8, 0x6C, 0x16, 0x0B, 0x0D, 0x06, 0x82, 0xC1, 0x61, 0xA0,
  0xC0, 0x06, 0x0F, 0xCC, 0x2C, 0x14, 0x0E, 0x07, 0x07, 0x83, 0xC3, 0x63,
  0x9F, 0x00, 0x07, 0x07, 0xF1, 0x0C, 0xC1, 0x30, 0x48, 0x12, 0x0D, 0x83,
  0x61, 0x90, 0xC7, 0xE3, 0x00, 0xC0, 0x30, 0x08, 0x00, 0x03, 0x07, 0xF3,
  0x09, 0x82, 0x41, 0xB0, 0x6C, 0x13, 0x04, 0xC3, 0x31, 0xC7, 0xE0, 0x08,
  0x06, 0x01, 0x80, 0x40, 0x03, 0xC7, 0xE3, 0x00, 0xC0, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x0C, 0x00, 0x07, 0x0F, 0xCC, 0x06, 0x03, 0x00,
  0xE0, 0x1C, 0x06, 0x03, 0x21, 0xBF, 0x80, 0x08, 0x0C, 0x06, 0x03, 0x1F,
  0xF0, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x21, 0xF0, 0x60,
  0xD8, 0x26, 0x19, 0x06, 0xC1, 0x30, 0x4C, 0x33, 0x0C, 0xC7, 0x1F, 0xC0,
  0xC1, 0xE0, 0xB0, 0xC8, 0x44, 0x62, 0x21, 0xB0, 0xF0, 0x70, 0x30, 0x00,
  0x40, 0x68, 0x09, 0x11, 0x66, 0x6C, 0xC9, 0xAB, 0x3D, 0x47, 0x28, 0xC7,
  0x18, 0x40, 0x38, 0x63, 0x18, 0x36, 0x07, 0x80, 0x60, 0x1C, 0x06, 0xC1,
  0x98, 0x61, 0x98, 0x30, 0x18, 0x30, 0x83, 0x08, 0x20, 0x86, 0x0C, 0x40,
  0xCC, 0x0C, 0x80, 0x58, 0x05, 0x00, 0x70, 0x06, 0x00, 0xC0, 0xF8, 0x0E,
  0x00, 0x3F, 0x81, 0x81, 0x81, 0x81, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x7F,
  0x00, 0x01, 0xE0, 0x7C, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x18, 0x1E, 0x03, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0xF8, 0x0E, 0x00, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x04, 0x30,
  0xC2, 0x08, 0x61, 0x84, 0x10, 0x43, 0x0C, 0x20, 0x07, 0x01, 0xF8, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3C, 0x07, 0x81,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x83, 0xF0, 0x78, 0x00,
  0x78, 0xF3, 0xE4, 0x30,
};

const GFXglyph UbuntuSansMono_Italic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 14, 11, 3, -14 },
  { 10, 6, 5, 11, 4, -15 },
  { 14, 12, 14, 11, 0, -14 },
  { 35, 10, 18, 11, 1, -16 },
  { 58, 14, 14, 11, -1, -14 },
  { 83, 9, 14, 11, 1, -14 },
  { 99, 3, 6, 11, 6, -15 },
  { 102, 8, 20, 11, 3, -16 },
  { 122, 8, 20, 11, 1, -16 },
  { 142, 9, 8, 11, 2, -14 },
  { 151, 9, 10, 11, 1, -11 },
  { 163, 4, 6, 11, 2, -3 },
  { 166, 5, 1, 11, 3, -6 },
  { 167, 3, 3, 11, 3, -3 },
  { 169, 12, 20, 11, -1, -16 },
  { 199, 10, 14, 11, 1, -14 },
  { 217, 8, 14, 11, 1, -14 },
  { 231, 10, 14, 11, 1, -14 },
  { 249, 10, 14, 11, 1, -14 },
  { 267, 10, 14, 11, 0, -14 },
  { 285, 10, 14, 11, 1, -14 },
  { 303, 10, 14, 11, 1, -14 },
  { 321, 10, 14, 11, 2, -14 },
  { 339, 10, 14, 11, 1, -14 },
  { 357, 10, 14, 11, 1, -14 },
  { 375, 5, 10, 11, 3, -10 },
  { 382, 6, 13, 11, 2, -10 },
  { 392, 10, 9, 11, 1, -10 },
  { 404, 10, 6, 11, 1, -9 },
  { 412, 9, 9, 11, 1, -10 },
  { 423, 8, 14, 11, 3, -14 },
  { 437, 11, 17, 11, 1, -14 },
  { 461, 11, 14, 11, -1, -14 },
  { 481, 11, 14, 11, 0, -14 },
  { 501, 11, 14, 11, 1, -14 },
  { 521, 11, 14, 11, 0, -14 },
  { 541, 11, 14, 11, 1, -14 },
  { 561, 11, 14, 11, 1, -14 },
  { 581, 11, 14, 11, 1, -14 },
  { 601, 12, 14, 11, 0, -14 },
  { 622, 10, 14, 11, 1, -14 },
  { 640, 11, 14, 11, 1, -14 },
  { 660, 12, 14, 11, 0, -14 },
  { 681, 8, 14, 11, 0, -14 },
  { 695, 12, 14, 11, 0, -14 },
  { 716, 12, 14, 11, 0, -14 },
  { 737, 10, 14, 11, 1, -14 },
  { 755, 11, 14, 11, 0, -14 },
  { 775, 10, 18, 11, 1, -14 },
  { 798, 11, 14, 11, 0, -14 },
  { 818, 10, 14, 11, 1, -14 },
  { 836, 9, 14, 11, 3, -14 },
  { 852, 11, 14, 11, 1, -14 },
  { 872, 11, 14, 11, 2, -14 },
  { 892, 12, 14, 11, 1, -14 },
  { 913, 14, 14, 11, -1, -14 },
  { 938, 11, 14, 11, 2, -14 },
  { 958, 12, 14, 11, 0, -14 },
  { 979, 10, 20, 11, 1, -16 },
  { 1004, 3, 20, 11, 4, -16 },
  { 1012, 10, 20, 11, 0, -16 },
  { 1037, 9, 8, 11, 2, -14 },
  { 1046, 10, 2, 11, -1, 2 },
  { 1049, 4, 4, 11, 5, -15 },
  { 1051, 10, 11, 11, 1, -11 },
  { 1065, 10, 16, 11, 1, -16 },
  { 1085, 9, 11, 11, 1, -11 },
  { 1098, 11, 16, 11, 1, -16 },
  { 1120, 9, 11, 11, 1, -11 },
  { 1133, 13, 20, 11, 0, -16 },
  { 1166, 11, 15, 11, 0, -11 },
  { 1187, 10, 16, 11, 0, -16 },
  { 1207, 7, 15, 11, 2, -15 },
  { 1221, 11, 19, 11, 0, -15 },
  { 1248, 10, 16, 11, 1, -16 },
  { 1268, 6, 15, 11, 3, -15 },
  { 1280, 11, 11, 11, 0, -11 },
  { 1296, 9, 11, 11, 1, -11 },
  { 1309, 9, 11, 11, 1, -11 },
  { 1322, 10, 15, 11, 0, -11 },
  { 1341, 10, 15, 11, 1, -11 },
  { 1360, 10, 11, 11, 1, -11 },
  { 1374, 9, 11, 11, 1, -11 },
  { 1387, 9, 14, 11, 2, -14 },
  { 1403, 10, 10, 11, 1, -10 },
  { 1416, 9, 10, 11, 2, -10 },
  { 1428, 11, 10, 11, 1, -10 },
  { 1442, 11, 10, 11, 0, -10 },
  { 1456, 12, 14, 11, -1, -10 },
  { 1477, 9, 10, 11, 1, -10 },
  { 1489, 11, 20, 11, 1, -16 },
  { 1517, 6, 20, 11, 3, -16 },
  { 1532, 11, 20, 11, -1, -16 },
  { 1560, 10, 3, 11, 1, -7 },
};

const GFXfont UbuntuSansMono_Italic20pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic20pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic20pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _UBUNTUSANSMONO_ITALIC20PT7B_H_
