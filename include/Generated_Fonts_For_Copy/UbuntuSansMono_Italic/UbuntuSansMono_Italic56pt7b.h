#ifndef _UBUNTUSANSMONO_ITALIC56PT7B_H_
#define _UBUNTUSANSMONO_ITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x0C, 0x00, 0x1E,
  0x07, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x38, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x30, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xC0, 0x1C, 0x01, 0xF8, 0x00, 0x20, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x03, 0x80, 0x07, 0xE0,
  0x1F, 0x81, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x0F, 0xF8, 0x00, 0x3C, 0x00, 0xF3,
  0xE0, 0x03, 0xC0, 0x0F, 0x0F, 0x00, 0x3E, 0x00, 0x70, 0x78, 0x03, 0xE0,
  0x07, 0x83, 0xC0, 0x1E, 0x00, 0x38, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0xF0,
  0x1E, 0x00, 0x1E, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x1E, 0x00, 0x07,
  0x81, 0xE1, 0xF0, 0x00, 0x3C, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0xF0,
  0x00, 0x0F, 0x07, 0x8F, 0x00, 0x00, 0x78, 0x78, 0xF0, 0x00, 0x03, 0xE7,
  0x8F, 0x00, 0x00, 0x0F, 0xFC, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0x80, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x30, 0x00, 0x00, 0x07, 0x8F, 0xF0, 0x00, 0x00, 0x78, 0xFF, 0x80, 0x00,
  0x07, 0x8F, 0x9E, 0x00, 0x00, 0x7C, 0xF0, 0xF0, 0x00, 0x03, 0xC7, 0x83,
  0x80, 0x00, 0x3C, 0x78, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0xE0, 0x00, 0x3C,
  0x1C, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x38, 0x00, 0x3C, 0x0F, 0x03, 0xC0,
  0x03, 0xE0, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x1E,
  0x07, 0x00, 0x1E, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x83, 0x80, 0x1E,
  0x00, 0x1E, 0x3C, 0x01, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x0F,
  0x01, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x7B, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0xE0, 0x1F, 0xE0, 0x3E, 0x07, 0xFE, 0x07, 0x81, 0xF3, 0xE0, 0xF0,
  0x7C, 0x3C, 0x3C, 0x1F, 0x07, 0xC7, 0x87, 0xC0, 0x7C, 0xF0, 0xF0, 0x0F,
  0xBC, 0x3E, 0x00, 0xFF, 0x87, 0xC0, 0x0F, 0xE0, 0xF0, 0x01, 0xFC, 0x1E,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0xC1, 0xF0, 0x07, 0xF8, 0x3F, 0x03, 0xFF, 0x07, 0xFB, 0xFD, 0xF0, 0x7F,
  0xFF, 0x3E, 0x07, 0xFF, 0x83, 0xC0, 0x7F, 0xC0, 0x7C, 0x00, 0x80, 0x00,
  0x00, 0x1E, 0x3C, 0xF9, 0xF3, 0xC7, 0x9F, 0x3E, 0x78, 0xF1, 0xE3, 0x8F,
  0x1E, 0x38, 0x70, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x10, 0x0E, 0x01, 0x3C, 0x1C, 0x1E, 0xFE, 0x38, 0xFF,
  0xFF, 0x77, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7B, 0x80, 0x01, 0xF7, 0x80, 0x07, 0xC7, 0x80, 0x0F,
  0x8F, 0x80, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0xC0,
  0x38, 0x00, 0x80, 0x20, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFA, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x0F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x1F, 0xC3, 0xFE, 0x07, 0xF0, 0x1F,
  0x00, 0x60, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x38, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xF9, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x78, 0xF0, 0x00, 0x1F, 0x3E, 0x0F, 0x03, 0xE7, 0xC3, 0xF0, 0x7C, 0xF0,
  0xFF, 0x0F, 0xBE, 0x1F, 0xE1, 0xE7, 0xC3, 0xFC, 0x3C, 0xF8, 0x7F, 0x0F,
  0x9E, 0x07, 0xE1, 0xF3, 0xC0, 0x70, 0x3C, 0xF8, 0x00, 0x0F, 0x9F, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x07,
  0xF1, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFC, 0xF0, 0x0F, 0xC7, 0xC0, 0x3C, 0x1F, 0x00,
  0xC0, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x60, 0x01, 0xF0, 0x04, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0x00, 0x3E, 0x00, 0x40,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x06, 0x00, 0x0F, 0xE0, 0x7E, 0x07, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xBC, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x7C, 0x7C,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x0F,
  0x00, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x1E, 0x01, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xC0, 0x7C, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x06, 0x00, 0x1F, 0xC0, 0x1E, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x7F, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0x0F, 0xE0, 0x7E, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xFE, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0x7F, 0x80, 0x07, 0xC1, 0xFC, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x03, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x03, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xFC, 0x00, 0x7E, 0x07,
  0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0x7C, 0x00, 0x0C, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x1F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7E, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xE0, 0x1C, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE,
  0x07, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFE,
  0x3F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0x1E, 0x01, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0xFF,
  0x83, 0xE0, 0x0F, 0xFF, 0x0F, 0x80, 0x7F, 0xFE, 0x1F, 0x03, 0xFF, 0xFC,
  0x3C, 0x0F, 0xC0, 0xF0, 0xF8, 0x3F, 0x01, 0xE1, 0xF0, 0x7C, 0x07, 0xC3,
  0xC1, 0xF0, 0x0F, 0x8F, 0x83, 0xC0, 0x1E, 0x1F, 0x0F, 0x80, 0x3C, 0x3E,
  0x1F, 0x00, 0x78, 0x78, 0x3C, 0x01, 0xF0, 0xF0, 0x78, 0x03, 0xC3, 0xE0,
  0xF0, 0x07, 0x87, 0xC1, 0xE0, 0x0F, 0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x07,
  0x80, 0x78, 0x3E, 0x0F, 0x00, 0xF0, 0x7C, 0x1F, 0x01, 0xE0, 0xF8, 0x3F,
  0x07, 0xC1, 0xF0, 0x3F, 0x9F, 0x83, 0xE0, 0x3F, 0xFE, 0x03, 0xC0, 0x3F,
  0xFC, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xC0, 0x3E,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x0F,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F,
  0x1E, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x3F, 0x80, 0xF8, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78,
  0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x3C,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0xF8, 0x07, 0x80, 0x3F, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x0F, 0xE0, 0x7C,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E,
  0x1E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x78,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x81, 0xF8, 0x7F,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0x00, 0x3F, 0x00, 0x02, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x60, 0x01, 0xFC, 0x07, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xF0, 0x07, 0xF0, 0x03,
  0xC0, 0x0F, 0xC0, 0x0F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3C,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x78, 0x3E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8,
  0x0F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x01, 0xE0, 0x03, 0xF8, 0x07,
  0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1D, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0x80, 0x7F, 0x00, 0x38, 0x07, 0xE0, 0x00,
  0x40, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x03, 0xE0,
  0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x78, 0x03, 0xFC, 0x07,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0,
  0x07, 0xC0, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x1F, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x80,
  0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x1F, 0x80, 0x07, 0x80,
  0x1F, 0x80, 0x03, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xE0,
  0x1F, 0x80, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x0F,
  0x3F, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x07, 0xBF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x79, 0xF8, 0x00, 0x00, 0x3C, 0x7E, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7B, 0x80, 0xF7,
  0x00, 0x39, 0xC0, 0x73, 0x80, 0x1C, 0xE0, 0x79, 0xC0, 0x1E, 0x70, 0x39,
  0xE0, 0x0F, 0x3C, 0x3C, 0xF0, 0x07, 0x1E, 0x1C, 0x78, 0x07, 0x8F, 0x1E,
  0x38, 0x03, 0xC7, 0x8E, 0x1C, 0x01, 0xC3, 0xCE, 0x1E, 0x01, 0xE1, 0xEF,
  0x0F, 0x00, 0xF0, 0x77, 0x07, 0x80, 0x78, 0x3F, 0x83, 0xC0, 0x78, 0x1F,
  0x83, 0xC0, 0x3C, 0x0F, 0xC1, 0xE0, 0x1E, 0x07, 0xC0, 0xF0, 0x1F, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x78, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x7F, 0x00,
  0x07, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x0F, 0xF0, 0x00, 0xF0, 0x03, 0xDE,
  0x00, 0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x00, 0x39, 0xE0, 0x03, 0xC0, 0x1E,
  0x78, 0x01, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x00,
  0x78, 0xF0, 0x07, 0x80, 0x3C, 0x1E, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0xF0,
  0x03, 0xC1, 0xE0, 0x3C, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x07,
  0x80, 0x1E, 0x03, 0xC1, 0xE0, 0x07, 0x80, 0xF0, 0x78, 0x01, 0xE0, 0x3C,
  0x1E, 0x00, 0xF0, 0x07, 0x0F, 0x00, 0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x00,
  0x78, 0xF0, 0x03, 0xC0, 0x1E, 0x3C, 0x01, 0xE0, 0x03, 0x8F, 0x00, 0x78,
  0x00, 0xE7, 0x80, 0x1E, 0x00, 0x3D, 0xE0, 0x07, 0x80, 0x0F, 0x78, 0x03,
  0xE0, 0x03, 0xDE, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x1F, 0xC0,
  0x0F, 0x00, 0x07, 0xF0, 0x03, 0xC0, 0x01, 0xFC, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0x78, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF0, 0x3E,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x07, 0x9F, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x78,
  0x01, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0,
  0x3E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x3C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x7F, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xF8, 0x03, 0xC0, 0x03, 0xE0, 0x1F,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3C,
  0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0xFC, 0x03,
  0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x78, 0x03,
  0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x0F, 0xC0, 0x0F,
  0xC0, 0x01, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x80, 0x00, 0x7E, 0x01, 0xC0, 0x01, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07,
  0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0x8F, 0x80,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0,
  0x3C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x1E, 0x07, 0xC0,
  0xF0, 0x0F, 0x07, 0xE0, 0x78, 0x07, 0x03, 0xF0, 0x3C, 0x07, 0x83, 0xF8,
  0x1C, 0x03, 0xC1, 0xDC, 0x1E, 0x01, 0xE1, 0xEE, 0x0F, 0x00, 0xF1, 0xE7,
  0x07, 0x00, 0x70, 0xF3, 0xC7, 0x80, 0x38, 0xF1, 0xE3, 0xC0, 0x3C, 0x70,
  0xF1, 0xC0, 0x1E, 0x78, 0x38, 0xE0, 0x0F, 0x38, 0x1C, 0xF0, 0x07, 0x3C,
  0x0E, 0x70, 0x03, 0x9C, 0x07, 0x38, 0x01, 0xDE, 0x03, 0xBC, 0x00, 0xFE,
  0x01, 0xDC, 0x00, 0xEF, 0x00, 0xEE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x1F, 0x1E, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0xF8,
  0x78, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x7C,
  0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x3E,
  0x00, 0x0F, 0x3E, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF1,
  0x00, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x18, 0x0F, 0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x2E, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x01, 0xE0,
  0x1F, 0xC0, 0x1E, 0x03, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x0F, 0x80,
  0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF8,
  0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0xC0, 0x3F, 0x03, 0xFE, 0x03, 0xFF, 0xFD, 0xE0, 0x1F, 0xFF, 0x9E, 0x00,
  0x7F, 0xE1, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7B, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x81, 0xF8, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0x80,
  0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE0,
  0xF0, 0x03, 0xF8, 0x1E, 0x00, 0xFE, 0x03, 0xE1, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xE0, 0x1C, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x80, 0xFF, 0x00, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0x00, 0x3F,
  0x80, 0x1E, 0x00, 0xFC, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x01, 0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x7C, 0x00, 0x3F, 0xF8, 0x78, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xC0, 0xFC, 0x0F, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x7F, 0x1E,
  0x03, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x80, 0xFF, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x04, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x1E, 0x00, 0x3F, 0xC0, 0x3E,
  0x00, 0x7F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3C,
  0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0xF0,
  0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x01, 0xE0,
  0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC7, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x30, 0x00, 0xFC, 0x00,
  0x7E, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x07, 0xF8, 0x0F, 0x80, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC1, 0xF0,
  0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFE, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x30, 0x03, 0xE0, 0x00, 0xFC, 0x1F, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x03,
  0xC0, 0x07, 0xE0, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x0F, 0xC0, 0x0F, 0x80,
  0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xC1, 0xF8, 0x00, 0x1E, 0x1F, 0x80,
  0x01, 0xF3, 0xF8, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x7B, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x3F,
  0x00, 0x00, 0x78, 0xFC, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xE0, 0x3F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x78, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x07,
  0xC0, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x01, 0x3E, 0x07, 0x3F, 0xFF, 0x1F,
  0xFF, 0x0F, 0xFE, 0x00, 0xE0, 0x00, 0x1F, 0x01, 0xC0, 0x07, 0xFF, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xE3, 0xFC, 0x7C,
  0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC1, 0xE0, 0x7C, 0x0F, 0x07,
  0x81, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xF0, 0xF8, 0x1E, 0x07, 0x83, 0xC0,
  0x78, 0x1E, 0x0F, 0x03, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x3C,
  0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x1E, 0x07, 0xC0, 0xF0, 0x78, 0x1E, 0x03,
  0xC1, 0xE0, 0x78, 0x1F, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0x07, 0xF8, 0x07, 0x80, 0x1F, 0x80, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x1E, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1,
  0xE0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0x81, 0xFC, 0x03, 0xE0,
  0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0xF3, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F,
  0x3C, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0x7E, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7E, 0x03, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0,
  0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x1F,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x03,
  0xE0, 0x03, 0xF0, 0x0F, 0x00, 0x1F, 0x80, 0x3C, 0x01, 0xFC, 0x01, 0xF8,
  0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xEF, 0x40, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x03, 0xE0, 0x3F, 0x80, 0x3E,
  0x07, 0xE0, 0x03, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x0F,
  0x80, 0x03, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0x80,
  0x01, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xF8, 0x01, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFC, 0x07, 0x80, 0x7C, 0x00, 0x20, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x0C, 0x00,
  0x3E, 0x07, 0xC0, 0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x00, 0x2F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x80, 0x7C, 0x0F, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x78, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x01, 0xFC, 0x0F,
  0xC1, 0xFF, 0x80, 0xFF, 0xFE, 0xF0, 0x1F, 0xFF, 0x9E, 0x00, 0xFF, 0xC3,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x3C,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3E, 0x3C,
  0x03, 0xC0, 0x78, 0x78, 0x07, 0x80, 0xF0, 0xF0, 0x1F, 0x03, 0xC1, 0xE0,
  0x3E, 0x07, 0x83, 0xC0, 0xFC, 0x0F, 0x07, 0x83, 0xF8, 0x3C, 0x0F, 0x07,
  0xF0, 0x78, 0x1E, 0x1E, 0xE1, 0xE0, 0x3C, 0x39, 0xC3, 0xC0, 0x78, 0xF3,
  0x87, 0x81, 0xF3, 0xC7, 0x1E, 0x03, 0xC7, 0x0F, 0x3C, 0x07, 0x9E, 0x1E,
  0xF0, 0x0F, 0x38, 0x3D, 0xE0, 0x1E, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7E, 0x3C, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x01, 0xF8, 0x1E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x0F,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x3C, 0x7F, 0xF0, 0x07, 0x9F, 0xFF, 0x01, 0xE7,
  0xC3, 0xF8, 0x78, 0xF0, 0x1F, 0xFF, 0x3C, 0x01, 0xFF, 0xC7, 0x00, 0x1F,
  0xF0, 0x20, 0x00, 0xF0, 0x00,
};

const GFXglyph UbuntuSansMono_Italic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 14, 40, 31, 9, -39 },
  { 71, 16, 15, 31, 12, -43 },
  { 101, 33, 39, 31, 0, -39 },
  { 262, 29, 49, 31, 2, -43 },
  { 440, 37, 41, 31, -2, -40 },
  { 630, 27, 41, 31, 1, -40 },
  { 769, 7, 17, 31, 17, -43 },
  { 784, 23, 54, 31, 7, -44 },
  { 940, 24, 54, 31, 1, -44 },
  { 1102, 23, 23, 31, 7, -39 },
  { 1169, 26, 27, 31, 3, -30 },
  { 1257, 14, 17, 31, 4, -8 },
  { 1287, 14, 4, 31, 9, -18 },
  { 1294, 8, 9, 31, 9, -8 },
  { 1303, 36, 54, 31, -4, -44 },
  { 1546, 27, 41, 31, 3, -40 },
  { 1685, 22, 39, 31, 4, -39 },
  { 1793, 28, 40, 31, 2, -40 },
  { 1933, 28, 41, 31, 2, -40 },
  { 2077, 28, 39, 31, 1, -39 },
  { 2214, 30, 40, 31, 2, -39 },
  { 2364, 28, 40, 31, 4, -39 },
  { 2504, 28, 39, 31, 7, -39 },
  { 2641, 28, 41, 31, 3, -40 },
  { 2785, 28, 40, 31, 3, -40 },
  { 2925, 13, 30, 31, 9, -29 },
  { 2974, 18, 38, 31, 4, -29 },
  { 3060, 27, 24, 31, 3, -28 },
  { 3141, 29, 15, 31, 2, -24 },
  { 3196, 27, 24, 31, 2, -28 },
  { 3277, 22, 41, 31, 8, -40 },
  { 3390, 31, 48, 31, 2, -40 },
  { 3576, 30, 39, 31, -3, -39 },
  { 3723, 29, 39, 31, 1, -39 },
  { 3865, 31, 41, 31, 3, -40 },
  { 4024, 30, 39, 31, 0, -39 },
  { 4171, 31, 39, 31, 2, -39 },
  { 4323, 31, 39, 31, 2, -39 },
  { 4475, 29, 41, 31, 3, -40 },
  { 4624, 34, 39, 31, 0, -39 },
  { 4790, 28, 39, 31, 3, -39 },
  { 4927, 30, 40, 31, 2, -39 },
  { 5077, 33, 39, 31, 1, -39 },
  { 5238, 23, 39, 31, 1, -39 },
  { 5351, 33, 39, 31, -1, -39 },
  { 5512, 34, 39, 31, 0, -39 },
  { 5678, 29, 41, 31, 3, -40 },
  { 5827, 30, 39, 31, 1, -39 },
  { 5974, 29, 50, 31, 3, -40 },
  { 6156, 30, 39, 31, 1, -39 },
  { 6303, 31, 41, 31, 1, -40 },
  { 6462, 26, 39, 31, 8, -39 },
  { 6589, 31, 40, 31, 3, -39 },
  { 6744, 30, 39, 31, 6, -39 },
  { 6891, 33, 39, 31, 2, -39 },
  { 7052, 38, 39, 31, -2, -39 },
  { 7238, 30, 39, 31, 7, -39 },
  { 7385, 34, 39, 31, 0, -39 },
  { 7551, 27, 54, 31, 4, -44 },
  { 7734, 8, 54, 31, 12, -44 },
  { 7788, 28, 54, 31, -1, -44 },
  { 7977, 25, 21, 31, 5, -39 },
  { 8043, 29, 3, 31, -4, 7 },
  { 8054, 11, 11, 31, 14, -43 },
  { 8070, 28, 31, 31, 2, -30 },
  { 8179, 27, 44, 31, 2, -43 },
  { 8328, 27, 31, 31, 2, -30 },
  { 8433, 31, 44, 31, 3, -43 },
  { 8604, 27, 31, 31, 2, -30 },
  { 8709, 36, 54, 31, -1, -43 },
  { 8952, 32, 41, 31, -1, -30 },
  { 9116, 27, 43, 31, 0, -43 },
  { 9262, 18, 43, 31, 6, -43 },
  { 9359, 31, 53, 31, -1, -43 },
  { 9565, 29, 43, 31, 2, -43 },
  { 9721, 16, 44, 31, 9, -43 },
  { 9809, 30, 30, 31, 0, -30 },
  { 9922, 27, 30, 31, 2, -30 },
  { 10024, 26, 31, 31, 3, -30 },
  { 10125, 30, 40, 31, -1, -30 },
  { 10275, 28, 40, 31, 3, -30 },
  { 10415, 26, 30, 31, 4, -30 },
  { 10513, 26, 31, 31, 3, -30 },
  { 10614, 23, 39, 31, 7, -38 },
  { 10727, 27, 30, 31, 3, -29 },
  { 10829, 24, 29, 31, 7, -29 },
  { 10916, 31, 29, 31, 3, -29 },
  { 11029, 32, 29, 31, -1, -29 },
  { 11145, 34, 40, 31, -3, -29 },
  { 11315, 28, 29, 31, 1, -29 },
  { 11417, 30, 54, 31, 3, -44 },
  { 11620, 17, 54, 31, 8, -44 },
  { 11735, 30, 54, 31, -2, -44 },
  { 11938, 27, 9, 31, 3, -21 },
};

const GFXfont UbuntuSansMono_Italic56pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic56pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic56pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _UBUNTUSANSMONO_ITALIC56PT7B_H_
