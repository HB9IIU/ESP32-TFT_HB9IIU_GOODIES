#ifndef _UBUNTUSANSMONO_ITALIC40PT7B_H_
#define _UBUNTUSANSMONO_ITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xE0,
  0x20, 0x00, 0x70, 0xEE, 0x1D, 0xC3, 0xB0, 0x6E, 0x1D, 0xC3, 0xB0, 0x66,
  0x0C, 0xC1, 0x90, 0x20, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1E,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x70, 0x39, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0xE0,
  0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x83,
  0xC0, 0x03, 0x83, 0x80, 0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x1C, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x70,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0x1E,
  0x07, 0x80, 0x20, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x60, 0x0F, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xC0,
  0xFE, 0x00, 0xE0, 0x71, 0xC0, 0x70, 0x1C, 0x70, 0x1C, 0x06, 0x1C, 0x0E,
  0x03, 0x87, 0x07, 0x00, 0xE1, 0xC3, 0x80, 0x30, 0x71, 0xC0, 0x0C, 0x18,
  0xE0, 0x03, 0x0E, 0x70, 0x00, 0xE3, 0x9C, 0x00, 0x3F, 0xCE, 0x00, 0x07,
  0xE7, 0x00, 0x00, 0x43, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE7, 0xE0,
  0x00, 0x73, 0xF8, 0x00, 0x1C, 0xC7, 0x00, 0x0E, 0x71, 0xC0, 0x07, 0x18,
  0x70, 0x03, 0x8E, 0x1C, 0x01, 0xC3, 0x87, 0x00, 0xE0, 0xE1, 0xC0, 0x70,
  0x30, 0x60, 0x1C, 0x0E, 0x38, 0x0E, 0x03, 0x8E, 0x07, 0x00, 0xFF, 0x03,
  0x80, 0x1F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0,
  0x07, 0x8F, 0x01, 0xE0, 0xE0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0,
  0x38, 0x1C, 0x07, 0x07, 0x00, 0xF1, 0xE0, 0x0E, 0x78, 0x01, 0xFE, 0x00,
  0x3F, 0x00, 0x07, 0x81, 0xC3, 0xF8, 0x38, 0xF7, 0x8E, 0x3C, 0x71, 0xCF,
  0x0F, 0x31, 0xC0, 0xEE, 0x38, 0x0F, 0xCF, 0x01, 0xF1, 0xE0, 0x1E, 0x3C,
  0x03, 0x87, 0x80, 0xF8, 0xF0, 0x3F, 0x0F, 0xBF, 0xF1, 0xFF, 0x8E, 0x0F,
  0xC1, 0xC0, 0x39, 0xDE, 0xE7, 0x39, 0xCC, 0xE7, 0x30, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x03, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x08,
  0x1C, 0x17, 0x0C, 0x3B, 0xE6, 0x7D, 0xFF, 0xFF, 0x3F, 0xFC, 0x01, 0xE0,
  0x01, 0xF8, 0x01, 0xEE, 0x01, 0xE7, 0x80, 0xF1, 0xE0, 0xF0, 0xF0, 0x30,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x0F, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x03, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3, 0xE0, 0x38, 0x1C, 0x0F,
  0x1F, 0x8F, 0xC3, 0xC0, 0xFF, 0xFF, 0xEF, 0xF8, 0x39, 0xFF, 0xFF, 0xFD,
  0xE1, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x3C, 0x1E, 0x07, 0x80, 0xE0, 0xF0, 0x0E, 0x0E, 0x00, 0xF1,
  0xE0, 0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x00, 0xF3, 0x8F, 0x0E,
  0x79, 0xF8, 0xE7, 0x1F, 0x8E, 0x71, 0xF9, 0xE7, 0x0F, 0x1E, 0x70, 0x01,
  0xCF, 0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00,
  0x70, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0x70, 0x3C, 0x07, 0xCF, 0x80, 0x3F,
  0xF0, 0x01, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x7E, 0x00, 0xFE, 0x07, 0xFC, 0x0F, 0x9C, 0x0E, 0x1C, 0x08,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xE7, 0xE0, 0x70,
  0x1E, 0x02, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x01, 0xF7, 0xE0, 0x18, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x40, 0x0F, 0x87, 0xC3, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xDE, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x00, 0xE1,
  0xC0, 0x1C, 0x3C, 0x03, 0x83, 0x80, 0x70, 0x38, 0x0F, 0x03, 0x80, 0xE0,
  0x78, 0x1C, 0x07, 0x03, 0x80, 0x70, 0x78, 0x07, 0x07, 0x00, 0x70, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x40, 0x0F, 0x01, 0xC1, 0xFC, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x8F, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7C, 0x07, 0x87, 0x00, 0x38,
  0xF0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03,
  0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xF0, 0x1E, 0x07, 0x83,
  0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFE,
  0x03, 0xF1, 0xF0, 0x3C, 0x0F, 0x07, 0x80, 0x70, 0x70, 0x07, 0x0F, 0x00,
  0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x0F, 0x01, 0xE0, 0x78,
  0x3C, 0x07, 0xC7, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xF1, 0xF0, 0x3C,
  0x07, 0x83, 0x80, 0x38, 0x70, 0x03, 0xC7, 0x00, 0x3C, 0xE0, 0x03, 0xCE,
  0x00, 0x3C, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xF0, 0x0F, 0x07, 0x83, 0xF0,
  0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xFC, 0x03, 0xF3, 0xE0, 0x78, 0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x1E,
  0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0xF1, 0xE0, 0x1F, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xF9, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0x78, 0x04, 0x00, 0x00, 0xF0,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x0F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x01, 0xC0, 0x1C, 0x01,
  0xE0, 0x7E, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x88, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x3F, 0xF8, 0x70, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x02, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80,
  0x7F, 0xFC, 0x07, 0xC0, 0xF0, 0x7C, 0x03, 0x83, 0xC0, 0x1C, 0x3C, 0x00,
  0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x39, 0xE0, 0x3F, 0xCE, 0x07, 0xFE, 0xF0,
  0xFD, 0xF7, 0x8F, 0x07, 0x38, 0x70, 0x3B, 0xC7, 0x81, 0xDE, 0x38, 0x1E,
  0xE1, 0xC0, 0xE7, 0x1E, 0x07, 0x38, 0xE0, 0x39, 0xC7, 0x03, 0xCE, 0x3C,
  0x1C, 0x71, 0xE0, 0xE3, 0x87, 0x07, 0x1C, 0x3F, 0xF8, 0xE0, 0xFF, 0x87,
  0x01, 0xF8, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x67, 0x00, 0x07, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x38, 0x38, 0x01, 0xC1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8E, 0x00, 0x1C, 0x70, 0x00,
  0xE7, 0x00, 0x07, 0x38, 0x00, 0x3B, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x70, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xE0,
  0x1E, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xC0, 0x0E,
  0x07, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0xF0, 0x07, 0x03, 0x80, 0x78, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0x00, 0x78, 0x1C, 0x00,
  0xF0, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xF0,
  0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x07, 0xC1, 0xE3,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xF8, 0x06, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x01, 0x00, 0xFC, 0x3C, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0xE0, 0x7C, 0x07, 0x80, 0x70, 0x1C, 0x01, 0xE0, 0x70, 0x03, 0x81, 0xC0,
  0x0E, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x0F,
  0x0E, 0x00, 0x3C, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C,
  0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x3C, 0x38, 0x00,
  0xE1, 0xE0, 0x07, 0x87, 0x00, 0x3C, 0x1C, 0x01, 0xE0, 0x70, 0x1F, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0,
  0x7F, 0x3E, 0x07, 0x80, 0x20, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x38,
  0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x0E, 0x00,
  0x38, 0x78, 0x01, 0xC3, 0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0x78, 0x07, 0x01,
  0xF0, 0x78, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x07, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x0F, 0x03, 0x80, 0x0E, 0x03,
  0x80, 0x0E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1C, 0x00, 0x70, 0x1C,
  0x00, 0x70, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x38,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x70,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x60, 0x1E, 0x07, 0x83, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x78, 0x0E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0x70, 0x1E, 0x00, 0xE0, 0x78, 0x01, 0xC1, 0xE0, 0x07, 0x87,
  0x80, 0x0E, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x39, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x38, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xE0, 0x07,
  0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0xE0,
  0x07, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0x01, 0xB8,
  0x3E, 0x01, 0xB8, 0x36, 0x01, 0xB8, 0x76, 0x03, 0xB8, 0xEE, 0x03, 0x38,
  0xCE, 0x03, 0x39, 0xCE, 0x07, 0x19, 0x8E, 0x07, 0x1B, 0x8C, 0x06, 0x1B,
  0x1C, 0x0E, 0x1F, 0x1C, 0x0E, 0x1E, 0x1C, 0x0C, 0x1C, 0x1C, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x01, 0xE0,
  0x07, 0x03, 0xE0, 0x07, 0x03, 0xE0, 0x0E, 0x03, 0xF0, 0x0E, 0x03, 0xF0,
  0x0E, 0x07, 0x70, 0x0E, 0x07, 0x30, 0x0C, 0x07, 0x38, 0x1C, 0x07, 0x38,
  0x1C, 0x06, 0x38, 0x1C, 0x0E, 0x1C, 0x18, 0x0E, 0x1C, 0x38, 0x0E, 0x1C,
  0x38, 0x0C, 0x1C, 0x38, 0x1C, 0x0C, 0x38, 0x1C, 0x0E, 0x70, 0x1C, 0x0E,
  0x70, 0x18, 0x0E, 0x70, 0x38, 0x06, 0x70, 0x38, 0x06, 0xE0, 0x38, 0x07,
  0xE0, 0x38, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x03, 0xC0, 0x70, 0x03,
  0xC0, 0x70, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFE,
  0x00, 0x7C, 0xF8, 0x07, 0x81, 0xE0, 0x70, 0x07, 0x07, 0x80, 0x38, 0x38,
  0x01, 0xC3, 0x80, 0x0F, 0x1C, 0x00, 0x79, 0xC0, 0x03, 0xCE, 0x00, 0x1C,
  0xF0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00,
  0x1E, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x79, 0xC0, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x01, 0xC3, 0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0x78, 0x1E,
  0x03, 0xE1, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0x01, 0xF0, 0x38,
  0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xE0, 0xE0, 0x0F, 0x0F, 0x00,
  0xF0, 0x70, 0x3F, 0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x7C, 0xF8, 0x07, 0x81,
  0xE0, 0x70, 0x07, 0x07, 0x80, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x0F, 0x1C,
  0x00, 0x79, 0xC0, 0x03, 0xCE, 0x00, 0x1E, 0xF0, 0x00, 0xE7, 0x00, 0x07,
  0x38, 0x00, 0x39, 0xC0, 0x01, 0xDE, 0x00, 0x1E, 0xE0, 0x00, 0xE7, 0x00,
  0x07, 0x38, 0x00, 0x79, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x01, 0xC3,
  0xC0, 0x1E, 0x1E, 0x00, 0xE0, 0x78, 0x1E, 0x03, 0xE1, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xE0, 0x1E, 0x03, 0x80, 0x3C,
  0x0E, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0xE0, 0x70, 0x03, 0x83, 0xC0, 0x0E, 0x0E, 0x00, 0xF0, 0x38, 0x07,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x70, 0x38, 0x01,
  0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0F, 0x07, 0x00, 0x1C,
  0x3C, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xF8, 0x02, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x40, 0x07, 0x81,
  0xE0, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x05, 0xC0, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x1C,
  0x3C, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x78,
  0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01,
  0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0F, 0x00,
  0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x78,
  0x1C, 0x01, 0xC0, 0x70, 0x0F, 0x01, 0xF0, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00,
  0x07, 0x9C, 0x00, 0x1C, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x70, 0x1C,
  0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x1C, 0x0F,
  0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x00, 0x1E, 0x38, 0x00,
  0x38, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x18, 0x38, 0x38, 0x38, 0x78,
  0x30, 0x38, 0x78, 0x70, 0x38, 0xF8, 0x70, 0x38, 0xDC, 0x70, 0x31, 0xDC,
  0x60, 0x33, 0x9C, 0xE0, 0x73, 0x9C, 0xE0, 0x77, 0x0C, 0xC0, 0x76, 0x0D,
  0xC0, 0x6E, 0x0D, 0x80, 0x6C, 0x0D, 0x80, 0x7C, 0x0D, 0x80, 0x78, 0x0F,
  0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0,
  0x01, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x38, 0x03, 0x80,
  0x07, 0x80, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x3C, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xC0, 0x38, 0x00, 0x70, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xB8, 0x00, 0x3C, 0xE0, 0x01, 0xC7, 0x00, 0x1C, 0x38, 0x01,
  0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0xF0, 0x0E,
  0x07, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x78, 0x00, 0x3B, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xF1, 0xE3, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x78, 0xF1, 0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1D, 0xC0, 0x1C, 0x70,
  0x1E, 0x38, 0x1E, 0x1C, 0x0E, 0x06, 0x0E, 0x03, 0x8E, 0x01, 0xCF, 0x00,
  0x6F, 0x00, 0x3F, 0x00, 0x1D, 0x00, 0x04, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x20, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x04, 0x00, 0x3F, 0xE0,
  0x3F, 0xFC, 0x1F, 0xEF, 0x87, 0xC0, 0xE1, 0xE0, 0x1C, 0x78, 0x03, 0x8E,
  0x00, 0x73, 0xC0, 0x1E, 0x70, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x0E, 0x70,
  0x03, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0,
  0x0E, 0x1E, 0x03, 0xC1, 0xE1, 0xFC, 0x3F, 0xFB, 0x83, 0xFE, 0x70, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x7F, 0x80, 0x7F, 0xFC, 0x07, 0xF7, 0xE0, 0xF0, 0x1E, 0x0E, 0x00,
  0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0,
  0x07, 0x1C, 0x00, 0xF1, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x1E, 0x38,
  0x03, 0xC3, 0x80, 0x78, 0x70, 0x0F, 0x87, 0x01, 0xF0, 0x79, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xF9,
  0xE0, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x08, 0x3E, 0x07, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFD, 0xE0,
  0x1F, 0x03, 0x80, 0xF0, 0x0E, 0x07, 0x80, 0x70, 0x3C, 0x01, 0xC0, 0xE0,
  0x07, 0x07, 0x80, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0x83, 0xC0, 0x0E,
  0x0E, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0F,
  0x00, 0x70, 0x1C, 0x03, 0xC0, 0x78, 0x3F, 0x00, 0xFF, 0xFC, 0x01, 0xFE,
  0x38, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x0E,
  0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x78, 0x01,
  0xE7, 0x00, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x08, 0x3F,
  0x0F, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7C, 0x0E, 0x03, 0xC0, 0x38, 0x1E, 0x00, 0xE0, 0xF0, 0x07, 0x83,
  0x80, 0x1C, 0x1E, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00,
  0x38, 0x3C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0F, 0x00, 0x70,
  0x1C, 0x03, 0xC0, 0x7C, 0x7F, 0x00, 0xFF, 0xFC, 0x01, 0xFE, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x80, 0x1E,
  0x03, 0xC1, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1D, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0E, 0x03, 0xC3, 0xC0, 0x38,
  0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x03, 0xCF, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7,
  0x00, 0x79, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0F, 0x3C,
  0x01, 0xC0, 0x00, 0x80, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0xFF, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0xF0, 0xFF, 0x03,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x20, 0x0E, 0x01, 0xE1, 0xF0, 0x0F,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x1E, 0x0E, 0x01,
  0xE0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x3E, 0x01, 0xC3, 0xC0, 0x0E,
  0x7C, 0x00, 0xF7, 0xC0, 0x07, 0x78, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0E, 0xF0, 0x00, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x38, 0x3C, 0x01, 0xC0,
  0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1E, 0x07, 0x00, 0x70, 0x38, 0x03, 0xC3,
  0xC0, 0x0E, 0x00, 0xFF, 0xDF, 0xF3, 0xFE, 0x01, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x86, 0xFF, 0xCF, 0xF8, 0x03, 0xF9,
  0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0x87, 0x0F, 0x0E, 0x1C, 0x3C,
  0x38, 0x70, 0xE1, 0xC1, 0xC3, 0x87, 0x0F, 0x0E, 0x1C, 0x38, 0x38, 0x70,
  0xE1, 0xC3, 0x83, 0x87, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0x03,
  0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8E,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0x80, 0xF0, 0xF0, 0x0E, 0x1C, 0x01, 0xC3, 0x80,
  0x38, 0x70, 0x07, 0x1E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0xF3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x78, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xCF, 0x00, 0x70, 0x00, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0x81, 0xE1, 0xE0, 0x1E, 0x78, 0x01,
  0xCF, 0x00, 0x3B, 0xC0, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07,
  0xF8, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07, 0xB8, 0x00, 0xE7, 0x00, 0x3C,
  0xF0, 0x0F, 0x0E, 0x03, 0xE1, 0xFB, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x3C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0xC3, 0xC0, 0x0E, 0x0E, 0x00, 0x38,
  0x38, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x80, 0x3C, 0x1C, 0x01, 0xE0, 0x70,
  0x1F, 0x01, 0xE7, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x03, 0xFD,
  0xE0, 0x78, 0x0E, 0x0F, 0x00, 0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xC3, 0x80,
  0x1C, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0x8E, 0x00, 0x38, 0xE0,
  0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xF0, 0x07, 0x07,
  0x00, 0xF0, 0x78, 0x3E, 0x03, 0xFF, 0xE0, 0x1F, 0xEE, 0x00, 0x31, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x01, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0x80, 0x20, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x08, 0x01, 0xE1,
  0xE0, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x38, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF3, 0x80,
  0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x78, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x0E, 0x38, 0x03, 0xCF, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0xF0, 0x0F, 0x0E, 0x03, 0xE1, 0xE1, 0xFC, 0x1F, 0xFB,
  0x81, 0xFC, 0x70, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xDC, 0x00, 0xEE,
  0x00, 0xE7, 0x00, 0x73, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x38, 0x70, 0x1C,
  0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x0E, 0x03, 0x8F, 0x01, 0xC7, 0x00, 0xE7,
  0x00, 0x77, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70,
  0x00, 0x39, 0xC0, 0x01, 0xC7, 0x07, 0x07, 0x1C, 0x1C, 0x1C, 0x70, 0xF0,
  0xE1, 0xC7, 0xC3, 0x87, 0x1F, 0x1C, 0x1C, 0xEC, 0x70, 0xE3, 0x39, 0xC3,
  0x9C, 0xEE, 0x0E, 0xE3, 0xB8, 0x3B, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0x03, 0x80,
  0x0E, 0x07, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x0E, 0x0F,
  0x00, 0x1E, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x79, 0xC0, 0x01, 0xE1, 0xC0, 0x07, 0x83, 0x80, 0x1E,
  0x03, 0x80, 0x78, 0x07, 0x01, 0xE0, 0x0F, 0x0F, 0x80, 0x0E, 0x00, 0x01,
  0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x0E, 0x01,
  0xC0, 0x0E, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x1C, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00,
  0xF0, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x71, 0xE0, 0x00, 0x71, 0xC0, 0x00,
  0x7B, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x43, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x43, 0xF8, 0x0C, 0xFF, 0x83, 0xB8, 0x7C, 0xEE, 0x07, 0xF9, 0xC0, 0x3E,
  0x00,
};

const GFXglyph UbuntuSansMono_Italic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 10, 29, 22, 6, -28 },
  { 38, 11, 10, 22, 9, -30 },
  { 52, 24, 28, 22, 0, -28 },
  { 136, 20, 35, 22, 2, -31 },
  { 224, 26, 29, 22, -1, -28 },
  { 319, 19, 28, 22, 1, -28 },
  { 386, 5, 11, 22, 12, -30 },
  { 393, 17, 38, 22, 5, -31 },
  { 474, 17, 38, 22, 1, -31 },
  { 555, 17, 16, 22, 5, -28 },
  { 589, 19, 20, 22, 2, -22 },
  { 637, 10, 12, 22, 3, -6 },
  { 652, 10, 3, 22, 7, -13 },
  { 656, 6, 7, 22, 6, -6 },
  { 662, 26, 38, 22, -3, -31 },
  { 786, 20, 29, 22, 2, -28 },
  { 859, 16, 28, 22, 3, -28 },
  { 915, 20, 28, 22, 2, -28 },
  { 985, 20, 29, 22, 1, -28 },
  { 1058, 20, 28, 22, 1, -28 },
  { 1128, 22, 29, 22, 1, -28 },
  { 1208, 20, 29, 22, 3, -28 },
  { 1281, 20, 28, 22, 5, -28 },
  { 1351, 20, 29, 22, 2, -28 },
  { 1424, 20, 28, 22, 2, -28 },
  { 1494, 10, 22, 22, 6, -21 },
  { 1522, 13, 27, 22, 3, -21 },
  { 1566, 19, 17, 22, 2, -20 },
  { 1607, 21, 11, 22, 1, -17 },
  { 1636, 20, 17, 22, 1, -20 },
  { 1679, 15, 29, 22, 6, -28 },
  { 1734, 21, 34, 22, 2, -28 },
  { 1824, 21, 28, 22, -2, -28 },
  { 1898, 22, 28, 22, 0, -28 },
  { 1975, 22, 29, 22, 2, -28 },
  { 2055, 22, 28, 22, 0, -28 },
  { 2132, 22, 28, 22, 2, -28 },
  { 2209, 22, 28, 22, 2, -28 },
  { 2286, 21, 29, 22, 2, -28 },
  { 2363, 24, 28, 22, 0, -28 },
  { 2447, 20, 28, 22, 2, -28 },
  { 2517, 21, 29, 22, 2, -28 },
  { 2594, 23, 28, 22, 1, -28 },
  { 2675, 16, 28, 22, 1, -28 },
  { 2731, 24, 28, 22, -1, -28 },
  { 2815, 24, 28, 22, 0, -28 },
  { 2899, 21, 29, 22, 2, -28 },
  { 2976, 21, 28, 22, 1, -28 },
  { 3050, 21, 35, 22, 2, -28 },
  { 3142, 22, 28, 22, 0, -28 },
  { 3219, 22, 29, 22, 1, -28 },
  { 3299, 20, 28, 22, 5, -28 },
  { 3369, 22, 29, 22, 2, -28 },
  { 3449, 22, 28, 22, 4, -28 },
  { 3526, 24, 28, 22, 1, -28 },
  { 3610, 27, 28, 22, -1, -28 },
  { 3705, 21, 28, 22, 5, -28 },
  { 3779, 24, 28, 22, 0, -28 },
  { 3863, 19, 38, 22, 3, -31 },
  { 3954, 7, 38, 22, 8, -31 },
  { 3988, 19, 38, 22, 0, -31 },
  { 4079, 17, 15, 22, 4, -28 },
  { 4111, 21, 2, 22, -3, 5 },
  { 4117, 8, 8, 22, 10, -31 },
  { 4125, 19, 21, 22, 2, -21 },
  { 4175, 20, 31, 22, 1, -31 },
  { 4253, 20, 22, 22, 1, -21 },
  { 4308, 22, 31, 22, 2, -31 },
  { 4394, 20, 22, 22, 1, -21 },
  { 4449, 26, 39, 22, -1, -31 },
  { 4576, 22, 29, 22, 0, -21 },
  { 4656, 19, 31, 22, 0, -31 },
  { 4730, 12, 31, 22, 5, -31 },
  { 4777, 21, 38, 22, 0, -31 },
  { 4877, 21, 31, 22, 1, -31 },
  { 4959, 11, 31, 22, 7, -31 },
  { 5002, 22, 21, 22, 0, -21 },
  { 5060, 19, 21, 22, 1, -21 },
  { 5110, 19, 21, 22, 2, -21 },
  { 5160, 22, 28, 22, -1, -21 },
  { 5237, 20, 28, 22, 2, -21 },
  { 5307, 19, 21, 22, 3, -21 },
  { 5357, 19, 21, 22, 2, -21 },
  { 5407, 16, 27, 22, 5, -27 },
  { 5461, 19, 21, 22, 2, -21 },
  { 5511, 17, 21, 22, 5, -21 },
  { 5556, 22, 21, 22, 2, -21 },
  { 5614, 23, 21, 22, -1, -21 },
  { 5675, 24, 29, 22, -2, -21 },
  { 5762, 20, 21, 22, 1, -21 },
  { 5815, 22, 38, 22, 2, -31 },
  { 5920, 12, 38, 22, 6, -31 },
  { 5977, 22, 38, 22, -2, -31 },
  { 6082, 19, 6, 22, 2, -15 },
};

const GFXfont UbuntuSansMono_Italic40pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic40pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic40pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _UBUNTUSANSMONO_ITALIC40PT7B_H_
