#ifndef _UBUNTUSANSMONO_ITALIC41PT7B_H_
#define _UBUNTUSANSMONO_ITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x1F,
  0x83, 0xF0, 0x3C, 0x02, 0x00, 0x38, 0x77, 0x06, 0x70, 0xE7, 0x0E, 0x70,
  0xE6, 0x0C, 0xE0, 0xCE, 0x1C, 0xC1, 0x8C, 0x18, 0xC1, 0x80, 0x00, 0x0F,
  0x07, 0x00, 0x0E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x38, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xE0, 0x01, 0xC0,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x03,
  0x80, 0x07, 0x07, 0x84, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x1E, 0x0E,
  0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0x70, 0x38, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xC0, 0x30, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0xC0, 0x1E, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x20, 0x3F, 0x80, 0x38, 0x0E, 0x70, 0x0E, 0x03, 0x8E, 0x03, 0x80, 0x60,
  0xC0, 0xF0, 0x1C, 0x18, 0x1C, 0x03, 0x87, 0x07, 0x00, 0x70, 0xE1, 0xC0,
  0x0E, 0x1C, 0x70, 0x01, 0xC3, 0x1C, 0x00, 0x38, 0xE7, 0x00, 0x07, 0x1C,
  0xE0, 0x00, 0x7F, 0x38, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE1, 0x00, 0x00, 0x39, 0xFC, 0x00, 0x0E, 0x7F, 0x80, 0x01, 0xCE,
  0x30, 0x00, 0x73, 0x87, 0x00, 0x1C, 0x60, 0xE0, 0x07, 0x0C, 0x18, 0x01,
  0xC3, 0x83, 0x00, 0x70, 0x70, 0xE0, 0x1C, 0x0E, 0x1C, 0x03, 0x81, 0xC3,
  0x80, 0xE0, 0x38, 0xE0, 0x38, 0x03, 0xB8, 0x0E, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xE0,
  0xE0, 0x3C, 0x1C, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x83,
  0x80, 0xF0, 0xF0, 0x0E, 0x3C, 0x01, 0xCF, 0x00, 0x3F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x38, 0x7F, 0x87, 0x1E, 0x70, 0xE7, 0x0F, 0x39, 0xE0, 0xE7,
  0x38, 0x0F, 0xC7, 0x01, 0xF9, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x1F, 0x1E, 0x07, 0xF1, 0xFF, 0xEE, 0x1F, 0xF1, 0xC1, 0xFC, 0x3C,
  0x3C, 0xE3, 0x8E, 0x79, 0xC7, 0x1C, 0x61, 0x8E, 0x30, 0x00, 0x01, 0x00,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x04, 0x1C, 0x17, 0xCE, 0x7F,
  0xFB, 0xFE, 0xFF, 0xFE, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xDC, 0x01, 0xEF,
  0x01, 0xE3, 0xC1, 0xF1, 0xF0, 0x70, 0x70, 0x10, 0x10, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xC0,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x83, 0xE0,
  0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0x38, 0x1E, 0x0F, 0x1F, 0x8F, 0xC3, 0xC0,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0xFD, 0xFF, 0xF7, 0xCF, 0x84,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3E, 0x1E, 0x03, 0xC0, 0xF0,
  0x78, 0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x1E, 0x00, 0x71, 0xC0, 0x07,
  0x3C, 0x00, 0x73, 0x87, 0x07, 0x38, 0xF8, 0xF7, 0x8F, 0x8F, 0x78, 0xF8,
  0xE7, 0x0F, 0x8E, 0x70, 0xF0, 0xE7, 0x00, 0x1E, 0xF0, 0x01, 0xCF, 0x00,
  0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0x70,
  0x1E, 0x07, 0x83, 0xE0, 0x7C, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFE,
  0x0F, 0xFE, 0x0F, 0x9E, 0x04, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x78, 0x1F, 0x02, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0x81, 0xE0, 0x10, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC2, 0x00, 0x7C, 0x1F, 0x1F, 0xC1, 0xFF, 0xFC,
  0x07, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1E, 0xE0, 0x03, 0xCE, 0x00, 0x79, 0xE0,
  0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x03, 0x83, 0xC0, 0x70, 0x38,
  0x0F, 0x03, 0x81, 0xE0, 0x38, 0x1C, 0x07, 0x83, 0x80, 0x70, 0x78, 0x07,
  0x07, 0x00, 0x70, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x40, 0x0F, 0x80, 0xF0, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x00, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3B, 0xFE,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0x80, 0x38, 0x70, 0x03, 0xCF, 0x00,
  0x1C, 0xF0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0xCE, 0x00, 0x38, 0xE0,
  0x03, 0x8E, 0x00, 0x78, 0xF0, 0x07, 0x07, 0x00, 0xF0, 0x78, 0x3E, 0x03,
  0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x20, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0x81, 0xE0, 0x78, 0x07, 0x83, 0x80, 0x3C, 0x1C, 0x00, 0xE1,
  0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0x83, 0xC0, 0x3C, 0x0E, 0x03,
  0xC0, 0x78, 0x3C, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xF7, 0xE0, 0x1E,
  0x0F, 0x81, 0xE0, 0x3E, 0x1E, 0x00, 0xF0, 0xE0, 0x03, 0x87, 0x00, 0x1C,
  0x78, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80,
  0x3C, 0x1E, 0x07, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xA0, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0x81, 0xE0, 0x78,
  0x07, 0x07, 0x80, 0x3C, 0x38, 0x01, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x38,
  0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x0F, 0x00,
  0x38, 0x3C, 0x0F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x07, 0x8F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x7E, 0x1F, 0x8F, 0xE1, 0xF0, 0x7C, 0x04, 0x00, 0x00, 0xF0, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F,
  0x80, 0x7E, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xC0, 0x1E, 0x01, 0xE0,
  0x7E, 0x07, 0xE0, 0x3C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07,
  0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x30, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0,
  0x08, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFE, 0x10, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7C, 0x1E, 0x03, 0xC0, 0x3C, 0x1E,
  0x00, 0x70, 0xF0, 0x01, 0xC3, 0xC0, 0x07, 0x1E, 0x00, 0x1C, 0x70, 0x03,
  0xF3, 0xC0, 0xFF, 0x8E, 0x0F, 0xFE, 0x78, 0x7C, 0x39, 0xE3, 0xC1, 0xE7,
  0x0E, 0x07, 0xBC, 0x78, 0x1C, 0xF1, 0xC0, 0x73, 0x87, 0x01, 0xCE, 0x1C,
  0x0F, 0x38, 0xF0, 0x38, 0xE3, 0xC0, 0xE3, 0x87, 0x03, 0x8E, 0x1C, 0x1E,
  0x38, 0x78, 0x70, 0xE0, 0xFF, 0xC3, 0x81, 0xFF, 0x0F, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0x70,
  0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1E, 0x00, 0x38, 0x78, 0x00,
  0xE0, 0xE0, 0x07, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xE3, 0xC0,
  0x03, 0x8E, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0xF0, 0x3F, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0,
  0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x83, 0xC0, 0x3C,
  0x0E, 0x03, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0x87, 0xF8, 0x1C,
  0x00, 0xF0, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x3C, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x01, 0xE1,
  0xC0, 0x1F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0x80, 0xE0, 0x3C,
  0x00, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x02, 0x00, 0xFC, 0x3C, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xE0,
  0xFC, 0x03, 0x80, 0xF8, 0x1E, 0x01, 0xE0, 0x70, 0x03, 0xC1, 0xC0, 0x0F,
  0x07, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x00, 0x0F, 0x1C, 0x00,
  0x38, 0x70, 0x00, 0xE3, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x1C, 0x00, 0xF0, 0x70, 0x07, 0x81, 0xC0,
  0x7C, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xF8, 0x0E, 0x07, 0xC0, 0x08, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0F, 0x00, 0x38, 0x1C,
  0x00, 0xE0, 0x78, 0x03, 0x81, 0xF0, 0x1E, 0x03, 0xF0, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x81, 0xE0,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x3C,
  0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x1E, 0x07,
  0x80, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x78,
  0x0E, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0F,
  0x01, 0xC0, 0x07, 0x01, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x01,
  0xE0, 0x38, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x00, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x10, 0x03, 0xC0, 0x60, 0x1E, 0x03, 0xE1, 0xF0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x1F,
  0x03, 0x80, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x07, 0x01, 0xE0,
  0x07, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0E, 0x1E, 0x00,
  0x0E, 0x7C, 0x00, 0x0E, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x3C, 0xF0, 0x00,
  0x38, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x1E, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0xF0, 0x03, 0x80,
  0xE0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0x80,
  0x3E, 0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xB0, 0x0F, 0xC1, 0xF8,
  0x06, 0xE0, 0xDC, 0x03, 0x70, 0xEE, 0x03, 0xB8, 0x67, 0x01, 0x8C, 0x73,
  0x01, 0xC6, 0x73, 0x80, 0xE3, 0x31, 0xC0, 0x71, 0xB8, 0xE0, 0x30, 0xD8,
  0x70, 0x38, 0x7C, 0x38, 0x1C, 0x3C, 0x38, 0x0E, 0x1E, 0x1C, 0x0E, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0,
  0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x03,
  0x80, 0xF0, 0x03, 0x80, 0xF8, 0x01, 0xC0, 0x7E, 0x00, 0xE0, 0x3F, 0x00,
  0x70, 0x1F, 0x80, 0x70, 0x1C, 0xE0, 0x38, 0x0E, 0x70, 0x1C, 0x07, 0x38,
  0x0E, 0x03, 0x8C, 0x0E, 0x01, 0x87, 0x07, 0x01, 0xC3, 0x83, 0x80, 0xE1,
  0xC1, 0xC0, 0x70, 0x61, 0xC0, 0x30, 0x38, 0xE0, 0x38, 0x1C, 0x70, 0x1C,
  0x0E, 0x38, 0x0E, 0x03, 0x18, 0x07, 0x01, 0x9C, 0x07, 0x00, 0xEE, 0x03,
  0x80, 0x77, 0x01, 0xC0, 0x3B, 0x80, 0xE0, 0x0F, 0x80, 0xE0, 0x07, 0xC0,
  0x70, 0x03, 0xE0, 0x38, 0x01, 0xF0, 0x1C, 0x00, 0xF0, 0x1C, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0x81, 0xE0,
  0x78, 0x07, 0x03, 0x80, 0x3C, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00,
  0x39, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x80, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x80, 0x03,
  0xB8, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x70, 0x00, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0x70, 0x70, 0x07, 0x03, 0xC0, 0x78, 0x1F, 0x0F, 0x80,
  0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xE0, 0x3E, 0x03, 0x80, 0x38, 0x0E, 0x00,
  0xF0, 0x78, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xF0,
  0xF0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x78, 0x38, 0x03, 0xC1, 0xE0,
  0x1E, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF8,
  0x07, 0x81, 0xE0, 0x78, 0x07, 0x83, 0x80, 0x3C, 0x38, 0x00, 0xE3, 0xC0,
  0x07, 0x1C, 0x00, 0x39, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x77,
  0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xEE, 0x00, 0x0E, 0xF0, 0x00,
  0x77, 0x80, 0x03, 0xB8, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x70,
  0x00, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x70, 0x70, 0x07, 0x03, 0xC0, 0x78,
  0x1F, 0x0F, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x78, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x70, 0x3F, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0x70, 0x38,
  0x01, 0xC0, 0xE0, 0x07, 0x07, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01,
  0xC1, 0xC0, 0x0F, 0x0F, 0x00, 0x38, 0x38, 0x03, 0xC0, 0xE0, 0x3E, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xC0, 0xE0, 0x07, 0x03,
  0xC0, 0x1C, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0,
  0x38, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xF0,
  0x01, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7C,
  0x06, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC1, 0x80,
  0x1E, 0x07, 0xC3, 0xF8, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x16, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x1E, 0x1E,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x38, 0x00,
  0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1C,
  0x1E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0x83,
  0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x3C,
  0x00, 0xE0, 0x38, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xF8, 0x7C, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x70, 0x00, 0xE3,
  0x80, 0x0F, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x87, 0x00, 0x38, 0x38, 0x03,
  0xC1, 0xC0, 0x1C, 0x0E, 0x01, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C,
  0x07, 0x00, 0xF0, 0x70, 0x07, 0x83, 0x80, 0x1C, 0x38, 0x00, 0xE3, 0xC0,
  0x07, 0x1C, 0x00, 0x39, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0x77,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00,
  0x07, 0x83, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x1C,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x03, 0x87, 0x87, 0x03,
  0x87, 0xC3, 0x81, 0xC3, 0xE1, 0xC0, 0xE3, 0xB1, 0xC0, 0x71, 0x98, 0xE0,
  0x31, 0xCC, 0x70, 0x18, 0xC6, 0x30, 0x1C, 0xE3, 0x38, 0x0E, 0xE1, 0x9C,
  0x07, 0x70, 0xCC, 0x03, 0x70, 0x7E, 0x01, 0xB0, 0x3F, 0x00, 0xF8, 0x1F,
  0x00, 0x78, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x1E,
  0x00, 0x3C, 0x03, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x0E,
  0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x07, 0x80, 0x0E, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xE7, 0x00, 0x0F, 0x1C, 0x00, 0x38,
  0x70, 0x01, 0xE1, 0xC0, 0x0F, 0x07, 0x80, 0x38, 0x0E, 0x01, 0xC0, 0x38,
  0x0F, 0x00, 0xE0, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x70,
  0x00, 0x39, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0xF1, 0xE3,
  0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C,
  0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x80, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xB8, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x78, 0x70, 0x3C, 0x1C, 0x1E,
  0x07, 0x07, 0x00, 0xC3, 0x80, 0x39, 0xE0, 0x0E, 0xF0, 0x01, 0xB8, 0x00,
  0x72, 0x00, 0x10, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x21,
  0xC3, 0xC3, 0xC3, 0x87, 0x87, 0x86, 0x08, 0x00, 0x07, 0x80, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7E, 0x0E, 0x0F, 0x80, 0xE1, 0xE0, 0x0E, 0x3C, 0x01,
  0xC3, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x00, 0x1C, 0xF0, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0xF0, 0x1F, 0x07, 0x87, 0xF0, 0x7F, 0xF7, 0x01,
  0xFE, 0x78, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x1E, 0x00, 0xEF, 0xF8, 0x0F, 0xFF, 0xC0, 0xF8,
  0x3E, 0x1E, 0x01, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0F, 0x1C,
  0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE7,
  0x00, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x07, 0x8E, 0x01, 0xF0,
  0xE0, 0x3E, 0x0F, 0x3F, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7E, 0x02, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x83, 0xF0, 0x78,
  0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFC, 0x0E,
  0x03, 0xE0, 0x38, 0x0F, 0x80, 0x70, 0x1E, 0x00, 0xE0, 0x78, 0x01, 0xC0,
  0xE0, 0x07, 0x03, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x3C,
  0x00, 0xE0, 0x78, 0x01, 0xC0, 0xF0, 0x03, 0x81, 0xE0, 0x07, 0x03, 0xC0,
  0x0E, 0x07, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x0F, 0x87, 0xE0, 0x0F, 0xFE,
  0xE0, 0x0F, 0xF1, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07,
  0xC0, 0xF1, 0xF0, 0x0E, 0x78, 0x01, 0xCF, 0x00, 0x3B, 0xC0, 0x0F, 0x70,
  0x01, 0xFE, 0x00, 0xFB, 0x80, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0x81, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x04, 0x3F, 0x0F, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF0,
  0x20, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x02,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x04, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xE0, 0xE0, 0x3E, 0x01, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x0E, 0x07, 0x80,
  0x1C, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x70, 0x01, 0xC0, 0xE0, 0x03,
  0x81, 0xC0, 0x07, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x70,
  0x3C, 0x00, 0xE0, 0x38, 0x07, 0xC0, 0x7E, 0x7F, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x9C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x01, 0x00, 0x1E, 0x03, 0x80, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x78, 0x3E, 0x07, 0x00, 0xE0, 0xF0, 0x0F, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x0E,
  0x1C, 0x00, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01,
  0xC7, 0x80, 0x1C, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x8F, 0x00,
  0x78, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0xFF, 0x80, 0x38, 0x07, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0xF0, 0x7F, 0x03, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x08, 0x03, 0xC0,
  0x38, 0x1E, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x1F, 0x07, 0x00, 0xF0,
  0x1C, 0x07, 0x80, 0xF0, 0x7C, 0x03, 0x83, 0xC0, 0x0E, 0x1E, 0x00, 0x39,
  0xF0, 0x00, 0xEF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xF0, 0x03,
  0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x1E, 0x07, 0x00,
  0x38, 0x3C, 0x00, 0xF0, 0x7F, 0xDF, 0xFB, 0xFF, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0xDF, 0xF9, 0xFF,
  0x01, 0xE0, 0x70, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0x87, 0xCF, 0x0E,
  0x1C, 0x1C, 0x38, 0x70, 0x70, 0xE1, 0xC1, 0xC7, 0x07, 0x07, 0x1C, 0x1C,
  0x38, 0x70, 0xF0, 0xE1, 0xC3, 0x83, 0x8E, 0x0E, 0x0E, 0x38, 0x38, 0x70,
  0xE1, 0xE1, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0,
  0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x78, 0x3E, 0x07,
  0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71,
  0xE0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0E,
  0x38, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x70, 0x03,
  0xC7, 0x00, 0x38, 0x70, 0x03, 0x8F, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0x07, 0xE1, 0xF0, 0xF0, 0x1E, 0x3C, 0x01, 0xCF, 0x00,
  0x39, 0xC0, 0x07, 0x78, 0x00, 0xEF, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x77, 0x00, 0x1E, 0xF0, 0x07,
  0x9E, 0x01, 0xF1, 0xE0, 0x7C, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x3C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x07,
  0x80, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0F, 0x00,
  0x3C, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x1E, 0x00, 0xF0,
  0x70, 0x07, 0x81, 0xC0, 0x7C, 0x07, 0xDF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7E, 0x0F, 0x0F, 0x80,
  0xF1, 0xF0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE7, 0x00,
  0x1C, 0x70, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCE, 0x00, 0x38, 0xE0,
  0x03, 0x8E, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x70, 0x70, 0x0F, 0x07,
  0xC3, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0x80,
  0x20, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0xFC, 0x0F, 0xFF, 0x83, 0xE0, 0x60, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE1, 0x00, 0x3C, 0x3C, 0x1F, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x1C, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x1E, 0x00, 0xF1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x3C,
  0x01, 0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x78, 0x03, 0xC7,
  0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0xF0, 0x03, 0x8F, 0x00, 0x78,
  0xE0, 0x07, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x07, 0x01, 0xF0, 0x7C, 0x7F,
  0x03, 0xFF, 0x70, 0x1F, 0xE3, 0x80, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00,
  0x7B, 0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x03, 0x8E, 0x01, 0xE3, 0xC0, 0x70,
  0xF0, 0x3C, 0x3C, 0x0E, 0x07, 0x07, 0x81, 0xC1, 0xC0, 0x70, 0xE0, 0x1C,
  0x38, 0x07, 0x1C, 0x01, 0xCE, 0x00, 0x7B, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x39,
  0xE0, 0x00, 0x73, 0x80, 0x01, 0xE7, 0x00, 0x03, 0x8E, 0x06, 0x07, 0x1C,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0xF0, 0x70, 0xE3, 0xF1, 0xC1, 0xC7,
  0xE3, 0x83, 0x9D, 0xCE, 0x07, 0x33, 0x9C, 0x1C, 0xE7, 0x38, 0x3B, 0x86,
  0xE0, 0x77, 0x0D, 0xC0, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x78,
  0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x01, 0xC0,
  0x1E, 0x01, 0xE0, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0x71,
  0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF7,
  0x00, 0x01, 0xE3, 0x80, 0x03, 0xC3, 0x80, 0x07, 0x83, 0xC0, 0x0F, 0x01,
  0xC0, 0x1E, 0x01, 0xE0, 0x3C, 0x00, 0xE0, 0xF8, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x01, 0xE0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00,
  0xE0, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xF3, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x21, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x63, 0xFC, 0x07, 0x7F, 0xF0, 0xE7, 0x0F, 0xFC,
  0xE0, 0x3F, 0x86, 0x01, 0xF0,
};

const GFXglyph UbuntuSansMono_Italic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 11, 29, 23, 6, -28 },
  { 41, 12, 11, 23, 9, -31 },
  { 58, 24, 28, 23, 0, -28 },
  { 142, 21, 36, 23, 2, -32 },
  { 237, 27, 30, 23, -1, -29 },
  { 339, 19, 29, 23, 1, -29 },
  { 408, 6, 12, 23, 12, -31 },
  { 417, 17, 40, 23, 5, -32 },
  { 502, 17, 40, 23, 1, -32 },
  { 587, 17, 16, 23, 5, -28 },
  { 621, 19, 20, 23, 2, -22 },
  { 669, 10, 13, 23, 3, -6 },
  { 686, 10, 3, 23, 7, -13 },
  { 690, 7, 7, 23, 6, -6 },
  { 697, 26, 40, 23, -3, -32 },
  { 827, 20, 30, 23, 2, -29 },
  { 902, 16, 28, 23, 3, -28 },
  { 958, 20, 29, 23, 2, -29 },
  { 1031, 21, 30, 23, 1, -29 },
  { 1110, 20, 28, 23, 1, -28 },
  { 1180, 23, 29, 23, 1, -28 },
  { 1264, 20, 30, 23, 3, -29 },
  { 1339, 20, 28, 23, 5, -28 },
  { 1409, 21, 30, 23, 2, -29 },
  { 1488, 21, 29, 23, 2, -29 },
  { 1565, 10, 22, 23, 6, -21 },
  { 1593, 13, 28, 23, 3, -21 },
  { 1639, 20, 18, 23, 2, -21 },
  { 1684, 21, 12, 23, 1, -18 },
  { 1716, 20, 18, 23, 1, -21 },
  { 1761, 16, 30, 23, 6, -29 },
  { 1821, 22, 35, 23, 2, -29 },
  { 1918, 22, 28, 23, -2, -28 },
  { 1995, 22, 29, 23, 0, -29 },
  { 2075, 23, 30, 23, 2, -29 },
  { 2162, 22, 29, 23, 0, -29 },
  { 2242, 22, 28, 23, 2, -28 },
  { 2319, 22, 28, 23, 2, -28 },
  { 2396, 22, 30, 23, 2, -29 },
  { 2479, 25, 28, 23, 0, -28 },
  { 2567, 21, 28, 23, 2, -28 },
  { 2641, 22, 29, 23, 2, -28 },
  { 2721, 24, 28, 23, 1, -28 },
  { 2805, 16, 28, 23, 1, -28 },
  { 2861, 25, 28, 23, -1, -28 },
  { 2949, 25, 28, 23, 0, -28 },
  { 3037, 21, 30, 23, 2, -29 },
  { 3116, 22, 29, 23, 1, -29 },
  { 3196, 21, 37, 23, 2, -29 },
  { 3294, 22, 29, 23, 0, -29 },
  { 3374, 22, 30, 23, 1, -29 },
  { 3457, 19, 28, 23, 6, -28 },
  { 3524, 23, 29, 23, 2, -28 },
  { 3608, 21, 28, 23, 5, -28 },
  { 3682, 25, 28, 23, 1, -28 },
  { 3770, 27, 28, 23, -1, -28 },
  { 3865, 22, 28, 23, 5, -28 },
  { 3942, 25, 28, 23, 0, -28 },
  { 4030, 20, 40, 23, 3, -32 },
  { 4130, 7, 40, 23, 8, -32 },
  { 4165, 20, 40, 23, 0, -32 },
  { 4265, 18, 15, 23, 4, -28 },
  { 4299, 21, 3, 23, -3, 5 },
  { 4307, 7, 9, 23, 11, -32 },
  { 4315, 20, 22, 23, 2, -22 },
  { 4370, 20, 32, 23, 2, -32 },
  { 4450, 20, 23, 23, 1, -22 },
  { 4508, 23, 32, 23, 2, -32 },
  { 4600, 19, 23, 23, 2, -22 },
  { 4655, 27, 40, 23, -1, -32 },
  { 4790, 23, 30, 23, 0, -22 },
  { 4877, 20, 32, 23, 0, -32 },
  { 4957, 12, 31, 23, 5, -31 },
  { 5004, 22, 39, 23, 0, -31 },
  { 5112, 22, 32, 23, 1, -32 },
  { 5200, 11, 32, 23, 7, -32 },
  { 5244, 22, 22, 23, 0, -22 },
  { 5305, 20, 22, 23, 1, -22 },
  { 5360, 19, 22, 23, 2, -22 },
  { 5413, 22, 30, 23, -1, -22 },
  { 5496, 20, 30, 23, 2, -22 },
  { 5571, 19, 22, 23, 3, -22 },
  { 5624, 19, 22, 23, 2, -22 },
  { 5677, 17, 28, 23, 5, -28 },
  { 5737, 20, 21, 23, 2, -21 },
  { 5790, 18, 21, 23, 5, -21 },
  { 5838, 23, 21, 23, 2, -21 },
  { 5899, 24, 21, 23, -1, -21 },
  { 5962, 25, 29, 23, -2, -21 },
  { 6053, 20, 21, 23, 1, -21 },
  { 6106, 22, 40, 23, 2, -32 },
  { 6216, 12, 40, 23, 6, -32 },
  { 6276, 22, 40, 23, -2, -32 },
  { 6386, 20, 6, 23, 2, -15 },
};

const GFXfont UbuntuSansMono_Italic41pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic41pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic41pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _UBUNTUSANSMONO_ITALIC41PT7B_H_
