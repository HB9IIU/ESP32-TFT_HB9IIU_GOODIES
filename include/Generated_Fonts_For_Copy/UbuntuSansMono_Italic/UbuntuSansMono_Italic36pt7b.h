#ifndef _UBUNTUSANSMONO_ITALIC36PT7B_H_
#define _UBUNTUSANSMONO_ITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x70, 0xDC, 0x76, 0x1D, 0x86, 0xE1,
  0xB0, 0x6C, 0x33, 0x0C, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0xC1, 0xC0,
  0x0E, 0x0C, 0x00, 0x60, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x70, 0x03, 0x83,
  0x83, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x0E, 0x1C, 0x00, 0xE0, 0xE0, 0x07,
  0x06, 0x00, 0x30, 0x70, 0x03, 0x83, 0x00, 0x1C, 0x38, 0x01, 0xC1, 0xC0,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0x06, 0x00, 0x30, 0x70, 0x03, 0x83,
  0x00, 0x18, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x7F, 0xF0, 0x3F, 0xFC, 0x1C, 0x02, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE1, 0x00, 0x70, 0xF0, 0xFC, 0x3F, 0xFE, 0x03, 0xFE,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x03, 0xF0, 0x07, 0x07, 0x70, 0x0E, 0x06, 0x38, 0x1C, 0x0E, 0x38, 0x38,
  0x0C, 0x38, 0x70, 0x0C, 0x30, 0xE0, 0x0C, 0x30, 0xC0, 0x0C, 0x31, 0x80,
  0x0C, 0x73, 0x80, 0x0C, 0x67, 0x00, 0x0F, 0xCE, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x67, 0xE0, 0x00, 0xEE, 0x70,
  0x01, 0xCC, 0x70, 0x03, 0x9C, 0x30, 0x07, 0x18, 0x70, 0x0E, 0x18, 0x70,
  0x0C, 0x18, 0x70, 0x18, 0x18, 0x60, 0x38, 0x18, 0xE0, 0x70, 0x1D, 0xC0,
  0xE0, 0x0F, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0x70, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x18, 0x1C, 0x0C, 0x1C, 0x06,
  0x0E, 0x03, 0x8E, 0x01, 0xDE, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x7E, 0x1C,
  0x77, 0x0C, 0x71, 0xCE, 0x70, 0xE7, 0x38, 0x3B, 0x38, 0x0F, 0x9C, 0x07,
  0x8E, 0x01, 0xC7, 0x01, 0xE3, 0x81, 0xF1, 0xF3, 0xDC, 0x7F, 0xCE, 0x1F,
  0xC7, 0x80, 0x3B, 0x9C, 0xE6, 0x73, 0x98, 0xC6, 0x00, 0x00, 0x0C, 0x00,
  0x70, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x01, 0xC0, 0x01, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C,
  0x06, 0x18, 0x6F, 0x33, 0xFF, 0xFF, 0x8F, 0xF8, 0x03, 0xC0, 0x0F, 0xC0,
  0x39, 0xC0, 0xF3, 0xC3, 0xC3, 0xC3, 0x07, 0x02, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x07, 0x0E, 0x1C, 0xF8, 0xF0, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0xF8, 0xF0, 0x70, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x38, 0x07,
  0x38, 0x03, 0x9C, 0x01, 0xCE, 0x20, 0xEE, 0x3C, 0x77, 0x3E, 0x3B, 0x9F,
  0x1F, 0x87, 0x8F, 0xC1, 0x8E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0x9C,
  0x01, 0xCE, 0x01, 0xC7, 0x01, 0xE3, 0xC1, 0xE0, 0xE1, 0xE0, 0x7F, 0xE0,
  0x1F, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x7E,
  0x07, 0xF8, 0x7C, 0xE0, 0xC7, 0x04, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x3F, 0xFE, 0xFF,
  0xF8, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3C, 0x1E, 0x04, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x0E, 0x0F, 0x02, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x01, 0xE1, 0x81, 0xF8, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x20,
  0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3B,
  0x80, 0x1C, 0xC0, 0x0E, 0x70, 0x07, 0x1C, 0x03, 0x87, 0x01, 0xC1, 0x80,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x03, 0x07, 0x01, 0xC1, 0xC0,
  0x70, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x60, 0x7C, 0x0F, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x40, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x7F, 0x81, 0xFF, 0xF0, 0x7E, 0x3E, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8C, 0x00, 0xE3, 0x80, 0x38,
  0xE0, 0x1C, 0x38, 0x0F, 0x0F, 0x07, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x01,
  0x00, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x1E, 0x0F, 0x07, 0x01, 0xC3, 0x80,
  0x70, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x80, 0xE0, 0xE0, 0x78,
  0x3C, 0x3C, 0x07, 0xFE, 0x01, 0xFE, 0x01, 0xE7, 0xC0, 0xF0, 0x78, 0x78,
  0x0E, 0x1C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03,
  0x8E, 0x01, 0xE3, 0xC0, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x30, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x78, 0x38, 0x38, 0x07, 0x1E, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80,
  0x1C, 0x70, 0x0E, 0x1F, 0x3F, 0x83, 0xFF, 0xE0, 0x7F, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0xF8, 0x0B, 0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF0, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x1C, 0x07, 0x01, 0xC1, 0xF0, 0x3C, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC,
  0x03, 0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x08, 0x1F, 0xFF,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0x08, 0x00,
  0x07, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x7F, 0xC1, 0xFF, 0x84, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0x70, 0x78, 0x07, 0x0F,
  0x00, 0x70, 0xE0, 0x07, 0x1E, 0x00, 0x71, 0xC0, 0xFF, 0x38, 0x3F, 0xE3,
  0x87, 0x8E, 0x38, 0xE0, 0xE7, 0x1C, 0x0E, 0x71, 0xC0, 0xC7, 0x1C, 0x1C,
  0x71, 0x81, 0xC7, 0x38, 0x1C, 0xE3, 0x81, 0xCE, 0x18, 0x38, 0xE1, 0xC3,
  0x8E, 0x1E, 0x38, 0x70, 0xFF, 0x87, 0x07, 0xF0, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x10, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x06, 0xE0,
  0x01, 0xDC, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0x86, 0x00, 0x60, 0xC0,
  0x1C, 0x18, 0x03, 0x03, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0xC1,
  0xC0, 0x38, 0x30, 0x07, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x70, 0x03, 0x8C,
  0x00, 0x73, 0x80, 0x0E, 0x60, 0x01, 0xDC, 0x00, 0x3B, 0x00, 0x07, 0xE0,
  0x00, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0E, 0x0F, 0x83, 0x80, 0x70,
  0x70, 0x0E, 0x0E, 0x00, 0xC1, 0xC0, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xC1,
  0xC0, 0x38, 0x38, 0x7E, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x38, 0x1F, 0x07,
  0x00, 0xF0, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x18,
  0x01, 0xC7, 0x00, 0x38, 0xE0, 0x1E, 0x1C, 0x0F, 0x83, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x3E, 0x0E,
  0x07, 0x80, 0x20, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0x0F, 0x80, 0x70, 0x3C, 0x07, 0x01, 0xE0, 0x60,
  0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x06, 0x0E, 0x00, 0x70, 0xC0, 0x07, 0x1C,
  0x00, 0x61, 0xC0, 0x06, 0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x38, 0x00, 0xE3,
  0x80, 0x0C, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x70, 0x03, 0x87, 0x00, 0x70,
  0x70, 0x0F, 0x07, 0x03, 0xE0, 0xE0, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x04, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x81, 0xE0, 0x60, 0x70,
  0x04, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x18, 0x70, 0x07,
  0x0E, 0x00, 0xE1, 0xE0, 0x1C, 0x1C, 0x03, 0x03, 0xE0, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x0C, 0x00, 0xE0,
  0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0xE0,
  0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0x81, 0xC0, 0x0E,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x70, 0x03, 0x01, 0x80, 0x1C, 0x0E,
  0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x06, 0x03, 0x00, 0x38, 0x1C, 0x00,
  0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0C, 0x06, 0x00, 0x70, 0x38, 0x01, 0xC0,
  0xE0, 0x07, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x80, 0x70, 0x38, 0x1E, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x3C, 0x0E, 0x01, 0xE0, 0x38, 0x0F, 0x00, 0xC0,
  0x78, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0x87, 0x00,
  0x0E, 0x78, 0x00, 0x3B, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x77, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0xE0, 0x03, 0x80, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x0D, 0x83, 0x60,
  0x37, 0x1D, 0x80, 0xDC, 0x66, 0x07, 0x73, 0xB8, 0x19, 0xCC, 0xE0, 0x63,
  0x63, 0x03, 0x8D, 0x8C, 0x0E, 0x3C, 0x70, 0x30, 0xF1, 0xC1, 0xC3, 0x87,
  0x07, 0x00, 0x1C, 0x18, 0x00, 0x60, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E,
  0x00, 0x38, 0x30, 0x00, 0xE1, 0xC0, 0x03, 0x07, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x0F, 0x00, 0x60, 0x3C, 0x01,
  0x81, 0xF0, 0x0E, 0x07, 0xE0, 0x38, 0x1F, 0x80, 0xC0, 0x66, 0x03, 0x03,
  0x98, 0x1C, 0x0E, 0x70, 0x70, 0x39, 0xC1, 0x80, 0xC3, 0x06, 0x03, 0x0C,
  0x38, 0x1C, 0x38, 0xE0, 0x70, 0xE3, 0x81, 0x81, 0x8C, 0x06, 0x06, 0x70,
  0x38, 0x1D, 0xC0, 0xE0, 0x77, 0x03, 0x00, 0xD8, 0x0C, 0x03, 0x60, 0x70,
  0x0F, 0x81, 0xC0, 0x3E, 0x06, 0x00, 0xF0, 0x18, 0x03, 0xC0, 0xE0, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x1E, 0x0E, 0x0F, 0x01,
  0xC3, 0x80, 0x71, 0xC0, 0x1C, 0x60, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x77,
  0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1B, 0x80,
  0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E,
  0x38, 0x07, 0x8F, 0x01, 0xC1, 0xE1, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x00,
  0x20, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1C, 0x0F, 0x03, 0x80, 0xF0,
  0x70, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1,
  0x80, 0x18, 0x70, 0x07, 0x0E, 0x01, 0xC1, 0xC0, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFE, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x1E, 0x0E, 0x0F,
  0x01, 0xC3, 0x80, 0x71, 0xC0, 0x1C, 0x60, 0x07, 0x38, 0x01, 0xCE, 0x00,
  0x77, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x0E, 0x38, 0x07, 0x8F, 0x01, 0xC1, 0xE1, 0xE0, 0x3F, 0xF0, 0x07, 0xF0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xC0, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0x83,
  0xE0, 0x30, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x60,
  0x07, 0x0E, 0x00, 0x60, 0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0xC0, 0x3C, 0x1C,
  0x1F, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xC3, 0x80, 0x38, 0x1C, 0x03,
  0x81, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0x70,
  0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x00, 0x04, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0x81, 0xE0, 0x30, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x10, 0x03, 0x83, 0x81, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x70, 0xE0, 0x06,
  0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0C, 0x18, 0x01,
  0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x18, 0x30, 0x03, 0x87, 0x00,
  0x38, 0x70, 0x03, 0x87, 0x00, 0x30, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x0E,
  0x01, 0xC0, 0x70, 0x78, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x20, 0x00,
  0xE0, 0x00, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xCE, 0x00, 0x39,
  0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x03, 0x83,
  0x80, 0x70, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0xE0, 0x18, 0x18, 0x03,
  0x87, 0x00, 0x70, 0xC0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07,
  0x70, 0x00, 0xEC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C,
  0x00, 0x30, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x06, 0x00, 0x18, 0x18, 0x00,
  0xE0, 0xE0, 0x03, 0x83, 0x87, 0x0C, 0x0E, 0x3C, 0x30, 0x31, 0xF1, 0xC0,
  0xC6, 0xC7, 0x03, 0x3B, 0x18, 0x1C, 0xCC, 0x60, 0x67, 0x33, 0x81, 0x98,
  0xCC, 0x06, 0xC3, 0xB0, 0x1F, 0x0F, 0xC0, 0x78, 0x1E, 0x03, 0xE0, 0x78,
  0x0F, 0x01, 0xC0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x0F,
  0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x78,
  0x00, 0x70, 0x70, 0x00, 0x70, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC7, 0x00,
  0x03, 0xC3, 0x00, 0x07, 0x83, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0xF0, 0x01, 0xE0,
  0xE0, 0x00, 0xF6, 0x00, 0x0E, 0x70, 0x01, 0xC7, 0x00, 0x38, 0x70, 0x03,
  0x83, 0x00, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x01, 0x83,
  0x80, 0x1C, 0x70, 0x01, 0xCE, 0x00, 0x0C, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x08, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0xE1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x87,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xD8, 0x03, 0x9C, 0x07, 0x9C, 0x07, 0x0C, 0x0E,
  0x0E, 0x1C, 0x0E, 0x38, 0x06, 0x78, 0x06, 0xF0, 0x07, 0x60, 0x03, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x21, 0xE1, 0xC1, 0xC1, 0xC3,
  0x83, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x7E, 0x1C, 0x3E, 0x06, 0x1E,
  0x03, 0x87, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0C, 0x70, 0x07, 0x1C, 0x01,
  0xC6, 0x00, 0x73, 0x80, 0x18, 0xE0, 0x0E, 0x38, 0x03, 0x86, 0x00, 0xE1,
  0xC0, 0x78, 0x78, 0x3E, 0x0F, 0xFF, 0x81, 0xFC, 0x60, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x9F, 0x80, 0xFF, 0xF0, 0x3F, 0x1E,
  0x0E, 0x03, 0x83, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC6,
  0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x8C, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x38, 0x70, 0x3C, 0x18, 0x3E, 0x0F, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7C, 0x18, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x7C, 0x06, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x7E,
  0x38, 0x0F, 0x03, 0x81, 0xE0, 0x38, 0x3C, 0x03, 0x07, 0x80, 0x70, 0x70,
  0x07, 0x07, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E,
  0x00, 0xE0, 0xE0, 0x0C, 0x0E, 0x00, 0xC0, 0xE0, 0x1C, 0x07, 0x07, 0xC0,
  0x7F, 0xEC, 0x03, 0xFC, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7C, 0xF8,
  0x3C, 0x0E, 0x1C, 0x01, 0xCF, 0x00, 0x63, 0x80, 0x39, 0xC0, 0x1E, 0x70,
  0x1F, 0x1F, 0xFF, 0x8F, 0xFF, 0x83, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x0E, 0x0F, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x0F, 0xFF, 0x01, 0xF8, 0xE0, 0x3C, 0x0E, 0x07, 0x80, 0xE0, 0xF0, 0x0E,
  0x0E, 0x00, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01,
  0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x07, 0x03, 0xC1,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0xC0, 0x3C, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x01,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xFE, 0x03,
  0xFF, 0xC1, 0xFB, 0xF0, 0xE0, 0x38, 0x70, 0x1C, 0x30, 0x06, 0x38, 0x03,
  0x1C, 0x01, 0x8E, 0x01, 0xC6, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x31, 0xC0,
  0x38, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x06, 0x38, 0x07, 0x18, 0x03, 0x9C,
  0x01, 0xC0, 0x00, 0x80, 0x78, 0x0F, 0x81, 0xF0, 0x3C, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x7F, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0xE4, 0x3F, 0x81, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x02, 0x03, 0x80, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x1C, 0x38, 0x0F, 0x07, 0x03, 0xC0, 0xE0, 0xF0,
  0x18, 0x78, 0x07, 0x1E, 0x00, 0xE7, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1D, 0xE0, 0x03, 0x9E, 0x00, 0x71, 0xE0, 0x1C, 0x1E, 0x03,
  0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0xC1, 0x80, 0x38, 0x70, 0x07, 0x80,
  0x7F, 0xBF, 0xEF, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x17, 0xFC, 0xFF, 0x07,
  0xE7, 0xC1, 0xFF, 0xFC, 0x39, 0xF7, 0x86, 0x1C, 0x71, 0xC3, 0x86, 0x38,
  0x61, 0xC7, 0x1C, 0x38, 0xC3, 0x87, 0x38, 0x70, 0xC7, 0x0E, 0x38, 0xE1,
  0x87, 0x18, 0x70, 0xE7, 0x00, 0x18, 0xE0, 0x03, 0x1C, 0x00, 0xE3, 0x00,
  0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x63, 0x80, 0x1C, 0x00, 0x01, 0xFC, 0x07,
  0xFF, 0x83, 0xF7, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x0C, 0x70, 0x06,
  0x38, 0x07, 0x1C, 0x03, 0x8C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x63, 0x80,
  0x71, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0C, 0x70, 0x0E, 0x30, 0x07, 0x38,
  0x03, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xC0, 0xE3, 0xC0,
  0x39, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x73, 0x80, 0x79, 0xC0, 0x78,
  0x78, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC,
  0x03, 0xE3, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00,
  0x70, 0x70, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0,
  0x0E, 0x0C, 0x01, 0xE1, 0xC0, 0x1C, 0x1C, 0x03, 0x81, 0xC0, 0x78, 0x18,
  0x3F, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x7E, 0x38, 0x3C, 0x0E, 0x1C, 0x03, 0x8E,
  0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x60, 0x07, 0x38, 0x01, 0x8E, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x0E, 0x01, 0xC3, 0x80, 0x70,
  0x70, 0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0x83, 0xFF, 0xC3, 0xF0, 0x41, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x81, 0xF3, 0xC1, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x60, 0x38, 0x7F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x40, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x1F, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x04, 0x1F, 0xF8, 0x1F, 0xF0, 0x1C, 0x03, 0x9C, 0x01,
  0xCE, 0x00, 0xE7, 0x00, 0x63, 0x80, 0x71, 0x80, 0x39, 0xC0, 0x1C, 0xE0,
  0x0C, 0x70, 0x0E, 0x30, 0x07, 0x38, 0x03, 0x9C, 0x01, 0x8E, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x78, 0x70, 0x7C, 0x3F, 0xFE, 0x0F, 0xE3,
  0x00, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0,
  0x1C, 0x60, 0x38, 0x70, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x70,
  0xC0, 0x71, 0xC0, 0x73, 0x80, 0x33, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x77, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x00,
  0x0E, 0x70, 0x00, 0xC6, 0x0E, 0x1C, 0x60, 0xE1, 0xC6, 0x1E, 0x18, 0xE1,
  0xE3, 0x8E, 0x36, 0x30, 0xE7, 0x67, 0x0E, 0x66, 0x70, 0xEE, 0x66, 0x0E,
  0xC6, 0xE0, 0xF8, 0x6C, 0x0F, 0x87, 0xC0, 0xF0, 0x78, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x00, 0x07, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xF0, 0x38, 0x03,
  0x83, 0xC0, 0x1E, 0x3C, 0x00, 0x73, 0xC0, 0x03, 0xDC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1C,
  0xE0, 0x01, 0xC7, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x1C, 0x07, 0x01,
  0xC0, 0x1C, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38,
  0x03, 0x80, 0xE0, 0x0E, 0x01, 0x80, 0x38, 0x07, 0x01, 0xC0, 0x1C, 0x07,
  0x00, 0x70, 0x18, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x1C, 0x00,
  0x38, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x06, 0x70, 0x00, 0x1D,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x01, 0xBF, 0xC1, 0xDC, 0x79, 0xDC,
  0x1F, 0xCC, 0x07, 0xC0,
};

const GFXglyph UbuntuSansMono_Italic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 9, 25, 20, 6, -25 },
  { 30, 10, 9, 20, 8, -27 },
  { 42, 21, 25, 20, 0, -25 },
  { 108, 18, 32, 20, 2, -28 },
  { 180, 24, 26, 20, -1, -25 },
  { 258, 17, 26, 20, 1, -26 },
  { 314, 5, 10, 20, 11, -27 },
  { 321, 14, 35, 20, 5, -28 },
  { 383, 15, 35, 20, 1, -28 },
  { 449, 15, 15, 20, 4, -25 },
  { 478, 17, 17, 20, 2, -19 },
  { 515, 8, 11, 20, 3, -5 },
  { 526, 9, 3, 20, 6, -12 },
  { 530, 5, 5, 20, 6, -5 },
  { 534, 22, 35, 20, -2, -28 },
  { 631, 17, 27, 20, 2, -26 },
  { 689, 14, 25, 20, 3, -25 },
  { 733, 18, 26, 20, 2, -26 },
  { 792, 18, 27, 20, 1, -26 },
  { 853, 18, 25, 20, 1, -25 },
  { 910, 20, 26, 20, 1, -25 },
  { 975, 18, 26, 20, 3, -25 },
  { 1034, 18, 25, 20, 4, -25 },
  { 1091, 18, 27, 20, 2, -26 },
  { 1152, 18, 25, 20, 2, -25 },
  { 1209, 8, 18, 20, 6, -18 },
  { 1227, 11, 24, 20, 3, -18 },
  { 1260, 17, 16, 20, 2, -18 },
  { 1294, 19, 10, 20, 1, -16 },
  { 1318, 18, 16, 20, 1, -18 },
  { 1354, 14, 26, 20, 5, -26 },
  { 1400, 20, 31, 20, 1, -26 },
  { 1478, 19, 25, 20, -2, -25 },
  { 1538, 19, 25, 20, 0, -25 },
  { 1598, 20, 27, 20, 2, -26 },
  { 1666, 20, 25, 20, 0, -25 },
  { 1729, 19, 25, 20, 2, -25 },
  { 1789, 19, 25, 20, 2, -25 },
  { 1849, 19, 27, 20, 2, -26 },
  { 1914, 22, 25, 20, 0, -25 },
  { 1983, 18, 25, 20, 2, -25 },
  { 2040, 19, 26, 20, 2, -25 },
  { 2102, 22, 25, 20, 0, -25 },
  { 2171, 14, 25, 20, 1, -25 },
  { 2215, 22, 25, 20, -1, -25 },
  { 2284, 22, 25, 20, 0, -25 },
  { 2353, 18, 27, 20, 2, -26 },
  { 2414, 19, 25, 20, 1, -25 },
  { 2474, 18, 33, 20, 2, -26 },
  { 2549, 20, 25, 20, 0, -25 },
  { 2612, 19, 27, 20, 1, -26 },
  { 2677, 17, 25, 20, 5, -25 },
  { 2731, 20, 26, 20, 2, -25 },
  { 2796, 19, 25, 20, 4, -25 },
  { 2856, 22, 25, 20, 1, -25 },
  { 2925, 24, 25, 20, -1, -25 },
  { 3000, 20, 25, 20, 4, -25 },
  { 3063, 22, 25, 20, 0, -25 },
  { 3132, 17, 35, 20, 3, -28 },
  { 3207, 6, 35, 20, 7, -28 },
  { 3234, 17, 35, 20, 0, -28 },
  { 3309, 16, 13, 20, 3, -25 },
  { 3335, 19, 3, 20, -3, 4 },
  { 3343, 7, 7, 20, 9, -28 },
  { 3350, 18, 19, 20, 1, -19 },
  { 3393, 18, 28, 20, 1, -28 },
  { 3456, 18, 19, 20, 1, -19 },
  { 3499, 20, 28, 20, 2, -28 },
  { 3569, 18, 19, 20, 1, -19 },
  { 3612, 24, 35, 20, -1, -28 },
  { 3717, 20, 26, 20, 0, -19 },
  { 3782, 17, 28, 20, 0, -28 },
  { 3842, 11, 28, 20, 4, -28 },
  { 3881, 19, 35, 20, 0, -28 },
  { 3965, 19, 28, 20, 1, -28 },
  { 4032, 10, 28, 20, 6, -28 },
  { 4067, 19, 19, 20, 0, -19 },
  { 4113, 17, 19, 20, 1, -19 },
  { 4154, 17, 19, 20, 2, -19 },
  { 4195, 20, 26, 20, -1, -19 },
  { 4260, 18, 26, 20, 2, -19 },
  { 4319, 17, 19, 20, 2, -19 },
  { 4360, 17, 19, 20, 2, -19 },
  { 4401, 15, 25, 20, 4, -25 },
  { 4448, 17, 19, 20, 2, -19 },
  { 4489, 16, 19, 20, 4, -19 },
  { 4527, 20, 19, 20, 2, -19 },
  { 4575, 21, 19, 20, -1, -19 },
  { 4625, 22, 26, 20, -2, -19 },
  { 4697, 18, 19, 20, 1, -19 },
  { 4740, 19, 35, 20, 2, -28 },
  { 4824, 11, 35, 20, 5, -28 },
  { 4873, 20, 35, 20, -2, -28 },
  { 4961, 17, 5, 20, 2, -13 },
};

const GFXfont UbuntuSansMono_Italic36pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic36pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic36pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _UBUNTUSANSMONO_ITALIC36PT7B_H_
