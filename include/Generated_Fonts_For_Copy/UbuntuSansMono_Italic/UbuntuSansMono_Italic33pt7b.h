#ifndef _UBUNTUSANSMONO_ITALIC33PT7B_H_
#define _UBUNTUSANSMONO_ITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x06,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0F,
  0x87, 0x83, 0xC0, 0x31, 0xDC, 0x66, 0x19, 0x86, 0x63, 0x98, 0xCC, 0x33,
  0x0C, 0x82, 0x00, 0x00, 0x38, 0x70, 0x03, 0x06, 0x00, 0x70, 0xE0, 0x06,
  0x0C, 0x00, 0xE1, 0xC0, 0x0C, 0x18, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x23,
  0x87, 0x00, 0x38, 0x70, 0x03, 0x0E, 0x00, 0x70, 0xE0, 0x06, 0x0C, 0x00,
  0xE1, 0xC0, 0x0C, 0x18, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0x87, 0x00,
  0x38, 0x70, 0x03, 0x06, 0x00, 0x70, 0xE0, 0x06, 0x0C, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x07, 0xE0,
  0x0F, 0xFC, 0x0F, 0xBE, 0x0E, 0x01, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE1,
  0xC0, 0xF1, 0xFF, 0xF0, 0x3F, 0xE0, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x1C, 0x1D, 0x80, 0xE0, 0xE7,
  0x07, 0x03, 0x0C, 0x38, 0x0C, 0x70, 0xC0, 0x71, 0x86, 0x01, 0x86, 0x30,
  0x06, 0x19, 0xC0, 0x1C, 0xEE, 0x00, 0x3F, 0x70, 0x00, 0x7B, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x67, 0x80, 0x03, 0x3F, 0x00, 0x1D, 0xCC, 0x00, 0xE6,
  0x30, 0x07, 0x30, 0xC0, 0x18, 0xC3, 0x00, 0xC3, 0x0C, 0x06, 0x0C, 0x30,
  0x30, 0x31, 0x81, 0xC0, 0xEE, 0x0E, 0x01, 0xF0, 0x00, 0x01, 0x00, 0x01,
  0xF8, 0x07, 0xF8, 0x1C, 0x38, 0x30, 0x70, 0xE0, 0xC1, 0xC3, 0x83, 0x87,
  0x07, 0x1C, 0x0E, 0x70, 0x0F, 0xC0, 0x1E, 0x00, 0x7C, 0x33, 0xF8, 0xE6,
  0x39, 0x9C, 0x3B, 0x70, 0x7E, 0xE0, 0x79, 0xC0, 0xF3, 0x80, 0xE7, 0x03,
  0xCF, 0x1F, 0x8F, 0xF3, 0x8F, 0xC7, 0x00, 0x37, 0x76, 0x6E, 0xEC, 0xC0,
  0x00, 0x08, 0x00, 0x60, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x10, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xE3,
  0x1B, 0xED, 0xFF, 0xFF, 0x80, 0xC0, 0x07, 0x80, 0x37, 0x01, 0xCE, 0x0E,
  0x3C, 0x18, 0x60, 0x41, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x3C, 0xF9, 0xF1, 0xE1, 0xC7, 0x1C, 0xF1, 0xC0, 0xFF, 0xFE, 0xFE, 0x77,
  0xFF, 0xF7, 0x80, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0x0E, 0x0E, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x73, 0xC7, 0x63,
  0xC6, 0xE3, 0xCE, 0xE3, 0xCE, 0xE1, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0x70, 0xF1, 0xE0, 0x7F, 0xC0, 0x3F,
  0x80, 0x0C, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x1E, 0x03, 0xF0, 0x7B, 0x07,
  0xB8, 0x31, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFF, 0x81, 0xC1, 0xC0,
  0x80, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0xFF, 0xE3, 0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0xC1,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x86, 0x07, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xB8, 0x03, 0x9C,
  0x03, 0x8C, 0x03, 0x86, 0x03, 0x87, 0x03, 0x83, 0x83, 0x81, 0x81, 0x80,
  0xC1, 0xC0, 0xE1, 0xC0, 0x70, 0xFF, 0xFE, 0x7F, 0xFF, 0x40, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x03,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x40, 0x78, 0x3F, 0xFC, 0x0F,
  0xFE, 0x00, 0x30, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1D,
  0xF8, 0x0F, 0xFE, 0x0F, 0xC7, 0x87, 0x00, 0xE3, 0x00, 0x71, 0x80, 0x39,
  0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x06, 0x38, 0x07, 0x0C, 0x07, 0x07, 0x07,
  0x81, 0xFF, 0x80, 0xFF, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0x07, 0x0E,
  0x03, 0x1C, 0x03, 0x1C, 0x03, 0x1C, 0x03, 0x1C, 0x07, 0x1C, 0x0E, 0x0E,
  0x1C, 0x0F, 0xB8, 0x0F, 0xF0, 0x1C, 0xF8, 0x38, 0x3C, 0x70, 0x1C, 0xE0,
  0x1C, 0xE0, 0x0C, 0xC0, 0x1C, 0xC0, 0x1C, 0xE0, 0x38, 0xE0, 0x78, 0x7F,
  0xF0, 0x3F, 0xC0, 0x04, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0x07, 0x1C,
  0x07, 0x1C, 0x03, 0x38, 0x03, 0x38, 0x03, 0x38, 0x03, 0x38, 0x03, 0x38,
  0x07, 0x38, 0x07, 0x1E, 0x7F, 0x1F, 0xFE, 0x07, 0xEE, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0xFF,
  0x00, 0xF8, 0x00, 0x0E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0x78, 0x03, 0x81, 0xF0, 0x7C,
  0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x07, 0x83, 0xE0, 0xF8, 0x1E, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x38, 0x00,
  0x00, 0x00, 0x80, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x20, 0x3F, 0xFF, 0x9F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x1F, 0xE0,
  0xFF, 0x88, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x3C, 0x1C, 0x1E, 0x07, 0x0F, 0x00, 0xC3,
  0x80, 0x31, 0xC0, 0x0C, 0x70, 0x3F, 0x38, 0x3F, 0xCE, 0x3C, 0x77, 0x1C,
  0x19, 0xC7, 0x0E, 0x73, 0x83, 0x98, 0xE0, 0xEE, 0x38, 0x33, 0x8C, 0x1C,
  0xE3, 0x07, 0x38, 0xE1, 0xCE, 0x38, 0x63, 0x87, 0xF8, 0x60, 0xFE, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xC8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x6E,
  0x00, 0x3B, 0x80, 0x0C, 0xE0, 0x06, 0x38, 0x03, 0x8E, 0x00, 0xC1, 0x80,
  0x70, 0x60, 0x18, 0x18, 0x0E, 0x06, 0x03, 0x01, 0x81, 0x80, 0x60, 0x60,
  0x18, 0x3F, 0xFF, 0x1F, 0xFF, 0xC6, 0x00, 0x73, 0x80, 0x1C, 0xC0, 0x07,
  0x70, 0x01, 0xD8, 0x00, 0x7E, 0x00, 0x1C, 0x03, 0xFE, 0x01, 0xFF, 0xE0,
  0x70, 0x78, 0x1C, 0x07, 0x06, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38,
  0x06, 0x0C, 0x03, 0x87, 0x03, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x18, 0x1E,
  0x06, 0x01, 0xC3, 0x80, 0x30, 0xE0, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x38, 0x60, 0x3C, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0xF0, 0x78, 0x18, 0x3C, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x18, 0x0F, 0xFE,
  0x01, 0xFF, 0x00, 0x08, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x60, 0xF0,
  0x18, 0x1E, 0x0E, 0x03, 0x83, 0x80, 0x70, 0xC0, 0x1C, 0x30, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x71, 0x80, 0x1C, 0x60, 0x07, 0x38, 0x01, 0x8E, 0x00,
  0x63, 0x00, 0x38, 0xC0, 0x0C, 0x70, 0x07, 0x1C, 0x03, 0x87, 0x01, 0xE1,
  0x80, 0xF0, 0xE0, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xF8, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xFF, 0x01, 0xFF, 0xC1, 0xE0, 0xC1, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0xE6, 0x00, 0x73, 0x00, 0x31, 0x80, 0x38, 0xC0, 0x1C, 0x70,
  0x0E, 0x38, 0x06, 0x1C, 0x07, 0x07, 0x83, 0x81, 0xFF, 0xC0, 0x7F, 0xC0,
  0x04, 0x00, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x60, 0x60, 0x0E,
  0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xC0, 0xC0, 0x1C, 0x1C, 0x01,
  0xC1, 0xC0, 0x1C, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x18, 0x03, 0x83, 0x80,
  0x38, 0x38, 0x03, 0x03, 0x00, 0x30, 0x30, 0x07, 0x07, 0x00, 0x70, 0x70,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0C, 0x00,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC1, 0x00, 0xE0, 0x60, 0x78, 0x3F, 0xFC, 0x03,
  0xFC, 0x00, 0x18, 0x00, 0x03, 0x00, 0xF0, 0x30, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x78, 0x06, 0x0F, 0x00, 0x61, 0xE0, 0x0E, 0x3C, 0x00, 0xE7, 0x00,
  0x0C, 0xE0, 0x00, 0xDC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0x9C, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x38, 0x30, 0x03, 0x03,
  0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x06, 0x00, 0xE0, 0xE0,
  0x07, 0x00, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xE1, 0xB0, 0x3E, 0x1E, 0x06, 0x63, 0x60, 0x66, 0x66,
  0x06, 0x66, 0x60, 0xE6, 0xC6, 0x0C, 0x6C, 0xE0, 0xC7, 0x8C, 0x1C, 0x78,
  0xC1, 0xC7, 0x0C, 0x18, 0x01, 0xC1, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x00,
  0x18, 0x30, 0x01, 0x87, 0x00, 0x38, 0x70, 0x03, 0x86, 0x00, 0x38, 0xE0,
  0x03, 0x00, 0x03, 0x80, 0x70, 0x78, 0x07, 0x07, 0x80, 0x60, 0x7C, 0x06,
  0x07, 0xC0, 0xE0, 0xEC, 0x0E, 0x0E, 0xC0, 0xC0, 0xCE, 0x0C, 0x0C, 0x60,
  0xC0, 0xC6, 0x1C, 0x1C, 0x61, 0x81, 0x87, 0x18, 0x18, 0x31, 0x81, 0x83,
  0x38, 0x38, 0x33, 0x83, 0x03, 0x30, 0x30, 0x3B, 0x03, 0x01, 0xF0, 0x70,
  0x1F, 0x06, 0x01, 0xE0, 0x60, 0x1E, 0x06, 0x01, 0xE0, 0xE0, 0x0E, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0x01, 0xC3, 0xC1, 0xC0, 0xE1, 0xC0, 0x31, 0xC0,
  0x1C, 0xE0, 0x0E, 0x60, 0x07, 0x70, 0x03, 0xB0, 0x01, 0x98, 0x00, 0xDC,
  0x00, 0x6E, 0x00, 0x77, 0x00, 0x3B, 0x00, 0x19, 0x80, 0x1C, 0xC0, 0x0C,
  0x60, 0x0E, 0x38, 0x06, 0x1C, 0x07, 0x07, 0x07, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0x08, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0x81, 0xE1, 0xC0, 0x70,
  0xE0, 0x18, 0x70, 0x0C, 0x30, 0x06, 0x38, 0x03, 0x1C, 0x03, 0x8E, 0x01,
  0x86, 0x01, 0xC7, 0x03, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xC3, 0xC1, 0xC0,
  0xE1, 0xC0, 0x31, 0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x07, 0x70, 0x03, 0xB0,
  0x01, 0x98, 0x00, 0xDC, 0x00, 0x6E, 0x00, 0x77, 0x00, 0x3B, 0x00, 0x19,
  0x80, 0x1C, 0xC0, 0x0C, 0x60, 0x0E, 0x38, 0x06, 0x1C, 0x07, 0x07, 0x07,
  0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x70,
  0x78, 0x1C, 0x07, 0x06, 0x01, 0xC1, 0x80, 0x30, 0xE0, 0x1C, 0x38, 0x07,
  0x0C, 0x01, 0x83, 0x00, 0xE1, 0xC0, 0x70, 0x71, 0xF8, 0x1F, 0xFC, 0x07,
  0xFC, 0x03, 0x83, 0x00, 0xE0, 0xE0, 0x38, 0x18, 0x0C, 0x07, 0x07, 0x01,
  0xC1, 0xC0, 0x70, 0x70, 0x0C, 0x18, 0x03, 0x8E, 0x00, 0xE0, 0x00, 0xFF,
  0x80, 0xFF, 0xF0, 0x78, 0x18, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x60, 0x3C, 0x3F, 0xFE, 0x07,
  0xFE, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x81, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x18, 0x60, 0x0E, 0x18,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x30, 0xC0, 0x0C, 0x30, 0x07, 0x1C, 0x01,
  0xC7, 0x00, 0x61, 0x80, 0x18, 0x60, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xC3,
  0x80, 0x30, 0xC0, 0x1C, 0x30, 0x07, 0x0E, 0x01, 0x83, 0x80, 0xE0, 0xF0,
  0x70, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x10, 0x00, 0xC0, 0x03, 0xE0, 0x01,
  0xB0, 0x01, 0xD8, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0x63, 0x80, 0x71, 0xC0,
  0x30, 0xE0, 0x38, 0x70, 0x18, 0x38, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x07,
  0x0E, 0x03, 0x87, 0x01, 0xC7, 0x00, 0x63, 0x00, 0x33, 0x80, 0x19, 0x80,
  0x0D, 0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x71,
  0xC0, 0x06, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x18, 0x00, 0xC1, 0x80, 0x0C,
  0x18, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0x83, 0x0E, 0x18, 0x31, 0xE3,
  0x83, 0x1E, 0x30, 0x73, 0x63, 0x06, 0x36, 0x70, 0x66, 0x66, 0x06, 0xE6,
  0x60, 0x6C, 0x66, 0x07, 0xC6, 0xC0, 0x58, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00,
  0x07, 0x38, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xB0, 0x00, 0x1C, 0xE0,
  0x00, 0xE3, 0x80, 0x07, 0x86, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x70, 0x07,
  0x00, 0xC0, 0x38, 0x03, 0x81, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xF8, 0x00, 0xE6, 0x00, 0x71, 0x80, 0x18, 0x60, 0x0E, 0x1C, 0x07,
  0x07, 0x03, 0x80, 0xC0, 0xC0, 0x38, 0x70, 0x0E, 0x38, 0x01, 0x9C, 0x00,
  0x66, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x04, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE3, 0x18, 0xC6, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0xC6,
  0x31, 0x8E, 0x73, 0x9C, 0xE7, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x1F, 0x00, 0xEC, 0x07, 0x30, 0x38, 0xE0, 0xC1, 0x87, 0x06, 0x38,
  0x1D, 0xC0, 0x3E, 0x00, 0xD0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x46,
  0x38, 0xE3, 0x1C, 0x60, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0x07, 0x1E, 0x07,
  0x3C, 0x06, 0x38, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0C, 0xE0, 0x0C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x60, 0x18, 0x70, 0x78, 0x7F, 0xFC,
  0x1F, 0xDC, 0x00, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x20, 0x0F, 0xFC, 0x0F, 0xFE,
  0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x38, 0x03,
  0x38, 0x07, 0x30, 0x07, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x60, 0x38,
  0x60, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x18, 0x01, 0xFF, 0x07, 0xFF,
  0x0F, 0x01, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x08, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7C, 0x18, 0x1C, 0x06, 0x0E,
  0x03, 0x87, 0x00, 0xE1, 0xC0, 0x30, 0xE0, 0x0C, 0x38, 0x07, 0x0E, 0x01,
  0xC3, 0x00, 0x60, 0xC0, 0x18, 0x38, 0x06, 0x0E, 0x03, 0x83, 0x81, 0xE0,
  0x7F, 0xD8, 0x0F, 0xE6, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x1E, 0x07, 0x1C,
  0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x60, 0x3E, 0xFF, 0xF8, 0xFF,
  0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x08, 0x3F,
  0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x02, 0x1C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xF0,
  0x3C, 0x1C, 0x1C, 0x06, 0x0E, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x60,
  0x0C, 0x38, 0x03, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x18, 0x38, 0x06,
  0x0E, 0x07, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0xC0, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x0C, 0x0F, 0x1C,
  0x07, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x07, 0x18, 0x07, 0x38, 0x06, 0x38,
  0x06, 0x30, 0x0E, 0x30, 0x0E, 0x70, 0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x60,
  0x1C, 0xE0, 0x1C, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x3F, 0x07, 0xC0, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x0C, 0x1E,
  0x07, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x43, 0x80, 0xE0, 0xC0, 0xF0, 0x30, 0x78, 0x1C, 0x38, 0x07, 0x3C,
  0x01, 0x9E, 0x00, 0x6E, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0x3C, 0x00,
  0xC7, 0x00, 0x70, 0xE0, 0x1C, 0x1C, 0x06, 0x03, 0x81, 0x80, 0xE0, 0xE0,
  0x1C, 0x38, 0x07, 0x00, 0xFF, 0x7F, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70,
  0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30,
  0x18, 0x1C, 0x0E, 0x07, 0x03, 0x82, 0xFF, 0x7F, 0x80, 0x01, 0x02, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x18, 0x71, 0x86,
  0x18, 0xE3, 0x86, 0x38, 0xE3, 0x8C, 0x38, 0xE3, 0x0C, 0x31, 0xC0, 0x0C,
  0x70, 0x07, 0x18, 0x01, 0xC6, 0x00, 0x63, 0x80, 0x18, 0xE0, 0x0E, 0x30,
  0x03, 0x80, 0x0F, 0xFC, 0x0F, 0xFE, 0x0C, 0x0E, 0x1C, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x30, 0x0E,
  0x70, 0x0E, 0x70, 0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0xE0, 0x18,
  0x07, 0xF8, 0x1F, 0xF8, 0x78, 0x39, 0xC0, 0x77, 0x80, 0x6E, 0x00, 0xD8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x36, 0x00, 0xEC, 0x03,
  0xDC, 0x0F, 0x3C, 0x3C, 0x3F, 0xF0, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x70, 0x3C, 0x1C, 0x07, 0x07, 0x00, 0xC1, 0x80, 0x30, 0xE0, 0x0C,
  0x38, 0x07, 0x0E, 0x01, 0xC3, 0x00, 0x71, 0xC0, 0x18, 0x70, 0x0E, 0x1C,
  0x07, 0x06, 0x03, 0xC1, 0x83, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xFF, 0x07, 0xFF, 0x1F, 0x06, 0x1C, 0x0E, 0x38, 0x0E, 0x70, 0x0E,
  0x60, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0xFF,
  0x0F, 0xFE, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xFE, 0x1F, 0xFC,
  0x38, 0x10, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x10, 0x1C,
  0x7F, 0xF8, 0x7F, 0xC0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE1, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x43, 0xFE, 0x0F, 0xF0, 0x38, 0x07, 0x38, 0x06, 0x30, 0x0E, 0x30, 0x0E,
  0x70, 0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x18,
  0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x38, 0xE0, 0x38, 0xE0, 0xF0, 0x7F, 0xF8,
  0x3F, 0xB8, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xB8, 0x0E, 0xE0, 0x33, 0x81,
  0xCE, 0x06, 0x38, 0x38, 0xE0, 0xC1, 0x87, 0x06, 0x38, 0x18, 0xC0, 0x77,
  0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x70, 0x01, 0xD8, 0x00,
  0x66, 0x00, 0x19, 0x80, 0x0E, 0x61, 0xC3, 0x38, 0x70, 0xCE, 0x3C, 0x73,
  0x8F, 0x18, 0xE6, 0xCE, 0x39, 0xB3, 0x0C, 0xCC, 0xC3, 0x73, 0x70, 0xD8,
  0xD8, 0x3C, 0x3E, 0x0F, 0x0F, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x00, 0x07,
  0x00, 0xF0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x1C, 0x30, 0x01, 0xC7, 0x00,
  0x0E, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x80,
  0x01, 0xD8, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x00, 0xE0, 0xE0, 0x1C, 0x0E,
  0x03, 0x80, 0x60, 0xF0, 0x07, 0x00, 0x03, 0x80, 0x70, 0x38, 0x07, 0x03,
  0x80, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x01, 0x81, 0xC0,
  0x18, 0x1C, 0x01, 0xC1, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x00, 0x0C, 0x70,
  0x00, 0xE6, 0x00, 0x0E, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x43, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x0F, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x3E, 0x03, 0x7F, 0x86, 0xE3, 0xEE, 0xC1, 0xFC, 0x40, 0x70,
};

const GFXglyph UbuntuSansMono_Italic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 9, 23, 18, 5, -23 },
  { 27, 10, 9, 18, 7, -25 },
  { 39, 20, 23, 18, 0, -23 },
  { 97, 17, 30, 18, 1, -26 },
  { 161, 22, 24, 18, -1, -23 },
  { 227, 15, 23, 18, 1, -23 },
  { 271, 4, 9, 18, 10, -25 },
  { 276, 14, 32, 18, 4, -26 },
  { 332, 14, 32, 18, 1, -26 },
  { 388, 14, 14, 18, 4, -23 },
  { 413, 15, 16, 18, 2, -18 },
  { 443, 7, 10, 18, 3, -5 },
  { 452, 8, 3, 18, 6, -11 },
  { 455, 5, 5, 18, 5, -5 },
  { 459, 21, 32, 18, -2, -26 },
  { 543, 16, 24, 18, 2, -23 },
  { 591, 13, 23, 18, 2, -23 },
  { 629, 17, 23, 18, 1, -23 },
  { 678, 17, 24, 18, 1, -23 },
  { 729, 17, 23, 18, 0, -23 },
  { 778, 18, 24, 18, 1, -23 },
  { 832, 17, 24, 18, 2, -23 },
  { 883, 16, 23, 18, 4, -23 },
  { 929, 16, 24, 18, 2, -23 },
  { 977, 16, 23, 18, 2, -23 },
  { 1023, 8, 17, 18, 5, -17 },
  { 1040, 10, 22, 18, 3, -17 },
  { 1068, 17, 15, 18, 1, -17 },
  { 1100, 17, 9, 18, 1, -14 },
  { 1120, 16, 15, 18, 1, -17 },
  { 1150, 13, 23, 18, 5, -23 },
  { 1188, 18, 28, 18, 1, -23 },
  { 1251, 18, 23, 18, -2, -23 },
  { 1303, 18, 23, 18, 0, -23 },
  { 1355, 18, 24, 18, 2, -23 },
  { 1409, 18, 23, 18, 0, -23 },
  { 1461, 19, 23, 18, 1, -23 },
  { 1516, 19, 23, 18, 1, -23 },
  { 1571, 17, 24, 18, 2, -23 },
  { 1622, 20, 23, 18, 0, -23 },
  { 1680, 16, 23, 18, 2, -23 },
  { 1726, 18, 24, 18, 1, -23 },
  { 1780, 20, 23, 18, 0, -23 },
  { 1838, 13, 23, 18, 1, -23 },
  { 1876, 20, 23, 18, -1, -23 },
  { 1934, 20, 23, 18, 0, -23 },
  { 1992, 17, 24, 18, 2, -23 },
  { 2043, 17, 23, 18, 1, -23 },
  { 2092, 17, 29, 18, 2, -23 },
  { 2154, 18, 23, 18, 0, -23 },
  { 2206, 18, 24, 18, 1, -23 },
  { 2260, 16, 23, 18, 4, -23 },
  { 2306, 18, 24, 18, 2, -23 },
  { 2360, 17, 23, 18, 4, -23 },
  { 2409, 20, 23, 18, 1, -23 },
  { 2467, 22, 23, 18, -1, -23 },
  { 2531, 18, 23, 18, 4, -23 },
  { 2583, 20, 23, 18, 0, -23 },
  { 2641, 17, 32, 18, 2, -26 },
  { 2709, 5, 32, 18, 7, -26 },
  { 2729, 16, 32, 18, 0, -26 },
  { 2793, 14, 12, 18, 3, -23 },
  { 2814, 17, 2, 18, -2, 4 },
  { 2819, 5, 7, 18, 9, -26 },
  { 2824, 16, 17, 18, 1, -17 },
  { 2858, 16, 26, 18, 1, -26 },
  { 2910, 16, 18, 18, 1, -18 },
  { 2946, 18, 26, 18, 2, -26 },
  { 3005, 16, 17, 18, 1, -17 },
  { 3039, 22, 32, 18, -1, -26 },
  { 3127, 18, 23, 18, 0, -17 },
  { 3179, 16, 26, 18, 0, -26 },
  { 3231, 10, 25, 18, 4, -25 },
  { 3263, 17, 31, 18, 0, -25 },
  { 3329, 18, 26, 18, 1, -26 },
  { 3388, 9, 25, 18, 6, -25 },
  { 3417, 18, 18, 18, 0, -18 },
  { 3458, 16, 17, 18, 1, -17 },
  { 3492, 15, 17, 18, 2, -17 },
  { 3524, 18, 23, 18, -1, -17 },
  { 3576, 16, 23, 18, 2, -17 },
  { 3622, 16, 17, 18, 2, -17 },
  { 3656, 15, 17, 18, 2, -17 },
  { 3688, 13, 22, 18, 4, -22 },
  { 3724, 16, 17, 18, 2, -17 },
  { 3758, 14, 17, 18, 4, -17 },
  { 3788, 18, 17, 18, 2, -17 },
  { 3827, 20, 17, 18, -1, -17 },
  { 3870, 20, 23, 18, -2, -17 },
  { 3928, 16, 17, 18, 1, -17 },
  { 3962, 18, 32, 18, 2, -26 },
  { 4034, 10, 32, 18, 5, -26 },
  { 4074, 17, 32, 18, -1, -26 },
  { 4142, 16, 5, 18, 2, -12 },
};

const GFXfont UbuntuSansMono_Italic33pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic33pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic33pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _UBUNTUSANSMONO_ITALIC33PT7B_H_
