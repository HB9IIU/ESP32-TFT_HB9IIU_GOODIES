#ifndef _UBUNTUSANSMONO_ITALIC13PT7B_H_
#define _UBUNTUSANSMONO_ITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x84, 0xC0, 0x9A, 0xAA, 0x09, 0x12, 0x7F, 0x24, 0x24,
  0x28, 0xFE, 0x50, 0x90, 0x08, 0x62, 0x50, 0x40, 0xC0, 0x82, 0x8B, 0xC4,
  0x00, 0x31, 0x52, 0x54, 0x78, 0x10, 0x1E, 0x2A, 0x52, 0x8C, 0x1C, 0x92,
  0x4A, 0x35, 0x5C, 0xF2, 0x74, 0x6A, 0x09, 0x88, 0x88, 0x42, 0x10, 0x84,
  0x20, 0x80, 0x10, 0x20, 0x81, 0x04, 0x10, 0x82, 0x08, 0x42, 0x30, 0x25,
  0x7E, 0xCD, 0x00, 0x10, 0x42, 0x3F, 0x20, 0x80, 0x6C, 0xE0, 0xE0, 0xF0,
  0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0xC0,
  0x3D, 0x14, 0x69, 0xB6, 0x38, 0xA6, 0xF0, 0x09, 0xD4, 0x21, 0x08, 0xC4,
  0xF8, 0x3D, 0x10, 0x43, 0x18, 0x84, 0x20, 0xF8, 0x1E, 0x04, 0x08, 0x21,
  0xC0, 0x81, 0x02, 0xF8, 0x06, 0x18, 0x51, 0x24, 0x49, 0x3F, 0x04, 0x08,
  0x1E, 0x20, 0x41, 0x80, 0xC0, 0x81, 0x02, 0xF8, 0x0C, 0xC4, 0x14, 0xEA,
  0x18, 0xE2, 0xF0, 0xFC, 0x21, 0x0C, 0x21, 0x04, 0x20, 0x80, 0x3D, 0x14,
  0x53, 0x72, 0x28, 0xA2, 0xF0, 0x3D, 0x14, 0x51, 0x7C, 0x30, 0x84, 0xE0,
  0x6C, 0x01, 0xB0, 0x33, 0x00, 0x06, 0x62, 0xC0, 0x04, 0x76, 0x20, 0x60,
  0x60, 0x7E, 0x00, 0x07, 0xE0, 0x40, 0x60, 0x30, 0x33, 0x98, 0x00, 0x78,
  0x42, 0x22, 0x20, 0x10, 0xC0, 0x3C, 0xC5, 0x0C, 0xEA, 0x54, 0xA9, 0x5C,
  0x81, 0x01, 0xC0, 0x06, 0x14, 0x28, 0x91, 0x24, 0x4F, 0xA1, 0xC2, 0x3E,
  0x44, 0x8A, 0x27, 0xC8, 0x91, 0x42, 0xF8, 0x3E, 0xC1, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x78, 0x3C, 0x4C, 0x8A, 0x14, 0x28, 0x51, 0x46, 0xF0, 0x3E,
  0x81, 0x02, 0x07, 0x90, 0x20, 0x40, 0xF8, 0x3E, 0x81, 0x02, 0x07, 0x90,
  0x20, 0x40, 0x80, 0x3E, 0x83, 0x04, 0x08, 0x11, 0xA2, 0x44, 0x78, 0x21,
  0x22, 0x22, 0x42, 0x7E, 0x44, 0x44, 0x84, 0x84, 0x3C, 0x41, 0x04, 0x20,
  0x82, 0x08, 0xF0, 0x3E, 0x08, 0x10, 0x20, 0x81, 0x02, 0x0C, 0xF0, 0x23,
  0x24, 0x28, 0x50, 0x70, 0x50, 0x48, 0x4C, 0x84, 0x21, 0x08, 0x44, 0x21,
  0x08, 0xF8, 0x33, 0x32, 0x36, 0x5A, 0x5A, 0x52, 0x82, 0x84, 0x84, 0x21,
  0x31, 0x32, 0x52, 0x4A, 0x4A, 0x4C, 0x8C, 0x84, 0x3D, 0x14, 0x61, 0x86,
  0x18, 0xA2, 0xF0, 0x3E, 0x44, 0x89, 0x14, 0x4F, 0x10, 0x20, 0x80, 0x3D,
  0x14, 0x61, 0x86, 0x18, 0xA2, 0xF1, 0x03, 0x00, 0x3C, 0x44, 0x8A, 0x17,
  0xC9, 0x12, 0x26, 0x84, 0x1E, 0x40, 0x81, 0x81, 0x80, 0x81, 0x02, 0xF8,
  0xFC, 0x82, 0x08, 0x41, 0x04, 0x10, 0x80, 0x42, 0x89, 0x14, 0x28, 0x51,
  0xA2, 0x44, 0xF0, 0xC3, 0x85, 0x12, 0x64, 0x8A, 0x14, 0x30, 0x60, 0x21,
  0x21, 0x42, 0x4A, 0x5A, 0x6A, 0x6C, 0x4C, 0xC8, 0x21, 0x12, 0x14, 0x1C,
  0x18, 0x18, 0x24, 0x44, 0x84, 0x87, 0x1A, 0x24, 0x86, 0x08, 0x10, 0x20,
  0xC0, 0x3F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0x40, 0xFC, 0x1C, 0x42,
  0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x38, 0xAA, 0xAA, 0xAD, 0x1C, 0x10,
  0x42, 0x08, 0x20, 0x84, 0x10, 0x41, 0x38, 0x18, 0xE2, 0x91, 0x84, 0xFE,
  0xC8, 0x80, 0x3D, 0x18, 0xA2, 0x8A, 0x2F, 0x80, 0x10, 0x40, 0x81, 0xE2,
  0x28, 0x50, 0xA2, 0x4D, 0xF0, 0x1E, 0x41, 0x02, 0x08, 0x08, 0x1F, 0x00,
  0x02, 0x0C, 0x11, 0xE4, 0x50, 0xA2, 0x44, 0x89, 0xF0, 0x1C, 0x45, 0x1B,
  0xE8, 0x08, 0x1F, 0x00, 0x07, 0x08, 0x08, 0x3E, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0xE0, 0x1E, 0x65, 0x0A, 0x24, 0x48, 0x8F, 0x04, 0xF8,
  0x30, 0x82, 0x0F, 0x45, 0x14, 0x51, 0x86, 0x20, 0x26, 0x0E, 0x44, 0x44,
  0x47, 0x06, 0x0C, 0x00, 0xE2, 0x40, 0x81, 0x04, 0x08, 0x10, 0x27, 0x80,
  0x10, 0x40, 0x81, 0x12, 0xCB, 0x1C, 0x2C, 0x49, 0x88, 0xE2, 0x22, 0x44,
  0x44, 0x87, 0x36, 0x95, 0x4A, 0x94, 0x50, 0xA1, 0x00, 0x3C, 0x4C, 0x8A,
  0x24, 0x48, 0xB1, 0x00, 0x39, 0x18, 0x61, 0x8A, 0x2F, 0x00, 0x3C, 0x4D,
  0x0A, 0x14, 0x49, 0x9E, 0x40, 0x80, 0x3D, 0x18, 0xE2, 0x8A, 0x2F, 0x84,
  0x10, 0x3D, 0x04, 0x10, 0x82, 0x08, 0x00, 0x3D, 0x04, 0x0C, 0x08, 0x2F,
  0x00, 0x22, 0x3E, 0x84, 0x42, 0x10, 0xF0, 0x46, 0x18, 0xA2, 0x8A, 0x2F,
  0x80, 0x8C, 0x65, 0x2A, 0x63, 0x00, 0x83, 0x0A, 0x55, 0xAD, 0x9B, 0x24,
  0x00, 0x22, 0x48, 0x60, 0x83, 0x8D, 0x21, 0x00, 0x11, 0x11, 0x12, 0x12,
  0x12, 0x14, 0x08, 0x08, 0xF0, 0x3E, 0x08, 0x20, 0x82, 0x08, 0x3E, 0x00,
  0x1E, 0x20, 0x81, 0x02, 0x08, 0x30, 0x20, 0x40, 0x81, 0x03, 0x80, 0x12,
  0x22, 0x24, 0x44, 0x48, 0x88, 0x1E, 0x04, 0x10, 0x20, 0x40, 0x81, 0x84,
  0x08, 0x10, 0x27, 0x80, 0x66, 0x60,
};

const GFXglyph UbuntuSansMono_Italic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 4, 4, 7, 3, -10 },
  { 7, 8, 9, 7, 0, -9 },
  { 16, 6, 11, 7, 1, -10 },
  { 25, 8, 9, 7, 0, -9 },
  { 34, 6, 9, 7, 0, -9 },
  { 41, 2, 4, 7, 4, -10 },
  { 42, 5, 12, 7, 2, -10 },
  { 50, 6, 12, 7, 0, -10 },
  { 59, 5, 5, 7, 2, -9 },
  { 63, 6, 6, 7, 1, -7 },
  { 68, 3, 4, 7, 1, -2 },
  { 70, 3, 1, 7, 2, -4 },
  { 71, 2, 2, 7, 2, -2 },
  { 72, 8, 12, 7, -1, -10 },
  { 84, 6, 9, 7, 1, -9 },
  { 91, 5, 9, 7, 1, -9 },
  { 97, 6, 9, 7, 1, -9 },
  { 104, 7, 9, 7, 0, -9 },
  { 112, 7, 9, 7, 0, -9 },
  { 120, 7, 9, 7, 0, -9 },
  { 128, 6, 9, 7, 1, -9 },
  { 135, 6, 9, 7, 2, -9 },
  { 142, 6, 9, 7, 1, -9 },
  { 149, 6, 9, 7, 1, -9 },
  { 156, 3, 7, 7, 2, -7 },
  { 159, 4, 9, 7, 1, -7 },
  { 164, 6, 6, 7, 1, -7 },
  { 169, 7, 4, 7, 0, -6 },
  { 173, 7, 6, 7, 0, -7 },
  { 179, 5, 9, 7, 2, -9 },
  { 185, 7, 11, 7, 1, -9 },
  { 195, 7, 9, 7, -1, -9 },
  { 203, 7, 9, 7, 0, -9 },
  { 211, 7, 9, 7, 1, -9 },
  { 219, 7, 9, 7, 0, -9 },
  { 227, 7, 9, 7, 1, -9 },
  { 235, 7, 9, 7, 1, -9 },
  { 243, 7, 9, 7, 1, -9 },
  { 251, 8, 9, 7, 0, -9 },
  { 260, 6, 9, 7, 1, -9 },
  { 267, 7, 9, 7, 1, -9 },
  { 275, 8, 9, 7, 0, -9 },
  { 284, 5, 9, 7, 0, -9 },
  { 290, 8, 9, 7, 0, -9 },
  { 299, 8, 9, 7, 0, -9 },
  { 308, 6, 9, 7, 1, -9 },
  { 315, 7, 9, 7, 0, -9 },
  { 323, 6, 11, 7, 1, -9 },
  { 332, 7, 9, 7, 0, -9 },
  { 340, 7, 9, 7, 0, -9 },
  { 348, 6, 9, 7, 2, -9 },
  { 355, 7, 9, 7, 1, -9 },
  { 363, 7, 9, 7, 1, -9 },
  { 371, 8, 9, 7, 0, -9 },
  { 380, 8, 9, 7, 0, -9 },
  { 389, 7, 9, 7, 2, -9 },
  { 397, 8, 9, 7, 0, -9 },
  { 406, 6, 12, 7, 1, -10 },
  { 415, 2, 12, 7, 3, -10 },
  { 418, 6, 12, 7, 0, -10 },
  { 427, 6, 5, 7, 1, -9 },
  { 431, 7, 1, 7, -1, 1 },
  { 432, 3, 3, 7, 3, -10 },
  { 434, 6, 7, 7, 1, -7 },
  { 440, 7, 10, 7, 0, -10 },
  { 449, 7, 7, 7, 0, -7 },
  { 456, 7, 10, 7, 1, -10 },
  { 465, 7, 7, 7, 0, -7 },
  { 472, 8, 12, 7, 0, -10 },
  { 484, 7, 9, 7, 0, -7 },
  { 492, 6, 10, 7, 0, -10 },
  { 500, 4, 10, 7, 2, -10 },
  { 505, 7, 12, 7, 0, -10 },
  { 516, 7, 10, 7, 0, -10 },
  { 525, 4, 10, 7, 2, -10 },
  { 530, 7, 7, 7, 0, -7 },
  { 537, 7, 7, 7, 0, -7 },
  { 544, 6, 7, 7, 1, -7 },
  { 550, 7, 9, 7, 0, -7 },
  { 558, 6, 9, 7, 1, -7 },
  { 565, 6, 7, 7, 1, -7 },
  { 571, 6, 7, 7, 1, -7 },
  { 577, 5, 9, 7, 2, -9 },
  { 583, 6, 7, 7, 1, -7 },
  { 589, 5, 7, 7, 2, -7 },
  { 594, 7, 7, 7, 1, -7 },
  { 601, 7, 7, 7, 0, -7 },
  { 608, 8, 9, 7, -1, -7 },
  { 617, 7, 7, 7, 0, -7 },
  { 624, 7, 12, 7, 1, -10 },
  { 635, 4, 12, 7, 2, -10 },
  { 641, 7, 12, 7, -1, -10 },
  { 652, 6, 2, 7, 1, -5 },
};

const GFXfont UbuntuSansMono_Italic13pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic13pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic13pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _UBUNTUSANSMONO_ITALIC13PT7B_H_
