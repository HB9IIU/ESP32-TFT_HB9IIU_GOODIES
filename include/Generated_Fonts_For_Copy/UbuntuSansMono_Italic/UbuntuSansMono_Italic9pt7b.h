#ifndef _UBUNTUSANSMONO_ITALIC9PT7B_H_
#define _UBUNTUSANSMONO_ITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x21, 0x80, 0xBB, 0x00, 0x2B, 0xD4, 0xAE, 0xD0, 0x11, 0xD0,
  0x41, 0x0B, 0x88, 0x6E, 0xC5, 0x0E, 0x6A, 0xE0, 0x35, 0x27, 0x9F, 0xE0,
  0x12, 0x48, 0x88, 0x84, 0x40, 0x21, 0x11, 0x11, 0x24, 0x80, 0x4F, 0x60,
  0x24, 0xF4, 0x40, 0xF0, 0xE0, 0xC0, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10,
  0x80, 0x3A, 0x5B, 0x19, 0x30, 0x74, 0xA5, 0xC0, 0x78, 0x44, 0x44, 0x78,
  0x38, 0x4C, 0x21, 0x78, 0x19, 0x95, 0x27, 0x10, 0x39, 0x18, 0x21, 0x78,
  0x3C, 0xE9, 0x9E, 0x79, 0x08, 0x84, 0x40, 0x3A, 0x4C, 0xA8, 0xB8, 0x3A,
  0x52, 0x71, 0x70, 0x60, 0x60, 0x60, 0x6C, 0x09, 0xB0, 0x60, 0x78, 0x3C,
  0x41, 0x07, 0xC0, 0x71, 0x24, 0x0C, 0x3A, 0x5F, 0x5A, 0xC9, 0x80, 0x18,
  0xCA, 0x55, 0xE4, 0x7A, 0x5C, 0x98, 0xF8, 0x78, 0x88, 0x8E, 0x72, 0x53,
  0x19, 0x70, 0x3A, 0x1C, 0x84, 0x78, 0x3A, 0x1C, 0x84, 0x40, 0x3A, 0x21,
  0x19, 0x38, 0x4A, 0x5F, 0x19, 0x48, 0x38, 0x88, 0x42, 0x78, 0x38, 0x42,
  0x21, 0x78, 0x4D, 0x46, 0x18, 0x92, 0x40, 0x44, 0x44, 0x8F, 0x2B, 0x5F,
  0x58, 0xC8, 0x6B, 0x5B, 0x39, 0x48, 0x3A, 0x53, 0x19, 0x38, 0x7A, 0x52,
  0xE8, 0x40, 0x3A, 0x53, 0x19, 0x38, 0x82, 0x7A, 0x56, 0xC9, 0x48, 0x3A,
  0x08, 0x21, 0x78, 0xF9, 0x10, 0x84, 0x20, 0x4A, 0x53, 0x19, 0x38, 0x8C,
  0xA9, 0x4C, 0x60, 0x45, 0x26, 0xAA, 0xD2, 0x40, 0x6C, 0xA3, 0x0C, 0x52,
  0x40, 0x8C, 0x98, 0x84, 0x20, 0x78, 0x88, 0x44, 0x78, 0x34, 0x44, 0x88,
  0x88, 0xC0, 0xFF, 0x80, 0x31, 0x11, 0x22, 0x22, 0xC0, 0x25, 0x90, 0xF8,
  0x90, 0x3A, 0x65, 0x27, 0x00, 0x22, 0x1C, 0x94, 0xCB, 0x80, 0x3A, 0x21,
  0x07, 0x00, 0x08, 0x4E, 0x98, 0xC9, 0xC0, 0x32, 0x7D, 0x07, 0x00, 0x1C,
  0x47, 0x88, 0x20, 0x84, 0x10, 0x80, 0x3A, 0x53, 0x27, 0x0B, 0x80, 0x44,
  0x75, 0x59, 0x90, 0x63, 0x24, 0x98, 0x18, 0x0C, 0x21, 0x08, 0x44, 0xC0,
  0x22, 0x12, 0xA6, 0x52, 0x40, 0xDA, 0xAC, 0x7B, 0x6B, 0x29, 0x00, 0x72,
  0x52, 0xA9, 0x00, 0x32, 0x63, 0x27, 0x00, 0x72, 0x53, 0x2E, 0x42, 0x00,
  0x3A, 0x63, 0x27, 0x08, 0x40, 0x78, 0x88, 0x80, 0x3A, 0x08, 0x2F, 0x00,
  0x4F, 0x44, 0x86, 0x4A, 0x55, 0x27, 0x00, 0x99, 0xAA, 0x40, 0x4A, 0x6A,
  0xA9, 0x00, 0x49, 0x88, 0xA9, 0x00, 0x4A, 0x54, 0xA2, 0x13, 0x00, 0x78,
  0x88, 0x8F, 0x00, 0x19, 0x08, 0x4C, 0x21, 0x08, 0x60, 0x24, 0xA4, 0x94,
  0x80, 0x31, 0x11, 0x12, 0x22, 0xC0, 0xF8,
};

const GFXglyph UbuntuSansMono_Italic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 6, 5, 1, -6 },
  { 4, 3, 3, 5, 2, -7 },
  { 6, 5, 6, 5, 0, -6 },
  { 10, 5, 8, 5, 0, -7 },
  { 15, 6, 6, 5, 0, -6 },
  { 20, 4, 6, 5, 0, -6 },
  { 23, 1, 3, 5, 3, -7 },
  { 24, 4, 9, 5, 1, -7 },
  { 29, 4, 9, 5, 0, -7 },
  { 34, 4, 3, 5, 1, -6 },
  { 36, 4, 5, 5, 1, -5 },
  { 39, 2, 2, 5, 1, -1 },
  { 40, 3, 1, 5, 1, -3 },
  { 41, 2, 1, 5, 1, -1 },
  { 42, 6, 9, 5, -1, -7 },
  { 49, 5, 6, 5, 0, -6 },
  { 53, 3, 6, 5, 1, -6 },
  { 56, 5, 6, 5, 0, -6 },
  { 60, 5, 6, 5, 0, -6 },
  { 64, 5, 6, 5, 0, -6 },
  { 68, 5, 6, 5, 0, -6 },
  { 72, 4, 6, 5, 1, -6 },
  { 75, 5, 6, 5, 1, -6 },
  { 79, 5, 6, 5, 0, -6 },
  { 83, 5, 6, 5, 0, -6 },
  { 87, 3, 4, 5, 1, -4 },
  { 89, 3, 5, 5, 1, -4 },
  { 91, 5, 4, 5, 0, -5 },
  { 94, 5, 3, 5, 0, -4 },
  { 96, 5, 4, 5, 0, -5 },
  { 99, 4, 6, 5, 1, -6 },
  { 102, 5, 7, 5, 0, -6 },
  { 107, 5, 6, 5, -1, -6 },
  { 111, 5, 6, 5, 0, -6 },
  { 115, 4, 6, 5, 1, -6 },
  { 118, 5, 6, 5, 0, -6 },
  { 122, 5, 6, 5, 0, -6 },
  { 126, 5, 6, 5, 0, -6 },
  { 130, 5, 6, 5, 0, -6 },
  { 134, 5, 6, 5, 0, -6 },
  { 138, 5, 6, 5, 0, -6 },
  { 142, 5, 6, 5, 0, -6 },
  { 146, 6, 6, 5, 0, -6 },
  { 151, 4, 6, 5, 0, -6 },
  { 154, 5, 6, 5, 0, -6 },
  { 158, 5, 6, 5, 0, -6 },
  { 162, 5, 6, 5, 0, -6 },
  { 166, 5, 6, 5, 0, -6 },
  { 170, 5, 8, 5, 0, -6 },
  { 175, 5, 6, 5, 0, -6 },
  { 179, 5, 6, 5, 0, -6 },
  { 183, 5, 6, 5, 1, -6 },
  { 187, 5, 6, 5, 0, -6 },
  { 191, 5, 6, 5, 1, -6 },
  { 195, 6, 6, 5, 0, -6 },
  { 200, 6, 6, 5, 0, -6 },
  { 205, 5, 6, 5, 1, -6 },
  { 209, 5, 6, 5, 0, -6 },
  { 213, 4, 9, 5, 1, -7 },
  { 218, 1, 9, 5, 2, -7 },
  { 220, 4, 9, 5, 0, -7 },
  { 225, 4, 3, 5, 1, -6 },
  { 227, 5, 1, 5, -1, 1 },
  { 228, 2, 2, 5, 2, -7 },
  { 229, 5, 5, 5, 0, -5 },
  { 233, 5, 7, 5, 0, -7 },
  { 238, 5, 5, 5, 0, -5 },
  { 242, 5, 7, 5, 0, -7 },
  { 247, 5, 5, 5, 0, -5 },
  { 251, 6, 9, 5, 0, -7 },
  { 258, 5, 7, 5, 0, -5 },
  { 263, 4, 7, 5, 0, -7 },
  { 267, 3, 7, 5, 1, -7 },
  { 270, 5, 9, 5, 0, -7 },
  { 276, 5, 7, 5, 0, -7 },
  { 281, 2, 7, 5, 2, -7 },
  { 283, 5, 5, 5, 0, -5 },
  { 287, 5, 5, 5, 0, -5 },
  { 291, 5, 5, 5, 0, -5 },
  { 295, 5, 7, 5, 0, -5 },
  { 300, 5, 7, 5, 0, -5 },
  { 305, 4, 5, 5, 1, -5 },
  { 308, 5, 5, 5, 0, -5 },
  { 312, 4, 6, 5, 1, -6 },
  { 315, 5, 5, 5, 0, -5 },
  { 319, 4, 5, 5, 1, -5 },
  { 322, 5, 5, 5, 0, -5 },
  { 326, 5, 5, 5, 0, -5 },
  { 330, 5, 7, 5, 0, -5 },
  { 335, 5, 5, 5, 0, -5 },
  { 339, 5, 9, 5, 0, -7 },
  { 345, 3, 9, 5, 1, -7 },
  { 349, 4, 9, 5, 0, -7 },
  { 354, 5, 1, 5, 0, -3 },
};

const GFXfont UbuntuSansMono_Italic9pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic9pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _UBUNTUSANSMONO_ITALIC9PT7B_H_
