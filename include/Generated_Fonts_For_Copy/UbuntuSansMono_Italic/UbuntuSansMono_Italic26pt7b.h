#ifndef _UBUNTUSANSMONO_ITALIC26PT7B_H_
#define _UBUNTUSANSMONO_ITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x80,
  0x00, 0x00, 0x70, 0xF1, 0xC0, 0x66, 0x8F, 0x1E, 0x2C, 0xD1, 0xA2, 0x00,
  0x00, 0xC6, 0x03, 0x0C, 0x06, 0x30, 0x0C, 0x60, 0x30, 0xC7, 0xFF, 0xC1,
  0x86, 0x03, 0x18, 0x0C, 0x30, 0x18, 0xC0, 0x61, 0x83, 0xFF, 0xEF, 0xFF,
  0x86, 0x18, 0x0C, 0x60, 0x30, 0xC0, 0x63, 0x01, 0x86, 0x00, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0xFF, 0x0F, 0xF8, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x61, 0xCF, 0x0F, 0xF8, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x07, 0x81, 0x86, 0x41, 0x86, 0x21, 0x83, 0x11, 0x81,
  0x88, 0xC0, 0xCC, 0xC0, 0x66, 0xC0, 0x3E, 0xC0, 0x04, 0xC0, 0x00, 0xCC,
  0x00, 0xCF, 0x00, 0x6C, 0xC0, 0x64, 0x60, 0x66, 0x30, 0x63, 0x10, 0x61,
  0x98, 0x60, 0xCC, 0x60, 0x3C, 0x00, 0x07, 0xE0, 0xE6, 0x1C, 0x61, 0x86,
  0x18, 0x61, 0x8C, 0x19, 0x80, 0xF0, 0x1E, 0x33, 0xE3, 0x67, 0x6E, 0x36,
  0xC1, 0xCC, 0x1C, 0xC1, 0xCC, 0x3C, 0xFF, 0xE7, 0xC6, 0x6D, 0xED, 0xB4,
  0x00, 0x60, 0x1C, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x08, 0x00, 0x02,
  0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x80, 0x80, 0x00, 0x0E, 0x00, 0xC0, 0x18, 0x72,
  0x7F, 0xFE, 0x3E, 0x03, 0x80, 0xD8, 0x39, 0x8E, 0x38, 0x44, 0x00, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xE0, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x00, 0x18, 0xF3, 0xCF, 0x1C, 0x6F,
  0x38, 0x7F, 0xF8, 0x6F, 0xFF, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x3B, 0x83, 0x0E, 0x30, 0x31, 0x81, 0x98, 0x0C, 0xC0, 0x6E, 0xE3,
  0x67, 0x9B, 0x39, 0x98, 0x8C, 0xC0, 0x6E, 0x06, 0x70, 0x31, 0x83, 0x0C,
  0x38, 0x7F, 0x81, 0xF8, 0x00, 0x00, 0xC0, 0x70, 0x7C, 0x7E, 0x19, 0x80,
  0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x30, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x73, 0xC2, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xF0,
  0x73, 0x82, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0, 0xFC, 0x07,
  0x80, 0x0F, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0xFF, 0xC7, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x0F, 0x80, 0x76, 0x03,
  0xB0, 0x0C, 0xC0, 0x63, 0x03, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x18,
  0x18, 0x7F, 0xFA, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x03, 0xFC, 0x1F, 0xF0, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0xC0, 0x1F, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x38, 0xFF, 0xC3, 0xFC, 0x00, 0x00, 0x78, 0x1F, 0xC1,
  0xE0, 0x1C, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0D, 0xF0, 0x7F, 0xC7, 0x03,
  0x30, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x03, 0x98, 0x18, 0x63, 0x83,
  0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x3C, 0xE0,
  0xC1, 0x86, 0x07, 0x18, 0x18, 0x60, 0x61, 0x83, 0x87, 0x1C, 0x0F, 0xE0,
  0x7F, 0x03, 0x0E, 0x18, 0x1C, 0x60, 0x33, 0x00, 0xCC, 0x07, 0x38, 0x18,
  0x73, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x71, 0xC7, 0x06, 0x30, 0x33, 0x81,
  0x98, 0x0C, 0xC0, 0x66, 0x03, 0x38, 0x38, 0xFF, 0xC1, 0xEC, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x7E, 0x07, 0xC0, 0x00, 0x1C, 0xF3,
  0xC7, 0x00, 0x00, 0x00, 0x00, 0x06, 0x3C, 0xF3, 0xC0, 0x07, 0x0F, 0x0F,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x3C, 0x3C, 0x3C, 0x1C,
  0x18, 0xF0, 0xE0, 0x00, 0x18, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0x70,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x30, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x30, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x01, 0xF0, 0x78, 0x3E, 0x0F, 0x00,
  0xC0, 0x00, 0x3F, 0x88, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x38,
  0x00, 0x03, 0xF8, 0x1E, 0xF0, 0xE0, 0xC7, 0x03, 0x18, 0x0C, 0xC0, 0x33,
  0x1F, 0xD8, 0xE3, 0x67, 0x19, 0x98, 0x6C, 0x61, 0xB3, 0x06, 0xCC, 0x33,
  0x38, 0xCC, 0x63, 0x30, 0xFC, 0xE0, 0xC1, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x3F, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x06, 0x60,
  0x0C, 0xC0, 0x31, 0x80, 0x63, 0x01, 0x86, 0x02, 0x0C, 0x0C, 0x18, 0x30,
  0x30, 0x7F, 0xE1, 0xFF, 0xC3, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x60, 0x0D,
  0xC0, 0x1C, 0x0F, 0xF0, 0x3F, 0xF0, 0xC1, 0xC3, 0x03, 0x18, 0x0C, 0x60,
  0x31, 0x81, 0x86, 0x3C, 0x3F, 0xC0, 0xC3, 0xC3, 0x03, 0x8C, 0x06, 0x30,
  0x19, 0x80, 0x66, 0x03, 0x18, 0x1C, 0x7F, 0xE3, 0xFE, 0x00, 0x03, 0xFC,
  0x3C, 0xE1, 0xC0, 0x8E, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x38, 0x10, 0x7B, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0xC3, 0x86,
  0x07, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33,
  0x01, 0xD8, 0x06, 0x60, 0x19, 0x80, 0xC6, 0x07, 0x18, 0x78, 0xFF, 0x83,
  0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x04, 0x3F, 0xE0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFC,
  0x3F, 0xF0, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x3F, 0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x03, 0xFC, 0x1E, 0x70, 0xC0, 0x86,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0xCC,
  0x03, 0x30, 0x0C, 0xC0, 0x73, 0x81, 0x86, 0x06, 0x1C, 0x18, 0x3D, 0xE0,
  0x7F, 0x00, 0x0C, 0x07, 0x0C, 0x06, 0x0C, 0x06, 0x1C, 0x06, 0x18, 0x06,
  0x18, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x3F, 0xFC, 0x30, 0x18, 0x30, 0x18,
  0x30, 0x18, 0x60, 0x18, 0x60, 0x30, 0x60, 0x30, 0x60, 0x30, 0xC0, 0x30,
  0xC0, 0x60, 0x0F, 0xF8, 0x7F, 0xC0, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x7F, 0x87, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xF0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x10, 0x30,
  0xF7, 0x81, 0xFC, 0x00, 0x06, 0x07, 0x0C, 0x0C, 0x0C, 0x18, 0x0C, 0x30,
  0x0C, 0x60, 0x19, 0xC0, 0x1B, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x36, 0x00,
  0x33, 0x00, 0x31, 0x80, 0x31, 0xC0, 0x60, 0xC0, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x30, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xFF, 0xFF, 0xF0, 0x06, 0x06, 0x0C, 0x1C, 0x38, 0x38, 0x58, 0xF0, 0xB1,
  0x43, 0x66, 0x86, 0xDB, 0x09, 0xA6, 0x33, 0xCC, 0x67, 0x18, 0xCE, 0x23,
  0x00, 0xC6, 0x01, 0x8C, 0x03, 0x30, 0x06, 0x60, 0x1C, 0xC0, 0x31, 0x80,
  0x60, 0x0E, 0x03, 0x0E, 0x06, 0x0E, 0x06, 0x0F, 0x06, 0x1B, 0x06, 0x1B,
  0x04, 0x19, 0x8C, 0x19, 0x8C, 0x31, 0x8C, 0x30, 0x88, 0x30, 0xD8, 0x30,
  0xD8, 0x20, 0xD8, 0x60, 0xD0, 0x60, 0x70, 0x60, 0x70, 0x40, 0x70, 0xC0,
  0x70, 0x03, 0xF0, 0x1C, 0xE0, 0xC1, 0x86, 0x07, 0x30, 0x0C, 0xC0, 0x33,
  0x00, 0xD8, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0xB0, 0x0E, 0xC0, 0x33,
  0x00, 0xC6, 0x06, 0x18, 0x30, 0x7B, 0x80, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0xE1, 0x81, 0x86, 0x06, 0x18, 0x1C, 0x60, 0x63, 0x01, 0x8C, 0x0E, 0x30,
  0x70, 0xFF, 0x87, 0xF8, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x1C, 0xE0, 0xC1, 0x86, 0x07,
  0x30, 0x0C, 0xC0, 0x37, 0x00, 0xD8, 0x07, 0x60, 0x19, 0x80, 0x66, 0x01,
  0xB0, 0x0E, 0xC0, 0x33, 0x00, 0xCE, 0x06, 0x18, 0x30, 0x7B, 0xC0, 0xFC,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x08, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x06,
  0x18, 0x38, 0xFF, 0x83, 0xF8, 0x0C, 0x30, 0x30, 0xC1, 0x81, 0x86, 0x06,
  0x18, 0x18, 0x60, 0x63, 0x00, 0xC0, 0x07, 0xFC, 0x3C, 0xE0, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x20, 0x38, 0xFF, 0xC3,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x18, 0x0E, 0x30, 0x18, 0x60, 0x30, 0xC0,
  0x63, 0x00, 0xC6, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x60, 0x18, 0xC0, 0x61,
  0x80, 0xC3, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x18, 0x18, 0x30, 0x70, 0x7B,
  0xC0, 0x7F, 0x00, 0xC0, 0x1F, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xC0, 0x63,
  0x01, 0x8C, 0x0C, 0x30, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x30, 0xC0,
  0x66, 0x01, 0xB0, 0x06, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x18,
  0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x98, 0x02,
  0x31, 0x8C, 0x67, 0x18, 0xCE, 0x21, 0xB6, 0xC2, 0x4D, 0x8D, 0x9A, 0x1A,
  0x34, 0x3C, 0x78, 0x70, 0xE0, 0xE1, 0xC1, 0x83, 0x80, 0x07, 0x01, 0xC0,
  0xC0, 0xE0, 0x30, 0x70, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0C, 0xC0,
  0x06, 0x30, 0x03, 0x0C, 0x01, 0xC1, 0x80, 0xE0, 0x60, 0x70, 0x18, 0x38,
  0x07, 0x00, 0xC0, 0x1F, 0x00, 0x66, 0x03, 0x18, 0x1C, 0x60, 0x61, 0x83,
  0x03, 0x18, 0x0C, 0x60, 0x33, 0x00, 0x78, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xF8,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x67, 0x73, 0x33,
  0x33, 0x33, 0x33, 0x30, 0x07, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x06, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0x80, 0x38, 0x06, 0xC0, 0xEC,
  0x0C, 0x41, 0x86, 0x30, 0x66, 0x02, 0xE0, 0x34, 0x02, 0xFF, 0xFF, 0xFF,
  0xE0, 0xCE, 0x63, 0x10, 0x01, 0xF0, 0x7F, 0xC7, 0x8C, 0x70, 0x67, 0x03,
  0x30, 0x19, 0x81, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x11, 0xC1, 0x87,
  0x3C, 0x1F, 0x30, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x6F, 0x03, 0xFE, 0x18, 0x31, 0x81, 0xCC, 0x06, 0x60, 0x33, 0x03,
  0xB0, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0xE6, 0x0E, 0x3F, 0xE1, 0xFC, 0x00,
  0x03, 0xF8, 0x7F, 0x87, 0x04, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x07, 0xDC, 0x1F, 0xE0, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x7E,
  0x03, 0xFC, 0x1E, 0x18, 0x70, 0x60, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x0C,
  0x0C, 0x38, 0x18, 0x60, 0x30, 0xE0, 0x60, 0xC1, 0xC1, 0xEF, 0x81, 0xFB,
  0x00, 0x03, 0xC0, 0xFF, 0x1C, 0x33, 0x03, 0x70, 0x36, 0x03, 0xC1, 0xEF,
  0xFC, 0xF8, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x0F, 0xFE, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x0F, 0xF0, 0xF0, 0xC3, 0x03, 0x18, 0x18, 0xE0, 0x63, 0x01,
  0x8C, 0x06, 0x30, 0x31, 0xC0, 0xC3, 0x03, 0x0E, 0x3C, 0x1F, 0xE0, 0x11,
  0x80, 0x06, 0x00, 0x30, 0x81, 0xC3, 0xFE, 0x07, 0xE0, 0x00, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x7F, 0x03, 0xFE, 0x18,
  0x30, 0xC1, 0x8E, 0x06, 0x60, 0x73, 0x03, 0x18, 0x18, 0xC0, 0xCC, 0x06,
  0x60, 0x63, 0x03, 0x18, 0x19, 0x80, 0xC0, 0x06, 0x0F, 0x0E, 0x06, 0x00,
  0x00, 0x00, 0xFC, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30,
  0x38, 0x1F, 0x0F, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xC0, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x08, 0x38, 0x3F, 0xC0, 0x7C, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x46,
  0x0E, 0x18, 0x60, 0xC7, 0x03, 0x38, 0x0F, 0x80, 0x3C, 0x01, 0xB8, 0x06,
  0x70, 0x18, 0xC0, 0x61, 0x83, 0x07, 0x0C, 0x0C, 0x30, 0x18, 0x7E, 0xFC,
  0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30,
  0x60, 0x60, 0x60, 0x60, 0x73, 0x3F, 0x0F, 0x38, 0x7F, 0xF1, 0x9C, 0xCC,
  0x63, 0x31, 0x8C, 0xC6, 0x33, 0x31, 0x98, 0xC6, 0x63, 0x19, 0x80, 0x66,
  0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC0, 0x07, 0xC1, 0xFE, 0x18, 0x73,
  0x03, 0x30, 0x33, 0x03, 0x30, 0x37, 0x03, 0x60, 0x76, 0x06, 0x60, 0x66,
  0x06, 0xC0, 0x6C, 0x0C, 0x03, 0xC0, 0x7F, 0x07, 0x0C, 0x70, 0x63, 0x01,
  0xB0, 0x0D, 0x80, 0xCC, 0x06, 0xE0, 0x36, 0x03, 0xB8, 0x18, 0xC1, 0xC7,
  0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x3F, 0xC1, 0xC3, 0x86, 0x06, 0x18, 0x1C,
  0x60, 0x31, 0x81, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0xE3, 0x03, 0x18, 0x38,
  0x7F, 0xC1, 0xFE, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xF0, 0x3F, 0xC7, 0x86, 0x70, 0x73, 0x03, 0x30, 0x19, 0x80,
  0xCC, 0x0E, 0xC0, 0x66, 0x03, 0x30, 0x18, 0xC1, 0xC7, 0x3C, 0x1F, 0xE0,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xF1, 0xFF, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0xE0, 0xFF, 0x0C, 0x11, 0x80, 0x18,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x73,
  0xCF, 0xF8, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC3, 0xFF, 0x86, 0x00,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x7B, 0x87, 0xF0, 0x38, 0x19, 0x81, 0x8C, 0x0C, 0xE0, 0x66, 0x03, 0x30,
  0x31, 0x81, 0x8C, 0x0C, 0xC0, 0x66, 0x03, 0x18, 0x30, 0xFF, 0x83, 0xE6,
  0x00, 0xC0, 0x78, 0x1F, 0x03, 0x60, 0x6C, 0x19, 0xC3, 0x18, 0xC3, 0x30,
  0x66, 0x0D, 0x81, 0xF0, 0x3C, 0x03, 0x00, 0x60, 0x0E, 0xC0, 0x19, 0x80,
  0x33, 0x18, 0xC6, 0x31, 0x8C, 0xE3, 0x19, 0x4C, 0x36, 0x98, 0x59, 0xE1,
  0xA3, 0xC3, 0xC7, 0x07, 0x0E, 0x0C, 0x1C, 0x00, 0x0E, 0x07, 0x06, 0x0C,
  0x03, 0x18, 0x03, 0x30, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0x60, 0x0E, 0x60, 0x1C, 0x30, 0x38, 0x30, 0xE0, 0x38, 0x0C, 0x06,
  0x18, 0x0C, 0x30, 0x30, 0x70, 0x60, 0x60, 0xC0, 0xC3, 0x01, 0x86, 0x03,
  0x18, 0x07, 0x30, 0x06, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x1F, 0xF8, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0x80,
  0x18, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1F, 0xC0, 0x0F, 0x00, 0x07, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60,
  0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0x03, 0xF0, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x1F, 0x00, 0x7C, 0x03, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x3F, 0x80,
  0xF0, 0x00, 0x18, 0x01, 0xF0, 0xD9, 0xFD, 0x83, 0xC0,
};

const GFXglyph UbuntuSansMono_Italic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 18, 15, 4, -18 },
  { 17, 7, 7, 15, 6, -20 },
  { 24, 15, 18, 15, 0, -18 },
  { 58, 14, 23, 15, 1, -20 },
  { 99, 17, 18, 15, -1, -18 },
  { 138, 12, 18, 15, 1, -18 },
  { 165, 3, 8, 15, 8, -20 },
  { 168, 11, 25, 15, 3, -20 },
  { 203, 10, 25, 15, 1, -20 },
  { 235, 11, 11, 15, 3, -18 },
  { 251, 12, 13, 15, 2, -14 },
  { 271, 6, 8, 15, 2, -4 },
  { 277, 7, 2, 15, 4, -8 },
  { 279, 4, 4, 15, 4, -4 },
  { 281, 17, 25, 15, -2, -20 },
  { 335, 13, 18, 15, 1, -18 },
  { 365, 10, 18, 15, 2, -18 },
  { 388, 13, 18, 15, 1, -18 },
  { 418, 13, 18, 15, 1, -18 },
  { 448, 14, 18, 15, 0, -18 },
  { 480, 14, 18, 15, 1, -18 },
  { 512, 13, 18, 15, 2, -18 },
  { 542, 13, 18, 15, 3, -18 },
  { 572, 14, 18, 15, 1, -18 },
  { 604, 13, 18, 15, 1, -18 },
  { 634, 6, 14, 15, 4, -14 },
  { 645, 8, 18, 15, 2, -14 },
  { 663, 13, 11, 15, 1, -13 },
  { 681, 13, 7, 15, 1, -11 },
  { 693, 12, 11, 15, 1, -13 },
  { 710, 10, 18, 15, 4, -18 },
  { 733, 14, 22, 15, 1, -18 },
  { 772, 15, 18, 15, -2, -18 },
  { 806, 14, 18, 15, 0, -18 },
  { 838, 14, 18, 15, 2, -18 },
  { 870, 14, 18, 15, 0, -18 },
  { 902, 14, 18, 15, 1, -18 },
  { 934, 14, 18, 15, 1, -18 },
  { 966, 14, 18, 15, 1, -18 },
  { 998, 16, 18, 15, 0, -18 },
  { 1034, 13, 18, 15, 1, -18 },
  { 1064, 14, 18, 15, 1, -18 },
  { 1096, 16, 18, 15, 0, -18 },
  { 1132, 10, 18, 15, 1, -18 },
  { 1155, 15, 18, 15, 0, -18 },
  { 1189, 16, 18, 15, 0, -18 },
  { 1225, 14, 18, 15, 1, -18 },
  { 1257, 14, 18, 15, 1, -18 },
  { 1289, 14, 23, 15, 1, -18 },
  { 1330, 14, 18, 15, 0, -18 },
  { 1362, 14, 18, 15, 1, -18 },
  { 1394, 12, 18, 15, 4, -18 },
  { 1421, 15, 18, 15, 1, -18 },
  { 1455, 14, 18, 15, 3, -18 },
  { 1487, 15, 18, 15, 1, -18 },
  { 1521, 18, 18, 15, -1, -18 },
  { 1562, 14, 18, 15, 3, -18 },
  { 1594, 16, 18, 15, 0, -18 },
  { 1630, 13, 25, 15, 2, -20 },
  { 1671, 4, 25, 15, 5, -20 },
  { 1684, 12, 25, 15, 0, -20 },
  { 1722, 12, 10, 15, 2, -18 },
  { 1737, 14, 2, 15, -2, 3 },
  { 1741, 4, 5, 15, 7, -20 },
  { 1744, 13, 14, 15, 1, -14 },
  { 1767, 13, 20, 15, 1, -20 },
  { 1800, 13, 14, 15, 1, -14 },
  { 1823, 15, 20, 15, 1, -20 },
  { 1861, 12, 14, 15, 1, -14 },
  { 1882, 16, 25, 15, 0, -20 },
  { 1932, 14, 19, 15, 0, -14 },
  { 1966, 13, 20, 15, 0, -20 },
  { 1999, 8, 20, 15, 3, -20 },
  { 2019, 14, 25, 15, 0, -20 },
  { 2063, 14, 20, 15, 1, -20 },
  { 2098, 8, 20, 15, 4, -20 },
  { 2118, 14, 14, 15, 0, -14 },
  { 2143, 12, 14, 15, 1, -14 },
  { 2164, 13, 14, 15, 1, -14 },
  { 2187, 14, 19, 15, 0, -14 },
  { 2221, 13, 19, 15, 1, -14 },
  { 2252, 12, 14, 15, 2, -14 },
  { 2273, 12, 14, 15, 1, -14 },
  { 2294, 11, 18, 15, 3, -18 },
  { 2319, 13, 13, 15, 1, -13 },
  { 2341, 11, 13, 15, 3, -13 },
  { 2359, 15, 13, 15, 1, -13 },
  { 2384, 16, 13, 15, -1, -13 },
  { 2410, 15, 18, 15, -1, -13 },
  { 2444, 13, 13, 15, 1, -13 },
  { 2466, 15, 25, 15, 1, -20 },
  { 2513, 8, 25, 15, 4, -20 },
  { 2538, 14, 25, 15, -1, -20 },
  { 2582, 13, 4, 15, 1, -10 },
};

const GFXfont UbuntuSansMono_Italic26pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic26pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic26pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _UBUNTUSANSMONO_ITALIC26PT7B_H_
