#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/UbuntuSansMono_Italic
// Headers: 67

#include "UbuntuSansMono_Italic6pt7b.h"
#include "UbuntuSansMono_Italic7pt7b.h"
#include "UbuntuSansMono_Italic8pt7b.h"
#include "UbuntuSansMono_Italic9pt7b.h"
#include "UbuntuSansMono_Italic10pt7b.h"
#include "UbuntuSansMono_Italic11pt7b.h"
#include "UbuntuSansMono_Italic12pt7b.h"
#include "UbuntuSansMono_Italic13pt7b.h"
#include "UbuntuSansMono_Italic14pt7b.h"
#include "UbuntuSansMono_Italic15pt7b.h"
#include "UbuntuSansMono_Italic16pt7b.h"
#include "UbuntuSansMono_Italic17pt7b.h"
#include "UbuntuSansMono_Italic18pt7b.h"
#include "UbuntuSansMono_Italic19pt7b.h"
#include "UbuntuSansMono_Italic20pt7b.h"
#include "UbuntuSansMono_Italic21pt7b.h"
#include "UbuntuSansMono_Italic22pt7b.h"
#include "UbuntuSansMono_Italic23pt7b.h"
#include "UbuntuSansMono_Italic24pt7b.h"
#include "UbuntuSansMono_Italic25pt7b.h"
#include "UbuntuSansMono_Italic26pt7b.h"
#include "UbuntuSansMono_Italic27pt7b.h"
#include "UbuntuSansMono_Italic28pt7b.h"
#include "UbuntuSansMono_Italic29pt7b.h"
#include "UbuntuSansMono_Italic30pt7b.h"
#include "UbuntuSansMono_Italic31pt7b.h"
#include "UbuntuSansMono_Italic32pt7b.h"
#include "UbuntuSansMono_Italic33pt7b.h"
#include "UbuntuSansMono_Italic34pt7b.h"
#include "UbuntuSansMono_Italic35pt7b.h"
#include "UbuntuSansMono_Italic36pt7b.h"
#include "UbuntuSansMono_Italic37pt7b.h"
#include "UbuntuSansMono_Italic38pt7b.h"
#include "UbuntuSansMono_Italic39pt7b.h"
#include "UbuntuSansMono_Italic40pt7b.h"
#include "UbuntuSansMono_Italic41pt7b.h"
#include "UbuntuSansMono_Italic42pt7b.h"
#include "UbuntuSansMono_Italic43pt7b.h"
#include "UbuntuSansMono_Italic44pt7b.h"
#include "UbuntuSansMono_Italic45pt7b.h"
#include "UbuntuSansMono_Italic46pt7b.h"
#include "UbuntuSansMono_Italic47pt7b.h"
#include "UbuntuSansMono_Italic48pt7b.h"
#include "UbuntuSansMono_Italic49pt7b.h"
#include "UbuntuSansMono_Italic50pt7b.h"
#include "UbuntuSansMono_Italic51pt7b.h"
#include "UbuntuSansMono_Italic52pt7b.h"
#include "UbuntuSansMono_Italic53pt7b.h"
#include "UbuntuSansMono_Italic54pt7b.h"
#include "UbuntuSansMono_Italic55pt7b.h"
#include "UbuntuSansMono_Italic56pt7b.h"
#include "UbuntuSansMono_Italic57pt7b.h"
#include "UbuntuSansMono_Italic58pt7b.h"
#include "UbuntuSansMono_Italic59pt7b.h"
#include "UbuntuSansMono_Italic60pt7b.h"
#include "UbuntuSansMono_Italic61pt7b.h"
#include "UbuntuSansMono_Italic62pt7b.h"
#include "UbuntuSansMono_Italic63pt7b.h"
#include "UbuntuSansMono_Italic64pt7b.h"
#include "UbuntuSansMono_Italic65pt7b.h"
#include "UbuntuSansMono_Italic66pt7b.h"
#include "UbuntuSansMono_Italic67pt7b.h"
#include "UbuntuSansMono_Italic68pt7b.h"
#include "UbuntuSansMono_Italic69pt7b.h"
#include "UbuntuSansMono_Italic70pt7b.h"
#include "UbuntuSansMono_Italic71pt7b.h"
#include "UbuntuSansMono_Italic72pt7b.h"
