#ifndef _UBUNTUSANSMONO_ITALIC17PT7B_H_
#define _UBUNTUSANSMONO_ITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x22, 0x26, 0x44, 0x00, 0xCC, 0xDC, 0xA5, 0x2A, 0x00, 0x06,
  0x41, 0x30, 0xC9, 0xFF, 0x19, 0x04, 0xC3, 0x20, 0x88, 0xFF, 0x91, 0x04,
  0xC3, 0x20, 0x06, 0x04, 0x1F, 0x30, 0x20, 0x20, 0x38, 0x0C, 0x02, 0x02,
  0x02, 0xFC, 0x30, 0x20, 0x20, 0x1C, 0x31, 0x46, 0x24, 0x42, 0x48, 0x25,
  0x01, 0xA0, 0x05, 0x80, 0xF4, 0x1A, 0x41, 0x24, 0x22, 0xCC, 0x38, 0x0F,
  0x19, 0x11, 0x13, 0x16, 0x1C, 0x39, 0x4D, 0x46, 0xC2, 0x46, 0x7B, 0x56,
  0x80, 0x06, 0x18, 0x61, 0x82, 0x0C, 0x10, 0x60, 0xC1, 0x02, 0x06, 0x0C,
  0x08, 0x18, 0x18, 0x0C, 0x04, 0x06, 0x02, 0x02, 0x03, 0x02, 0x02, 0x02,
  0x06, 0x04, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x10, 0x23, 0x4F, 0xF3, 0x8D,
  0x99, 0x00, 0x0C, 0x08, 0x08, 0xFF, 0xFF, 0x10, 0x10, 0x30, 0x13, 0x31,
  0x68, 0xF0, 0x7C, 0x00, 0x60, 0x18, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x0E, 0x33, 0x21, 0x61, 0x41, 0xD9, 0xDB, 0x82, 0x82, 0x86, 0xCC,
  0x78, 0x02, 0x1C, 0xF1, 0x20, 0x41, 0x82, 0x04, 0x08, 0x30, 0x4F, 0xE0,
  0x1E, 0x23, 0x01, 0x01, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xC0, 0xFE,
  0x1E, 0x23, 0x01, 0x01, 0x02, 0x1C, 0x06, 0x02, 0x02, 0x02, 0x86, 0xFC,
  0x01, 0x81, 0xC1, 0x41, 0x21, 0x31, 0x99, 0x88, 0x84, 0xFF, 0x03, 0x01,
  0x00, 0x80, 0x0F, 0xC2, 0x00, 0x80, 0x60, 0x10, 0x07, 0x80, 0x30, 0x04,
  0x01, 0x00, 0xC4, 0x63, 0xF0, 0x03, 0x87, 0x06, 0x06, 0x06, 0x03, 0xF1,
  0x09, 0x86, 0xC3, 0x61, 0x31, 0x8F, 0x80, 0x7F, 0x80, 0x80, 0x80, 0x80,
  0xC0, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x10, 0x18, 0x00, 0x1F, 0x18, 0x88,
  0x64, 0x22, 0x31, 0xB0, 0xB8, 0x84, 0x82, 0x41, 0x31, 0x8F, 0x80, 0x1E,
  0x31, 0x61, 0x61, 0x41, 0x61, 0x3F, 0x03, 0x06, 0x0C, 0x18, 0xE0, 0x27,
  0x70, 0x00, 0x4C, 0xC0, 0x08, 0x71, 0xC0, 0x00, 0x01, 0x0C, 0x30, 0x46,
  0x20, 0x01, 0x07, 0x1C, 0xE0, 0xC0, 0x70, 0x1E, 0x04, 0xFF, 0x00, 0x00,
  0xFE, 0x20, 0x18, 0x03, 0x80, 0x70, 0x38, 0x73, 0xC0, 0x80, 0x3C, 0x04,
  0x08, 0x30, 0x43, 0x0C, 0x10, 0x00, 0x01, 0x87, 0x00, 0x0F, 0x0C, 0xC8,
  0x2C, 0x14, 0xFE, 0xCA, 0x45, 0x22, 0xB3, 0x49, 0x27, 0x90, 0x0C, 0x03,
  0xC0, 0x40, 0x03, 0x01, 0x81, 0x60, 0xB0, 0x98, 0xC4, 0x42, 0x61, 0x3F,
  0xB0, 0x50, 0x38, 0x10, 0x1F, 0x08, 0xCC, 0x24, 0x12, 0x19, 0xF1, 0x8C,
  0xC2, 0x41, 0x20, 0xB0, 0xDF, 0x80, 0x0F, 0x8C, 0x48, 0x0C, 0x04, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x60, 0x10, 0x8F, 0xC0, 0x1E, 0x19, 0x8C, 0x64,
  0x12, 0x0B, 0x05, 0x82, 0x83, 0x41, 0x21, 0xB1, 0x9F, 0x00, 0x1F, 0x98,
  0x08, 0x04, 0x02, 0x03, 0xF1, 0x00, 0x80, 0x40, 0x60, 0x20, 0x1F, 0xC0,
  0x1F, 0x98, 0x08, 0x04, 0x02, 0x03, 0xF1, 0x00, 0x80, 0x40, 0x60, 0x20,
  0x10, 0x00, 0x0F, 0x98, 0x88, 0x08, 0x04, 0x04, 0x02, 0x0D, 0x04, 0x82,
  0x41, 0x31, 0x8F, 0x80, 0x10, 0x44, 0x13, 0x0C, 0x82, 0x20, 0x8F, 0xE6,
  0x19, 0x04, 0x41, 0x10, 0x4C, 0x32, 0x08, 0x1F, 0x24, 0x0C, 0x08, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0xFC, 0x1F, 0x80, 0xC0, 0x40, 0x20,
  0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x23, 0x1F, 0x00, 0x10, 0xC4, 0x63,
  0x30, 0xD8, 0x2C, 0x0E, 0x03, 0x81, 0xB0, 0x44, 0x11, 0x84, 0x23, 0x0C,
  0x18, 0x20, 0x41, 0x83, 0x04, 0x08, 0x30, 0x60, 0x81, 0x07, 0xF0, 0x18,
  0xC6, 0x31, 0x94, 0xA6, 0x2A, 0x8A, 0xA6, 0xC9, 0x02, 0x41, 0xB0, 0x48,
  0x12, 0x04, 0x10, 0x46, 0x13, 0x8C, 0xA2, 0x2C, 0x89, 0x26, 0x49, 0x16,
  0x45, 0x10, 0xC4, 0x32, 0x0C, 0x0E, 0x18, 0x88, 0x48, 0x34, 0x1E, 0x0A,
  0x05, 0x02, 0x83, 0x41, 0x31, 0x0F, 0x00, 0x1F, 0x04, 0x61, 0x0C, 0xC2,
  0x30, 0x88, 0x63, 0xF1, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x0E, 0x18,
  0x88, 0x68, 0x34, 0x1E, 0x0A, 0x05, 0x02, 0x83, 0x41, 0x31, 0x0F, 0x03,
  0x01, 0x80, 0x70, 0x1F, 0x08, 0xCC, 0x26, 0x12, 0x09, 0x08, 0xF8, 0xC8,
  0x46, 0x21, 0x10, 0x98, 0x60, 0x0F, 0xC6, 0x21, 0x00, 0x40, 0x10, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x44, 0x33, 0xF8, 0xFF, 0x08, 0x18, 0x10,
  0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x60, 0x40, 0x20, 0x90, 0x58, 0x68,
  0x24, 0x12, 0x0B, 0x0D, 0x04, 0x82, 0x41, 0x31, 0x0F, 0x80, 0x81, 0xC0,
  0xA0, 0xD0, 0x48, 0x64, 0x23, 0x31, 0x90, 0xD0, 0x68, 0x18, 0x0C, 0x00,
  0x60, 0xD8, 0x24, 0x09, 0x06, 0x41, 0x36, 0x49, 0x92, 0xA8, 0xAA, 0x32,
  0x8C, 0xC2, 0x10, 0x08, 0x30, 0xC6, 0x04, 0x40, 0x48, 0x07, 0x80, 0x30,
  0x07, 0x00, 0xD0, 0x19, 0x01, 0x18, 0x20, 0x8E, 0x08, 0x80, 0xE0, 0x90,
  0xC8, 0xC4, 0x43, 0x40, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x00, 0x1F,
  0xC0, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x40, 0x30, 0x18, 0x04,
  0x03, 0xFC, 0x0F, 0x84, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20,
  0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01, 0xF0, 0xAA, 0xAB, 0xFF, 0xD5,
  0x0F, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x08,
  0x08, 0x08, 0x18, 0xF0, 0x08, 0x38, 0xD3, 0x24, 0x70, 0x40, 0xFF, 0x80,
  0xCC, 0x80, 0x1F, 0x33, 0x42, 0xC2, 0x82, 0x86, 0x86, 0x84, 0x7E, 0x10,
  0x30, 0x20, 0x20, 0x3E, 0x63, 0x41, 0x41, 0x43, 0xC2, 0x86, 0x8C, 0xF8,
  0x1F, 0x61, 0x40, 0x80, 0x80, 0x80, 0x80, 0xC2, 0x7C, 0x00, 0x80, 0x40,
  0x60, 0x21, 0xF1, 0x89, 0x8D, 0x84, 0x82, 0x41, 0x21, 0x98, 0xC7, 0xA0,
  0x1E, 0x63, 0x43, 0xC2, 0xFE, 0x80, 0x80, 0xC2, 0x7E, 0x03, 0xE0, 0x40,
  0x10, 0x02, 0x01, 0xFC, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x07, 0x00, 0x0F, 0x8C, 0x4C, 0x64, 0x36,
  0x12, 0x09, 0x04, 0xCE, 0x3A, 0x01, 0x21, 0x9F, 0x80, 0x18, 0x10, 0x10,
  0x30, 0x3E, 0x23, 0x21, 0x61, 0x61, 0x43, 0x43, 0x42, 0xC2, 0x18, 0xC0,
  0x0F, 0x18, 0xC4, 0x21, 0x18, 0x43, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x01,
  0xF0, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x22, 0x31,
  0xF0, 0x10, 0x18, 0x08, 0x04, 0x02, 0x1B, 0x31, 0x30, 0xA0, 0x70, 0x6C,
  0x23, 0x10, 0x88, 0x60, 0xF1, 0x88, 0x42, 0x31, 0x08, 0x46, 0x31, 0x87,
  0x80, 0x3F, 0x92, 0x59, 0x2D, 0x94, 0x9A, 0x49, 0x05, 0x82, 0x83, 0x00,
  0x3E, 0x62, 0x43, 0x43, 0x42, 0xC2, 0xC2, 0x86, 0x84, 0x1E, 0x33, 0x41,
  0xC1, 0x83, 0x82, 0x82, 0xC4, 0x78, 0x1F, 0x18, 0xC8, 0x64, 0x12, 0x1B,
  0x09, 0x0C, 0x8C, 0x7C, 0x60, 0x20, 0x10, 0x00, 0x1F, 0x31, 0x63, 0xC2,
  0x82, 0x82, 0x86, 0xC4, 0x7C, 0x04, 0x0C, 0x08, 0x1F, 0x20, 0x20, 0x60,
  0x60, 0x40, 0x40, 0xC0, 0xC0, 0x1F, 0x31, 0x20, 0x30, 0x18, 0x04, 0x06,
  0x84, 0xFC, 0x10, 0x20, 0xC7, 0xF2, 0x04, 0x18, 0x30, 0x40, 0x81, 0x03,
  0xE0, 0x61, 0x43, 0x42, 0xC2, 0xC2, 0x86, 0x86, 0xC4, 0x7E, 0x83, 0x06,
  0x16, 0x2C, 0x9B, 0x14, 0x30, 0x60, 0x40, 0xE0, 0x72, 0x53, 0x29, 0xB5,
  0x52, 0xA9, 0x98, 0x84, 0x00, 0x30, 0xC4, 0x41, 0xB0, 0x38, 0x0C, 0x07,
  0x03, 0x61, 0x88, 0xC3, 0x00, 0x10, 0x44, 0x11, 0x8C, 0x62, 0x08, 0x82,
  0x40, 0x90, 0x38, 0x06, 0x01, 0x00, 0x83, 0xC0, 0x1F, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xC0, 0xFE, 0x00, 0x07, 0x84, 0x02, 0x03, 0x01,
  0x00, 0x80, 0x41, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00,
  0xF0, 0x0C, 0x20, 0x86, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x18, 0x41, 0x04,
  0x30, 0x0F, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x07, 0x03, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x21, 0xE0, 0x71, 0x8E,
};

const GFXglyph UbuntuSansMono_Italic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 5, 5, 10, 4, -13 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 8, 15, 10, 1, -13 },
  { 41, 12, 12, 10, -1, -12 },
  { 59, 8, 12, 10, 0, -12 },
  { 71, 2, 5, 10, 5, -13 },
  { 73, 7, 16, 10, 2, -13 },
  { 87, 8, 16, 10, 0, -13 },
  { 103, 7, 7, 10, 2, -12 },
  { 110, 8, 8, 10, 1, -9 },
  { 118, 4, 6, 10, 1, -3 },
  { 121, 4, 1, 10, 3, -5 },
  { 122, 2, 3, 10, 3, -3 },
  { 123, 11, 16, 10, -1, -13 },
  { 145, 8, 12, 10, 1, -12 },
  { 157, 7, 12, 10, 1, -12 },
  { 168, 8, 12, 10, 1, -12 },
  { 180, 8, 12, 10, 1, -12 },
  { 192, 9, 12, 10, 0, -12 },
  { 206, 10, 12, 10, 0, -12 },
  { 221, 9, 12, 10, 1, -12 },
  { 235, 9, 12, 10, 2, -12 },
  { 249, 9, 12, 10, 1, -12 },
  { 263, 8, 12, 10, 1, -12 },
  { 275, 4, 9, 10, 3, -9 },
  { 280, 6, 12, 10, 1, -9 },
  { 289, 8, 8, 10, 1, -9 },
  { 297, 8, 4, 10, 1, -7 },
  { 301, 9, 8, 10, 0, -9 },
  { 310, 7, 12, 10, 2, -12 },
  { 321, 9, 15, 10, 1, -12 },
  { 338, 9, 12, 10, -1, -12 },
  { 352, 9, 12, 10, 0, -12 },
  { 366, 9, 12, 10, 1, -12 },
  { 380, 9, 12, 10, 0, -12 },
  { 394, 9, 12, 10, 1, -12 },
  { 408, 9, 12, 10, 1, -12 },
  { 422, 9, 12, 10, 1, -12 },
  { 436, 10, 12, 10, 0, -12 },
  { 451, 8, 12, 10, 1, -12 },
  { 463, 9, 12, 10, 1, -12 },
  { 477, 10, 12, 10, 0, -12 },
  { 492, 7, 12, 10, 0, -12 },
  { 503, 10, 12, 10, 0, -12 },
  { 518, 10, 12, 10, 0, -12 },
  { 533, 9, 12, 10, 1, -12 },
  { 547, 10, 12, 10, 0, -12 },
  { 562, 9, 15, 10, 1, -12 },
  { 579, 9, 12, 10, 0, -12 },
  { 593, 10, 12, 10, 0, -12 },
  { 608, 8, 12, 10, 2, -12 },
  { 620, 9, 12, 10, 1, -12 },
  { 634, 9, 12, 10, 2, -12 },
  { 648, 10, 12, 10, 1, -12 },
  { 663, 12, 12, 10, -1, -12 },
  { 681, 9, 12, 10, 2, -12 },
  { 695, 10, 12, 10, 0, -12 },
  { 710, 9, 16, 10, 1, -13 },
  { 728, 2, 16, 10, 4, -13 },
  { 732, 8, 16, 10, 0, -13 },
  { 748, 7, 6, 10, 2, -12 },
  { 754, 9, 1, 10, -1, 2 },
  { 756, 3, 3, 10, 4, -13 },
  { 758, 8, 9, 10, 1, -9 },
  { 767, 8, 13, 10, 1, -13 },
  { 780, 8, 9, 10, 1, -9 },
  { 789, 9, 13, 10, 1, -13 },
  { 804, 8, 9, 10, 1, -9 },
  { 813, 11, 16, 10, 0, -13 },
  { 835, 9, 12, 10, 0, -9 },
  { 849, 8, 13, 10, 0, -13 },
  { 862, 5, 13, 10, 2, -13 },
  { 871, 9, 16, 10, 0, -13 },
  { 889, 9, 13, 10, 1, -13 },
  { 904, 5, 13, 10, 3, -13 },
  { 913, 9, 9, 10, 0, -9 },
  { 924, 8, 9, 10, 1, -9 },
  { 933, 8, 9, 10, 1, -9 },
  { 942, 9, 12, 10, 0, -9 },
  { 956, 8, 12, 10, 1, -9 },
  { 968, 8, 9, 10, 1, -9 },
  { 977, 8, 9, 10, 1, -9 },
  { 986, 7, 12, 10, 2, -12 },
  { 997, 8, 9, 10, 1, -9 },
  { 1006, 7, 9, 10, 2, -9 },
  { 1014, 9, 9, 10, 1, -9 },
  { 1025, 10, 9, 10, 0, -9 },
  { 1037, 10, 12, 10, -1, -9 },
  { 1052, 9, 9, 10, 0, -9 },
  { 1063, 9, 16, 10, 1, -13 },
  { 1081, 6, 16, 10, 2, -13 },
  { 1093, 9, 16, 10, -1, -13 },
  { 1111, 8, 2, 10, 1, -6 },
};

const GFXfont UbuntuSansMono_Italic17pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic17pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _UBUNTUSANSMONO_ITALIC17PT7B_H_
