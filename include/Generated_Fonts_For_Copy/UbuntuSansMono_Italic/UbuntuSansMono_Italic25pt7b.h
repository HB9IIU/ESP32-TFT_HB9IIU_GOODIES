#ifndef _UBUNTUSANSMONO_ITALIC25PT7B_H_
#define _UBUNTUSANSMONO_ITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x8C, 0x30, 0xC2, 0x00, 0x00, 0x0E,
  0x38, 0xE0, 0x23, 0x62, 0x66, 0x46, 0x44, 0x44, 0x84, 0x01, 0xC6, 0x03,
  0x18, 0x04, 0x30, 0x18, 0xC3, 0xFF, 0xE7, 0xFF, 0x81, 0x8C, 0x06, 0x30,
  0x0C, 0x60, 0x30, 0xC0, 0x63, 0x03, 0xFF, 0xCB, 0x18, 0x06, 0x30, 0x18,
  0xC0, 0x31, 0x80, 0xC6, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x0F, 0xF0,
  0xE1, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x73, 0xC3, 0xFC, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x87, 0xC1, 0x82, 0x61, 0x83,
  0x31, 0x81, 0x18, 0xC0, 0x8C, 0xC0, 0x64, 0xC0, 0x36, 0xC0, 0x0E, 0xC0,
  0x00, 0xC0, 0x00, 0x4F, 0x00, 0x6D, 0x80, 0x6C, 0xC0, 0x66, 0x60, 0x62,
  0x30, 0x61, 0x18, 0x60, 0xD8, 0x60, 0x78, 0x00, 0x03, 0x80, 0xF8, 0x31,
  0x8C, 0x31, 0x86, 0x31, 0x86, 0x60, 0xDC, 0x0E, 0x07, 0x8D, 0x99, 0xF1,
  0xAC, 0x3D, 0x83, 0xB0, 0x66, 0x1E, 0xFE, 0xCF, 0x9C, 0x7F, 0x6D, 0x20,
  0x00, 0x40, 0x18, 0x07, 0x81, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x10, 0x00, 0x02,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x0E, 0x03, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x82, 0x31, 0x72,
  0xEF, 0xFE, 0x18, 0x06, 0x81, 0x98, 0x71, 0x84, 0x20, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x07, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0xF3, 0xCF, 0x18, 0xEF, 0x30, 0xFF, 0xF0, 0x6F,
  0xFE, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0x8C, 0x38, 0x61, 0x83, 0x18,
  0x1C, 0xC0, 0xCC, 0x46, 0x67, 0x33, 0x39, 0x98, 0x8D, 0xC0, 0xCE, 0x06,
  0x70, 0x73, 0x83, 0x0C, 0x30, 0x77, 0x81, 0xF0, 0x00, 0x01, 0xC0, 0xE0,
  0xF8, 0xF6, 0x11, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x00, 0xC3, 0xFE, 0xFF, 0x80, 0x01, 0xC0, 0x7F, 0x87, 0x0C,
  0x10, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x03, 0xC0, 0xFE, 0x08, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x0E, 0x07, 0x80, 0x7C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0xFF, 0xCF, 0xF0, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x33,
  0x03, 0x18, 0x31, 0x83, 0x0C, 0x30, 0x61, 0x83, 0x18, 0x30, 0xFF, 0xE8,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x07, 0xF8, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x07, 0x1C, 0xF0, 0xFF, 0x00,
  0x01, 0xF0, 0x3C, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x63, 0x07, 0xFC,
  0xF0, 0xCC, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0xC1, 0xCE, 0x38,
  0x7F, 0x00, 0x3F, 0xF0, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0x8E, 0x30, 0x31, 0x81,
  0x8C, 0x0C, 0x60, 0xC3, 0x0E, 0x0E, 0xE0, 0xFE, 0x0E, 0x38, 0xC0, 0xC6,
  0x06, 0x60, 0x33, 0x01, 0x9C, 0x1C, 0x73, 0xC1, 0xFC, 0x00, 0x01, 0xC0,
  0x3F, 0x83, 0x0C, 0x30, 0x33, 0x81, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30,
  0x38, 0xFF, 0x83, 0xEC, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x7E, 0x07, 0xC0, 0x00, 0x18, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x01, 0x8F,
  0x3C, 0xE0, 0x06, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x3C, 0x3C, 0x3C, 0x18, 0x38, 0xF0, 0xC0, 0x00, 0x10, 0x03, 0x01, 0xF0,
  0xF8, 0x3C, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xC0,
  0x7F, 0xFB, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x20, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0xF0, 0x7C,
  0x3E, 0x0F, 0x80, 0xC0, 0x00, 0x1E, 0x1F, 0xC8, 0x60, 0x30, 0x18, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x00, 0x00, 0x01, 0xC0, 0xE0,
  0x70, 0x00, 0x00, 0xE0, 0x1F, 0xE0, 0xE1, 0x87, 0x06, 0x18, 0x0C, 0xC0,
  0x33, 0x0F, 0x98, 0xFE, 0x67, 0x19, 0x98, 0x6C, 0xC3, 0x33, 0x0C, 0xCC,
  0x33, 0x30, 0xCC, 0xE6, 0x31, 0xF8, 0xC1, 0xC1, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x07, 0x80, 0x6C, 0x03, 0x60,
  0x33, 0x01, 0x98, 0x18, 0x40, 0x83, 0x0C, 0x18, 0xC0, 0xC6, 0x06, 0x7F,
  0xF3, 0x01, 0xB0, 0x0D, 0x80, 0x78, 0x03, 0xC0, 0x18, 0x00, 0x80, 0x3F,
  0xC0, 0xC3, 0x83, 0x07, 0x18, 0x18, 0x60, 0x61, 0x81, 0x86, 0x0C, 0x3F,
  0xE0, 0xFF, 0x83, 0x03, 0x0C, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x18,
  0x18, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0xF0, 0x0F, 0xF0, 0xF0, 0x87, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x39, 0xC0, 0x7F,
  0x00, 0x01, 0x00, 0x3F, 0x80, 0xC7, 0x06, 0x0E, 0x18, 0x18, 0x60, 0x61,
  0x80, 0xCC, 0x03, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x98, 0x06, 0x60, 0x31,
  0x80, 0xC6, 0x06, 0x10, 0x70, 0xFF, 0x83, 0xF8, 0x00, 0x0F, 0xFC, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0F, 0xF8, 0x3F,
  0xE0, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x3F,
  0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x3F,
  0xC3, 0x86, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x0D, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x81, 0x8C, 0x18, 0x79,
  0xC1, 0xFE, 0x00, 0x0C, 0x06, 0x18, 0x0C, 0x60, 0x30, 0xC0, 0x61, 0x80,
  0xC3, 0x01, 0x86, 0x06, 0x1F, 0xFC, 0x3F, 0xF8, 0x60, 0x30, 0xC0, 0xC3,
  0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x08, 0x60, 0x30, 0xC0, 0x60, 0x0F,
  0xF8, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x0F,
  0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x61, 0x07, 0x1C, 0xF0, 0x7F, 0x00, 0x0C, 0x0E, 0x18, 0x30, 0x30,
  0xC0, 0x63, 0x01, 0x8C, 0x03, 0x30, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x6E, 0x00, 0xCC, 0x01, 0x8C, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30,
  0x30, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0xFF, 0xFF,
  0x80, 0x06, 0x0C, 0x38, 0x30, 0xE1, 0xC2, 0x8F, 0x1A, 0x2C, 0x69, 0xB1,
  0x24, 0xCC, 0xF2, 0x33, 0x98, 0xCE, 0x66, 0x01, 0x98, 0x06, 0x60, 0x11,
  0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x30, 0x0E, 0x06, 0x1C, 0x0C, 0x38,
  0x10, 0xD8, 0x61, 0xB0, 0xC3, 0x61, 0x86, 0x42, 0x18, 0xCC, 0x31, 0x98,
  0x63, 0x30, 0xC2, 0x61, 0x05, 0x86, 0x0F, 0x0C, 0x1E, 0x18, 0x3C, 0x20,
  0x30, 0xC0, 0x60, 0x01, 0xC0, 0x3F, 0x83, 0x8C, 0x30, 0x31, 0x81, 0x98,
  0x0C, 0xC0, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xF0, 0x0D, 0x80, 0x6C, 0x03,
  0x60, 0x33, 0x01, 0x8C, 0x18, 0x73, 0x81, 0xF8, 0x00, 0x00, 0x80, 0x7F,
  0x86, 0x1C, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0xC0, 0x66, 0x06, 0x30, 0x71,
  0x8F, 0x1F, 0xE0, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0x8C, 0x30, 0x31, 0x81, 0x98,
  0x0C, 0xC0, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xF0, 0x0D, 0x80, 0x6C, 0x03,
  0x60, 0x33, 0x01, 0x8C, 0x18, 0x73, 0x81, 0xF8, 0x07, 0x00, 0x18, 0x00,
  0xF4, 0x03, 0xC0, 0x02, 0x00, 0x00, 0x80, 0x3F, 0xC0, 0xC3, 0x83, 0x07,
  0x08, 0x0C, 0x60, 0x31, 0x80, 0x86, 0x06, 0x18, 0x30, 0xFF, 0x83, 0xFC,
  0x0C, 0x60, 0x30, 0xC1, 0x83, 0x06, 0x0E, 0x18, 0x18, 0x60, 0x63, 0x01,
  0x80, 0x01, 0xE0, 0x3F, 0xC3, 0x82, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x18, 0xF7, 0xC7, 0xF8, 0x00, 0x7F, 0xF8, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x00, 0x18, 0x0C, 0x60,
  0x31, 0x81, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x18, 0x0C, 0x60,
  0x31, 0x80, 0xC6, 0x02, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x86, 0x0C, 0x1C,
  0xE0, 0x3F, 0x00, 0xC0, 0x1E, 0x01, 0xB0, 0x0D, 0x80, 0xCC, 0x06, 0x60,
  0x63, 0x02, 0x18, 0x30, 0xC3, 0x06, 0x18, 0x31, 0x81, 0x8C, 0x04, 0xC0,
  0x26, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x0E, 0x60, 0x18, 0xC0,
  0x31, 0x80, 0x63, 0x01, 0x8C, 0x03, 0x18, 0xC6, 0x33, 0x88, 0x65, 0x30,
  0x9A, 0x61, 0x24, 0x86, 0xCB, 0x0F, 0x16, 0x1E, 0x28, 0x38, 0x70, 0x60,
  0xE0, 0xC1, 0x80, 0x07, 0x03, 0x81, 0x83, 0x80, 0xC1, 0x80, 0x71, 0x80,
  0x19, 0x80, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xD8, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0xE0, 0x60, 0x60,
  0x30, 0xE0, 0x18, 0x00, 0xC0, 0x1E, 0x01, 0x98, 0x1C, 0xC0, 0xC6, 0x0C,
  0x30, 0xC0, 0xCC, 0x06, 0x60, 0x36, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x0F, 0xFE, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xF0, 0x7F, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xCC, 0xCC, 0xE6, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x67, 0x33, 0x33, 0x33, 0x30, 0x03, 0xF0, 0x7F, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0x80, 0xF0,
  0x1A, 0x06, 0x61, 0x8C, 0x60, 0x9C, 0x1F, 0x03, 0x40, 0x20, 0x7F, 0xFF,
  0xFF, 0xC0, 0xE3, 0x0C, 0x31, 0x00, 0x07, 0xF1, 0xF3, 0x38, 0x33, 0x02,
  0x60, 0x66, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0xCC, 0x0C, 0xC0, 0xC7, 0x7C,
  0x3E, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F,
  0xC1, 0xEE, 0x30, 0x33, 0x03, 0x30, 0x32, 0x03, 0x60, 0x36, 0x07, 0x60,
  0x66, 0x0E, 0xC1, 0xCE, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xE3, 0x38, 0x07,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x9C, 0x3F, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x7F, 0x83, 0xCC, 0x1C, 0x30, 0xC0, 0xC7, 0x03, 0x18, 0x18,
  0x60, 0x63, 0x01, 0x8C, 0x06, 0x30, 0x30, 0x60, 0xC1, 0xCF, 0x03, 0xE6,
  0x00, 0x0F, 0xE1, 0xEF, 0x38, 0x37, 0x03, 0x60, 0x7C, 0x0E, 0xFF, 0xCF,
  0xE0, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x9C, 0x3F, 0xC0, 0x00, 0x3F, 0x00,
  0x72, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xFC, 0x0F,
  0xFC, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x01, 0xFC, 0x1F,
  0x70, 0xE1, 0x86, 0x06, 0x38, 0x18, 0xC0, 0x63, 0x03, 0x08, 0x0C, 0x60,
  0x31, 0xC0, 0x83, 0x0E, 0x0F, 0xF8, 0x0C, 0x60, 0x01, 0x00, 0x0C, 0x20,
  0x60, 0xFF, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x1F, 0xE1, 0xFF, 0x18, 0x33, 0x83, 0x30, 0x33, 0x03, 0x30,
  0x33, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0xC0, 0xC0, 0x0E, 0x0E,
  0x0E, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30,
  0x30, 0x30, 0x30, 0x3F, 0x1E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x41, 0x83, 0xF8, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0xE2, 0x0C, 0x30, 0xC1, 0x9C,
  0x0D, 0xC0, 0x78, 0x07, 0xC0, 0x33, 0x01, 0x8C, 0x0C, 0x70, 0xC1, 0x86,
  0x06, 0x30, 0x38, 0xFC, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x30, 0x60,
  0xC1, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xE5, 0xF8, 0x1F, 0x78, 0x6F, 0xE3,
  0x19, 0xCC, 0x66, 0x31, 0x18, 0xCC, 0x66, 0x31, 0x98, 0xCC, 0x60, 0x31,
  0x80, 0xCC, 0x03, 0x30, 0x08, 0xC0, 0x60, 0x1F, 0xC1, 0xFE, 0x30, 0x73,
  0x03, 0x30, 0x33, 0x03, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0xC0, 0xCC,
  0x0C, 0xC0, 0xC0, 0x07, 0xC1, 0xFE, 0x38, 0x33, 0x03, 0x60, 0x36, 0x03,
  0x60, 0x3C, 0x07, 0xC0, 0x6C, 0x0E, 0x60, 0xC7, 0xF8, 0x3F, 0x00, 0x0F,
  0xE0, 0xF7, 0x86, 0x06, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0xC0, 0x66, 0x03,
  0x30, 0x31, 0x83, 0x98, 0x38, 0xFF, 0x87, 0xF0, 0x30, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x03, 0xF8, 0x79, 0x86, 0x0C, 0x60, 0x66,
  0x03, 0x30, 0x31, 0x81, 0x98, 0x0C, 0xC0, 0x66, 0x06, 0x38, 0x30, 0xE7,
  0x83, 0xFC, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x1F,
  0xE7, 0xCC, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x07, 0xF0, 0xFE, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC7, 0x3C, 0xFF,
  0x00, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0xFF, 0xFF, 0xF1, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xEC, 0x3F, 0x00, 0x30,
  0x33, 0x03, 0x30, 0x36, 0x02, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0xC0,
  0xCC, 0x0C, 0xE0, 0xC7, 0x3C, 0x3E, 0xC0, 0xC0, 0x78, 0x1B, 0x03, 0x60,
  0xCC, 0x19, 0x86, 0x30, 0xC2, 0x30, 0x66, 0x0D, 0x81, 0xE0, 0x3C, 0x07,
  0x00, 0x60, 0x0D, 0x80, 0x36, 0x01, 0x98, 0xC6, 0x63, 0x19, 0x9C, 0xC4,
  0xF3, 0x13, 0xC8, 0xD9, 0x63, 0x45, 0x0F, 0x1C, 0x38, 0x70, 0xC1, 0x80,
  0x18, 0x0C, 0x30, 0x60, 0xC3, 0x01, 0x98, 0x06, 0xC0, 0x0E, 0x00, 0x30,
  0x01, 0xE0, 0x0D, 0x80, 0x63, 0x03, 0x0C, 0x18, 0x18, 0xC0, 0x60, 0x0C,
  0x06, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC1, 0x80, 0xC3, 0x01, 0x86,
  0x03, 0x18, 0x06, 0x30, 0x0C, 0xC0, 0x0D, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x47, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00,
  0x60, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x3C, 0x03, 0xF0, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x07, 0x00, 0x70, 0x02, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xC0, 0x0F,
  0x00, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C,
  0x08, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60,
  0x60, 0xC0, 0x03, 0x80, 0x3F, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x80,
  0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x1F, 0x80, 0xE0, 0x00, 0x3C, 0x17, 0xF3, 0xC3, 0xE0,
  0x08,
};

const GFXglyph UbuntuSansMono_Italic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 17, 14, 4, -17 },
  { 14, 8, 7, 14, 5, -19 },
  { 21, 15, 17, 14, 0, -17 },
  { 53, 13, 22, 14, 1, -19 },
  { 89, 17, 18, 14, -1, -18 },
  { 128, 11, 18, 14, 1, -18 },
  { 153, 3, 7, 14, 8, -19 },
  { 156, 11, 25, 14, 3, -20 },
  { 191, 10, 25, 14, 1, -20 },
  { 223, 11, 10, 14, 3, -17 },
  { 237, 12, 12, 14, 1, -13 },
  { 255, 6, 8, 14, 2, -4 },
  { 261, 6, 2, 14, 4, -8 },
  { 263, 4, 4, 14, 4, -4 },
  { 265, 16, 25, 14, -2, -20 },
  { 315, 13, 18, 14, 1, -18 },
  { 345, 10, 17, 14, 2, -17 },
  { 367, 13, 18, 14, 1, -18 },
  { 397, 12, 18, 14, 1, -18 },
  { 424, 13, 17, 14, 0, -17 },
  { 452, 13, 17, 14, 1, -17 },
  { 480, 12, 17, 14, 2, -17 },
  { 506, 12, 17, 14, 3, -17 },
  { 532, 13, 18, 14, 1, -18 },
  { 562, 13, 18, 14, 1, -18 },
  { 592, 6, 13, 14, 4, -13 },
  { 602, 8, 17, 14, 2, -13 },
  { 619, 12, 11, 14, 1, -13 },
  { 636, 13, 7, 14, 1, -11 },
  { 648, 12, 11, 14, 1, -13 },
  { 665, 9, 18, 14, 4, -18 },
  { 686, 14, 22, 14, 1, -18 },
  { 725, 13, 17, 14, -1, -17 },
  { 753, 14, 18, 14, 0, -18 },
  { 785, 14, 18, 14, 1, -18 },
  { 817, 14, 18, 14, 0, -18 },
  { 849, 14, 17, 14, 1, -17 },
  { 879, 14, 17, 14, 1, -17 },
  { 909, 13, 18, 14, 1, -18 },
  { 939, 15, 17, 14, 0, -17 },
  { 971, 13, 17, 14, 1, -17 },
  { 999, 13, 17, 14, 1, -17 },
  { 1027, 15, 17, 14, 0, -17 },
  { 1059, 10, 17, 14, 1, -17 },
  { 1081, 14, 17, 14, 0, -17 },
  { 1111, 15, 17, 14, 0, -17 },
  { 1143, 13, 18, 14, 1, -18 },
  { 1173, 13, 18, 14, 1, -18 },
  { 1203, 13, 23, 14, 1, -18 },
  { 1241, 14, 18, 14, 0, -18 },
  { 1273, 13, 18, 14, 1, -18 },
  { 1303, 12, 17, 14, 3, -17 },
  { 1329, 14, 17, 14, 1, -17 },
  { 1359, 13, 17, 14, 3, -17 },
  { 1387, 15, 17, 14, 1, -17 },
  { 1419, 17, 17, 14, -1, -17 },
  { 1456, 13, 17, 14, 3, -17 },
  { 1484, 15, 17, 14, 0, -17 },
  { 1516, 12, 25, 14, 2, -20 },
  { 1554, 4, 25, 14, 5, -20 },
  { 1567, 12, 25, 14, 0, -20 },
  { 1605, 11, 9, 14, 2, -17 },
  { 1618, 13, 2, 14, -2, 3 },
  { 1622, 5, 5, 14, 6, -19 },
  { 1626, 12, 13, 14, 1, -13 },
  { 1646, 12, 19, 14, 1, -19 },
  { 1675, 12, 13, 14, 1, -13 },
  { 1695, 14, 19, 14, 1, -19 },
  { 1729, 12, 13, 14, 1, -13 },
  { 1749, 16, 24, 14, 0, -19 },
  { 1797, 14, 18, 14, 0, -13 },
  { 1829, 12, 19, 14, 0, -19 },
  { 1858, 8, 19, 14, 3, -19 },
  { 1877, 13, 24, 14, 0, -19 },
  { 1916, 13, 19, 14, 1, -19 },
  { 1947, 7, 19, 14, 4, -19 },
  { 1964, 14, 13, 14, 0, -13 },
  { 1987, 12, 13, 14, 1, -13 },
  { 2007, 12, 13, 14, 1, -13 },
  { 2027, 13, 18, 14, 0, -13 },
  { 2057, 13, 18, 14, 1, -13 },
  { 2087, 11, 13, 14, 2, -13 },
  { 2105, 12, 13, 14, 1, -13 },
  { 2125, 10, 17, 14, 3, -17 },
  { 2147, 12, 13, 14, 1, -13 },
  { 2167, 11, 13, 14, 3, -13 },
  { 2185, 14, 13, 14, 1, -13 },
  { 2208, 14, 13, 14, 0, -13 },
  { 2231, 15, 18, 14, -1, -13 },
  { 2265, 12, 13, 14, 1, -13 },
  { 2285, 14, 25, 14, 1, -20 },
  { 2329, 8, 25, 14, 3, -20 },
  { 2354, 13, 25, 14, -1, -20 },
  { 2395, 12, 4, 14, 1, -9 },
};

const GFXfont UbuntuSansMono_Italic25pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic25pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic25pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _UBUNTUSANSMONO_ITALIC25PT7B_H_
