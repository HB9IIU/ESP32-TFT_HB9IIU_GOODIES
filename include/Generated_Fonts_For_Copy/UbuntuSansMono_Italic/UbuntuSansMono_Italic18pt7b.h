#ifndef _UBUNTUSANSMONO_ITALIC18PT7B_H_
#define _UBUNTUSANSMONO_ITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x32, 0x22, 0x64, 0x00, 0xCC, 0x4A, 0x67, 0x29, 0x00, 0x06,
  0x60, 0x88, 0x32, 0x3F, 0xF1, 0x98, 0x22, 0x0C, 0xC3, 0xFC, 0xFF, 0x8C,
  0x81, 0x10, 0x64, 0x00, 0x02, 0x01, 0x03, 0xC3, 0x33, 0x01, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0x80, 0xC0, 0x4F, 0xE1, 0xC0, 0xC0, 0x40, 0x0C, 0x01,
  0x63, 0x12, 0x62, 0x2C, 0x24, 0x83, 0x50, 0x1A, 0x00, 0x5C, 0x0D, 0x41,
  0xA4, 0x12, 0x42, 0x24, 0xC3, 0x80, 0x07, 0x04, 0x84, 0x62, 0x21, 0x30,
  0xF0, 0x62, 0x5B, 0x45, 0x23, 0xB0, 0x88, 0xE7, 0x90, 0x6D, 0x25, 0x00,
  0x03, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0,
  0xC0, 0x40, 0x60, 0x20, 0x30, 0x0C, 0x06, 0x06, 0x02, 0x03, 0x01, 0x01,
  0x01, 0x03, 0x02, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x70, 0xC0, 0x18, 0x99,
  0xF7, 0x18, 0x3C, 0x66, 0x24, 0x04, 0x0C, 0x08, 0x08, 0xFF, 0x18, 0x18,
  0x10, 0x10, 0x11, 0xCE, 0x2F, 0x20, 0xFF, 0x5F, 0x00, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x00, 0x0E, 0x0F, 0x8C,
  0x64, 0x36, 0x1A, 0x4F, 0x75, 0xB2, 0xC3, 0x61, 0x31, 0x99, 0x87, 0x80,
  0x06, 0x1C, 0xD8, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x67, 0xF0, 0x0E,
  0x1D, 0x88, 0x60, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x0F, 0xE0, 0x0E, 0x1F, 0x80, 0x60, 0x30, 0x10, 0x30, 0x70, 0x04, 0x03,
  0x01, 0x80, 0xD0, 0xCF, 0xC0, 0x01, 0x81, 0xC1, 0x61, 0x21, 0x11, 0x89,
  0x8C, 0x84, 0xFF, 0x81, 0x01, 0x80, 0xC0, 0x0F, 0xC3, 0x00, 0x80, 0x60,
  0x18, 0x03, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x44, 0x31, 0xF8, 0x00, 0x83,
  0xC3, 0x02, 0x02, 0x03, 0x61, 0xFC, 0x82, 0xC1, 0x60, 0xB0, 0xC8, 0xC7,
  0xC0, 0x7F, 0x81, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x30,
  0x10, 0x18, 0x00, 0x0F, 0x0C, 0xCC, 0x24, 0x12, 0x19, 0x98, 0x78, 0xCC,
  0xC3, 0x41, 0xA0, 0xD8, 0xC7, 0xC0, 0x0E, 0x0D, 0xC8, 0x6C, 0x16, 0x0B,
  0x0D, 0x86, 0x7E, 0x03, 0x01, 0x03, 0x83, 0x0E, 0x00, 0x37, 0x70, 0x00,
  0x04, 0xEC, 0x0C, 0x71, 0xC0, 0x00, 0x00, 0x04, 0x38, 0xE1, 0x3C, 0x40,
  0x01, 0x83, 0x8E, 0x1C, 0x0E, 0x01, 0xC0, 0x38, 0x04, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x38, 0xE1, 0xC1, 0x00,
  0x38, 0x98, 0x18, 0x30, 0xC3, 0x0C, 0x30, 0x40, 0x00, 0x06, 0x0C, 0x00,
  0x07, 0x07, 0xE3, 0x08, 0x83, 0x63, 0x93, 0xED, 0x9A, 0x46, 0x91, 0x24,
  0x49, 0x92, 0x3C, 0xC0, 0x30, 0x07, 0xC0, 0x60, 0x03, 0x80, 0xA0, 0x48,
  0x12, 0x08, 0x86, 0x21, 0x08, 0xFE, 0x3F, 0xD8, 0x34, 0x0F, 0x03, 0x0E,
  0x07, 0xE1, 0x0C, 0xC3, 0x30, 0x88, 0x63, 0xE1, 0x86, 0x61, 0x90, 0x64,
  0x19, 0x0C, 0xFC, 0x00, 0x07, 0x87, 0xF3, 0x00, 0x80, 0x40, 0x10, 0x0C,
  0x03, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x88, 0x3E, 0x00, 0x0C, 0x07, 0xC3,
  0x08, 0xC3, 0x20, 0xC8, 0x36, 0x0D, 0x82, 0x40, 0x90, 0x64, 0x33, 0x18,
  0xFC, 0x00, 0x1F, 0xCC, 0x02, 0x00, 0x80, 0x20, 0x1F, 0xC6, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x03, 0xF8, 0x1F, 0xCC, 0x02, 0x00, 0x80, 0x20, 0x1F,
  0xC4, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x07, 0x0E, 0xCC, 0x0C,
  0x04, 0x06, 0x03, 0x01, 0x02, 0x83, 0x41, 0xB0, 0x98, 0x47, 0xE0, 0x10,
  0x62, 0x08, 0xC1, 0x10, 0x62, 0x0C, 0x7F, 0x18, 0x22, 0x0C, 0x41, 0x88,
  0x23, 0x04, 0x61, 0x80, 0x1F, 0x82, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20,
  0x30, 0x10, 0x08, 0x04, 0x1F, 0x80, 0x1F, 0x80, 0x40, 0x60, 0x20, 0x10,
  0x08, 0x0C, 0x04, 0x02, 0x03, 0x21, 0x1F, 0x80, 0x18, 0xE2, 0x30, 0x4C,
  0x1B, 0x02, 0xC0, 0x70, 0x0A, 0x03, 0x20, 0x46, 0x08, 0x41, 0x0C, 0x60,
  0xC0, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0x41,
  0xFE, 0x18, 0x46, 0x31, 0x94, 0xA5, 0x2A, 0x4A, 0xB6, 0xC9, 0x02, 0x40,
  0xB0, 0x68, 0x1A, 0x04, 0x18, 0x63, 0x08, 0xF1, 0x12, 0x22, 0x4C, 0x49,
  0x19, 0xA3, 0x14, 0x43, 0x88, 0x61, 0x0C, 0x61, 0x80, 0x0E, 0x0D, 0xCC,
  0x6C, 0x14, 0x0A, 0x07, 0x03, 0x03, 0x81, 0x40, 0xB0, 0x98, 0xC7, 0xC0,
  0x07, 0x07, 0xE1, 0x0C, 0x41, 0x30, 0x4C, 0x32, 0x18, 0xFC, 0x60, 0x18,
  0x04, 0x01, 0x00, 0xC0, 0x00, 0x0E, 0x0D, 0xCC, 0x6C, 0x14, 0x0A, 0x07,
  0x03, 0x03, 0x81, 0x40, 0xB0, 0x98, 0xC7, 0xC1, 0x80, 0xE0, 0x3C, 0x0E,
  0x07, 0xE1, 0x0C, 0xC3, 0x30, 0xC8, 0x22, 0x18, 0xF8, 0x66, 0x10, 0x84,
  0x31, 0x0C, 0xC1, 0x00, 0x07, 0x83, 0xF1, 0x80, 0x40, 0x10, 0x06, 0x00,
  0xE0, 0x0C, 0x01, 0x80, 0x60, 0x19, 0x0C, 0xFE, 0x00, 0xFF, 0x84, 0x06,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x00, 0x20,
  0xC8, 0x26, 0x09, 0x06, 0x41, 0x90, 0x4C, 0x13, 0x04, 0x83, 0x20, 0x8C,
  0x61, 0xF0, 0x80, 0xF0, 0x6C, 0x13, 0x08, 0xC2, 0x31, 0x0C, 0xC3, 0x20,
  0xD8, 0x14, 0x07, 0x01, 0x80, 0x60, 0x58, 0x34, 0x09, 0x02, 0x48, 0xB6,
  0x69, 0x52, 0x94, 0xA7, 0x31, 0x8C, 0x62, 0x10, 0x0C, 0x30, 0x46, 0x06,
  0x40, 0x68, 0x03, 0x80, 0x30, 0x07, 0x00, 0xD0, 0x19, 0x81, 0x08, 0x20,
  0x8E, 0x0C, 0xC0, 0xD0, 0x44, 0x31, 0x08, 0x64, 0x0A, 0x03, 0x80, 0xC0,
  0x30, 0x08, 0x02, 0x01, 0x80, 0x1F, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x7F, 0x80, 0x0F, 0x84,
  0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x00, 0x80, 0xF8, 0x00, 0x92, 0x4D, 0xB6, 0xD9, 0x24, 0x92,
  0x60, 0x0F, 0x80, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0xF8, 0x00, 0x0C, 0x14, 0x36,
  0x62, 0xC2, 0x83, 0xFF, 0x80, 0x99, 0x10, 0x02, 0x8F, 0x98, 0x48, 0x2C,
  0x34, 0x12, 0x09, 0x04, 0xC6, 0x3D, 0x00, 0x10, 0x10, 0x30, 0x20, 0x24,
  0x3F, 0x61, 0x41, 0x41, 0x41, 0xC3, 0xC2, 0x8C, 0xF8, 0x06, 0x3F, 0x60,
  0xC0, 0x80, 0x80, 0x80, 0x80, 0xC2, 0x7E, 0x00, 0xC0, 0x30, 0x08, 0x02,
  0x03, 0x87, 0xE3, 0x11, 0x84, 0xC3, 0x30, 0xC8, 0x22, 0x08, 0xC6, 0x1E,
  0x80, 0x04, 0x3F, 0x61, 0xC1, 0xC3, 0xFE, 0x80, 0x80, 0xC2, 0x7E, 0x01,
  0xE0, 0x64, 0x08, 0x03, 0x00, 0x40, 0x3F, 0x81, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0xE0, 0x00, 0x01,
  0x03, 0xF1, 0x8C, 0xC2, 0x60, 0x98, 0x64, 0x19, 0x84, 0x77, 0x06, 0xC0,
  0x22, 0x18, 0xFC, 0x00, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x41, 0xF8, 0x86,
  0x43, 0x61, 0xB0, 0x90, 0x48, 0x64, 0x36, 0x10, 0x18, 0x61, 0x80, 0x03,
  0xC1, 0x0C, 0x30, 0x82, 0x08, 0x20, 0xF0, 0x00, 0x80, 0x70, 0x18, 0x00,
  0x00, 0x07, 0xE0, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x10, 0xF8, 0x00, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x09, 0x19,
  0x98, 0xD8, 0x70, 0x38, 0x36, 0x19, 0x88, 0x64, 0x10, 0xF0, 0x84, 0x62,
  0x10, 0x8C, 0x42, 0x11, 0x8C, 0xBC, 0x09, 0x0F, 0xF2, 0x4D, 0x93, 0x64,
  0x93, 0x24, 0x19, 0x06, 0xC1, 0x20, 0x40, 0x04, 0x3F, 0x61, 0x61, 0x41,
  0x43, 0xC3, 0xC2, 0x82, 0x86, 0x04, 0x3F, 0x61, 0x41, 0xC1, 0xC1, 0x83,
  0x82, 0xC6, 0x7C, 0x06, 0x0F, 0xCC, 0x26, 0x12, 0x09, 0x05, 0x86, 0xC2,
  0x47, 0x3E, 0x30, 0x18, 0x08, 0x00, 0x02, 0x0F, 0xCC, 0x48, 0x2C, 0x36,
  0x1A, 0x09, 0x04, 0xC6, 0x3F, 0x01, 0x00, 0x80, 0xC0, 0x07, 0x9F, 0x88,
  0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x00, 0x06, 0x1F, 0x20,
  0x20, 0x30, 0x0C, 0x06, 0x02, 0x86, 0xFC, 0x18, 0x20, 0x47, 0xF2, 0x04,
  0x08, 0x30, 0x40, 0x81, 0x03, 0xE0, 0x61, 0xA0, 0x90, 0xD8, 0x6C, 0x24,
  0x12, 0x09, 0x8C, 0x7A, 0x00, 0xC3, 0xC2, 0xC6, 0xC4, 0xCC, 0x48, 0x50,
  0x70, 0x60, 0x40, 0xF0, 0x2C, 0x8B, 0x66, 0x99, 0x2B, 0xCA, 0x63, 0x18,
  0x84, 0x00, 0x30, 0xC6, 0x60, 0xB0, 0x38, 0x0C, 0x07, 0x83, 0x21, 0x8C,
  0xC1, 0x00, 0x18, 0x63, 0x08, 0x61, 0x04, 0x60, 0x88, 0x13, 0x03, 0x40,
  0x38, 0x06, 0x00, 0x80, 0x20, 0x78, 0x00, 0x1F, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xC2, 0xFE, 0x00, 0x07, 0xC3, 0x00, 0x80, 0x20, 0x08,
  0x06, 0x01, 0x00, 0xC0, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x00, 0x7C, 0x00, 0x04, 0x30, 0x82, 0x08, 0x61, 0x04, 0x10, 0xC2,
  0x08, 0x21, 0x84, 0x10, 0xC0, 0x0F, 0x00, 0x60, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0xC0, 0xC0, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x30, 0xF8, 0x00, 0x31, 0xBC, 0xA3, 0x80,
};

const GFXglyph UbuntuSansMono_Italic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 5, 5, 10, 4, -14 },
  { 11, 11, 12, 10, 0, -12 },
  { 28, 9, 16, 10, 1, -14 },
  { 46, 12, 13, 10, -1, -13 },
  { 66, 9, 13, 10, 0, -13 },
  { 81, 3, 6, 10, 5, -14 },
  { 84, 8, 17, 10, 2, -14 },
  { 101, 8, 17, 10, 0, -14 },
  { 118, 8, 7, 10, 2, -12 },
  { 125, 8, 9, 10, 1, -10 },
  { 134, 5, 6, 10, 1, -3 },
  { 138, 4, 2, 10, 3, -6 },
  { 139, 3, 3, 10, 3, -3 },
  { 141, 11, 17, 10, -1, -14 },
  { 165, 9, 13, 10, 1, -13 },
  { 180, 7, 12, 10, 1, -12 },
  { 191, 9, 13, 10, 1, -13 },
  { 206, 9, 13, 10, 1, -13 },
  { 221, 9, 12, 10, 0, -12 },
  { 235, 10, 12, 10, 0, -12 },
  { 250, 9, 13, 10, 1, -13 },
  { 265, 9, 12, 10, 2, -12 },
  { 279, 9, 13, 10, 1, -13 },
  { 294, 9, 13, 10, 1, -13 },
  { 309, 4, 10, 10, 3, -10 },
  { 314, 6, 13, 10, 1, -10 },
  { 324, 9, 8, 10, 1, -9 },
  { 333, 9, 5, 10, 1, -8 },
  { 339, 9, 8, 10, 0, -9 },
  { 348, 7, 13, 10, 3, -13 },
  { 360, 10, 16, 10, 1, -13 },
  { 380, 10, 12, 10, -1, -12 },
  { 395, 10, 13, 10, 0, -13 },
  { 412, 10, 13, 10, 1, -13 },
  { 429, 10, 13, 10, 0, -13 },
  { 446, 10, 12, 10, 1, -12 },
  { 461, 10, 12, 10, 1, -12 },
  { 476, 9, 13, 10, 1, -13 },
  { 491, 11, 12, 10, 0, -12 },
  { 508, 9, 12, 10, 1, -12 },
  { 522, 9, 12, 10, 1, -12 },
  { 536, 11, 12, 10, 0, -12 },
  { 553, 8, 12, 10, 0, -12 },
  { 565, 10, 12, 10, 0, -12 },
  { 580, 11, 12, 10, 0, -12 },
  { 597, 9, 13, 10, 1, -13 },
  { 612, 10, 13, 10, 0, -13 },
  { 629, 9, 16, 10, 1, -13 },
  { 647, 10, 13, 10, 0, -13 },
  { 664, 10, 13, 10, 0, -13 },
  { 681, 9, 12, 10, 2, -12 },
  { 695, 10, 12, 10, 1, -12 },
  { 710, 10, 12, 10, 2, -12 },
  { 725, 10, 12, 10, 1, -12 },
  { 740, 12, 12, 10, -1, -12 },
  { 758, 10, 12, 10, 2, -12 },
  { 773, 11, 12, 10, 0, -12 },
  { 790, 9, 17, 10, 1, -14 },
  { 810, 3, 17, 10, 4, -14 },
  { 817, 9, 17, 10, 0, -14 },
  { 837, 8, 6, 10, 2, -12 },
  { 843, 9, 1, 10, -1, 2 },
  { 845, 3, 4, 10, 5, -14 },
  { 847, 9, 10, 10, 1, -10 },
  { 859, 8, 14, 10, 1, -14 },
  { 873, 8, 10, 10, 1, -10 },
  { 883, 10, 14, 10, 1, -14 },
  { 901, 8, 10, 10, 1, -10 },
  { 911, 11, 17, 10, 0, -14 },
  { 935, 10, 13, 10, 0, -10 },
  { 952, 9, 14, 10, 0, -14 },
  { 968, 6, 14, 10, 2, -14 },
  { 979, 10, 17, 10, 0, -14 },
  { 1001, 9, 14, 10, 1, -14 },
  { 1017, 5, 14, 10, 3, -14 },
  { 1026, 10, 10, 10, 0, -10 },
  { 1039, 8, 10, 10, 1, -10 },
  { 1049, 8, 10, 10, 1, -10 },
  { 1059, 9, 13, 10, 0, -10 },
  { 1074, 9, 13, 10, 1, -10 },
  { 1089, 9, 10, 10, 1, -10 },
  { 1101, 8, 10, 10, 1, -10 },
  { 1111, 7, 12, 10, 2, -12 },
  { 1122, 9, 9, 10, 1, -9 },
  { 1133, 8, 9, 10, 2, -9 },
  { 1142, 10, 9, 10, 1, -9 },
  { 1154, 10, 9, 10, 0, -9 },
  { 1166, 11, 12, 10, -1, -9 },
  { 1183, 9, 9, 10, 0, -9 },
  { 1194, 10, 17, 10, 1, -14 },
  { 1216, 6, 17, 10, 2, -14 },
  { 1229, 10, 17, 10, -1, -14 },
  { 1251, 9, 3, 10, 1, -7 },
};

const GFXfont UbuntuSansMono_Italic18pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic18pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic18pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _UBUNTUSANSMONO_ITALIC18PT7B_H_
