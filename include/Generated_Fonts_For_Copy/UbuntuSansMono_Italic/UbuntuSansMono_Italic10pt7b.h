#ifndef _UBUNTUSANSMONO_ITALIC10PT7B_H_
#define _UBUNTUSANSMONO_ITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x88, 0xB6, 0x80, 0x14, 0xA7, 0xD2, 0xF9, 0x4A, 0x00, 0x08,
  0x72, 0x08, 0x30, 0x20, 0xBC, 0x20, 0x65, 0xA7, 0x08, 0x39, 0x69, 0x80,
  0x3A, 0x4C, 0xD9, 0xC9, 0xA0, 0xE0, 0x12, 0x24, 0x88, 0x88, 0x44, 0x21,
  0x11, 0x11, 0x12, 0x48, 0x2F, 0x25, 0x22, 0xD4, 0x40, 0x58, 0xC0, 0x80,
  0x02, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x41, 0x00, 0x79, 0x9F, 0x99,
  0xE0, 0x16, 0x22, 0x24, 0xE0, 0x38, 0x42, 0x22, 0x23, 0xE0, 0x38, 0x42,
  0x60, 0x87, 0xC0, 0x08, 0xCA, 0xAF, 0x88, 0x40, 0x1C, 0x82, 0x04, 0x08,
  0x2F, 0x00, 0x3A, 0x21, 0xE9, 0x4B, 0x80, 0x78, 0x84, 0x44, 0x22, 0x00,
  0x72, 0x64, 0xC9, 0x4B, 0x80, 0x39, 0x14, 0x5E, 0x08, 0x4E, 0x00, 0xC0,
  0x80, 0x60, 0x04, 0xA0, 0x0B, 0xB0, 0x70, 0x7F, 0xC0, 0x60, 0xC7, 0xC0,
  0x71, 0x12, 0x40, 0xC0, 0x3C, 0x95, 0xD9, 0xAA, 0xA9, 0x1C, 0x08, 0x51,
  0x49, 0x3D, 0x1C, 0x40, 0x3A, 0x52, 0xE4, 0xC7, 0xC0, 0x7C, 0x21, 0x08,
  0x43, 0xC0, 0x3A, 0x52, 0x98, 0xC7, 0xC0, 0x3C, 0x84, 0x1E, 0x41, 0x0F,
  0x80, 0x3C, 0x84, 0x1E, 0x41, 0x08, 0x00, 0x3D, 0x04, 0x20, 0x8A, 0x27,
  0x00, 0x45, 0x14, 0x5E, 0x8A, 0x28, 0x80, 0x3C, 0x41, 0x04, 0x20, 0x8F,
  0x00, 0x3C, 0x10, 0x82, 0x08, 0x2F, 0x00, 0x25, 0x25, 0x18, 0x62, 0x48,
  0x80, 0x24, 0x44, 0x48, 0xF0, 0x24, 0xB7, 0x5E, 0x8A, 0x28, 0x80, 0x25,
  0x96, 0x56, 0x5A, 0x69, 0x00, 0x74, 0x63, 0x19, 0x4B, 0x80, 0x39, 0x14,
  0x56, 0x62, 0x08, 0x00, 0x74, 0x63, 0x19, 0x4B, 0x88, 0x20, 0x3A, 0x52,
  0xF5, 0x4A, 0x20, 0x3D, 0x02, 0x0C, 0x08, 0x2F, 0x00, 0xF9, 0x08, 0x84,
  0x21, 0x00, 0x8C, 0x63, 0x29, 0x4B, 0x80, 0x8C, 0x65, 0x2A, 0x51, 0x00,
  0x45, 0x14, 0x5E, 0xBB, 0x69, 0x00, 0x24, 0xA2, 0x84, 0x31, 0x28, 0x80,
  0x8E, 0x25, 0x18, 0x41, 0x04, 0x00, 0x3C, 0x21, 0x08, 0x21, 0x0F, 0x80,
  0x39, 0x10, 0x84, 0x22, 0x10, 0x86, 0x00, 0xAA, 0xA9, 0x50, 0x38, 0x44,
  0x21, 0x08, 0x84, 0x27, 0x00, 0x25, 0x59, 0xF8, 0xC0, 0x3A, 0x63, 0x17,
  0x80, 0x21, 0x08, 0xF4, 0xA5, 0x3E, 0x7A, 0x21, 0x07, 0x00, 0x08, 0x42,
  0xE9, 0x4A, 0x5E, 0x7A, 0x7D, 0x07, 0x00, 0x0C, 0x41, 0x0F, 0x20, 0x82,
  0x08, 0x43, 0x00, 0x3D, 0x24, 0xA2, 0x70, 0x4E, 0x00, 0x21, 0x10, 0xF4,
  0xA6, 0x32, 0x24, 0x74, 0x93, 0x08, 0x40, 0x70, 0x88, 0x42, 0x17, 0x00,
  0x20, 0x82, 0x52, 0x71, 0x85, 0x26, 0xC9, 0x49, 0x27, 0x7A, 0xEB, 0x18,
  0x80, 0x7A, 0x52, 0x98, 0x80, 0x79, 0x99, 0xE0, 0x7A, 0x52, 0x9F, 0x42,
  0x00, 0x79, 0x99, 0xE2, 0x20, 0x78, 0x88, 0x80, 0x78, 0x61, 0xE0, 0x24,
  0xF4, 0x44, 0x60, 0x99, 0x99, 0xF0, 0x99, 0xAA, 0x40, 0x8D, 0x7D, 0x6A,
  0x00, 0x4C, 0xC2, 0x14, 0x98, 0x26, 0x48, 0x90, 0xC1, 0x02, 0x38, 0x00,
  0x78, 0x88, 0x8F, 0x00, 0x19, 0x10, 0x84, 0x41, 0x10, 0x87, 0x00, 0x24,
  0x92, 0x92, 0x50, 0x30, 0x84, 0x21, 0x0C, 0x84, 0x26, 0x00, 0x6C, 0xC0,
};

const GFXglyph UbuntuSansMono_Italic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -8 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 9, 6, 0, -8 },
  { 18, 6, 7, 6, 0, -7 },
  { 24, 5, 7, 6, 0, -7 },
  { 29, 1, 3, 6, 3, -8 },
  { 30, 4, 10, 6, 1, -8 },
  { 35, 4, 10, 6, 0, -8 },
  { 40, 4, 4, 6, 1, -7 },
  { 42, 4, 5, 6, 1, -5 },
  { 45, 2, 3, 6, 1, -1 },
  { 46, 2, 1, 6, 2, -3 },
  { 47, 1, 1, 6, 2, -1 },
  { 48, 7, 10, 6, -1, -8 },
  { 57, 4, 7, 6, 1, -7 },
  { 61, 4, 7, 6, 1, -7 },
  { 65, 5, 7, 6, 0, -7 },
  { 70, 5, 7, 6, 0, -7 },
  { 75, 5, 7, 6, 0, -7 },
  { 80, 6, 7, 6, 0, -7 },
  { 86, 5, 7, 6, 1, -7 },
  { 91, 5, 7, 6, 1, -7 },
  { 96, 5, 7, 6, 1, -7 },
  { 101, 6, 7, 6, 0, -7 },
  { 107, 2, 5, 6, 2, -5 },
  { 109, 3, 7, 6, 1, -5 },
  { 112, 5, 4, 6, 0, -5 },
  { 115, 5, 2, 6, 0, -4 },
  { 117, 5, 4, 6, 0, -5 },
  { 120, 4, 7, 6, 1, -7 },
  { 124, 6, 8, 6, 0, -7 },
  { 130, 6, 7, 6, -1, -7 },
  { 136, 5, 7, 6, 0, -7 },
  { 141, 5, 7, 6, 1, -7 },
  { 146, 5, 7, 6, 0, -7 },
  { 151, 6, 7, 6, 0, -7 },
  { 157, 6, 7, 6, 0, -7 },
  { 163, 6, 7, 6, 0, -7 },
  { 169, 6, 7, 6, 0, -7 },
  { 175, 6, 7, 6, 0, -7 },
  { 181, 6, 7, 6, 0, -7 },
  { 187, 6, 7, 6, 0, -7 },
  { 193, 4, 7, 6, 0, -7 },
  { 197, 6, 7, 6, 0, -7 },
  { 203, 6, 7, 6, 0, -7 },
  { 209, 5, 7, 6, 1, -7 },
  { 214, 6, 7, 6, 0, -7 },
  { 220, 5, 9, 6, 1, -7 },
  { 226, 5, 7, 6, 0, -7 },
  { 231, 6, 7, 6, 0, -7 },
  { 237, 5, 7, 6, 1, -7 },
  { 242, 5, 7, 6, 1, -7 },
  { 247, 5, 7, 6, 1, -7 },
  { 252, 6, 7, 6, 0, -7 },
  { 258, 6, 7, 6, 0, -7 },
  { 264, 6, 7, 6, 1, -7 },
  { 270, 6, 7, 6, 0, -7 },
  { 276, 5, 10, 6, 1, -8 },
  { 283, 2, 10, 6, 2, -8 },
  { 286, 5, 10, 6, 0, -8 },
  { 293, 4, 4, 6, 1, -7 },
  { 295, 5, 1, 6, -1, 1 },
  { 296, 1, 2, 6, 3, -8 },
  { 297, 5, 5, 6, 0, -5 },
  { 301, 5, 8, 6, 0, -8 },
  { 306, 5, 5, 6, 0, -5 },
  { 310, 5, 8, 6, 1, -8 },
  { 315, 5, 5, 6, 0, -5 },
  { 319, 6, 10, 6, 0, -8 },
  { 327, 6, 7, 6, 0, -5 },
  { 333, 5, 8, 6, 0, -8 },
  { 338, 3, 8, 6, 1, -8 },
  { 341, 5, 10, 6, 0, -8 },
  { 348, 6, 8, 6, 0, -8 },
  { 354, 3, 8, 6, 2, -8 },
  { 357, 5, 5, 6, 0, -5 },
  { 361, 5, 5, 6, 0, -5 },
  { 365, 4, 5, 6, 1, -5 },
  { 368, 5, 7, 6, 0, -5 },
  { 373, 4, 7, 6, 1, -5 },
  { 377, 4, 5, 6, 1, -5 },
  { 380, 4, 5, 6, 1, -5 },
  { 383, 4, 7, 6, 1, -7 },
  { 387, 4, 5, 6, 1, -5 },
  { 390, 4, 5, 6, 1, -5 },
  { 393, 5, 5, 6, 1, -5 },
  { 397, 6, 5, 6, 0, -5 },
  { 401, 7, 7, 6, -1, -5 },
  { 408, 5, 5, 6, 0, -5 },
  { 412, 5, 10, 6, 1, -8 },
  { 419, 3, 10, 6, 1, -8 },
  { 423, 5, 10, 6, 0, -8 },
  { 430, 5, 2, 6, 0, -4 },
};

const GFXfont UbuntuSansMono_Italic10pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic10pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _UBUNTUSANSMONO_ITALIC10PT7B_H_
