#ifndef _UBUNTUSANSMONO_ITALIC15PT7B_H_
#define _UBUNTUSANSMONO_ITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x22, 0x22, 0x40, 0x4C, 0x5A, 0xA5, 0x20, 0x0D, 0x84, 0x9F,
  0xE2, 0x43, 0x21, 0x23, 0xFC, 0x90, 0x48, 0x4C, 0x00, 0x04, 0x18, 0x79,
  0x16, 0x04, 0x0E, 0x06, 0x04, 0x0A, 0x33, 0x82, 0x04, 0x00, 0x08, 0x05,
  0x12, 0x48, 0x94, 0x2A, 0x05, 0x00, 0xB8, 0x72, 0x14, 0x89, 0x2C, 0x70,
  0x0C, 0x24, 0xC9, 0xB1, 0xC2, 0x5A, 0xA5, 0xC5, 0x99, 0xF8, 0xEA, 0x04,
  0x31, 0x08, 0x61, 0x0C, 0x20, 0x82, 0x08, 0x20, 0x41, 0x82, 0x00, 0x08,
  0x10, 0x10, 0x20, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x20, 0xC3, 0x1C, 0x10,
  0x00, 0x32, 0x9F, 0xCC, 0x49, 0x20, 0x08, 0x20, 0x47, 0xF1, 0x04, 0x08,
  0x00, 0x77, 0x2C, 0xF0, 0xFC, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x02, 0x01,
  0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x00,
  0x0C, 0x6D, 0x8A, 0x1D, 0x37, 0x65, 0xC2, 0x85, 0x13, 0xC0, 0x0C, 0xF2,
  0x82, 0x08, 0x61, 0x04, 0x13, 0xF0, 0x1C, 0x6C, 0x08, 0x10, 0x61, 0x86,
  0x10, 0x41, 0x03, 0xF0, 0x18, 0x4C, 0x08, 0x10, 0x47, 0x01, 0x02, 0x04,
  0x1B, 0xE0, 0x03, 0x0E, 0x1A, 0x12, 0x26, 0x44, 0xFE, 0x04, 0x0C, 0x08,
  0x0F, 0x8C, 0x04, 0x02, 0x03, 0xC0, 0x10, 0x08, 0x04, 0x06, 0x7E, 0x00,
  0x0F, 0x10, 0x20, 0x40, 0x7C, 0xC6, 0x86, 0x84, 0x84, 0x78, 0x7E, 0x08,
  0x20, 0xC3, 0x04, 0x18, 0x20, 0xC1, 0x00, 0x0C, 0x64, 0x8A, 0x16, 0x67,
  0x93, 0x42, 0x85, 0x0B, 0xE0, 0x0C, 0x6D, 0x8A, 0x14, 0x28, 0x4F, 0x82,
  0x0C, 0x33, 0x80, 0x33, 0x00, 0x00, 0xEE, 0x18, 0xC0, 0x00, 0x01, 0xCE,
  0x26, 0x00, 0x02, 0x1C, 0xE6, 0x0E, 0x07, 0x03, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xC0, 0x20, 0x30, 0x0C, 0x03, 0x0E, 0x30, 0xC0, 0x39, 0x30, 0x41,
  0x08, 0x42, 0x10, 0x03, 0x0C, 0x00, 0x0C, 0x3A, 0x21, 0x41, 0xCF, 0x92,
  0xA2, 0xA2, 0xA6, 0x9C, 0x80, 0xC0, 0x70, 0x07, 0x05, 0x09, 0x09, 0x11,
  0x31, 0x3F, 0x61, 0x41, 0xC1, 0x04, 0x3F, 0x21, 0x21, 0x22, 0x7C, 0x42,
  0x42, 0x42, 0xC6, 0xFC, 0x0E, 0x3B, 0x20, 0x40, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0xC0, 0x7C, 0x08, 0x3E, 0x23, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42,
  0x8C, 0xF8, 0x3F, 0x20, 0x60, 0x40, 0x7C, 0x40, 0x40, 0x80, 0x80, 0xFC,
  0x3F, 0x20, 0x60, 0x40, 0x7C, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x0E, 0x33,
  0x60, 0x40, 0x80, 0x80, 0x86, 0x84, 0x84, 0xC4, 0x7C, 0x30, 0x90, 0xC8,
  0x44, 0x27, 0xF2, 0x19, 0x08, 0x84, 0xC2, 0x43, 0x00, 0x3E, 0x10, 0x60,
  0x81, 0x02, 0x04, 0x10, 0x21, 0xF0, 0x1F, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x04, 0x88, 0xF8, 0x31, 0x91, 0x09, 0x05, 0x03, 0x02, 0xC1, 0x20,
  0x88, 0x44, 0x41, 0x00, 0x10, 0xC2, 0x08, 0x21, 0x84, 0x10, 0x43, 0xF0,
  0x11, 0x99, 0x8C, 0xC6, 0xA4, 0xD2, 0x49, 0x05, 0x84, 0x82, 0x41, 0x00,
  0x30, 0x98, 0x4A, 0x45, 0x24, 0x92, 0x49, 0x18, 0x8C, 0xC6, 0x43, 0x00,
  0x0C, 0x6D, 0x8A, 0x1C, 0x30, 0x60, 0xC1, 0x85, 0x19, 0xE0, 0x04, 0x1F,
  0x31, 0x21, 0x21, 0x22, 0x7C, 0x40, 0x40, 0x40, 0xC0, 0x0C, 0x6D, 0x8A,
  0x1C, 0x30, 0x60, 0xC1, 0x85, 0x19, 0xE1, 0x03, 0x01, 0x00, 0x04, 0x3F,
  0x21, 0x21, 0x21, 0x62, 0x7C, 0x44, 0x44, 0x44, 0x86, 0x06, 0x8C, 0x8C,
  0x06, 0x01, 0x00, 0xE0, 0x18, 0x04, 0x02, 0x03, 0x3F, 0x00, 0xFE, 0x20,
  0xC1, 0x02, 0x04, 0x18, 0x20, 0x40, 0x80, 0x61, 0x43, 0x42, 0x42, 0xC2,
  0x86, 0x84, 0x84, 0x8C, 0x78, 0x83, 0x86, 0x84, 0x8C, 0x88, 0x98, 0x90,
  0xA0, 0xA0, 0xC0, 0x20, 0x90, 0x48, 0x68, 0x24, 0x92, 0xA9, 0x58, 0xCC,
  0x46, 0x62, 0x00, 0x30, 0xC4, 0x41, 0xA0, 0x38, 0x0C, 0x07, 0x01, 0x40,
  0x98, 0x42, 0x20, 0x80, 0x83, 0x86, 0xC4, 0x48, 0x50, 0x60, 0x20, 0x60,
  0x40, 0x40, 0x3F, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40,
  0x7F, 0x00, 0x0E, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02,
  0x04, 0x10, 0x3C, 0x00, 0xAB, 0xD5, 0x55, 0x54, 0x1E, 0x04, 0x08, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x3C, 0x00, 0x0C, 0x28,
  0x93, 0x1C, 0x20, 0xFF, 0x99, 0x80, 0x1E, 0xC7, 0x14, 0x28, 0x50, 0xA3,
  0x7A, 0x20, 0x40, 0x81, 0x07, 0xC8, 0xD0, 0xA1, 0x87, 0x0A, 0x27, 0x80,
  0x3E, 0xC3, 0x04, 0x08, 0x10, 0x20, 0x3E, 0x01, 0x01, 0x03, 0x02, 0x1E,
  0x62, 0x46, 0x84, 0x84, 0x84, 0x8C, 0xF4, 0x3C, 0xCF, 0x1C, 0x6F, 0x90,
  0x20, 0x3E, 0x01, 0x83, 0x41, 0x01, 0x83, 0xF8, 0x40, 0x20, 0x30, 0x10,
  0x08, 0x04, 0x02, 0x03, 0x01, 0x03, 0x00, 0x0F, 0x31, 0x21, 0x42, 0x42,
  0x42, 0x46, 0x3C, 0x04, 0x8C, 0xF0, 0x10, 0x20, 0xC1, 0x03, 0xC4, 0x58,
  0xA1, 0x42, 0x87, 0x14, 0x20, 0x32, 0x0E, 0x22, 0x64, 0x44, 0x30, 0x03,
  0x02, 0x00, 0x1E, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x88,
  0xF0, 0x10, 0x10, 0x10, 0x10, 0x21, 0x26, 0x2C, 0x30, 0x58, 0x4C, 0x44,
  0xC6, 0xE2, 0x24, 0x44, 0x4C, 0x88, 0x8F, 0x3F, 0x29, 0x49, 0x49, 0x5A,
  0x42, 0x82, 0x86, 0x7C, 0x89, 0x1A, 0x3C, 0x50, 0xA1, 0x46, 0x3C, 0xCF,
  0x0C, 0x18, 0x70, 0xA3, 0x3C, 0x3E, 0x23, 0x21, 0x21, 0x43, 0x42, 0x46,
  0x78, 0x80, 0x80, 0x80, 0x1E, 0xC5, 0x1C, 0x28, 0x50, 0xA3, 0x7C, 0x08,
  0x10, 0x60, 0x3E, 0x41, 0x02, 0x04, 0x08, 0x20, 0x40, 0x1E, 0x41, 0x01,
  0x81, 0x80, 0x83, 0x7C, 0x30, 0x8F, 0xD8, 0x41, 0x04, 0x30, 0xC1, 0xE0,
  0x42, 0x87, 0x14, 0x28, 0x50, 0xA3, 0x7A, 0x86, 0x18, 0xA2, 0x92, 0xCE,
  0x10, 0xC1, 0x81, 0x92, 0x92, 0xB4, 0xCC, 0xCC, 0x88, 0x21, 0x32, 0x14,
  0x1C, 0x18, 0x34, 0x64, 0xC6, 0x10, 0x88, 0x44, 0x62, 0x21, 0x90, 0x50,
  0x28, 0x18, 0x08, 0x4C, 0x38, 0x00, 0x3F, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0xFC, 0x07, 0x08, 0x10, 0x10, 0x10, 0x30, 0x20, 0xC0, 0x60, 0x20,
  0x40, 0x40, 0x40, 0x40, 0x78, 0x08, 0x84, 0x21, 0x10, 0x84, 0x22, 0x10,
  0x84, 0x42, 0x00, 0x0E, 0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x03, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x18, 0xF0, 0x21, 0xE6, 0x30,
};

const GFXglyph UbuntuSansMono_Italic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 10, 8, 2, -10 },
  { 6, 5, 4, 8, 3, -11 },
  { 9, 9, 10, 8, 0, -10 },
  { 21, 7, 14, 8, 1, -12 },
  { 34, 10, 11, 8, -1, -11 },
  { 48, 7, 11, 8, 0, -11 },
  { 58, 2, 4, 8, 5, -11 },
  { 59, 6, 15, 8, 2, -12 },
  { 71, 7, 15, 8, 0, -12 },
  { 85, 6, 6, 8, 2, -10 },
  { 90, 7, 7, 8, 1, -8 },
  { 97, 4, 4, 8, 1, -2 },
  { 99, 4, 1, 8, 2, -5 },
  { 100, 3, 2, 8, 2, -2 },
  { 101, 10, 15, 8, -1, -12 },
  { 120, 7, 11, 8, 1, -11 },
  { 130, 6, 10, 8, 1, -10 },
  { 138, 7, 11, 8, 1, -11 },
  { 148, 7, 11, 8, 1, -11 },
  { 158, 8, 10, 8, 0, -10 },
  { 168, 9, 10, 8, 0, -10 },
  { 180, 8, 10, 8, 1, -10 },
  { 190, 7, 10, 8, 2, -10 },
  { 199, 7, 11, 8, 1, -11 },
  { 209, 7, 11, 8, 1, -11 },
  { 219, 4, 8, 8, 2, -8 },
  { 223, 5, 10, 8, 1, -8 },
  { 230, 7, 7, 8, 1, -8 },
  { 237, 7, 5, 8, 1, -7 },
  { 242, 8, 7, 8, 0, -8 },
  { 249, 6, 11, 8, 2, -11 },
  { 258, 8, 13, 8, 1, -11 },
  { 271, 8, 10, 8, -1, -10 },
  { 281, 8, 11, 8, 0, -11 },
  { 292, 8, 11, 8, 1, -11 },
  { 303, 8, 11, 8, 0, -11 },
  { 314, 8, 10, 8, 1, -10 },
  { 324, 8, 10, 8, 1, -10 },
  { 334, 8, 11, 8, 1, -11 },
  { 345, 9, 10, 8, 0, -10 },
  { 357, 7, 10, 8, 1, -10 },
  { 366, 8, 10, 8, 1, -10 },
  { 376, 9, 10, 8, 0, -10 },
  { 388, 6, 10, 8, 0, -10 },
  { 396, 9, 10, 8, 0, -10 },
  { 408, 9, 10, 8, 0, -10 },
  { 420, 7, 11, 8, 1, -11 },
  { 430, 8, 11, 8, 0, -11 },
  { 441, 7, 14, 8, 1, -11 },
  { 454, 8, 11, 8, 0, -11 },
  { 465, 9, 11, 8, 0, -11 },
  { 478, 7, 10, 8, 2, -10 },
  { 487, 8, 10, 8, 1, -10 },
  { 497, 8, 10, 8, 2, -10 },
  { 507, 9, 10, 8, 0, -10 },
  { 519, 10, 10, 8, 0, -10 },
  { 532, 8, 10, 8, 2, -10 },
  { 542, 9, 10, 8, 0, -10 },
  { 554, 7, 15, 8, 1, -12 },
  { 568, 2, 15, 8, 3, -12 },
  { 572, 7, 15, 8, 0, -12 },
  { 586, 7, 5, 8, 1, -10 },
  { 591, 8, 1, 8, -1, 2 },
  { 592, 3, 3, 8, 4, -12 },
  { 594, 7, 8, 8, 1, -8 },
  { 601, 7, 12, 8, 1, -12 },
  { 612, 7, 8, 8, 1, -8 },
  { 619, 8, 12, 8, 1, -12 },
  { 631, 7, 8, 8, 1, -8 },
  { 638, 9, 15, 8, 0, -12 },
  { 655, 8, 11, 8, 0, -8 },
  { 666, 7, 12, 8, 0, -12 },
  { 677, 4, 11, 8, 2, -11 },
  { 683, 8, 14, 8, 0, -11 },
  { 697, 8, 12, 8, 0, -12 },
  { 709, 4, 12, 8, 3, -12 },
  { 715, 8, 8, 8, 0, -8 },
  { 723, 7, 8, 8, 1, -8 },
  { 730, 7, 8, 8, 1, -8 },
  { 737, 8, 11, 8, 0, -8 },
  { 748, 7, 11, 8, 1, -8 },
  { 758, 7, 8, 8, 1, -8 },
  { 765, 7, 8, 8, 1, -8 },
  { 772, 6, 10, 8, 2, -10 },
  { 780, 7, 8, 8, 1, -8 },
  { 787, 6, 8, 8, 2, -8 },
  { 793, 8, 8, 8, 1, -8 },
  { 801, 8, 8, 8, 0, -8 },
  { 809, 9, 11, 8, -1, -8 },
  { 822, 8, 8, 8, 0, -8 },
  { 830, 8, 15, 8, 1, -12 },
  { 845, 5, 15, 8, 2, -12 },
  { 855, 8, 15, 8, -1, -12 },
  { 870, 7, 3, 8, 1, -6 },
};

const GFXfont UbuntuSansMono_Italic15pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic15pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _UBUNTUSANSMONO_ITALIC15PT7B_H_
