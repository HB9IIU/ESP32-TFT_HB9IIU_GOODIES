#ifndef _UBUNTUSANSMONO_ITALIC39PT7B_H_
#define _UBUNTUSANSMONO_ITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0x80,
  0x38, 0x73, 0x87, 0x38, 0x63, 0x0E, 0x70, 0xE7, 0x0C, 0x60, 0xC6, 0x0C,
  0x61, 0xC4, 0x18, 0xC1, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x1C,
  0x1C, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x07, 0x03,
  0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0,
  0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x81, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x3C, 0x06, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x06, 0x00, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xE0, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x3B, 0x80, 0x70, 0x1C, 0x60,
  0x18, 0x06, 0x1C, 0x0E, 0x03, 0x87, 0x07, 0x00, 0xE1, 0x83, 0x80, 0x30,
  0x61, 0xC0, 0x0C, 0x18, 0xE0, 0x03, 0x0E, 0x70, 0x00, 0xC3, 0x18, 0x00,
  0x39, 0xCE, 0x00, 0x0F, 0xE7, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x73, 0xF8, 0x00, 0x19, 0xCE, 0x00, 0x0E,
  0x61, 0x80, 0x07, 0x38, 0x60, 0x03, 0x8E, 0x18, 0x01, 0xC3, 0x06, 0x00,
  0xE0, 0xC1, 0x80, 0x70, 0x30, 0xE0, 0x1C, 0x0C, 0x38, 0x0E, 0x03, 0x1C,
  0x07, 0x00, 0xEF, 0x03, 0x80, 0x1F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x0F, 0x0E, 0x03, 0x83, 0x81, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x01, 0xC3, 0xC0, 0x71, 0xE0,
  0x0E, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x40, 0xFE, 0x1C, 0x7B, 0x87, 0x3C,
  0xF1, 0x8E, 0x1C, 0xE7, 0x03, 0xB9, 0xC0, 0xFC, 0xF0, 0x1F, 0x38, 0x07,
  0x8E, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x3F, 0x1F, 0x7D, 0xC7, 0xFE, 0x78,
  0x7E, 0x1E, 0x39, 0xDC, 0xE7, 0x3B, 0x9C, 0xE6, 0x31, 0x80, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0xC1, 0x82, 0xF1, 0x8F, 0xFD, 0xBF, 0xFF, 0xFE, 0x07, 0xC0,
  0x07, 0xC0, 0x0E, 0xE0, 0x0E, 0x70, 0x1C, 0x78, 0x3C, 0x3C, 0x18, 0x38,
  0x08, 0x10, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x07, 0xC7,
  0xE3, 0xF1, 0xF8, 0x7C, 0x1E, 0x0E, 0x0E, 0x7E, 0x3E, 0x1C, 0x00, 0xFF,
  0xFF, 0xC0, 0x39, 0xFF, 0xFF, 0xFD, 0xE2, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xF1, 0xE0,
  0x78, 0x1E, 0x0E, 0x01, 0xC3, 0xC0, 0x38, 0xF0, 0x07, 0x1C, 0x00, 0xE7,
  0x80, 0x1C, 0xE0, 0x03, 0x9C, 0x70, 0x77, 0x9F, 0x0E, 0xE3, 0xE3, 0xDC,
  0x7C, 0x73, 0x8F, 0x8E, 0xF0, 0xE1, 0xDE, 0x00, 0x7B, 0xC0, 0x0E, 0x70,
  0x03, 0xCE, 0x00, 0x71, 0xC0, 0x1E, 0x3C, 0x03, 0x87, 0x80, 0xF0, 0x70,
  0x3C, 0x0F, 0x1F, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0xC1, 0xFB, 0x83, 0xC7,
  0x06, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xC1, 0xE0,
  0x60, 0x1E, 0x08, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x1C, 0x1E, 0x01, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x40, 0x0F, 0x87,
  0x87, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7B,
  0x80, 0x1E, 0x70, 0x07, 0x1C, 0x01, 0xC3, 0x80, 0x78, 0x70, 0x1E, 0x0E,
  0x03, 0x83, 0x80, 0xE0, 0x70, 0x38, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70,
  0x70, 0x0E, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x08, 0x01, 0xE0, 0x70, 0x7E, 0x07, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFC, 0x01, 0xFF,
  0x80, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x80, 0x1D, 0xFE, 0x07, 0xFF, 0xE0,
  0xFC, 0x3E, 0x1C, 0x01, 0xC7, 0x80, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x73,
  0x80, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0x87,
  0x80, 0xF0, 0x78, 0x3C, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0x00, 0x00,
  0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x3C, 0x1E, 0x07, 0x80, 0xF0, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x01, 0xE0, 0xF0, 0x3C, 0x07,
  0x87, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xF3, 0xE0, 0x1C, 0x0F, 0x03,
  0x80, 0x78, 0x70, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38,
  0xE0, 0x03, 0x8E, 0x00, 0x70, 0xF0, 0x0F, 0x07, 0x83, 0xE0, 0x7F, 0xFC,
  0x03, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7C, 0x1E, 0x07, 0x00, 0xE0, 0xF0, 0x0F, 0x0E, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x0E,
  0x1C, 0x00, 0xE1, 0xE0, 0x1E, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFD,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0x80, 0x00, 0x07, 0x03, 0xE0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x20, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0x80, 0x38, 0x1F, 0x80, 0xF8, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x80, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x04, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xE1, 0xE0, 0x3C, 0x07,
  0x03, 0xC0, 0x3C, 0x3C, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x39, 0xE0,
  0x1F, 0xCE, 0x07, 0xFC, 0xF0, 0xFF, 0xE7, 0x0F, 0x87, 0x38, 0x70, 0x7B,
  0xC7, 0x03, 0x9E, 0x38, 0x1C, 0xE3, 0xC0, 0xE7, 0x1C, 0x07, 0x38, 0xE0,
  0x71, 0xC7, 0x03, 0x8E, 0x38, 0x1C, 0x71, 0xC0, 0xE3, 0x87, 0x0E, 0x1C,
  0x3E, 0xF0, 0xE0, 0xFF, 0x87, 0x01, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0D, 0xC0, 0x00, 0xEE, 0x00, 0x0E, 0x70, 0x00, 0x71, 0xC0,
  0x07, 0x0E, 0x00, 0x30, 0x70, 0x03, 0x83, 0x80, 0x18, 0x1C, 0x01, 0xC0,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x07,
  0x00, 0x70, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xC0, 0x07,
  0x0C, 0x00, 0x3C, 0xE0, 0x01, 0xE6, 0x00, 0x0F, 0x70, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1E, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xE0, 0xFC,
  0x07, 0x00, 0xF0, 0x38, 0x03, 0x83, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0,
  0x07, 0x07, 0x00, 0x70, 0x78, 0x03, 0x83, 0x80, 0x78, 0x1C, 0x1F, 0x80,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x70, 0x1F, 0x03, 0x80, 0x3C, 0x1C, 0x00,
  0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0xF1, 0xC0, 0x0F, 0x0E, 0x00, 0xF0, 0x70, 0x7F, 0x03, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x7C, 0x1E, 0x03, 0xC0, 0x10, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x01, 0x00,
  0xF8, 0x38, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xE3, 0xF8, 0x0F, 0x03, 0xE0, 0x70, 0x0F,
  0x03, 0x80, 0x3C, 0x1C, 0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C,
  0x70, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x8E, 0x00,
  0x38, 0x70, 0x03, 0xC7, 0x00, 0x1C, 0x38, 0x01, 0xC1, 0xC0, 0x3E, 0x0E,
  0x03, 0xE0, 0xFB, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xC0, 0xE0, 0x78, 0x02, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07,
  0x0E, 0x00, 0x38, 0x70, 0x03, 0x83, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x78,
  0x07, 0x01, 0xF0, 0x70, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0x70, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E,
  0x0F, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80,
  0x1E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01,
  0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x08, 0x03, 0x80, 0xF0, 0x7C, 0x07, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x03, 0x80, 0xF0, 0x03, 0x81, 0xE0, 0x03, 0x83, 0xC0, 0x07,
  0x07, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x3C, 0x00, 0x0F,
  0x78, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x38,
  0x07, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xB0, 0x36, 0x01, 0xB0, 0x7E, 0x01,
  0xB0, 0x6E, 0x03, 0xB0, 0xEE, 0x03, 0x38, 0xCC, 0x03, 0x39, 0xCC, 0x07,
  0x39, 0x9C, 0x07, 0x3B, 0x1C, 0x06, 0x3B, 0x1C, 0x0E, 0x3E, 0x1C, 0x0E,
  0x1E, 0x18, 0x0C, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x30,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x03, 0xC0, 0x0E, 0x03, 0xE0, 0x0E, 0x03,
  0xE0, 0x0E, 0x03, 0x60, 0x0C, 0x07, 0x70, 0x1C, 0x07, 0x70, 0x1C, 0x07,
  0x70, 0x1C, 0x07, 0x38, 0x1C, 0x06, 0x38, 0x38, 0x0E, 0x38, 0x38, 0x0E,
  0x18, 0x38, 0x0E, 0x1C, 0x38, 0x0C, 0x1C, 0x30, 0x1C, 0x1C, 0x70, 0x1C,
  0x0C, 0x70, 0x1C, 0x0C, 0x70, 0x18, 0x0E, 0x60, 0x38, 0x0E, 0xE0, 0x38,
  0x0E, 0xE0, 0x38, 0x06, 0xE0, 0x30, 0x06, 0xC0, 0x70, 0x07, 0xC0, 0x70,
  0x07, 0xC0, 0x70, 0x07, 0xC0, 0x60, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3C, 0x1E, 0x07, 0x80, 0xE0,
  0xF0, 0x0F, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x07,
  0x38, 0x00, 0x73, 0x80, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x0F, 0x00, 0xF0, 0x70,
  0x1E, 0x07, 0xC3, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xE0, 0xFC, 0x0F, 0x01, 0xE0, 0x70,
  0x07, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x38,
  0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1E, 0x0E, 0x03,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3C, 0x1E, 0x07, 0x80, 0xE0,
  0xF0, 0x0F, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x07,
  0x38, 0x00, 0x77, 0x80, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x0F, 0x00, 0xF0, 0x70,
  0x1E, 0x07, 0xC3, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x38, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xF0, 0x7C, 0x07,
  0x00, 0xF0, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07,
  0x07, 0x00, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0,
  0x1E, 0x07, 0x0F, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1C, 0x1C, 0x00,
  0xE0, 0x70, 0x0F, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0x1E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x3C,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xE0,
  0x60, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x40, 0x07, 0x83, 0xC1, 0xF8, 0x3F, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xE0,
  0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xE1,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x38, 0x00,
  0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0xC7, 0x00, 0x1C, 0x38,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x03, 0x83, 0xC0, 0x3C,
  0x0E, 0x01, 0xC0, 0x78, 0x3C, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xBC, 0x00, 0x1D, 0xE0, 0x01,
  0xCF, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x70,
  0x07, 0x83, 0x80, 0x38, 0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x03, 0x83,
  0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x00, 0x1D, 0xC0, 0x00,
  0xEE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00,
  0xE0, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x60, 0xE0, 0xC1, 0xC3, 0xC3, 0x83,
  0x87, 0x87, 0x07, 0x1F, 0x0C, 0x0E, 0x36, 0x38, 0x18, 0xEC, 0x70, 0x33,
  0x98, 0xC0, 0xE6, 0x31, 0x81, 0xDC, 0x67, 0x03, 0x30, 0xEC, 0x06, 0xE1,
  0xD8, 0x0D, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x07, 0x00,
  0x07, 0x81, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xB8, 0x00, 0x39, 0xC0, 0x03, 0x87, 0x00, 0x3C,
  0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x0E, 0x01, 0xC0, 0x38, 0x1E, 0x01, 0xC0,
  0xE0, 0x0E, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xE3,
  0x8E, 0x38, 0xF3, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xE7, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xCF, 0x3C,
  0x71, 0xC7, 0x1C, 0x70, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3B, 0x80, 0x3D, 0xC0, 0x3C, 0xE0,
  0x1C, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x1E, 0x03, 0x1E, 0x01, 0xCE, 0x00,
  0xEE, 0x00, 0x36, 0x00, 0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x21, 0xE1,
  0xE1, 0xC1, 0xC3, 0xC3, 0x82, 0x00, 0x07, 0x00, 0x1F, 0xFC, 0x0F, 0xFF,
  0x07, 0xE0, 0xE1, 0xF0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0xE3, 0xC0, 0x1C,
  0x70, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x03, 0xC3,
  0xE1, 0xF8, 0x3F, 0xFF, 0x03, 0xFC, 0x70, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE3, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0xF8, 0x1E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x1C, 0x00, 0xE3,
  0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0x80, 0x0E, 0x70, 0x03, 0xCE,
  0x00, 0x71, 0xC0, 0x1E, 0x38, 0x07, 0x8E, 0x01, 0xE1, 0xC0, 0x78, 0x38,
  0x7E, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFC,
  0x0F, 0xFF, 0x83, 0xE0, 0x20, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x20, 0xF8, 0x1C, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xC0, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x1C, 0x0F, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0,
  0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1C,
  0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0xC0, 0x1C, 0x07,
  0x00, 0xF0, 0x1E, 0x0F, 0xC0, 0x3F, 0xF7, 0x00, 0x7F, 0x9C, 0x00, 0x00,
  0x1E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xE0, 0xF0, 0xF0, 0x0E, 0x3C,
  0x01, 0xCF, 0x00, 0x39, 0xC0, 0x0F, 0x78, 0x01, 0xCE, 0x00, 0xF9, 0xFF,
  0xFE, 0x3F, 0xFF, 0x0F, 0xFC, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x20, 0xF8, 0x3C, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x04, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7E, 0x0E, 0x03, 0xE0, 0x38, 0x1E, 0x01, 0xC0, 0xF0, 0x07,
  0x03, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07,
  0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00,
  0x70, 0x3C, 0x03, 0xC0, 0x78, 0x7E, 0x00, 0xFF, 0xF8, 0x01, 0xFE, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x80,
  0x1E, 0x03, 0xC3, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE3, 0x80, 0x1F, 0xFE,
  0x03, 0xFF, 0xE0, 0x70, 0x3C, 0x1C, 0x03, 0xC3, 0x80, 0x38, 0x70, 0x07,
  0x0E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x1C,
  0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x0E, 0x00, 0x01, 0xC0,
  0x3E, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x8F, 0xF8, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1E, 0x01, 0xFF, 0x0F, 0xE0, 0x3E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x10, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x04, 0x01, 0xC0,
  0x3C, 0x3C, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x41,
  0xC0, 0x3C, 0x0E, 0x03, 0xC0, 0xE0, 0x3C, 0x07, 0x07, 0xC0, 0x38, 0x78,
  0x01, 0xC7, 0x80, 0x1C, 0xF8, 0x00, 0xEF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xDE, 0x00, 0x1C, 0x78, 0x00, 0xE1, 0xE0, 0x07, 0x07, 0x00,
  0x38, 0x3C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1E, 0x07, 0x00,
  0x70, 0x70, 0x03, 0xC0, 0xFF, 0x9F, 0xF3, 0xFE, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x1C, 0x03, 0xC0, 0x38, 0x27, 0xFC, 0x7F, 0xC0, 0x00, 0xE0,
  0xC0, 0x3F, 0xDF, 0x83, 0xFF, 0xFE, 0x1C, 0x7C, 0xF0, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x70, 0x60, 0xE3, 0x87, 0x06, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x8E, 0x0E, 0x1C, 0x70, 0xE0, 0xE3, 0x87, 0x0E, 0x1C, 0x00, 0x71, 0xC0,
  0x03, 0x8E, 0x00, 0x1C, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x71,
  0xC0, 0x03, 0x8E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0x81, 0xE0, 0xE0, 0x1E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0x80,
  0x1C, 0x70, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x1C, 0x38, 0x03, 0x8F, 0x00, 0x70, 0x00, 0x38, 0x00, 0x7F,
  0xC0, 0x7F, 0xF8, 0x3E, 0x1F, 0x1E, 0x01, 0xC7, 0x00, 0x73, 0xC0, 0x1D,
  0xE0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xEE, 0x00, 0x7B, 0x80, 0x1C, 0xE0, 0x0F, 0x1C, 0x07,
  0x87, 0xCF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x07, 0x81, 0xF0, 0x38, 0x07, 0x81, 0xC0, 0x1C,
  0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0,
  0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x87, 0x00, 0x38, 0x38, 0x03, 0xC3,
  0xC0, 0x1C, 0x1C, 0x03, 0xE0, 0xE0, 0x3E, 0x07, 0x1F, 0xE0, 0x7F, 0xFC,
  0x03, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xE0, 0xF0, 0xF0, 0x1C, 0x3C, 0x03,
  0x8F, 0x00, 0x71, 0xC0, 0x1E, 0x70, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x0E,
  0x70, 0x01, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38,
  0xE0, 0x0E, 0x1E, 0x01, 0xC1, 0xE0, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x04, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x01, 0xFF, 0xF0, 0xFF, 0xF8,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x3F, 0xFC,
  0x1E, 0x02, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0E, 0x10, 0x03, 0x87, 0x03, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x40, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x01, 0xFF, 0xFE, 0xFF, 0xFE, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x30, 0x3F, 0xF0, 0x1F, 0xF0, 0x1C,
  0x00, 0xE3, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x07, 0x0E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xE1, 0xC0,
  0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00,
  0x70, 0xF0, 0x1E, 0x0F, 0x0F, 0xC1, 0xFF, 0xF8, 0x1F, 0xE3, 0x80, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0xE0, 0x70, 0xE0, 0x71,
  0xC0, 0x71, 0xC0, 0x73, 0x80, 0x77, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC1, 0xC1, 0xC7, 0x0F, 0x0E, 0x1C, 0x3C,
  0x38, 0x71, 0xF0, 0xC1, 0x87, 0xC7, 0x0E, 0x3B, 0x1C, 0x38, 0xCC, 0xE0,
  0xE7, 0x33, 0x83, 0xB8, 0xCC, 0x0E, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8,
  0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x03, 0xC0,
  0x1E, 0x03, 0x80, 0x78, 0x07, 0x01, 0xE0, 0x07, 0x07, 0x80, 0x0E, 0x1E,
  0x00, 0x0E, 0x78, 0x00, 0x1D, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x3C, 0xE0, 0x00, 0xF1, 0xC0, 0x03, 0xC1, 0xC0, 0x0F, 0x03, 0x80, 0x3C,
  0x03, 0x80, 0xF0, 0x07, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xC0, 0x0F, 0x01,
  0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x78, 0x00,
  0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x71, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x47, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x80,
  0xE7, 0xF8, 0x19, 0xC7, 0xC7, 0x70, 0x7F, 0xCE, 0x03, 0xF0, 0x00, 0x10,
  0x00,
};

const GFXglyph UbuntuSansMono_Italic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 10, 28, 22, 6, -27 },
  { 36, 12, 11, 22, 8, -30 },
  { 53, 23, 27, 22, 0, -27 },
  { 131, 20, 34, 22, 2, -30 },
  { 216, 26, 29, 22, -1, -28 },
  { 311, 18, 28, 22, 1, -28 },
  { 374, 5, 12, 22, 12, -30 },
  { 382, 16, 38, 22, 5, -31 },
  { 458, 16, 38, 22, 1, -31 },
  { 534, 16, 16, 22, 5, -27 },
  { 566, 18, 19, 22, 2, -21 },
  { 609, 9, 12, 22, 3, -6 },
  { 623, 9, 2, 22, 7, -12 },
  { 626, 6, 7, 22, 6, -6 },
  { 632, 24, 38, 22, -2, -31 },
  { 746, 19, 29, 22, 2, -28 },
  { 815, 15, 27, 22, 3, -27 },
  { 866, 19, 28, 22, 2, -28 },
  { 933, 20, 29, 22, 1, -28 },
  { 1006, 19, 27, 22, 1, -27 },
  { 1071, 21, 28, 22, 1, -27 },
  { 1145, 19, 28, 22, 3, -27 },
  { 1212, 19, 27, 22, 5, -27 },
  { 1277, 20, 29, 22, 2, -28 },
  { 1350, 20, 28, 22, 2, -28 },
  { 1420, 10, 21, 22, 6, -20 },
  { 1447, 13, 26, 22, 3, -20 },
  { 1490, 19, 17, 22, 2, -20 },
  { 1531, 20, 11, 22, 1, -17 },
  { 1559, 19, 17, 22, 1, -20 },
  { 1600, 15, 29, 22, 6, -28 },
  { 1655, 21, 34, 22, 2, -28 },
  { 1745, 21, 27, 22, -2, -27 },
  { 1816, 21, 27, 22, 0, -27 },
  { 1887, 22, 29, 22, 2, -28 },
  { 1967, 21, 27, 22, 0, -27 },
  { 2038, 21, 27, 22, 2, -27 },
  { 2109, 21, 27, 22, 2, -27 },
  { 2180, 21, 29, 22, 2, -28 },
  { 2257, 23, 27, 22, 0, -27 },
  { 2335, 20, 27, 22, 2, -27 },
  { 2403, 21, 28, 22, 2, -27 },
  { 2477, 24, 27, 22, 0, -27 },
  { 2558, 15, 27, 22, 1, -27 },
  { 2609, 24, 27, 22, -1, -27 },
  { 2690, 24, 27, 22, 0, -27 },
  { 2771, 20, 29, 22, 2, -28 },
  { 2844, 21, 27, 22, 1, -27 },
  { 2915, 20, 35, 22, 2, -28 },
  { 3003, 21, 27, 22, 0, -27 },
  { 3074, 21, 29, 22, 1, -28 },
  { 3151, 19, 27, 22, 5, -27 },
  { 3216, 21, 28, 22, 2, -27 },
  { 3290, 21, 27, 22, 4, -27 },
  { 3361, 23, 27, 22, 1, -27 },
  { 3439, 26, 27, 22, -1, -27 },
  { 3527, 21, 27, 22, 5, -27 },
  { 3598, 23, 27, 22, 0, -27 },
  { 3676, 19, 38, 22, 3, -31 },
  { 3767, 6, 38, 22, 8, -31 },
  { 3796, 19, 38, 22, 0, -31 },
  { 3887, 17, 14, 22, 4, -27 },
  { 3917, 20, 2, 22, -3, 5 },
  { 3922, 7, 8, 22, 10, -30 },
  { 3929, 19, 21, 22, 2, -21 },
  { 3979, 19, 30, 22, 1, -30 },
  { 4051, 19, 22, 22, 1, -21 },
  { 4104, 22, 30, 22, 2, -30 },
  { 4187, 19, 22, 22, 1, -21 },
  { 4240, 26, 37, 22, -1, -30 },
  { 4361, 22, 28, 22, 0, -21 },
  { 4438, 19, 30, 22, 0, -30 },
  { 4510, 12, 30, 22, 5, -30 },
  { 4555, 21, 37, 22, 0, -30 },
  { 4653, 21, 30, 22, 1, -30 },
  { 4732, 11, 30, 22, 7, -30 },
  { 4774, 21, 21, 22, 0, -21 },
  { 4830, 19, 21, 22, 1, -21 },
  { 4880, 18, 21, 22, 2, -21 },
  { 4928, 21, 28, 22, -1, -21 },
  { 5002, 19, 28, 22, 2, -21 },
  { 5069, 18, 21, 22, 3, -21 },
  { 5117, 18, 21, 22, 2, -21 },
  { 5165, 16, 27, 22, 5, -27 },
  { 5219, 19, 20, 22, 2, -20 },
  { 5267, 16, 20, 22, 5, -20 },
  { 5307, 22, 20, 22, 2, -20 },
  { 5362, 23, 20, 22, -1, -20 },
  { 5420, 24, 27, 22, -2, -20 },
  { 5501, 19, 20, 22, 1, -20 },
  { 5549, 21, 38, 22, 2, -31 },
  { 5649, 12, 38, 22, 5, -31 },
  { 5706, 21, 38, 22, -2, -31 },
  { 5806, 19, 6, 22, 2, -14 },
};

const GFXfont UbuntuSansMono_Italic39pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic39pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic39pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _UBUNTUSANSMONO_ITALIC39PT7B_H_
