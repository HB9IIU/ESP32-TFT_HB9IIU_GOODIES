#ifndef _UBUNTUSANSMONO_ITALIC58PT7B_H_
#define _UBUNTUSANSMONO_ITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0x3F, 0x00, 0x38, 0x00, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1C, 0xF0, 0x1C,
  0xF0, 0x3C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xC0, 0x38, 0xC0, 0x30,
  0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFC, 0x00, 0xE0, 0x0F, 0x80, 0x01, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x10, 0x00, 0x1F,
  0x81, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x02, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0xFF,
  0xC0, 0x01, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x1F,
  0x00, 0x1C, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x00, 0xF0,
  0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x3C,
  0x00, 0x0F, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x83, 0xE0, 0x00, 0x3C,
  0x0F, 0x0F, 0x80, 0x00, 0x78, 0x1E, 0x3E, 0x00, 0x00, 0xF0, 0x78, 0x78,
  0x00, 0x01, 0xE0, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC7, 0x80, 0x00, 0x03,
  0xFF, 0x1E, 0x00, 0x00, 0x03, 0xFC, 0x7C, 0x00, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x7F, 0x00, 0x00, 0x00, 0xF1, 0xFF, 0x00, 0x00, 0x03, 0xC7,
  0xFF, 0x00, 0x00, 0x0F, 0x9F, 0x1E, 0x00, 0x00, 0x3E, 0x3C, 0x3C, 0x00,
  0x00, 0xF8, 0xF0, 0x38, 0x00, 0x01, 0xE1, 0xE0, 0x70, 0x00, 0x07, 0x83,
  0x80, 0xE0, 0x00, 0x1E, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x1E, 0x07, 0x80,
  0x01, 0xF0, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x1E, 0x00, 0x0F, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x03, 0xC1, 0xE0,
  0x03, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x00, 0x0F, 0x9F, 0x00, 0x3E, 0x00,
  0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x7C,
  0x00, 0x7C, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x80, 0x1F, 0xE0, 0x3E,
  0x0F, 0xFC, 0x07, 0x83, 0xF7, 0xC0, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x0F,
  0x87, 0x87, 0x80, 0xF8, 0xF1, 0xF0, 0x0F, 0xBC, 0x3C, 0x01, 0xF7, 0x8F,
  0x80, 0x1F, 0xF1, 0xF0, 0x03, 0xFC, 0x3E, 0x00, 0x3F, 0x87, 0xC0, 0x07,
  0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x07, 0xF8, 0x7C,
  0x01, 0xFF, 0x0F, 0xC0, 0x7F, 0xE0, 0xFF, 0xFF, 0x3E, 0x1F, 0xFF, 0xC7,
  0xC1, 0xFF, 0xF0, 0xF8, 0x0F, 0xF8, 0x0F, 0x80, 0x20, 0x00, 0x00, 0x1F,
  0x1F, 0x1F, 0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78,
  0x70, 0x70, 0x70, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x3C,
  0x06, 0x78, 0x3C, 0x1E, 0x7F, 0x1C, 0x7F, 0xFF, 0xDD, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xF7, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xE3, 0xE0, 0x0F, 0xC3,
  0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x07, 0x00, 0xF0, 0x03, 0x00,
  0x40, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xC0, 0x1F, 0x81, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0,
  0xFF, 0x07, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x0F, 0xE3, 0xFE,
  0x1F, 0xC0, 0xFC, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF8, 0x0C, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1E, 0x0F, 0x81, 0xF3, 0xE1, 0xFC,
  0x1F, 0x3E, 0x1F, 0xC1, 0xF3, 0xC1, 0xFC, 0x1F, 0x7C, 0x1F, 0xC1, 0xE7,
  0xC1, 0xFC, 0x3E, 0x7C, 0x1F, 0xC3, 0xE7, 0xC0, 0xF8, 0x3E, 0x78, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0xFC,
  0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xBC,
  0x03, 0xFE, 0xF8, 0x07, 0xF1, 0xF0, 0x07, 0x83, 0xE0, 0x08, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xC0, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x03, 0x00, 0x07, 0xC0, 0x10, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x7F, 0x00, 0x18, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x07,
  0x00, 0x0F, 0xE0, 0x3F, 0xC7, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x03,
  0xC0, 0x3C, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x03, 0x00, 0x0F, 0xF0, 0x07, 0xE1, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x20, 0x00,
  0x1F, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E,
  0x3E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E,
  0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0x80,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x7C, 0x00, 0x3F, 0xE7, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE,
  0x03, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x01, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0x02, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x20, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0xFC,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0xC0,
  0x01, 0xFE, 0x0F, 0x80, 0x3F, 0xFE, 0x0F, 0x80, 0xFF, 0xFE, 0x1F, 0x01,
  0xFF, 0xFE, 0x1F, 0x03, 0xF8, 0x3E, 0x3E, 0x07, 0xE0, 0x3C, 0x3E, 0x0F,
  0xC0, 0x7C, 0x3E, 0x0F, 0x80, 0x7C, 0x3C, 0x1F, 0x00, 0x7C, 0x7C, 0x1F,
  0x00, 0x78, 0x7C, 0x1E, 0x00, 0x78, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x3E,
  0x00, 0xF8, 0x78, 0x3E, 0x00, 0xF0, 0xF8, 0x3E, 0x00, 0xF0, 0xF8, 0x3E,
  0x01, 0xF0, 0xF8, 0x3E, 0x01, 0xF0, 0xF8, 0x3E, 0x01, 0xE0, 0xF8, 0x3E,
  0x01, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0xF8, 0x0F,
  0xFF, 0xC0, 0x78, 0x07, 0xFF, 0xC0, 0x7C, 0x03, 0xFF, 0xC0, 0x7C, 0x00,
  0xFF, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x1F,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x78, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x0F, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3E, 0x3C, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0xF8, 0x03, 0xE0, 0x07, 0xF0,
  0x0F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xF0, 0x01, 0xFC, 0x03, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xFC,
  0x1E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x7F, 0x00, 0x0C, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x1F,
  0x80, 0x0E, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0x83, 0xFF, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x78, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0xFE, 0x03, 0xE0, 0x03, 0xF8, 0x07, 0x80, 0x3F, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x03, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x0F,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x78, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x07,
  0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0xC0, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x03,
  0xF0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x07,
  0x80, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x00, 0x1E, 0x7E,
  0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x00, 0x78, 0x7E, 0x00,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0xEF, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x7B, 0x80, 0x1E, 0xF0, 0x1C,
  0xE0, 0x07, 0x3C, 0x0F, 0x38, 0x01, 0xCF, 0x03, 0x9E, 0x00, 0xF3, 0xC1,
  0xE7, 0x80, 0x3C, 0x70, 0xF1, 0xE0, 0x0E, 0x1C, 0x38, 0x78, 0x07, 0x87,
  0x1E, 0x3C, 0x01, 0xE1, 0xC7, 0x0F, 0x00, 0x78, 0x73, 0xC3, 0xC0, 0x3C,
  0x1E, 0xE0, 0xF0, 0x0F, 0x07, 0xF8, 0x3C, 0x03, 0xC1, 0xFC, 0x1F, 0x01,
  0xE0, 0x7E, 0x07, 0x80, 0x78, 0x1F, 0x81, 0xE0, 0x1E, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x3F, 0x80,
  0x01, 0xE0, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x1F,
  0xE0, 0x01, 0xE0, 0x07, 0xBC, 0x00, 0x3C, 0x00, 0xF7, 0xC0, 0x07, 0x80,
  0x1E, 0x78, 0x00, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x80, 0x1E, 0x3E, 0x00, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x00, 0x78, 0x78,
  0x07, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x1E, 0x00, 0x78,
  0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x78, 0x1E, 0x00,
  0x78, 0x07, 0x83, 0xC0, 0x0F, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x1E, 0x1F,
  0x00, 0x7C, 0x03, 0xC3, 0xC0, 0x0F, 0x00, 0x38, 0x78, 0x01, 0xE0, 0x07,
  0x8F, 0x00, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x80, 0x1E, 0x78, 0x01, 0xE0,
  0x03, 0xCF, 0x00, 0x3C, 0x00, 0x39, 0xE0, 0x07, 0x80, 0x07, 0xBC, 0x00,
  0xF0, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x07, 0x80, 0x03, 0xFC,
  0x00, 0xF0, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x78, 0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0xF9, 0xE0, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x78, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x7F,
  0xC0, 0x0F, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78,
  0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x7E, 0x00, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x7C,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1E, 0x7C,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x1E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x3C,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x3F, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1E,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x07, 0xC0, 0x0F, 0xC0,
  0x01, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x02, 0x00, 0x00, 0xF8, 0x07, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x78,
  0x07, 0x81, 0xF8, 0x1E, 0x01, 0xE0, 0xFE, 0x07, 0x80, 0x78, 0x3F, 0x83,
  0xC0, 0x3C, 0x1E, 0xE0, 0xF0, 0x0F, 0x07, 0x38, 0x3C, 0x03, 0xC3, 0xCE,
  0x0F, 0x00, 0xF0, 0xE3, 0x87, 0x80, 0x3C, 0x78, 0xE1, 0xE0, 0x0E, 0x3C,
  0x38, 0x78, 0x03, 0x8F, 0x0E, 0x1C, 0x01, 0xE7, 0x83, 0xCF, 0x00, 0x79,
  0xE0, 0xF3, 0xC0, 0x1E, 0xF0, 0x3C, 0xE0, 0x07, 0x38, 0x0F, 0x78, 0x01,
  0xDE, 0x03, 0xDC, 0x00, 0x7F, 0x00, 0x77, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F,
  0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xE3, 0xC0, 0x01,
  0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x01, 0xE0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x03, 0xC0, 0xF8, 0x00,
  0xF0, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xEF, 0xC0,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0x10, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0x10, 0x0E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0,
  0xF0, 0x3C, 0x04, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0x00, 0xFE, 0x00,
  0xF8, 0x0F, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0x3C, 0x0F, 0xC0, 0x01, 0xE0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x3C, 0x1E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xE0, 0x01,
  0xF0, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE7, 0x80, 0x1F, 0xFC, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x03, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0x3E, 0x03, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x3C, 0x00, 0x1F, 0x83, 0xC0, 0x03, 0xF0,
  0x7C, 0x00, 0x7F, 0x07, 0xC0, 0x0F, 0xE0, 0x78, 0x03, 0xFC, 0x07, 0xE7,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0xE0, 0x3F, 0x80,
  0x02, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x06, 0x03, 0xFE, 0x03, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0x81, 0xF0,
  0x01, 0xFC, 0x01, 0xE0, 0x03, 0xF0, 0x01, 0xE0, 0x07, 0xE0, 0x01, 0xE0,
  0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x9F, 0x00, 0x07, 0xFF, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x01,
  0xF0, 0xFC, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x3F,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0xE7, 0xC0, 0x01,
  0xFC, 0x7C, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x03, 0xFF,
  0x0F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x10, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0xF0, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xC0,
  0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xBC, 0x00, 0x01, 0xFE, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x02, 0x00,
  0x07, 0xE0, 0x03, 0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x1E, 0x00, 0x3E, 0x03, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x78,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03,
  0xE0, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3C, 0x1F,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x78, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x20, 0x01, 0xF0,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x80, 0xF0, 0x00, 0x7E, 0x01,
  0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x1E,
  0x00, 0xFC, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0,
  0x7F, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0x0F, 0x3F,
  0x80, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0x1E, 0x1F, 0x80, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80,
  0x01, 0xF0, 0x1F, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x01, 0x7E, 0x07, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFE, 0x01, 0xE0,
  0x00, 0x1F, 0x81, 0xE0, 0x03, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0x1F, 0xE7, 0xE0, 0x78, 0x1F, 0x07, 0xC0,
  0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x78, 0x0F, 0x07, 0xC0, 0xF0, 0x1E, 0x0F,
  0x01, 0xE0, 0x7C, 0x1E, 0x07, 0xC0, 0xF8, 0x7C, 0x0F, 0x81, 0xE0, 0xF8,
  0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x83, 0xC0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0x3C, 0x1F, 0x03, 0xC0, 0x78, 0x3C, 0x07, 0x81, 0xF0, 0x78, 0x1F,
  0x03, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x3E, 0x00, 0x7E, 0x03, 0xC0,
  0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8,
  0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x1E,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF8, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xF3, 0xFC, 0x07, 0xE0, 0x0F, 0x81, 0xF8,
  0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x3C,
  0xFC, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0xF8, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF8, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0x00,
  0x1F, 0x80, 0x1E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF8, 0x0F,
  0x80, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x80, 0x3C, 0x01, 0xFE, 0x00, 0x7F,
  0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF8, 0x1F, 0x00, 0xFE, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0x80, 0xFC,
  0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x00, 0xFE,
  0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFD,
  0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x0C, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF0, 0x7C, 0x03, 0xE0, 0x01, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x04, 0x00, 0x07, 0xC0, 0xC0, 0x01, 0xF0, 0x3F, 0x01,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x20, 0x1F, 0x87, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E,
  0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x07, 0xC0, 0x1F,
  0xC0, 0x7F, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x1E, 0x00,
  0xFF, 0xE1, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xE7, 0xC0,
  0x01, 0xF3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x1E, 0x03,
  0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0x80,
  0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x03, 0xC3, 0xE0,
  0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x78, 0x7C, 0x07, 0x80, 0x78, 0x7C, 0x07, 0x80, 0xF8, 0x7C, 0x0F, 0x80,
  0xF0, 0x78, 0x0F, 0x80, 0xF0, 0x78, 0x1F, 0xC1, 0xE0, 0x78, 0x1F, 0xC1,
  0xE0, 0x78, 0x3F, 0xC3, 0xE0, 0x78, 0x7B, 0xC3, 0xC0, 0x78, 0x7B, 0xC3,
  0xC0, 0x78, 0xF3, 0xC7, 0xC0, 0x78, 0xE3, 0xC7, 0x80, 0xF9, 0xE1, 0xCF,
  0x80, 0xFB, 0xC1, 0xCF, 0x00, 0xFB, 0xC1, 0xEF, 0x00, 0xF7, 0x81, 0xFE,
  0x00, 0xF7, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFB,
  0xC0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x7E, 0x1E, 0x00, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x06, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xE0,
  0xFF, 0xC0, 0x0F, 0x1F, 0xFE, 0x01, 0xE3, 0xE7, 0xF8, 0x3E, 0x7C, 0x1F,
  0xEF, 0xC7, 0x80, 0x7F, 0xF8, 0xF0, 0x03, 0xFF, 0x06, 0x00, 0x0F, 0xE0,
};

const GFXglyph UbuntuSansMono_Italic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 15, 41, 32, 9, -40 },
  { 78, 16, 15, 32, 13, -44 },
  { 108, 35, 40, 32, 0, -40 },
  { 283, 29, 51, 32, 3, -45 },
  { 468, 39, 42, 32, -2, -41 },
  { 673, 27, 42, 32, 2, -41 },
  { 815, 8, 17, 32, 17, -44 },
  { 832, 24, 56, 32, 7, -45 },
  { 1000, 24, 56, 32, 2, -45 },
  { 1168, 24, 23, 32, 7, -40 },
  { 1237, 27, 28, 32, 3, -31 },
  { 1332, 13, 18, 32, 5, -9 },
  { 1362, 14, 5, 32, 10, -19 },
  { 1371, 9, 10, 32, 9, -9 },
  { 1383, 37, 56, 32, -4, -45 },
  { 1642, 28, 42, 32, 3, -41 },
  { 1789, 23, 40, 32, 4, -40 },
  { 1904, 29, 41, 32, 3, -41 },
  { 2053, 29, 42, 32, 2, -41 },
  { 2206, 29, 40, 32, 1, -40 },
  { 2351, 31, 41, 32, 2, -40 },
  { 2510, 29, 41, 32, 4, -40 },
  { 2659, 29, 40, 32, 7, -40 },
  { 2804, 29, 42, 32, 3, -41 },
  { 2957, 29, 41, 32, 3, -41 },
  { 3106, 14, 31, 32, 9, -30 },
  { 3161, 18, 39, 32, 5, -30 },
  { 3249, 28, 25, 32, 3, -29 },
  { 3337, 30, 16, 32, 2, -25 },
  { 3397, 28, 25, 32, 2, -29 },
  { 3485, 23, 42, 32, 8, -41 },
  { 3606, 32, 50, 32, 2, -41 },
  { 3806, 31, 40, 32, -3, -40 },
  { 3961, 30, 41, 32, 1, -41 },
  { 4115, 32, 42, 32, 3, -41 },
  { 4283, 31, 41, 32, 0, -41 },
  { 4442, 31, 40, 32, 3, -40 },
  { 4597, 33, 40, 32, 2, -40 },
  { 4762, 31, 42, 32, 3, -41 },
  { 4925, 35, 40, 32, 0, -40 },
  { 5100, 29, 40, 32, 3, -40 },
  { 5245, 31, 41, 32, 2, -40 },
  { 5404, 35, 40, 32, 1, -40 },
  { 5579, 23, 40, 32, 1, -40 },
  { 5694, 34, 40, 32, -1, -40 },
  { 5864, 35, 40, 32, 0, -40 },
  { 6039, 30, 42, 32, 3, -41 },
  { 6197, 31, 41, 32, 1, -41 },
  { 6356, 30, 52, 32, 3, -41 },
  { 6551, 31, 41, 32, 1, -41 },
  { 6710, 31, 42, 32, 2, -41 },
  { 6873, 28, 40, 32, 8, -40 },
  { 7013, 32, 41, 32, 3, -40 },
  { 7177, 31, 40, 32, 6, -40 },
  { 7332, 34, 40, 32, 2, -40 },
  { 7502, 39, 40, 32, -2, -40 },
  { 7697, 31, 40, 32, 7, -40 },
  { 7852, 35, 40, 32, 0, -40 },
  { 8027, 29, 56, 32, 4, -45 },
  { 8230, 9, 56, 32, 12, -45 },
  { 8293, 29, 56, 32, -1, -45 },
  { 8496, 26, 21, 32, 5, -40 },
  { 8565, 30, 4, 32, -4, 7 },
  { 8580, 10, 12, 32, 15, -45 },
  { 8595, 29, 32, 32, 2, -31 },
  { 8711, 28, 46, 32, 2, -45 },
  { 8872, 28, 32, 32, 2, -31 },
  { 8984, 32, 46, 32, 3, -45 },
  { 9168, 28, 32, 32, 2, -31 },
  { 9280, 38, 56, 32, -1, -45 },
  { 9546, 33, 42, 32, -1, -31 },
  { 9720, 28, 45, 32, 0, -45 },
  { 9878, 18, 44, 32, 7, -44 },
  { 9977, 32, 55, 32, -1, -44 },
  { 10197, 31, 45, 32, 2, -45 },
  { 10372, 16, 46, 32, 10, -45 },
  { 10464, 31, 31, 32, 0, -31 },
  { 10585, 28, 31, 32, 2, -31 },
  { 10694, 27, 32, 32, 3, -31 },
  { 10802, 31, 42, 32, -1, -31 },
  { 10965, 29, 42, 32, 3, -31 },
  { 11118, 27, 31, 32, 4, -31 },
  { 11223, 27, 32, 32, 3, -31 },
  { 11331, 24, 41, 32, 7, -40 },
  { 11454, 28, 31, 32, 3, -30 },
  { 11563, 25, 30, 32, 7, -30 },
  { 11657, 32, 30, 32, 3, -30 },
  { 11777, 34, 30, 32, -1, -30 },
  { 11905, 35, 41, 32, -3, -30 },
  { 12085, 28, 30, 32, 2, -30 },
  { 12190, 32, 56, 32, 3, -45 },
  { 12414, 18, 56, 32, 8, -45 },
  { 12540, 32, 56, 32, -3, -45 },
  { 12764, 28, 8, 32, 3, -21 },
};

const GFXfont UbuntuSansMono_Italic58pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic58pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic58pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _UBUNTUSANSMONO_ITALIC58PT7B_H_
