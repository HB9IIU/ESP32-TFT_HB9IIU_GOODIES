#ifndef _UBUNTUSANSMONO_ITALIC60PT7B_H_
#define _UBUNTUSANSMONO_ITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E,
  0x00, 0x38, 0x00, 0x1E, 0x07, 0x8F, 0x03, 0xCF, 0x81, 0xE7, 0x80, 0xF3,
  0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0E, 0x3C, 0x0F,
  0x1C, 0x07, 0x8E, 0x03, 0x8F, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x61, 0xC0,
  0x70, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0xF8, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x0F, 0x01, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0xFE, 0x00, 0x7E, 0x00, 0x38, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x08, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x78, 0x01, 0xF0, 0x01, 0xE0, 0x38, 0x03, 0xE0, 0x01, 0xE0, 0x38, 0x07,
  0xC0, 0x01, 0xE0, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x03,
  0xC0, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x3C, 0x00, 0x03, 0xC0, 0x78,
  0x7C, 0x00, 0x03, 0xC0, 0xF0, 0xF8, 0x00, 0x03, 0xC0, 0xF1, 0xF0, 0x00,
  0x03, 0xC1, 0xE1, 0xE0, 0x00, 0x01, 0xE1, 0xE3, 0xC0, 0x00, 0x01, 0xFF,
  0xC7, 0x80, 0x00, 0x00, 0xFF, 0x8F, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x00, 0x00, 0xF1, 0xFF, 0x00, 0x00, 0x01, 0xE3,
  0xFF, 0x80, 0x00, 0x03, 0xC7, 0xC7, 0x80, 0x00, 0x07, 0xC7, 0x87, 0x80,
  0x00, 0x0F, 0x8F, 0x07, 0x80, 0x00, 0x1F, 0x0F, 0x03, 0x80, 0x00, 0x1E,
  0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x1C, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x07, 0x80, 0x03,
  0xE0, 0x3C, 0x07, 0x80, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x3C,
  0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0x9F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x80, 0x3C,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x1F, 0x03, 0xFF, 0x01, 0xE0, 0x7F, 0xF0, 0x1E, 0x0F, 0x8F, 0x83, 0xE1,
  0xF0, 0x7C, 0x3C, 0x3E, 0x07, 0xC3, 0xC3, 0xC0, 0x3E, 0x7C, 0x7C, 0x03,
  0xF7, 0x87, 0x80, 0x1F, 0xF8, 0xF8, 0x00, 0xFF, 0x0F, 0x80, 0x0F, 0xF0,
  0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xE0, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xF0, 0xFE, 0x07, 0xFF,
  0x07, 0xFF, 0xFC, 0xF8, 0x3F, 0xFF, 0x8F, 0x83, 0xFF, 0xE0, 0xF8, 0x0F,
  0xF8, 0x0F, 0xC0, 0x10, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xE0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x3C,
  0x06, 0x7C, 0x1E, 0x0F, 0x3F, 0x8E, 0x3F, 0xFF, 0xF7, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3E, 0x03, 0xE0,
  0x06, 0x00, 0xE0, 0x01, 0x00, 0x20, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x0F,
  0xE0, 0x7F, 0x81, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x0F, 0xF8, 0x3F,
  0xC0, 0xFE, 0x03, 0xE0, 0x08, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xE0, 0x1E, 0x0F, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFE, 0x7F, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0x81, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x00,
  0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x3C, 0x07, 0xCF, 0xC3, 0xF0,
  0x3E, 0x7C, 0x3F, 0xC1, 0xF3, 0xE1, 0xFE, 0x0F, 0x9F, 0x0F, 0xF0, 0xF9,
  0xF0, 0x7F, 0x87, 0xCF, 0x83, 0xFC, 0x3E, 0x7C, 0x0F, 0xC1, 0xF3, 0xE0,
  0x38, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0xFE, 0x01, 0xF8, 0x0F,
  0xE0, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xFE, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xE0, 0x78, 0x01, 0x80, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x0F,
  0xE0, 0x0F, 0x00, 0x1F, 0x80, 0x10, 0x00, 0x3E, 0x00, 0x40, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xF0, 0x07, 0xE0, 0x03, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x80, 0x00, 0xFE, 0x07, 0x00, 0x0F, 0xF0, 0x1F, 0xF7,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xBC, 0x00,
  0x00, 0xFC, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x01,
  0xF8, 0x78, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x1F,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x70,
  0x01, 0xFF, 0x00, 0x7F, 0xBF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x03, 0xE0, 0x00,
  0xFC, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x1F,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFE, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x7E,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFC, 0xFF, 0x80, 0x07, 0xE0, 0x7F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x80,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFB,
  0xFE, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x7C, 0x3E,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3E, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFB, 0xF0, 0x00, 0x08, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7E, 0x3F, 0xC0, 0x80, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xFE, 0x1F, 0x80, 0x3F, 0xFE, 0x0F, 0x80, 0x7F, 0xFF, 0x0F,
  0xC0, 0x7F, 0xFF, 0x87, 0xC0, 0x7F, 0x07, 0xC3, 0xE0, 0x7E, 0x03, 0xC3,
  0xE0, 0x7E, 0x01, 0xE1, 0xF0, 0x7E, 0x01, 0xF0, 0xF8, 0x3E, 0x00, 0xF8,
  0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x3C, 0x3E, 0x0F, 0x80, 0x3E,
  0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x87, 0xC0, 0x0F, 0x87, 0xC3, 0xE0, 0x07,
  0x83, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0xF8, 0x03, 0xE1, 0xF0, 0x7C, 0x01,
  0xF0, 0xF8, 0x1E, 0x00, 0xF0, 0x7C, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xC0,
  0x7C, 0x0F, 0x01, 0xF8, 0x3E, 0x07, 0x80, 0xFF, 0xFE, 0x03, 0xE0, 0x3F,
  0xFF, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0xF8, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x60, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01,
  0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0x80,
  0x3F, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x07,
  0xC0, 0x03, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3F, 0x07, 0x80, 0x01, 0xFC, 0x0F, 0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFE,
  0x00, 0xF8, 0x01, 0xFC, 0x00, 0x18, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x08, 0x00, 0x7F, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x7F, 0x80,
  0x07, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x03, 0xF0, 0x0F,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xF0, 0x03,
  0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x7E, 0x00,
  0x0C, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x78, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x20, 0x00, 0x7E, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x78, 0x01, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF0, 0x07, 0xE0,
  0x00, 0x0F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x00, 0x3D, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x00, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x1D, 0xE0, 0x03, 0xBC, 0x03, 0xDE, 0x00, 0x39, 0xE0, 0x39,
  0xC0, 0x07, 0x9E, 0x07, 0xBC, 0x00, 0x79, 0xE0, 0xF3, 0xC0, 0x07, 0x1E,
  0x0E, 0x3C, 0x00, 0xF1, 0xE1, 0xE3, 0xC0, 0x0F, 0x1E, 0x1C, 0x3C, 0x00,
  0xF1, 0xE3, 0xC7, 0xC0, 0x1E, 0x1E, 0x38, 0x78, 0x01, 0xE1, 0xE7, 0x87,
  0x80, 0x1E, 0x1E, 0xF0, 0x78, 0x03, 0xC0, 0xEE, 0x07, 0x80, 0x3C, 0x0F,
  0xE0, 0xF8, 0x03, 0xC0, 0xFC, 0x0F, 0x00, 0x7C, 0x0F, 0xC0, 0xF0, 0x07,
  0x80, 0xF8, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x07, 0xF8, 0x00, 0x1E, 0x00,
  0x7F, 0x80, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x7B, 0xC0, 0x03,
  0xC0, 0x0F, 0xBC, 0x00, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0xC0, 0x0F, 0x3E,
  0x00, 0x7C, 0x00, 0xF1, 0xE0, 0x07, 0x80, 0x1F, 0x1E, 0x00, 0x78, 0x01,
  0xE1, 0xF0, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0xF8, 0x01, 0xE0, 0xF0, 0x0F,
  0x00, 0x3E, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0xF8, 0x0F, 0x00, 0x3C, 0x07,
  0x81, 0xF0, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0x7C, 0x07, 0x81, 0xE0, 0x07,
  0x80, 0x7C, 0x1E, 0x00, 0x78, 0x03, 0xC3, 0xE0, 0x07, 0x80, 0x3C, 0x3C,
  0x00, 0xF8, 0x03, 0xC3, 0xC0, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x01,
  0xE7, 0xC0, 0x0F, 0x00, 0x1E, 0x7C, 0x01, 0xF0, 0x01, 0xE7, 0x80, 0x1F,
  0x00, 0x1E, 0x78, 0x01, 0xE0, 0x01, 0xE7, 0x80, 0x1E, 0x00, 0x0E, 0xF8,
  0x01, 0xE0, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x03, 0xC0, 0x00,
  0xFF, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x3E, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFC,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x1F, 0x00,
  0x00, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x3E,
  0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x78, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x04,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x20, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x7F, 0x80, 0xFF, 0x87, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x03,
  0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x00,
  0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x7E, 0x03, 0xC0,
  0x1E, 0x0F, 0xF0, 0x7C, 0x01, 0xE0, 0xFF, 0x07, 0x80, 0x1E, 0x1E, 0xF0,
  0x78, 0x03, 0xC1, 0xEF, 0x07, 0x80, 0x3C, 0x3C, 0xF0, 0xF0, 0x03, 0xC3,
  0xC7, 0x0F, 0x00, 0x3C, 0x78, 0x70, 0xF0, 0x03, 0x87, 0x07, 0x0E, 0x00,
  0x38, 0xF0, 0x71, 0xE0, 0x07, 0x9E, 0x07, 0x1E, 0x00, 0x79, 0xE0, 0x71,
  0xC0, 0x07, 0xBC, 0x07, 0xBC, 0x00, 0x73, 0xC0, 0x7B, 0xC0, 0x07, 0x78,
  0x07, 0xB8, 0x00, 0x77, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x1E, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xEF, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0xFC, 0x07, 0x80, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xF0,
  0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x1F, 0x80, 0x07, 0x83, 0xE0, 0x00, 0x78,
  0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3E, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x18, 0x0F, 0x83,
  0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07,
  0x00, 0x40, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0xF8, 0x07, 0xF8, 0x03,
  0xE0, 0x3F, 0x80, 0x0F, 0x81, 0xFC, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0xF0,
  0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78, 0x3F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x7C, 0x1E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F,
  0x83, 0xFF, 0x00, 0x7F, 0xFF, 0xBE, 0x00, 0xFF, 0xFC, 0xF8, 0x01, 0xFF,
  0xC1, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF7, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xC0, 0x3F, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07,
  0x01, 0xFE, 0x00, 0x08, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x40, 0x7F, 0x00, 0x06, 0x01,
  0xFF, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xF8, 0x1F, 0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x1F, 0xC0, 0x07,
  0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x3C, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0xFE, 0xF0, 0x00,
  0x7F, 0xFE, 0x7C, 0x00, 0x1F, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0x01, 0xFE, 0x00, 0xFC, 0x1F, 0xC0,
  0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x3E,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0xFF, 0x8F, 0x83, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x40, 0x7F, 0x00, 0x0E, 0x01, 0xFF, 0x9F, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x08, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFE, 0x0F, 0x80, 0x07, 0xF8, 0x03, 0xE0, 0x03, 0xF8, 0x00,
  0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x1E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x78, 0x00, 0x01, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x08, 0x00, 0x0F, 0xC0,
  0x07, 0x80, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x1F,
  0x00, 0x3F, 0x00, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x78, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x3E,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x04, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x1F,
  0x00, 0x03, 0x80, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0xFC, 0x01,
  0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x03,
  0xE0, 0x1F, 0x80, 0x03, 0xC0, 0x3F, 0x00, 0x03, 0xC0, 0xFE, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0x07,
  0x9F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0x7E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFF, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x4F, 0xC1, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x03, 0xC0, 0x00,
  0x1F, 0x80, 0xF8, 0x01, 0xFF, 0xE3, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x03, 0xF1, 0xFF, 0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x07, 0xC0, 0xF8, 0x0F, 0x07,
  0xC0, 0xF8, 0x1F, 0x07, 0x80, 0xF8, 0x1F, 0x07, 0x80, 0xF0, 0x1E, 0x0F,
  0x80, 0xF0, 0x1E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0x3E, 0x0F,
  0x01, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0x3C, 0x1F, 0x03, 0xE0, 0x7C, 0x1F,
  0x03, 0xE0, 0x7C, 0x1E, 0x03, 0xC0, 0x7C, 0x1E, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7,
  0xFE, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x3F, 0x80, 0x7E,
  0x07, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF1, 0xF8,
  0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0x7C, 0x00,
  0x7E, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0x80, 0x01, 0xF8, 0x07,
  0x80, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xF0, 0x0F, 0x80, 0x0F, 0xE0, 0x0F,
  0x80, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0xF8, 0x07, 0xF8,
  0x03, 0xE0, 0x3F, 0x80, 0x0F, 0x01, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x78, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x83, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xDF, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFE, 0x00, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x87, 0xE0, 0x1F, 0x80, 0x04, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x20, 0x00, 0x3E, 0x03,
  0x80, 0x07, 0xE0, 0x7F, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x01, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0x80, 0xFE,
  0x1F, 0xFC, 0x03, 0xFF, 0xFD, 0xF0, 0x0F, 0xFF, 0xCF, 0x80, 0x3F, 0xF8,
  0x3C, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1E, 0x00,
  0x1F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F,
  0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1F, 0x01, 0xF0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x1E,
  0xF8, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x7C, 0x3C, 0x03, 0xC0, 0x3C, 0x3E,
  0x01, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x1E, 0x0F, 0x81, 0xF8, 0x0F, 0x07,
  0xC0, 0xFC, 0x0F, 0x83, 0xE0, 0xFE, 0x07, 0x81, 0xE0, 0x7F, 0x03, 0xC0,
  0xF0, 0x7B, 0xC3, 0xE0, 0x78, 0x39, 0xE1, 0xE0, 0x3C, 0x3C, 0xF1, 0xF0,
  0x1E, 0x3C, 0x78, 0xF0, 0x0F, 0x1E, 0x3C, 0x78, 0x07, 0x9E, 0x1E, 0x78,
  0x03, 0xDE, 0x0F, 0x3C, 0x03, 0xEF, 0x07, 0xBE, 0x01, 0xFF, 0x01, 0xDE,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x3C, 0x1F,
  0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x04, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x20, 0x7F, 0xE0,
  0x03, 0xC7, 0xFF, 0xC0, 0x3C, 0x7F, 0xFF, 0x01, 0xE3, 0xC1, 0xFC, 0x3E,
  0x3C, 0x03, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0x1E, 0x00, 0x3F, 0xF0, 0x10,
  0x00, 0x7E, 0x00,
};

const GFXglyph UbuntuSansMono_Italic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 16, 43, 34, 9, -42 },
  { 87, 17, 16, 34, 13, -46 },
  { 121, 36, 42, 34, 0, -42 },
  { 310, 30, 54, 34, 3, -47 },
  { 513, 40, 43, 34, -2, -42 },
  { 728, 28, 44, 34, 2, -43 },
  { 882, 8, 18, 34, 18, -46 },
  { 900, 24, 58, 34, 8, -47 },
  { 1074, 24, 58, 34, 2, -47 },
  { 1248, 25, 25, 34, 7, -42 },
  { 1327, 27, 29, 34, 4, -32 },
  { 1425, 14, 19, 34, 5, -9 },
  { 1459, 15, 4, 34, 10, -19 },
  { 1467, 10, 10, 34, 9, -9 },
  { 1480, 38, 58, 34, -4, -47 },
  { 1756, 29, 44, 34, 3, -43 },
  { 1916, 24, 42, 34, 4, -42 },
  { 2042, 30, 43, 34, 3, -43 },
  { 2204, 30, 44, 34, 2, -43 },
  { 2369, 30, 42, 34, 1, -42 },
  { 2527, 32, 43, 34, 2, -42 },
  { 2699, 30, 43, 34, 4, -42 },
  { 2861, 30, 42, 34, 7, -42 },
  { 3019, 31, 44, 34, 3, -43 },
  { 3190, 30, 42, 34, 3, -42 },
  { 3348, 15, 32, 34, 9, -31 },
  { 3408, 19, 41, 34, 5, -31 },
  { 3506, 29, 26, 34, 3, -30 },
  { 3601, 31, 17, 34, 2, -26 },
  { 3667, 29, 26, 34, 2, -30 },
  { 3762, 23, 44, 34, 9, -43 },
  { 3889, 33, 52, 34, 2, -43 },
  { 4104, 33, 42, 34, -4, -42 },
  { 4278, 31, 42, 34, 1, -42 },
  { 4441, 33, 44, 34, 3, -43 },
  { 4623, 33, 42, 34, 0, -42 },
  { 4797, 33, 42, 34, 3, -42 },
  { 4971, 33, 42, 34, 3, -42 },
  { 5145, 32, 44, 34, 3, -43 },
  { 5321, 36, 42, 34, 0, -42 },
  { 5510, 30, 42, 34, 3, -42 },
  { 5668, 32, 43, 34, 3, -42 },
  { 5840, 36, 42, 34, 1, -42 },
  { 6029, 24, 42, 34, 1, -42 },
  { 6155, 36, 42, 34, -1, -42 },
  { 6344, 36, 42, 34, 0, -42 },
  { 6533, 31, 44, 34, 3, -43 },
  { 6704, 33, 42, 34, 1, -42 },
  { 6878, 31, 54, 34, 3, -43 },
  { 7088, 32, 42, 34, 1, -42 },
  { 7256, 32, 44, 34, 2, -43 },
  { 7432, 29, 42, 34, 8, -42 },
  { 7585, 33, 43, 34, 3, -42 },
  { 7763, 31, 42, 34, 7, -42 },
  { 7926, 36, 42, 34, 2, -42 },
  { 8115, 40, 42, 34, -2, -42 },
  { 8325, 32, 42, 34, 7, -42 },
  { 8493, 36, 42, 34, 0, -42 },
  { 8682, 30, 58, 34, 4, -47 },
  { 8900, 10, 58, 34, 12, -47 },
  { 8973, 30, 58, 34, -1, -47 },
  { 9191, 27, 23, 34, 5, -42 },
  { 9269, 31, 4, 34, -4, 7 },
  { 9285, 11, 12, 34, 15, -46 },
  { 9302, 30, 33, 34, 2, -32 },
  { 9426, 30, 48, 34, 2, -47 },
  { 9606, 29, 33, 34, 2, -32 },
  { 9726, 33, 48, 34, 3, -47 },
  { 9924, 29, 33, 34, 2, -32 },
  { 10044, 39, 58, 34, -1, -47 },
  { 10327, 34, 43, 34, -1, -32 },
  { 10510, 29, 47, 34, 0, -47 },
  { 10681, 19, 46, 34, 7, -46 },
  { 10791, 33, 57, 34, -1, -46 },
  { 11027, 32, 47, 34, 2, -47 },
  { 11215, 17, 47, 34, 10, -46 },
  { 11315, 32, 32, 34, 0, -32 },
  { 11443, 29, 32, 34, 2, -32 },
  { 11559, 28, 33, 34, 3, -32 },
  { 11675, 32, 43, 34, -1, -32 },
  { 11847, 30, 43, 34, 3, -32 },
  { 12009, 28, 32, 34, 4, -32 },
  { 12121, 28, 33, 34, 3, -32 },
  { 12237, 25, 42, 34, 7, -41 },
  { 12369, 29, 32, 34, 3, -31 },
  { 12485, 26, 31, 34, 7, -31 },
  { 12586, 33, 31, 34, 3, -31 },
  { 12714, 35, 31, 34, -1, -31 },
  { 12850, 36, 42, 34, -3, -31 },
  { 13039, 29, 31, 34, 2, -31 },
  { 13152, 33, 58, 34, 3, -47 },
  { 13392, 19, 58, 34, 8, -47 },
  { 13530, 33, 58, 34, -3, -47 },
  { 13770, 29, 9, 34, 3, -22 },
};

const GFXfont UbuntuSansMono_Italic60pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic60pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic60pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _UBUNTUSANSMONO_ITALIC60PT7B_H_
