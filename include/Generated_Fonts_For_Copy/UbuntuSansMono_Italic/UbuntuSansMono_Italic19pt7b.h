#ifndef _UBUNTUSANSMONO_ITALIC19PT7B_H_
#define _UBUNTUSANSMONO_ITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x63, 0x10, 0x84, 0x40, 0x01, 0xCC, 0x00, 0x4D, 0x2C,
  0xA2, 0x90, 0x02, 0x20, 0xCC, 0x11, 0x1F, 0xF7, 0xFE, 0x33, 0x04, 0x40,
  0x98, 0xFF, 0xC4, 0x41, 0x98, 0x22, 0x0C, 0xC0, 0x03, 0x00, 0x80, 0x30,
  0x7F, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x10, 0x04, 0x83,
  0x3F, 0x83, 0x80, 0x40, 0x30, 0x00, 0x1E, 0x18, 0x91, 0x84, 0x98, 0x65,
  0x83, 0x68, 0x0E, 0x80, 0x08, 0x00, 0xBC, 0x0D, 0x20, 0xD9, 0x0C, 0x88,
  0x44, 0x8C, 0x1C, 0x00, 0x0F, 0x8C, 0xC6, 0x62, 0x21, 0xB0, 0xF0, 0x72,
  0x49, 0x47, 0xA1, 0xB0, 0xCC, 0xE7, 0x98, 0x7E, 0x80, 0x01, 0x03, 0x06,
  0x0C, 0x18, 0x30, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x40, 0x40,
  0x60, 0x20, 0x30, 0x10, 0x04, 0x0E, 0x02, 0x03, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x18, 0x30, 0xE0, 0x40, 0x18,
  0x08, 0x4B, 0xFF, 0x18, 0x34, 0x66, 0x24, 0x04, 0x02, 0x03, 0x01, 0x0F,
  0xF8, 0x40, 0x60, 0x30, 0x10, 0x00, 0x11, 0xCE, 0x3B, 0x20, 0xF8, 0x5F,
  0x80, 0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x00, 0x0F, 0x8C, 0xCC, 0x2C, 0x16, 0x0A,
  0x67, 0x77, 0x93, 0xC1, 0x61, 0xB0, 0x98, 0xC7, 0xC0, 0x03, 0x06, 0x3A,
  0x26, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0xFE, 0x3F, 0x88,
  0xC0, 0x20, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x2F,
  0xE0, 0x1F, 0x08, 0xC0, 0x20, 0x30, 0x10, 0x70, 0x78, 0x06, 0x01, 0x00,
  0x80, 0xD0, 0xCF, 0xC0, 0x00, 0xC0, 0xE0, 0x68, 0x32, 0x19, 0x84, 0x42,
  0x11, 0x84, 0x7F, 0xBF, 0xE0, 0x20, 0x08, 0x06, 0x00, 0x0F, 0xC2, 0x01,
  0x80, 0x40, 0x10, 0x0F, 0x00, 0x60, 0x0C, 0x01, 0x00, 0xC0, 0x32, 0x18,
  0xFC, 0x00, 0x03, 0xC3, 0x81, 0x80, 0xC0, 0x20, 0x1F, 0x86, 0x31, 0x06,
  0xC1, 0xB0, 0x4C, 0x11, 0x0C, 0x7E, 0x00, 0x3F, 0xD0, 0x60, 0x30, 0x08,
  0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x00,
  0x1F, 0x84, 0x33, 0x0C, 0x82, 0x31, 0x8E, 0xC3, 0xE1, 0x8C, 0xC1, 0x30,
  0x4C, 0x13, 0x0C, 0x7C, 0x00, 0x1F, 0x8C, 0x22, 0x0D, 0x83, 0x60, 0xD8,
  0x23, 0xF8, 0x76, 0x03, 0x00, 0xC0, 0x60, 0xF0, 0xF0, 0x00, 0x31, 0xCC,
  0x00, 0x00, 0x08, 0xE7, 0x00, 0x0C, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x08,
  0x38, 0x70, 0x65, 0x84, 0x00, 0x00, 0x81, 0xC3, 0x8F, 0x0C, 0x07, 0x00,
  0xF0, 0x1E, 0x02, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x40, 0x38,
  0x07, 0x00, 0xE0, 0x18, 0x78, 0xE1, 0xC0, 0x80, 0x00, 0x7E, 0x04, 0x08,
  0x30, 0xC3, 0x0C, 0x30, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x0F, 0x86, 0x33,
  0x05, 0x81, 0x67, 0xD3, 0x3D, 0x8B, 0x62, 0x91, 0xA4, 0x69, 0x92, 0x3C,
  0xC0, 0x10, 0x07, 0xC0, 0x70, 0x01, 0x80, 0xE0, 0x28, 0x13, 0x0C, 0xC2,
  0x31, 0x8C, 0x43, 0x3F, 0xC8, 0x16, 0x05, 0x01, 0xC0, 0x40, 0x1F, 0xC4,
  0x31, 0x04, 0xC1, 0x30, 0xCF, 0xE3, 0xF1, 0x82, 0x60, 0x90, 0x24, 0x19,
  0x0C, 0xFE, 0x00, 0x0F, 0xC6, 0x13, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0x84, 0x3F, 0x00, 0x1F, 0x84, 0x73, 0x0C,
  0xC1, 0x20, 0x48, 0x16, 0x05, 0x83, 0x40, 0xD0, 0x64, 0x33, 0x18, 0xFC,
  0x00, 0x1F, 0xC4, 0x03, 0x00, 0xC0, 0x20, 0x0F, 0xC7, 0xF1, 0x80, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0xFF, 0x00, 0x1F, 0xC4, 0x03, 0x00, 0xC0, 0x20,
  0x0F, 0xC7, 0xF1, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x00, 0x0F,
  0xC6, 0x12, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x06, 0x81, 0x30, 0x4C,
  0x31, 0x8C, 0x3E, 0x00, 0x18, 0x22, 0x04, 0x41, 0x98, 0x33, 0x04, 0x7F,
  0x8F, 0xF3, 0x06, 0x60, 0x88, 0x11, 0x06, 0x60, 0xCC, 0x10, 0x1F, 0x83,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x0F,
  0xE0, 0x0F, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x22, 0x18, 0xFC, 0x00, 0x18, 0x71, 0x0C, 0x11, 0x81, 0x30,
  0x36, 0x03, 0xC0, 0x38, 0x02, 0xC0, 0x66, 0x06, 0x20, 0x43, 0x04, 0x10,
  0xC1, 0x80, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60,
  0x60, 0x40, 0xFF, 0x08, 0x63, 0x0C, 0x72, 0x8E, 0xF2, 0xD4, 0x4E, 0x89,
  0x93, 0x26, 0x40, 0xC8, 0x13, 0x02, 0x60, 0x48, 0x18, 0x18, 0x23, 0x04,
  0x71, 0x9A, 0x33, 0x44, 0x4C, 0x89, 0x93, 0x16, 0x62, 0x88, 0x51, 0x0E,
  0x21, 0xCC, 0x10, 0x0F, 0x84, 0x22, 0x0D, 0x83, 0x40, 0xD0, 0x3C, 0x0B,
  0x02, 0xC1, 0xB0, 0x4C, 0x33, 0x18, 0x7C, 0x00, 0x1F, 0xC3, 0x18, 0x41,
  0x88, 0x33, 0x04, 0x61, 0x88, 0x61, 0xF0, 0x20, 0x0C, 0x01, 0x80, 0x20,
  0x0C, 0x00, 0x0F, 0x84, 0x22, 0x0D, 0x83, 0x40, 0xD0, 0x3C, 0x0B, 0x02,
  0xC1, 0xB0, 0x4C, 0x33, 0x18, 0x7C, 0x0C, 0x01, 0x80, 0x78, 0x1F, 0x84,
  0x31, 0x04, 0xC1, 0x30, 0x4C, 0x33, 0xF8, 0xF8, 0x62, 0x18, 0xC4, 0x31,
  0x04, 0xC1, 0x80, 0x0F, 0xE3, 0x04, 0x60, 0x08, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x0C, 0x01, 0x80, 0x10, 0x06, 0x21, 0x8F, 0xE0, 0xFF, 0x8C, 0x04,
  0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x00,
  0x30, 0x48, 0x12, 0x0D, 0x83, 0x60, 0x90, 0x24, 0x1B, 0x06, 0xC1, 0x30,
  0x4C, 0x33, 0x18, 0x7C, 0x00, 0xC0, 0xF0, 0x2C, 0x1B, 0x04, 0xC3, 0x30,
  0x8C, 0x61, 0x10, 0x4C, 0x12, 0x05, 0x01, 0xC0, 0x60, 0x00, 0x20, 0x6C,
  0x09, 0x81, 0x20, 0x64, 0x0C, 0x99, 0x37, 0x26, 0xAC, 0xB5, 0x14, 0xA3,
  0x1C, 0x63, 0x08, 0x60, 0x0C, 0x18, 0x21, 0x81, 0x98, 0x0C, 0x80, 0x28,
  0x01, 0xC0, 0x0C, 0x00, 0xF0, 0x0D, 0x80, 0xC4, 0x04, 0x30, 0x61, 0x8E,
  0x04, 0x00, 0xC0, 0xD0, 0x24, 0x19, 0x8C, 0x62, 0x09, 0x02, 0xC0, 0xE0,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x00, 0x1F, 0xE0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0F,
  0xF8, 0x07, 0xC3, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x1F, 0x0F,
  0x80, 0xDB, 0x6D, 0xB6, 0x49, 0x24, 0xDB, 0x6D, 0x80, 0x0F, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x60, 0x30, 0x10, 0x08, 0x7C, 0x3E, 0x00, 0x0C, 0x1E, 0x12, 0x22, 0x62,
  0xC3, 0x81, 0xFF, 0xFF, 0xC0, 0x59, 0x90, 0x0F, 0x9C, 0xD8, 0x68, 0x2C,
  0x14, 0x1A, 0x0D, 0x04, 0xC6, 0x3D, 0x80, 0x18, 0x08, 0x04, 0x06, 0x03,
  0x01, 0xF8, 0xC6, 0xC3, 0x61, 0xA0, 0xD0, 0x78, 0x2C, 0x34, 0x73, 0xE0,
  0x1F, 0x98, 0x58, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC2, 0x3F, 0x00,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x1F, 0x0E, 0x23, 0x0C, 0x41,
  0x98, 0x23, 0x04, 0x61, 0x8C, 0x31, 0x8E, 0x1F, 0xC0, 0x1F, 0x18, 0xD8,
  0x78, 0x3C, 0x77, 0xE2, 0x01, 0x00, 0xC2, 0x3F, 0x00, 0x00, 0xF0, 0x1F,
  0x03, 0x00, 0x20, 0x06, 0x01, 0xFE, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x0F, 0x00,
  0xC0, 0x00, 0x07, 0xC7, 0x13, 0x0C, 0xC3, 0x60, 0x98, 0x26, 0x09, 0x86,
  0x3F, 0x07, 0x40, 0x30, 0x08, 0xFE, 0x0C, 0x00, 0x08, 0x0C, 0x06, 0x02,
  0x01, 0x01, 0xF8, 0xC6, 0x41, 0x20, 0xB0, 0x58, 0x68, 0x34, 0x12, 0x0B,
  0x0C, 0x08, 0x71, 0x80, 0x03, 0xE1, 0x84, 0x10, 0xC3, 0x08, 0x20, 0xC1,
  0xC0, 0x00, 0x80, 0x70, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x04, 0x3F, 0x02,
  0x00, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x72, 0x31, 0x98, 0x7C,
  0x1C, 0x05, 0x83, 0x30, 0xC4, 0x21, 0x88, 0x30, 0x7B, 0xE1, 0x04, 0x30,
  0xC2, 0x08, 0x61, 0x84, 0x10, 0x41, 0x17, 0xC0, 0x3D, 0xC9, 0x92, 0x65,
  0x91, 0x64, 0xD3, 0x24, 0x09, 0x02, 0xC1, 0xA0, 0x60, 0x3F, 0x11, 0x98,
  0x6C, 0x34, 0x1A, 0x09, 0x05, 0x86, 0xC3, 0x41, 0x00, 0x1F, 0x18, 0xD8,
  0x68, 0x3C, 0x1E, 0x0F, 0x05, 0x86, 0xC6, 0x3E, 0x00, 0x1F, 0x84, 0x73,
  0x0C, 0xC3, 0x20, 0xC8, 0x36, 0x09, 0x86, 0x47, 0x1F, 0x8C, 0x03, 0x00,
  0x80, 0x20, 0x00, 0x0F, 0x9C, 0xD8, 0x68, 0x3C, 0x16, 0x0A, 0x0D, 0x86,
  0xC6, 0x3F, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x1F, 0x98, 0x0C, 0x04, 0x02,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x00, 0x1F, 0x98, 0x48, 0x06, 0x01,
  0x80, 0x70, 0x08, 0x06, 0x86, 0x7E, 0x00, 0x18, 0x18, 0x10, 0x7F, 0xB0,
  0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x62, 0x3C, 0x60, 0xB0, 0xD0, 0x68,
  0x2C, 0x16, 0x1B, 0x0D, 0x84, 0xC6, 0x3D, 0x80, 0xC1, 0xC3, 0xC3, 0xC2,
  0x46, 0x4C, 0x48, 0x58, 0x70, 0x60, 0x40, 0x68, 0x0B, 0x03, 0x66, 0x4C,
  0xC9, 0xAB, 0x3D, 0x45, 0x38, 0xC6, 0x18, 0xC0, 0x30, 0x63, 0x18, 0x66,
  0x07, 0x80, 0x60, 0x1C, 0x06, 0x81, 0x98, 0x63, 0x18, 0x30, 0x18, 0x31,
  0x82, 0x18, 0x60, 0x84, 0x08, 0xC0, 0xCC, 0x0C, 0x80, 0xD8, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0xF8, 0x06, 0x00, 0x1F, 0xC0, 0x20, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0x00, 0x80, 0x60, 0x3F, 0xC0, 0x03, 0xC1, 0x80, 0xC0,
  0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x30, 0x38, 0x03, 0x00, 0xC0, 0x20,
  0x08, 0x02, 0x01, 0x80, 0x60, 0x1F, 0x00, 0xC0, 0x08, 0x46, 0x31, 0x08,
  0x46, 0x21, 0x08, 0xC4, 0x21, 0x18, 0xC4, 0x20, 0x0F, 0x00, 0x60, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x80, 0x70, 0x30, 0x08, 0x02,
  0x01, 0x80, 0x40, 0x10, 0x0C, 0x3E, 0x0C, 0x00, 0x70, 0xE6, 0xE1, 0xC0,
};

const GFXglyph UbuntuSansMono_Italic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 3, -13 },
  { 10, 6, 5, 11, 4, -14 },
  { 14, 11, 13, 11, 0, -13 },
  { 32, 10, 17, 11, 1, -15 },
  { 54, 13, 13, 11, -1, -13 },
  { 76, 9, 13, 11, 0, -13 },
  { 91, 2, 5, 11, 6, -14 },
  { 93, 8, 19, 11, 2, -15 },
  { 112, 8, 19, 11, 0, -15 },
  { 131, 8, 8, 11, 2, -13 },
  { 139, 9, 9, 11, 1, -10 },
  { 150, 5, 6, 11, 1, -3 },
  { 154, 5, 1, 11, 3, -6 },
  { 155, 3, 3, 11, 3, -3 },
  { 157, 12, 19, 11, -1, -15 },
  { 186, 9, 13, 11, 1, -13 },
  { 201, 8, 13, 11, 1, -13 },
  { 214, 9, 13, 11, 1, -13 },
  { 229, 9, 13, 11, 1, -13 },
  { 244, 10, 13, 11, 0, -13 },
  { 261, 10, 13, 11, 1, -13 },
  { 278, 10, 13, 11, 1, -13 },
  { 295, 10, 13, 11, 2, -13 },
  { 312, 10, 13, 11, 1, -13 },
  { 329, 10, 13, 11, 1, -13 },
  { 346, 5, 10, 11, 3, -10 },
  { 353, 7, 13, 11, 1, -10 },
  { 365, 9, 9, 11, 1, -10 },
  { 376, 9, 5, 11, 1, -8 },
  { 382, 9, 9, 11, 1, -10 },
  { 393, 7, 13, 11, 3, -13 },
  { 405, 10, 16, 11, 1, -13 },
  { 425, 10, 13, 11, -1, -13 },
  { 442, 10, 13, 11, 0, -13 },
  { 459, 10, 13, 11, 1, -13 },
  { 476, 10, 13, 11, 0, -13 },
  { 493, 10, 13, 11, 1, -13 },
  { 510, 10, 13, 11, 1, -13 },
  { 527, 10, 13, 11, 1, -13 },
  { 544, 11, 13, 11, 0, -13 },
  { 562, 9, 13, 11, 1, -13 },
  { 577, 10, 13, 11, 1, -13 },
  { 594, 12, 13, 11, 0, -13 },
  { 614, 8, 13, 11, 0, -13 },
  { 627, 11, 13, 11, 0, -13 },
  { 645, 11, 13, 11, 0, -13 },
  { 663, 10, 13, 11, 1, -13 },
  { 680, 11, 13, 11, 0, -13 },
  { 698, 10, 16, 11, 1, -13 },
  { 718, 10, 13, 11, 0, -13 },
  { 735, 11, 13, 11, 0, -13 },
  { 753, 9, 13, 11, 3, -13 },
  { 768, 10, 13, 11, 1, -13 },
  { 785, 10, 13, 11, 2, -13 },
  { 802, 11, 13, 11, 1, -13 },
  { 820, 13, 13, 11, -1, -13 },
  { 842, 10, 13, 11, 2, -13 },
  { 859, 11, 13, 11, 0, -13 },
  { 877, 10, 19, 11, 1, -15 },
  { 901, 3, 19, 11, 4, -15 },
  { 909, 9, 19, 11, 0, -15 },
  { 931, 8, 7, 11, 2, -13 },
  { 938, 9, 2, 11, -1, 2 },
  { 941, 3, 4, 11, 5, -15 },
  { 943, 9, 10, 11, 1, -10 },
  { 955, 9, 15, 11, 1, -15 },
  { 972, 9, 10, 11, 1, -10 },
  { 984, 11, 15, 11, 1, -15 },
  { 1005, 9, 10, 11, 1, -10 },
  { 1017, 12, 19, 11, 0, -15 },
  { 1046, 10, 14, 11, 0, -10 },
  { 1064, 9, 15, 11, 0, -15 },
  { 1081, 6, 15, 11, 2, -15 },
  { 1093, 10, 19, 11, 0, -15 },
  { 1117, 10, 15, 11, 1, -15 },
  { 1136, 6, 15, 11, 3, -15 },
  { 1148, 10, 10, 11, 0, -10 },
  { 1161, 9, 10, 11, 1, -10 },
  { 1173, 9, 10, 11, 1, -10 },
  { 1185, 10, 14, 11, 0, -10 },
  { 1203, 9, 14, 11, 1, -10 },
  { 1219, 9, 10, 11, 1, -10 },
  { 1231, 9, 10, 11, 1, -10 },
  { 1243, 8, 13, 11, 2, -13 },
  { 1256, 9, 10, 11, 1, -10 },
  { 1268, 8, 10, 11, 2, -10 },
  { 1278, 11, 10, 11, 1, -10 },
  { 1292, 11, 10, 11, 0, -10 },
  { 1306, 12, 14, 11, -1, -10 },
  { 1327, 10, 10, 11, 0, -10 },
  { 1340, 10, 19, 11, 1, -15 },
  { 1364, 5, 19, 11, 3, -15 },
  { 1376, 10, 19, 11, -1, -15 },
  { 1400, 9, 3, 11, 1, -7 },
};

const GFXfont UbuntuSansMono_Italic19pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic19pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic19pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _UBUNTUSANSMONO_ITALIC19PT7B_H_
