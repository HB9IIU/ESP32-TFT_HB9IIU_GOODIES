#ifndef _UBUNTUSANSMONO_ITALIC45PT7B_H_
#define _UBUNTUSANSMONO_ITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x02,
  0x00, 0x38, 0x39, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x73, 0x83,
  0x9C, 0x1C, 0xE0, 0xC6, 0x06, 0x30, 0x31, 0x81, 0x00, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0xE0, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0x70,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0x38,
  0x1E, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x78, 0x1C, 0x00,
  0x0E, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x07,
  0x80, 0x03, 0xC0, 0xE0, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x80, 0x70, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xF0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0,
  0x78, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFC, 0x3C, 0x07, 0xC0, 0x08, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x04, 0x00, 0x78, 0x1E, 0x07, 0xF0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xF0, 0x0E, 0xF0, 0x03,
  0x80, 0x71, 0xC0, 0x1C, 0x03, 0x83, 0x00, 0xE0, 0x0E, 0x0C, 0x07, 0x00,
  0x38, 0x30, 0x3C, 0x01, 0xC1, 0xC1, 0xE0, 0x07, 0x07, 0x0F, 0x00, 0x1C,
  0x1C, 0x38, 0x00, 0x70, 0x71, 0xC0, 0x01, 0xC3, 0x8E, 0x00, 0x07, 0x8E,
  0x70, 0x00, 0x0F, 0xF3, 0xC0, 0x00, 0x3F, 0x9E, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x7C, 0x00, 0x00, 0xE3, 0xF8,
  0x00, 0x07, 0x1C, 0xE0, 0x00, 0x3C, 0xE3, 0x80, 0x01, 0xE7, 0x07, 0x00,
  0x07, 0x1C, 0x1C, 0x00, 0x38, 0x70, 0x70, 0x01, 0xC1, 0x81, 0xC0, 0x0E,
  0x0E, 0x0E, 0x00, 0x70, 0x38, 0x38, 0x03, 0xC0, 0xE0, 0xE0, 0x1E, 0x03,
  0x87, 0x00, 0x70, 0x07, 0x1C, 0x03, 0x80, 0x1F, 0xE0, 0x3C, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0x1F,
  0xFC, 0x01, 0xE1, 0xE0, 0x1E, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0x01, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1C, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x87,
  0x80, 0x1C, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3E, 0x06, 0x07,
  0xF0, 0x38, 0x7F, 0xC3, 0xC7, 0x8F, 0x1C, 0x78, 0x78, 0xE3, 0x81, 0xEF,
  0x3C, 0x07, 0x71, 0xC0, 0x3F, 0x9E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80,
  0x1C, 0x3C, 0x01, 0xF1, 0xF0, 0x1F, 0x87, 0x83, 0xFE, 0x3F, 0xFE, 0xF0,
  0xFF, 0xC7, 0x83, 0xFC, 0x1E, 0x3C, 0xE7, 0x9E, 0x71, 0xCF, 0x3C, 0xE3,
  0x8E, 0x30, 0xC0, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xE1,
  0xC1, 0x9F, 0x19, 0xFF, 0xFB, 0xFF, 0x7F, 0xFF, 0xC0, 0x7F, 0x80, 0x07,
  0xC0, 0x01, 0xFC, 0x00, 0x79, 0xC0, 0x1F, 0x3C, 0x03, 0xC3, 0xC0, 0xF8,
  0x7C, 0x0E, 0x07, 0x00, 0x80, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x02, 0x03, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x0E, 0x07,
  0x83, 0xC3, 0xF3, 0xF0, 0xF8, 0x38, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0x00,
  0x18, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0x00, 0x3F, 0xFC, 0x03, 0xF3, 0xE0, 0x3E, 0x07, 0x83, 0xC0, 0x3C, 0x3C,
  0x01, 0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0x38, 0xF0, 0x01, 0xCF, 0x00, 0x0E,
  0x78, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x7C, 0x3D, 0xE3, 0xE1, 0xEE, 0x3F,
  0x8F, 0xF1, 0xFC, 0x77, 0x87, 0xC7, 0xBC, 0x1C, 0x3D, 0xE0, 0x01, 0xEE,
  0x00, 0x0E, 0x70, 0x00, 0xF3, 0x80, 0x07, 0x9C, 0x00, 0x78, 0xE0, 0x03,
  0xC7, 0x00, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0xE0,
  0x7F, 0x70, 0x1F, 0x1C, 0x06, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFC, 0x3F, 0x03, 0x80, 0x3C, 0x04, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x78, 0x3E, 0x01,
  0x80, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x60, 0x0F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xE7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x70, 0x03, 0xC1, 0xC0, 0x0E,
  0x0F, 0x00, 0x70, 0x3C, 0x03, 0xC0, 0xE0, 0x1E, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x78, 0x1C, 0x01, 0xC0, 0xF0, 0x07, 0x07, 0x80, 0x3C, 0x1C,
  0x00, 0xF0, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x0C, 0x01, 0xF8,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC7, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0x81, 0xF0, 0x78,
  0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x8F, 0x00,
  0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x70, 0xF0, 0x01,
  0xE1, 0xE0, 0x03, 0x81, 0xC0, 0x0F, 0x03, 0xC0, 0x3C, 0x03, 0xE1, 0xF0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0,
  0x0F, 0xC1, 0xE0, 0x1E, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0x83,
  0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x3C,
  0x01, 0xE0, 0x78, 0x07, 0x80, 0x78, 0x1F, 0x00, 0xFC, 0x7C, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0x9F, 0x80, 0x7C, 0x0F, 0x80, 0xF0, 0x0F,
  0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07,
  0x80, 0x7C, 0x0F, 0xC3, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F,
  0x83, 0xE0, 0x3E, 0x03, 0xC0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0xF0, 0x00,
  0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x07, 0x80, 0x1E,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x01, 0x83, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0x80,
  0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF0, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0xF0,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xE0, 0x10, 0x00, 0x00, 0x70, 0x03,
  0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x03, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x20, 0x1F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x18, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x3E, 0x01,
  0xF0, 0x0F, 0x03, 0xE0, 0x0F, 0x07, 0xC0, 0x07, 0x07, 0x80, 0x07, 0x0F,
  0x00, 0x07, 0x0F, 0x00, 0x07, 0x1E, 0x00, 0x1F, 0x1E, 0x03, 0xFF, 0x3C,
  0x0F, 0xFF, 0x3C, 0x1F, 0x9E, 0x78, 0x3C, 0x0E, 0x78, 0x78, 0x1E, 0x78,
  0xF0, 0x1E, 0x70, 0xF0, 0x1C, 0xF0, 0xE0, 0x1C, 0xF0, 0xE0, 0x3C, 0xF1,
  0xE0, 0x3C, 0xF1, 0xE0, 0x38, 0xF1, 0xE0, 0x38, 0xE1, 0xE0, 0x78, 0xE1,
  0xE0, 0x78, 0xE0, 0xF0, 0x70, 0xF0, 0xF8, 0x70, 0xF0, 0x7F, 0xF0, 0xF0,
  0x3F, 0xF0, 0xF0, 0x07, 0x80, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xEC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1D, 0xE0,
  0x00, 0x1E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x03, 0x81, 0xE0, 0x03, 0x80,
  0xF0, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0xF0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x78, 0x00, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1E, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xE3,
  0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xC0, 0x1F,
  0x01, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x07,
  0x03, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3C,
  0x07, 0x00, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x0E, 0x01, 0xF8, 0x0E, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C,
  0x38, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x03, 0xF0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFE, 0x3E, 0x03, 0xE0, 0x06,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x01, 0x80,
  0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x04, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x0F,
  0x07, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x0F, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0E,
  0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C,
  0x38, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x70, 0x07, 0xE0,
  0x70, 0x1F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0xFE, 0x1E, 0x01, 0xF0, 0x06, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x7C,
  0x01, 0xE0, 0x3E, 0x01, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C,
  0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80,
  0x07, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x80,
  0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00,
  0x70, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0E,
  0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x0E,
  0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x38, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0,
  0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x40, 0x07, 0x80, 0x70, 0x0F, 0x80, 0xFE, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0xE0,
  0x38, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0x38, 0x07,
  0xC0, 0x07, 0x01, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x07,
  0x07, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x71, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x0E, 0x03,
  0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xE0, 0x38, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x1D, 0x80,
  0x37, 0x03, 0xF0, 0x0E, 0xE0, 0xEE, 0x01, 0xDC, 0x1D, 0xC0, 0x3B, 0x87,
  0x38, 0x0E, 0x70, 0xC7, 0x01, 0xC6, 0x39, 0xC0, 0x38, 0xCE, 0x38, 0x0E,
  0x1D, 0xC7, 0x01, 0xC3, 0xF0, 0xE0, 0x38, 0x7E, 0x1C, 0x0F, 0x0F, 0x87,
  0x81, 0xC1, 0xE0, 0xE0, 0x38, 0x3C, 0x1C, 0x0F, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x70, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x0E, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0xE0, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0xFC,
  0x00, 0xE0, 0x1F, 0x80, 0x1C, 0x07, 0xF0, 0x03, 0x80, 0xEF, 0x00, 0xF0,
  0x1C, 0xE0, 0x1C, 0x03, 0x9C, 0x03, 0x80, 0x73, 0x80, 0x70, 0x1C, 0x78,
  0x1E, 0x03, 0x87, 0x03, 0x80, 0x70, 0xE0, 0x70, 0x0E, 0x1C, 0x0E, 0x03,
  0xC1, 0xC3, 0xC0, 0x70, 0x38, 0x70, 0x0E, 0x07, 0x0E, 0x01, 0xC0, 0xE1,
  0xC0, 0x78, 0x0E, 0x78, 0x0E, 0x01, 0xCE, 0x01, 0xC0, 0x39, 0xC0, 0x38,
  0x07, 0x38, 0x0F, 0x00, 0xE7, 0x01, 0xC0, 0x0F, 0xE0, 0x38, 0x01, 0xF8,
  0x07, 0x00, 0x3F, 0x01, 0xE0, 0x07, 0xE0, 0x38, 0x00, 0xFC, 0x07, 0x00,
  0x1F, 0x00, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xC3, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x3C,
  0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xE7, 0x00,
  0x01, 0xCE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xEF, 0x00, 0x03, 0x9E, 0x00, 0x07,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x38, 0xF0, 0x00, 0xF0, 0xE0, 0x03, 0xC1,
  0xC0, 0x07, 0x83, 0xC0, 0x1E, 0x07, 0xC0, 0xF8, 0x07, 0xE7, 0xE0, 0x07,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFD, 0xFE, 0x01, 0xC0, 0x1E, 0x03,
  0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x07,
  0x80, 0x07, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x7C, 0x0E, 0x01, 0xF8, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xC3, 0xE0, 0x1E, 0x03, 0xC0, 0x78,
  0x03, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x3C, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xE7, 0x00, 0x01,
  0xCE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x73, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0x3C,
  0x00, 0x1E, 0x78, 0x00, 0x38, 0xF0, 0x00, 0xF0, 0xE0, 0x03, 0xC1, 0xC0,
  0x07, 0x83, 0xC0, 0x1E, 0x07, 0xC0, 0xF8, 0x07, 0xE7, 0xE0, 0x07, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x03, 0xC0, 0x3E, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x0F,
  0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0E,
  0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x3C,
  0x1E, 0x00, 0xF8, 0x1E, 0x3F, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x1C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x07, 0x00, 0x38, 0x07, 0x80,
  0x38, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x70, 0x03, 0xC0,
  0x70, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xE0, 0x01, 0xE0,
  0xE0, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xC7, 0xE0, 0x1F, 0x00, 0x20, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0x00, 0x3E, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0xE0,
  0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1C,
  0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83,
  0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0,
  0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x03, 0xF3, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x01, 0xC0, 0xF0, 0x03, 0xC0, 0x70, 0x03, 0x80, 0x70, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1E, 0x00, 0x70,
  0x3C, 0x00, 0x70, 0x38, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70, 0x00, 0x78,
  0xF0, 0x00, 0x78, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0,
  0x78, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x38, 0x3C,
  0x1C, 0x07, 0x0F, 0x83, 0x80, 0xE1, 0xB0, 0xF0, 0x38, 0x76, 0x1C, 0x07,
  0x1C, 0xC3, 0x80, 0xE3, 0x98, 0x70, 0x1C, 0xE3, 0x9C, 0x03, 0x9C, 0x73,
  0x80, 0x67, 0x0E, 0x70, 0x1C, 0xC1, 0xDC, 0x03, 0xB8, 0x3B, 0x80, 0x7E,
  0x07, 0x70, 0x0D, 0xC0, 0xEC, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1F,
  0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x3E, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70, 0x70,
  0x00, 0xF0, 0x70, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x38, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0xF1, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x38, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xF7, 0x80, 0x1E, 0x38, 0x01, 0xE3,
  0x80, 0x3C, 0x38, 0x07, 0x81, 0xC0, 0xF0, 0x1C, 0x1E, 0x01, 0xC1, 0xE0,
  0x0E, 0x3C, 0x00, 0xE7, 0x80, 0x0E, 0xF0, 0x00, 0xF6, 0x00, 0x06, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x20, 0x70, 0xF0, 0x78,
  0x3C, 0x3C, 0x1E, 0x0F, 0x06, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFE, 0x0E, 0x07, 0xC0, 0x38, 0x3E, 0x01, 0xE1, 0xE0, 0x07,
  0x8F, 0x00, 0x1C, 0x3C, 0x00, 0x71, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3C,
  0x00, 0x38, 0xF0, 0x00, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0,
  0x78, 0x0F, 0xC1, 0xF9, 0xFF, 0x03, 0xFF, 0xDC, 0x07, 0xFC, 0x70, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE7, 0xE0, 0x07,
  0x7F, 0xE0, 0x1F, 0xFF, 0xC0, 0xFE, 0x1F, 0x03, 0xC0, 0x1E, 0x0E, 0x00,
  0x78, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x3C,
  0x70, 0x00, 0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x38, 0x00, 0x78, 0xE0,
  0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xE1, 0xC0, 0x0F,
  0x07, 0x00, 0xF8, 0x3C, 0x0F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xF8, 0x0E, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0xC0, 0xFF, 0x7F, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xE0, 0xF0, 0x0F,
  0xC0, 0x78, 0x0F, 0x80, 0x38, 0x0F, 0x80, 0x1C, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x07, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x03, 0xC0,
  0xE0, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x80, 0x3E, 0x3F, 0xC0, 0x1F, 0xFE, 0xF0, 0x03, 0xFE,
  0x78, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0xFF,
  0xFC, 0x0F, 0xC1, 0xF0, 0xF8, 0x07, 0x8F, 0x80, 0x1C, 0xF8, 0x00, 0xE7,
  0x80, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0xFD, 0xE0, 0x7F,
  0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x0C,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xF8, 0x20, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFE, 0x0E,
  0x00, 0xFC, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x00,
  0x1C, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x3C,
  0x00, 0x38, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0F, 0x00, 0xF0, 0x03,
  0x80, 0x3E, 0x03, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xE7, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x60, 0x07, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF7, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7E, 0x3F,
  0x81, 0xE0, 0x1E, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x80,
  0x1E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x1C,
  0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70,
  0x01, 0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x40, 0x1E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x1F, 0x03, 0x80, 0x3C, 0x07, 0x80, 0xF8, 0x07,
  0x81, 0xF0, 0x07, 0x03, 0xE0, 0x07, 0x0F, 0x80, 0x0F, 0x1F, 0x00, 0x0F,
  0x3E, 0x00, 0x0E, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1C, 0xF8, 0x00, 0x1C, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3C,
  0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x78,
  0x03, 0xC0, 0x78, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xFF,
  0xEF, 0xFC, 0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x01, 0x7C,
  0xF7, 0xFF, 0x3F, 0xF0, 0x20, 0x00, 0xF8, 0x3C, 0x07, 0xFE, 0xFE, 0x07,
  0xFF, 0xFF, 0x07, 0x8F, 0xCF, 0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x07, 0x0E,
  0x0F, 0x07, 0x0E, 0x0F, 0x0F, 0x0E, 0x0E, 0x0F, 0x1E, 0x0E, 0x0E, 0x1C,
  0x1E, 0x0E, 0x1C, 0x1E, 0x1E, 0x1C, 0x1C, 0x1E, 0x3C, 0x1C, 0x1C, 0x38,
  0x3C, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x78,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x1F, 0x8F, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x38, 0x01, 0xE1,
  0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00,
  0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x78,
  0x00, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0xCF, 0x00, 0x1C,
  0x78, 0x00, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFC, 0xFC, 0x0F, 0x80, 0x78, 0x3C, 0x01,
  0xE1, 0xE0, 0x03, 0x8F, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF7,
  0x80, 0x03, 0x9E, 0x00, 0x0E, 0x78, 0x00, 0x79, 0xC0, 0x01, 0xEF, 0x00,
  0x07, 0xBC, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x87, 0x00, 0x3E,
  0x1E, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x3E, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x0E, 0x00, 0x78,
  0x0F, 0x00, 0x1C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0x03,
  0xC0, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x38, 0x00,
  0x78, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x00,
  0x1E, 0x03, 0x80, 0x1E, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x3F, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3D, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xC1, 0xE0, 0x7E, 0x03, 0xC1,
  0xF0, 0x07, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70,
  0x00, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00,
  0x1C, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0x83, 0xC0, 0x07, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x7C, 0x07, 0xE7, 0xF0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xC0, 0x20, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0x03, 0xFF, 0xF0, 0x7E, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x60, 0x0F,
  0x0F, 0xEF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x10, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x04, 0x00, 0x0F,
  0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00,
  0x78, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0xF0,
  0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0,
  0x07, 0x87, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xF0, 0x01, 0xC1, 0xC0, 0x0F,
  0x07, 0x00, 0x7C, 0x1E, 0x03, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xF7, 0x01,
  0xFF, 0x1C, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x01,
  0xEF, 0x00, 0x1C, 0xF0, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x07, 0x87, 0x00,
  0x70, 0x70, 0x0F, 0x07, 0x00, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x78,
  0x3C, 0x07, 0x83, 0x80, 0x38, 0x70, 0x03, 0x8F, 0x00, 0x38, 0xE0, 0x03,
  0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xCE, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x71, 0xE0, 0x70,
  0x78, 0xF0, 0x78, 0x38, 0x78, 0x3C, 0x1C, 0x38, 0x3E, 0x1E, 0x1C, 0x3F,
  0x0E, 0x0E, 0x1F, 0x87, 0x07, 0x1D, 0xC7, 0x03, 0x8E, 0xE3, 0x81, 0xCE,
  0x3B, 0xC0, 0xEE, 0x1D, 0xC0, 0x77, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F,
  0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1C, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0x38, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00,
  0x38, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x0F,
  0x00, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x38, 0x0F, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x3C, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x40, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x3F, 0x80, 0x73, 0xFF, 0x03, 0xCF, 0x3E, 0x0E, 0x70, 0x3F,
  0xF3, 0xC0, 0x7F, 0x86, 0x00, 0xFC, 0x00,
};

const GFXglyph UbuntuSansMono_Italic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 12, 32, 25, 7, -31 },
  { 49, 13, 12, 25, 10, -34 },
  { 69, 27, 31, 25, 0, -31 },
  { 174, 23, 40, 25, 2, -35 },
  { 289, 30, 33, 25, -2, -32 },
  { 413, 21, 32, 25, 1, -32 },
  { 497, 6, 13, 25, 14, -34 },
  { 507, 18, 43, 25, 6, -35 },
  { 604, 19, 43, 25, 1, -35 },
  { 707, 19, 18, 25, 5, -31 },
  { 750, 20, 22, 25, 3, -24 },
  { 805, 10, 14, 25, 4, -7 },
  { 823, 11, 3, 25, 8, -14 },
  { 828, 7, 8, 25, 7, -7 },
  { 835, 29, 43, 25, -3, -35 },
  { 991, 21, 33, 25, 3, -32 },
  { 1078, 18, 31, 25, 3, -31 },
  { 1148, 22, 32, 25, 2, -32 },
  { 1236, 22, 33, 25, 2, -32 },
  { 1327, 22, 31, 25, 1, -31 },
  { 1413, 25, 32, 25, 1, -31 },
  { 1513, 23, 32, 25, 3, -31 },
  { 1605, 23, 31, 25, 5, -31 },
  { 1695, 23, 33, 25, 2, -32 },
  { 1790, 23, 32, 25, 2, -32 },
  { 1882, 11, 25, 25, 7, -24 },
  { 1917, 14, 31, 25, 4, -24 },
  { 1972, 22, 20, 25, 2, -23 },
  { 2027, 23, 13, 25, 2, -20 },
  { 2065, 22, 20, 25, 1, -23 },
  { 2120, 18, 33, 25, 6, -32 },
  { 2195, 24, 39, 25, 2, -32 },
  { 2312, 25, 31, 25, -3, -31 },
  { 2409, 24, 32, 25, 0, -32 },
  { 2505, 24, 33, 25, 3, -32 },
  { 2604, 24, 32, 25, 0, -32 },
  { 2700, 25, 31, 25, 2, -31 },
  { 2797, 25, 31, 25, 2, -31 },
  { 2894, 24, 33, 25, 2, -32 },
  { 2993, 27, 31, 25, 0, -31 },
  { 3098, 23, 31, 25, 2, -31 },
  { 3188, 24, 32, 25, 2, -31 },
  { 3284, 27, 31, 25, 1, -31 },
  { 3389, 18, 31, 25, 1, -31 },
  { 3459, 27, 31, 25, -1, -31 },
  { 3564, 27, 31, 25, 0, -31 },
  { 3669, 23, 33, 25, 2, -32 },
  { 3764, 24, 32, 25, 1, -32 },
  { 3860, 23, 40, 25, 2, -32 },
  { 3975, 24, 32, 25, 1, -32 },
  { 4071, 25, 33, 25, 1, -32 },
  { 4175, 22, 31, 25, 6, -31 },
  { 4261, 25, 32, 25, 2, -31 },
  { 4361, 24, 31, 25, 5, -31 },
  { 4454, 27, 31, 25, 1, -31 },
  { 4559, 30, 31, 25, -1, -31 },
  { 4676, 24, 31, 25, 6, -31 },
  { 4769, 27, 31, 25, 0, -31 },
  { 4874, 22, 43, 25, 3, -35 },
  { 4993, 7, 43, 25, 9, -35 },
  { 5031, 23, 43, 25, -1, -35 },
  { 5155, 20, 16, 25, 4, -31 },
  { 5195, 23, 3, 25, -3, 5 },
  { 5204, 8, 9, 25, 12, -35 },
  { 5213, 22, 25, 25, 2, -24 },
  { 5282, 22, 35, 25, 2, -35 },
  { 5379, 22, 25, 25, 2, -24 },
  { 5448, 25, 36, 25, 2, -35 },
  { 5561, 21, 25, 25, 2, -24 },
  { 5627, 29, 43, 25, -1, -35 },
  { 5783, 26, 32, 25, -1, -24 },
  { 5887, 22, 35, 25, 0, -35 },
  { 5984, 14, 34, 25, 5, -34 },
  { 6044, 24, 42, 25, 0, -34 },
  { 6170, 24, 35, 25, 1, -35 },
  { 6275, 12, 36, 25, 8, -35 },
  { 6329, 24, 24, 25, 0, -24 },
  { 6401, 21, 24, 25, 2, -24 },
  { 6464, 22, 25, 25, 2, -24 },
  { 6533, 25, 32, 25, -1, -24 },
  { 6633, 23, 32, 25, 2, -24 },
  { 6725, 21, 24, 25, 3, -24 },
  { 6788, 20, 25, 25, 3, -24 },
  { 6851, 18, 32, 25, 6, -31 },
  { 6923, 22, 24, 25, 2, -23 },
  { 6989, 20, 23, 25, 5, -23 },
  { 7047, 25, 23, 25, 2, -23 },
  { 7119, 26, 23, 25, -1, -23 },
  { 7194, 27, 31, 25, -2, -23 },
  { 7299, 22, 23, 25, 1, -23 },
  { 7363, 25, 43, 25, 2, -35 },
  { 7498, 14, 43, 25, 6, -35 },
  { 7574, 24, 43, 25, -2, -35 },
  { 7703, 22, 7, 25, 2, -17 },
};

const GFXfont UbuntuSansMono_Italic45pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic45pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic45pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _UBUNTUSANSMONO_ITALIC45PT7B_H_
