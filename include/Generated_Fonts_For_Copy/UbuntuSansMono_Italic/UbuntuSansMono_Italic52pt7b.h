#ifndef _UBUNTUSANSMONO_ITALIC52PT7B_H_
#define _UBUNTUSANSMONO_ITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x03,
  0x00, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0xF0, 0x79, 0xE0, 0xF3, 0x81, 0xC7,
  0x03, 0x9E, 0x0F, 0x3C, 0x1E, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x01,
  0x8E, 0x07, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC4, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0xF0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xC0, 0x78, 0x03,
  0xE0, 0x02, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x04, 0x00, 0x0F, 0x80, 0xE0, 0x07, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x01, 0xFF,
  0x00, 0x0F, 0x00, 0x78, 0xE0, 0x03, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0x03,
  0x83, 0xC0, 0x3C, 0x00, 0x70, 0x78, 0x0F, 0x00, 0x1E, 0x0F, 0x03, 0xC0,
  0x03, 0x81, 0xE0, 0x70, 0x00, 0x70, 0x3C, 0x1E, 0x00, 0x0E, 0x07, 0x07,
  0x80, 0x01, 0xC0, 0xE1, 0xE0, 0x00, 0x38, 0x3C, 0x78, 0x00, 0x07, 0x07,
  0x1E, 0x00, 0x00, 0xF1, 0xE7, 0x80, 0x00, 0x1F, 0x78, 0xE0, 0x00, 0x01,
  0xFE, 0x3C, 0x00, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x00, 0x00, 0x0F, 0x1F,
  0xE0, 0x00, 0x01, 0xC7, 0xBE, 0x00, 0x00, 0x79, 0xE1, 0xC0, 0x00, 0x1E,
  0x38, 0x38, 0x00, 0x07, 0x8F, 0x07, 0x00, 0x01, 0xE1, 0xC0, 0xE0, 0x00,
  0x78, 0x38, 0x1C, 0x00, 0x1E, 0x0F, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x70,
  0x00, 0xF0, 0x3C, 0x1E, 0x00, 0x3C, 0x07, 0x83, 0x80, 0x0F, 0x00, 0xF0,
  0x70, 0x03, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0x01, 0xC7, 0x80, 0x3C, 0x00,
  0x3F, 0xE0, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xEF,
  0xC0, 0x07, 0xC1, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x3C,
  0x0F, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x03, 0xCF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xE0,
  0x7F, 0xC0, 0xE0, 0xFD, 0xE0, 0xF0, 0x78, 0xF8, 0x78, 0x78, 0x3C, 0x38,
  0x78, 0x0F, 0x3C, 0x3C, 0x07, 0xDC, 0x3C, 0x01, 0xFE, 0x1E, 0x00, 0xFF,
  0x0F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0x83, 0xE0, 0x07,
  0xE1, 0xF0, 0x07, 0xF0, 0x7C, 0x07, 0xFC, 0x3F, 0x0F, 0xDE, 0x0F, 0xFF,
  0xCF, 0x03, 0xFF, 0x87, 0xC0, 0xFF, 0x03, 0xE0, 0x3E, 0x78, 0xF1, 0xE7,
  0xCF, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x01, 0x01,
  0xE0, 0x27, 0x03, 0x83, 0x9F, 0x0E, 0x3E, 0xFF, 0xB3, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x3C, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x81, 0xF0,
  0x3E, 0x03, 0xC0, 0x70, 0x02, 0x01, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x80,
  0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0xFC, 0x7F, 0x8F, 0xF0, 0xFC, 0x0F, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x18, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xC1, 0xF0,
  0x0F, 0x80, 0x78, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07,
  0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00,
  0x78, 0xF0, 0x00, 0x3C, 0xF8, 0x20, 0x1E, 0x78, 0x7C, 0x1F, 0x7C, 0x7F,
  0x0F, 0xBE, 0x3F, 0x87, 0x9E, 0x1F, 0xC3, 0xCF, 0x0F, 0xE1, 0xE7, 0x83,
  0xE1, 0xF7, 0xC1, 0xE0, 0xF3, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x7C, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x87, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0,
  0x78, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xBC, 0x07, 0xE3, 0xC0, 0x78, 0x3C, 0x02, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0x80, 0x38, 0x01, 0xF0, 0x08, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x70, 0x1F, 0x80, 0x10, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x40, 0x01,
  0xF8, 0x1E, 0x01, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x8F, 0x00,
  0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x1E,
  0x00, 0x78, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x04, 0x00, 0x3F, 0x80, 0x38,
  0x07, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xE0, 0x0F, 0xC1, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01,
  0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x03, 0xE0,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x40, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x7C, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xC7, 0xF0,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF8, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE0,
  0xF8, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x07,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1F, 0x80, 0x7F,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xC0, 0x7C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0xE0, 0x3F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x40, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x01, 0xF8,
  0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x1F, 0xF1, 0xF0,
  0x0F, 0xFF, 0x1E, 0x03, 0xFF, 0xF3, 0xE0, 0x7F, 0xFE, 0x3E, 0x0F, 0x81,
  0xE3, 0xC1, 0xF0, 0x1E, 0x7C, 0x3E, 0x03, 0xE7, 0xC3, 0xC0, 0x3C, 0x78,
  0x3C, 0x03, 0xC7, 0x87, 0x80, 0x3C, 0x78, 0x78, 0x07, 0xCF, 0x87, 0x80,
  0x78, 0xF8, 0x78, 0x07, 0x8F, 0x07, 0x80, 0x78, 0xF0, 0x78, 0x07, 0x8F,
  0x07, 0x80, 0xF0, 0xF0, 0x78, 0x0F, 0x0F, 0x07, 0xC0, 0xF0, 0xF0, 0x3E,
  0x0F, 0x0F, 0x81, 0xFF, 0xE0, 0xF8, 0x0F, 0xFE, 0x07, 0x80, 0x7F, 0xC0,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00,
  0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0xE0, 0x1E,
  0x00, 0x7E, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x0F, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x0F, 0x00, 0x3F, 0x01, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x07,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xE0, 0xF0, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x7E, 0x01, 0xE0, 0x1F, 0x80, 0x06, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x10, 0x03, 0xF8, 0x0F, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0x03, 0xF8, 0x01, 0xE0, 0x0F, 0xC0, 0x1E, 0x00, 0x3E, 0x01, 0xE0, 0x03,
  0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3C,
  0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x83, 0xC0,
  0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xE0, 0x78, 0x00, 0xFC,
  0x07, 0x80, 0x3F, 0x80, 0x7C, 0x3F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xC0, 0x3C, 0x03, 0xE0, 0x01,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x8F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x1E,
  0x03, 0xE0, 0x03, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x1E, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x78, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78,
  0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x78, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x04, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x20, 0x01, 0xF0, 0x03, 0x00, 0x1F, 0x00, 0x7C, 0x07,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7E, 0x01, 0xE0, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0x3C, 0x01, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E,
  0x3F, 0x00, 0x00, 0x78, 0xFC, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0x80,
  0x01, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1D,
  0xC0, 0x7F, 0x00, 0x3B, 0x80, 0xEE, 0x00, 0x77, 0x03, 0xDC, 0x01, 0xCE,
  0x07, 0x38, 0x03, 0x9C, 0x1C, 0xF0, 0x0F, 0x38, 0x39, 0xE0, 0x1E, 0x70,
  0xE3, 0x80, 0x38, 0xF1, 0xC7, 0x00, 0xF1, 0xE7, 0x0E, 0x01, 0xE3, 0xDE,
  0x3C, 0x03, 0x83, 0xB8, 0x78, 0x07, 0x07, 0xE0, 0xF0, 0x1E, 0x0F, 0xC1,
  0xC0, 0x3C, 0x1F, 0x07, 0x80, 0x70, 0x3E, 0x0F, 0x01, 0xE0, 0x78, 0x1E,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x78, 0x07, 0xE0, 0x00, 0xF0, 0x0F,
  0xE0, 0x01, 0xC0, 0x1F, 0xC0, 0x07, 0x80, 0x3B, 0x80, 0x0F, 0x00, 0xF7,
  0x80, 0x1E, 0x01, 0xEF, 0x00, 0x38, 0x03, 0x9E, 0x00, 0xF0, 0x07, 0x1C,
  0x01, 0xE0, 0x1E, 0x3C, 0x03, 0xC0, 0x3C, 0x78, 0x07, 0x00, 0x78, 0x70,
  0x1E, 0x00, 0xE0, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x78, 0x07, 0x83, 0xC0,
  0xE0, 0x0F, 0x03, 0x83, 0xC0, 0x1C, 0x07, 0x87, 0x80, 0x78, 0x0F, 0x0F,
  0x00, 0xF0, 0x1E, 0x1E, 0x01, 0xE0, 0x1C, 0x38, 0x03, 0x80, 0x38, 0xF0,
  0x0F, 0x00, 0x79, 0xE0, 0x1E, 0x00, 0xF3, 0xC0, 0x3C, 0x01, 0xE7, 0x00,
  0x70, 0x01, 0xDE, 0x01, 0xE0, 0x03, 0xBC, 0x03, 0xC0, 0x07, 0x78, 0x07,
  0x80, 0x0F, 0xE0, 0x0E, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x1F, 0x80, 0x78,
  0x00, 0x3F, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x3C,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F,
  0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0xFE, 0x00, 0xF0, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0,
  0x78, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x01, 0xF8, 0x0F, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x3C, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x07, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x81, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xF0, 0x0F, 0xE0,
  0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x1F, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x81, 0xE0, 0x0F, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0x80, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80,
  0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7C, 0x00, 0x10, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x30, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x03, 0xC0, 0x70, 0x0E, 0x07, 0xC1,
  0xE0, 0x3C, 0x1F, 0x83, 0xC0, 0x78, 0x7F, 0x07, 0x00, 0xF0, 0xEE, 0x0E,
  0x01, 0xC3, 0xDC, 0x3C, 0x03, 0x87, 0x38, 0x70, 0x07, 0x1E, 0x70, 0xE0,
  0x1E, 0x38, 0xE3, 0xC0, 0x38, 0xE1, 0xC7, 0x00, 0x73, 0xC3, 0x8E, 0x00,
  0xE7, 0x07, 0x1C, 0x01, 0xDE, 0x0F, 0x70, 0x03, 0xB8, 0x1E, 0xE0, 0x0E,
  0xF0, 0x1D, 0xC0, 0x1D, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7C, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x01,
  0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x01,
  0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0xF8,
  0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C,
  0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x0F, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0x78,
  0x00, 0xF8, 0x70, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x1F, 0x01, 0xC0,
  0x7C, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x0F, 0x00, 0x0F, 0x3E,
  0x00, 0x1E, 0xF8, 0x00, 0x1D, 0xE0, 0x00, 0x3C, 0x80, 0x00, 0x60, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x10, 0x1E, 0x0F, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x40, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x07, 0x80, 0xFC, 0x01, 0xE0, 0x7C, 0x00,
  0xF0, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3E, 0x00,
  0x1E, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x07, 0xE0, 0x7C, 0x07, 0xF8, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xF7, 0x80, 0x3F, 0xF0, 0xF0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x18, 0x00, 0x1E, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xE0, 0x07, 0xC1, 0xE0, 0x03,
  0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80,
  0x01, 0xE3, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF8, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x1E,
  0x00, 0x7E, 0x0F, 0x00, 0xFE, 0x0F, 0x03, 0xFE, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0x80, 0x30, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x10, 0x3F, 0x00, 0x78, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFC, 0x07, 0x00, 0x3F, 0x80, 0x78, 0x03, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0x80, 0x3E, 0x00, 0x3C, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x7F, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xF9, 0xE0, 0x01, 0xFF, 0x8F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F,
  0x81, 0xF0, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x9F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE7,
  0x80, 0x07, 0xE3, 0xC0, 0x7F, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x10, 0x3F, 0x00, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x0C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x78, 0x01, 0xFC, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF0,
  0x0F, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07,
  0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x78, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x20, 0x00, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x08, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x07, 0xC0, 0xF0, 0x03,
  0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0,
  0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xF3, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x04, 0x00, 0x78, 0x00, 0xC0, 0x1F,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0xFC, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x0F, 0x80, 0x1E, 0x07, 0xE0, 0x03, 0xC1, 0xF8, 0x00, 0xF0,
  0x7C, 0x00, 0x1E, 0x3F, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x7E,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x01,
  0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x01, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x7F, 0xFB, 0xFF, 0xCF, 0xFF, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x0D, 0xFF,
  0xF3, 0xFF, 0xC7, 0xFF, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x1F, 0xF9,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x07, 0x83, 0xF1, 0xF0,
  0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x0F, 0x03,
  0xC0, 0xF0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x1E,
  0x0E, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x1C, 0x1E, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x3C, 0x1C, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x38, 0x3C, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7C, 0x07, 0xE0,
  0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x0F,
  0x07, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0,
  0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x0F,
  0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0,
  0x7E, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x3E,
  0x00, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00,
  0x7C, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x3F, 0x00,
  0xF0, 0x07, 0xE0, 0x1E, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xC0, 0xF8, 0x3F, 0x00, 0x78, 0x3F,
  0x00, 0x3C, 0x3F, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE3,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x07, 0xF0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xBC, 0x00, 0x1C, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0x00, 0x10, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0x0E, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x40, 0x01, 0xF0, 0x78, 0x07, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x30, 0x1F, 0xFF,
  0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xE0, 0x0F, 0xC0, 0xF8, 0x1F, 0xE0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0x78, 0x07, 0xFE, 0x1E, 0x00, 0x30, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03,
  0xCF, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0xF8,
  0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x3E, 0x07,
  0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x7C,
  0x1E, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xCF,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xC7, 0x80, 0xE0, 0x3C, 0x78,
  0x1E, 0x03, 0x87, 0x81, 0xE0, 0x78, 0x78, 0x3E, 0x07, 0x87, 0x03, 0xE0,
  0xF0, 0xF0, 0x7F, 0x0F, 0x0F, 0x0F, 0xF0, 0xE0, 0xF0, 0xEF, 0x1E, 0x0F,
  0x1E, 0x71, 0xE0, 0xF1, 0xC7, 0x3C, 0x0F, 0x38, 0x73, 0xC0, 0xF7, 0x87,
  0x38, 0x0F, 0x70, 0x77, 0x80, 0xFF, 0x07, 0x78, 0x0F, 0xE0, 0x7F, 0x00,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x0F, 0xC7, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0x3C,
  0x00, 0x1F, 0x80, 0xF0, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x80,
  0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x40, 0x7E, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x03, 0x0F, 0xF8, 0x03, 0xCF, 0xFF, 0x03, 0xCF, 0x8F, 0xC3,
  0xE7, 0x03, 0xFF, 0xE7, 0x80, 0x7F, 0xE3, 0x80, 0x1F, 0xE0, 0x00, 0x03,
  0x80,
};

const GFXglyph UbuntuSansMono_Italic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 13, 37, 29, 8, -36 },
  { 62, 15, 14, 29, 11, -40 },
  { 89, 31, 36, 29, 0, -36 },
  { 229, 27, 46, 29, 2, -40 },
  { 385, 35, 38, 29, -2, -37 },
  { 552, 25, 37, 29, 1, -37 },
  { 668, 7, 15, 29, 16, -40 },
  { 682, 21, 51, 29, 7, -41 },
  { 816, 22, 51, 29, 1, -41 },
  { 957, 22, 21, 29, 6, -36 },
  { 1015, 24, 25, 29, 3, -28 },
  { 1090, 12, 16, 29, 4, -8 },
  { 1114, 12, 4, 29, 9, -17 },
  { 1120, 8, 9, 29, 8, -8 },
  { 1129, 33, 51, 29, -3, -41 },
  { 1340, 25, 38, 29, 3, -37 },
  { 1459, 20, 36, 29, 4, -36 },
  { 1549, 26, 37, 29, 2, -37 },
  { 1670, 26, 38, 29, 2, -37 },
  { 1794, 26, 36, 29, 1, -36 },
  { 1911, 29, 37, 29, 1, -36 },
  { 2046, 26, 37, 29, 4, -36 },
  { 2167, 26, 36, 29, 6, -36 },
  { 2284, 26, 38, 29, 3, -37 },
  { 2408, 27, 37, 29, 2, -37 },
  { 2533, 13, 28, 29, 8, -27 },
  { 2579, 17, 35, 29, 4, -27 },
  { 2654, 26, 23, 29, 2, -26 },
  { 2729, 26, 15, 29, 2, -23 },
  { 2778, 26, 23, 29, 1, -26 },
  { 2853, 21, 38, 29, 7, -37 },
  { 2953, 28, 45, 29, 2, -37 },
  { 3111, 28, 36, 29, -3, -36 },
  { 3237, 27, 36, 29, 1, -36 },
  { 3359, 28, 38, 29, 3, -37 },
  { 3492, 28, 36, 29, 0, -36 },
  { 3618, 29, 36, 29, 2, -36 },
  { 3749, 29, 36, 29, 2, -36 },
  { 3880, 27, 38, 29, 3, -37 },
  { 4009, 31, 36, 29, 0, -36 },
  { 4149, 26, 36, 29, 3, -36 },
  { 4266, 28, 37, 29, 2, -36 },
  { 4396, 31, 36, 29, 1, -36 },
  { 4536, 21, 36, 29, 1, -36 },
  { 4631, 31, 36, 29, -1, -36 },
  { 4771, 31, 36, 29, 0, -36 },
  { 4911, 26, 38, 29, 3, -37 },
  { 5035, 28, 36, 29, 1, -36 },
  { 5161, 26, 47, 29, 3, -37 },
  { 5314, 27, 36, 29, 1, -36 },
  { 5436, 29, 38, 29, 1, -37 },
  { 5574, 25, 36, 29, 7, -36 },
  { 5687, 28, 37, 29, 3, -36 },
  { 5817, 27, 36, 29, 6, -36 },
  { 5939, 31, 36, 29, 2, -36 },
  { 6079, 35, 36, 29, -2, -36 },
  { 6237, 28, 36, 29, 6, -36 },
  { 6363, 31, 36, 29, 0, -36 },
  { 6503, 25, 51, 29, 4, -41 },
  { 6663, 8, 51, 29, 11, -41 },
  { 6714, 26, 51, 29, -1, -41 },
  { 6880, 23, 19, 29, 5, -36 },
  { 6935, 27, 4, 29, -4, 6 },
  { 6949, 10, 10, 29, 13, -40 },
  { 6962, 26, 29, 29, 2, -28 },
  { 7057, 25, 41, 29, 2, -40 },
  { 7186, 25, 29, 29, 2, -28 },
  { 7277, 29, 41, 29, 3, -40 },
  { 7426, 25, 29, 29, 2, -28 },
  { 7517, 34, 50, 29, -1, -40 },
  { 7730, 30, 38, 29, -1, -28 },
  { 7873, 25, 40, 29, 0, -40 },
  { 7998, 16, 40, 29, 6, -40 },
  { 8078, 27, 50, 29, 0, -40 },
  { 8247, 27, 40, 29, 2, -40 },
  { 8382, 14, 41, 29, 9, -40 },
  { 8454, 28, 28, 29, 0, -28 },
  { 8552, 25, 28, 29, 2, -28 },
  { 8640, 24, 29, 29, 3, -28 },
  { 8727, 28, 38, 29, -1, -28 },
  { 8860, 25, 38, 29, 3, -28 },
  { 8979, 25, 28, 29, 3, -28 },
  { 9067, 24, 29, 29, 3, -28 },
  { 9154, 21, 36, 29, 6, -35 },
  { 9249, 25, 28, 29, 3, -27 },
  { 9337, 23, 27, 29, 6, -27 },
  { 9415, 28, 27, 29, 3, -27 },
  { 9510, 30, 27, 29, -1, -27 },
  { 9612, 32, 37, 29, -3, -27 },
  { 9760, 26, 27, 29, 1, -27 },
  { 9848, 28, 51, 29, 3, -41 },
  { 10027, 16, 51, 29, 7, -41 },
  { 10129, 28, 51, 29, -2, -41 },
  { 10308, 25, 8, 29, 3, -19 },
};

const GFXfont UbuntuSansMono_Italic52pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic52pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic52pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _UBUNTUSANSMONO_ITALIC52PT7B_H_
