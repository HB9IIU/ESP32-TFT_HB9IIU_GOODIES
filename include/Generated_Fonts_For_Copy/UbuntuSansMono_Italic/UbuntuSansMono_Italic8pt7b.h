#ifndef _UBUNTUSANSMONO_ITALIC8PT7B_H_
#define _UBUNTUSANSMONO_ITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xF0, 0x29, 0x54, 0xAF, 0x50, 0x17, 0x43, 0x1E, 0x40,
  0x4D, 0xB8, 0x67, 0x58, 0x25, 0x67, 0xAF, 0xC0, 0x2A, 0x49, 0x30, 0x21,
  0x11, 0x22, 0xC0, 0x5D, 0x50, 0x2F, 0x24, 0xE0, 0xC0, 0xC0, 0x0C, 0x21,
  0x04, 0x21, 0x0C, 0x00, 0x35, 0x5B, 0x96, 0x39, 0x25, 0xC0, 0x71, 0x12,
  0x4F, 0x31, 0x13, 0x1E, 0x13, 0x59, 0xF2, 0x39, 0x18, 0x21, 0x70, 0x34,
  0xCA, 0xAE, 0xF2, 0x24, 0x88, 0x35, 0x57, 0x9F, 0x35, 0x57, 0x1E, 0x43,
  0x43, 0x80, 0x3C, 0x70, 0x7F, 0x61, 0xE0, 0x64, 0xA1, 0x00, 0x32, 0x57,
  0x6D, 0x59, 0x80, 0x13, 0x55, 0xF9, 0x25, 0x5B, 0x9E, 0x3A, 0x11, 0x08,
  0x38, 0x65, 0x59, 0x9E, 0x3A, 0x10, 0xE4, 0x78, 0x3A, 0x10, 0xE4, 0x40,
  0x3A, 0x11, 0x29, 0x38, 0x4A, 0x55, 0x69, 0x48, 0x32, 0x22, 0x2E, 0x38,
  0x44, 0x21, 0x70, 0x4A, 0x98, 0x8A, 0x48, 0x49, 0x29, 0xC0, 0x4A, 0x95,
  0x69, 0x48, 0x4A, 0x5B, 0x69, 0x48, 0x32, 0x53, 0x19, 0x30, 0x35, 0x57,
  0x88, 0x32, 0x53, 0x19, 0x31, 0x80, 0x25, 0x56, 0xA9, 0x3A, 0x10, 0x61,
  0x70, 0xF4, 0x44, 0x48, 0x4A, 0x53, 0x29, 0x30, 0x99, 0xAA, 0xC8, 0x4A,
  0x53, 0x6D, 0x50, 0x49, 0x8C, 0x45, 0x48, 0x99, 0xA4, 0x48, 0x78, 0x88,
  0x44, 0x78, 0x74, 0x48, 0x88, 0xC0, 0xFE, 0x31, 0x22, 0x22, 0xC0, 0x2E,
  0x80, 0xF8, 0xC0, 0x79, 0x9F, 0x44, 0x75, 0x9E, 0x78, 0x87, 0x08, 0x5D,
  0x29, 0x38, 0x7B, 0xC7, 0x19, 0x1E, 0x44, 0x21, 0x10, 0x75, 0x97, 0x2C,
  0x44, 0x79, 0x99, 0x4D, 0x90, 0x10, 0x31, 0x22, 0x2C, 0x44, 0x56, 0xA9,
  0xC9, 0x29, 0xC0, 0x7B, 0x99, 0x75, 0x99, 0x79, 0x96, 0x75, 0x9E, 0x80,
  0x79, 0x96, 0x20, 0xF2, 0x40, 0x76, 0x1E, 0x5E, 0x4E, 0x59, 0x9F, 0xB7,
  0x40, 0x8D, 0xBD, 0x40, 0x59, 0x19, 0x20, 0x55, 0x52, 0x48, 0x72, 0x4E,
  0x39, 0x09, 0x84, 0x21, 0x80, 0x29, 0x25, 0x20, 0x71, 0x21, 0x22, 0xC0,
  0xF0,
};

const GFXglyph UbuntuSansMono_Italic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 6, 4, 1, -6 },
  { 3, 2, 2, 4, 2, -6 },
  { 4, 5, 6, 4, 0, -6 },
  { 8, 4, 7, 4, 0, -6 },
  { 12, 5, 6, 4, 0, -6 },
  { 16, 4, 6, 4, 0, -6 },
  { 19, 1, 2, 4, 2, -6 },
  { 20, 3, 7, 4, 1, -6 },
  { 23, 4, 7, 4, 0, -6 },
  { 27, 3, 4, 4, 1, -6 },
  { 29, 4, 4, 4, 0, -4 },
  { 31, 2, 2, 4, 1, -1 },
  { 32, 2, 1, 4, 1, -3 },
  { 33, 2, 1, 4, 1, -1 },
  { 34, 6, 7, 4, -1, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 3, 6, 4, 1, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 5, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 1, -6 },
  { 62, 4, 6, 4, 1, -6 },
  { 65, 4, 6, 4, 0, -6 },
  { 68, 4, 6, 4, 0, -6 },
  { 71, 2, 4, 4, 1, -4 },
  { 72, 2, 5, 4, 1, -4 },
  { 74, 4, 3, 4, 0, -4 },
  { 76, 4, 2, 4, 0, -3 },
  { 77, 4, 3, 4, 0, -4 },
  { 79, 3, 6, 4, 1, -6 },
  { 82, 5, 7, 4, 0, -6 },
  { 87, 4, 6, 4, 0, -6 },
  { 90, 4, 6, 4, 0, -6 },
  { 93, 5, 6, 4, 0, -6 },
  { 97, 4, 6, 4, 0, -6 },
  { 100, 5, 6, 4, 0, -6 },
  { 104, 5, 6, 4, 0, -6 },
  { 108, 5, 6, 4, 0, -6 },
  { 112, 5, 6, 4, 0, -6 },
  { 116, 4, 6, 4, 0, -6 },
  { 119, 5, 6, 4, 0, -6 },
  { 123, 5, 6, 4, 0, -6 },
  { 127, 3, 6, 4, 0, -6 },
  { 130, 5, 6, 4, 0, -6 },
  { 134, 5, 6, 4, 0, -6 },
  { 138, 5, 6, 4, 0, -6 },
  { 142, 4, 6, 4, 0, -6 },
  { 145, 5, 7, 4, 0, -6 },
  { 150, 4, 6, 4, 0, -6 },
  { 153, 5, 6, 4, 0, -6 },
  { 157, 4, 6, 4, 1, -6 },
  { 160, 5, 6, 4, 0, -6 },
  { 164, 4, 6, 4, 1, -6 },
  { 167, 5, 6, 4, 0, -6 },
  { 171, 5, 6, 4, 0, -6 },
  { 175, 4, 6, 4, 1, -6 },
  { 178, 5, 6, 4, 0, -6 },
  { 182, 4, 7, 4, 1, -6 },
  { 186, 1, 7, 4, 2, -6 },
  { 187, 4, 7, 4, 0, -6 },
  { 191, 3, 3, 4, 1, -6 },
  { 193, 5, 1, 4, -1, 1 },
  { 194, 2, 1, 4, 2, -6 },
  { 195, 4, 4, 4, 0, -4 },
  { 197, 4, 6, 4, 0, -6 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 5, 6, 4, 0, -6 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 5, 8, 4, 0, -6 },
  { 213, 4, 6, 4, 0, -4 },
  { 216, 4, 6, 4, 0, -6 },
  { 219, 2, 6, 4, 1, -6 },
  { 221, 4, 8, 4, 0, -6 },
  { 225, 4, 6, 4, 0, -6 },
  { 228, 3, 6, 4, 1, -6 },
  { 231, 4, 4, 4, 0, -4 },
  { 233, 4, 4, 4, 0, -4 },
  { 235, 4, 4, 4, 0, -4 },
  { 237, 4, 5, 4, 0, -4 },
  { 240, 4, 5, 4, 0, -4 },
  { 243, 3, 4, 4, 1, -4 },
  { 245, 4, 4, 4, 0, -4 },
  { 247, 3, 5, 4, 1, -5 },
  { 249, 4, 4, 4, 0, -4 },
  { 251, 3, 4, 4, 1, -4 },
  { 253, 5, 4, 4, 0, -4 },
  { 256, 5, 4, 4, 0, -4 },
  { 259, 4, 6, 4, 0, -4 },
  { 262, 4, 4, 4, 0, -4 },
  { 264, 5, 7, 4, 0, -6 },
  { 269, 3, 7, 4, 1, -6 },
  { 272, 4, 7, 4, 0, -6 },
  { 276, 4, 1, 4, 0, -3 },
};

const GFXfont UbuntuSansMono_Italic8pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic8pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _UBUNTUSANSMONO_ITALIC8PT7B_H_
