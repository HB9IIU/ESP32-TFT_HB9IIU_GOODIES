#ifndef _UBUNTUSANSMONO_ITALIC59PT7B_H_
#define _UBUNTUSANSMONO_ITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x70, 0x00, 0x1E, 0x07, 0x9E, 0x03,
  0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x78, 0xF0,
  0x3C, 0x78, 0x1E, 0x38, 0x0E, 0x3C, 0x07, 0x1E, 0x03, 0x8E, 0x03, 0x87,
  0x01, 0xC3, 0x00, 0xE1, 0x80, 0x60, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xC0, 0x3E, 0x00, 0xFC, 0x00, 0x10, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x02, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x1F, 0x80,
  0x7F, 0xCF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x00, 0xF0,
  0x03, 0xE7, 0x80, 0x03, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x3E, 0x00, 0x38, 0x1E, 0x00, 0xF8, 0x00, 0xF0, 0x3C, 0x03, 0xE0,
  0x01, 0xE0, 0x78, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x1E, 0x00, 0x0F, 0x01,
  0xE0, 0x78, 0x00, 0x1E, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x07, 0x07, 0xC0,
  0x00, 0x78, 0x1E, 0x1F, 0x00, 0x00, 0xF0, 0x3C, 0x7C, 0x00, 0x01, 0xE0,
  0xF0, 0xF0, 0x00, 0x03, 0xE1, 0xE3, 0xC0, 0x00, 0x03, 0xE7, 0x8F, 0x00,
  0x00, 0x07, 0xFE, 0x3C, 0x00, 0x00, 0x07, 0xF8, 0xF8, 0x00, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x0C,
  0x00, 0x00, 0x00, 0x78, 0xFF, 0x00, 0x00, 0x01, 0xE3, 0xFF, 0x00, 0x00,
  0x07, 0x8F, 0xBE, 0x00, 0x00, 0x1F, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0x78,
  0x3C, 0x00, 0x01, 0xF0, 0xE0, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0xF0, 0x00,
  0x0F, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x3C,
  0x07, 0x80, 0x03, 0xE0, 0x78, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x3C, 0x00,
  0x3E, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x07,
  0x83, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x7C, 0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x00, 0xF9, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x1E, 0x07, 0xFC, 0x03, 0xC1, 0xFF, 0xC0, 0xF8, 0x7E, 0x7C, 0x1E,
  0x1F, 0x0F, 0x83, 0xC7, 0xC0, 0xF8, 0xF8, 0xF0, 0x1F, 0x1E, 0x3E, 0x01,
  0xF3, 0xC7, 0x80, 0x1F, 0xF1, 0xF0, 0x03, 0xFE, 0x3E, 0x00, 0x3F, 0x87,
  0xC0, 0x07, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF8, 0x7C, 0x00, 0x7F, 0x0F, 0x80, 0x3F, 0xE1, 0xF8, 0x0F, 0xFE, 0x1F,
  0xFF, 0xF7, 0xC3, 0xFF, 0xF8, 0xF8, 0x3F, 0xFE, 0x0F, 0x81, 0xFF, 0x01,
  0xF0, 0x06, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C,
  0x7C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0x00, 0xF0, 0x04, 0xE0, 0x38,
  0x1E, 0x7E, 0x1C, 0x3F, 0x7F, 0xCE, 0x7F, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x7C, 0x07, 0xC0, 0x1C, 0x03, 0xC0,
  0x02, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0xC0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x07, 0xE0, 0x7F, 0x0F, 0xF8, 0x3F, 0xC0, 0xFC, 0x03, 0xC0,
  0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x1F, 0x9F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8,
  0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xFC,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x1F, 0x1F, 0x03, 0x00, 0xF9, 0xF0, 0x7E, 0x07, 0xCF, 0x87, 0xF0, 0x3C,
  0x7C, 0x3F, 0xC3, 0xE3, 0xE1, 0xFE, 0x1F, 0x3E, 0x0F, 0xF0, 0xF9, 0xF0,
  0x7F, 0x07, 0xCF, 0x83, 0xF8, 0x7C, 0x7C, 0x0F, 0x83, 0xE3, 0xE0, 0x00,
  0x1F, 0x1E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x00, 0xFF, 0x7F, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0x7C, 0x01, 0xFC, 0x78, 0x01, 0xF0, 0xF8,
  0x01, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0x80, 0x07, 0xE0, 0x08, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0xFF, 0x00, 0x1C, 0x00,
  0xFC, 0x00, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x04, 0x00, 0x03, 0xF8, 0x38, 0x00, 0x7F, 0x81, 0xFF, 0x7F, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x0F, 0xC7, 0x80, 0x00, 0x7E, 0x1E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x60, 0x01, 0xFE, 0x00, 0x7E, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x0F, 0xF0, 0x00, 0x7D, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0,
  0x1F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0x83, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xF8,
  0x3F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x01, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xF1, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFB, 0xE0,
  0x00, 0x7F, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1F,
  0x80, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x40, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0x80, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xF9, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x0F, 0x0F, 0xC0, 0x0F, 0xFF, 0x0F, 0x80, 0x3F, 0xFF, 0x1F, 0x80,
  0xFF, 0xFF, 0x1F, 0x01, 0xFF, 0xFE, 0x1F, 0x03, 0xF0, 0x3E, 0x3E, 0x07,
  0xE0, 0x3E, 0x3E, 0x0F, 0xC0, 0x3E, 0x3E, 0x0F, 0x80, 0x3C, 0x3E, 0x1F,
  0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x7C, 0x7C, 0x3E,
  0x00, 0x78, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x3E, 0x00, 0xF8, 0xF8, 0x3E,
  0x00, 0xF8, 0xF8, 0x3E, 0x00, 0xF0, 0xF8, 0x3E, 0x01, 0xF0, 0xF8, 0x3E,
  0x01, 0xF0, 0xF8, 0x1E, 0x01, 0xF0, 0xF8, 0x1F, 0x01, 0xE0, 0xF8, 0x1F,
  0x81, 0xE0, 0x78, 0x0F, 0xFF, 0xE0, 0x7C, 0x07, 0xFF, 0xE0, 0x7C, 0x03,
  0xFF, 0xC0, 0x7C, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x70, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x7C, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC1, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x07,
  0xC0, 0x07, 0xE0, 0x0F, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xC0,
  0x03, 0xF8, 0x07, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0xFC, 0x07, 0x80, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x8F, 0xF0, 0x01, 0xFC, 0x00,
  0x70, 0x01, 0xF8, 0x00, 0x10, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x70,
  0x00, 0x7F, 0xC1, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xF8, 0x07, 0xF8, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xE0, 0x3C, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x7F, 0x00, 0x78, 0x03,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x40, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0x80, 0x3F, 0x00,
  0x02, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x3C, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xF0, 0x03,
  0xE0, 0x07, 0xF8, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x03, 0x00,
  0x07, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x1F,
  0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x00, 0xF0, 0x3F, 0x00, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x1E, 0x3F, 0x00, 0x00,
  0x03, 0xCF, 0xC0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xF0,
  0x01, 0xFE, 0x01, 0xEE, 0x00, 0x3B, 0xC0, 0x3F, 0xC0, 0x07, 0x78, 0x0F,
  0x78, 0x01, 0xEF, 0x01, 0xCF, 0x00, 0x3D, 0xE0, 0x79, 0xE0, 0x07, 0x1C,
  0x0E, 0x38, 0x01, 0xE3, 0x83, 0xCF, 0x00, 0x3C, 0x78, 0x71, 0xE0, 0x07,
  0x0F, 0x1E, 0x3C, 0x01, 0xE1, 0xE7, 0x87, 0x80, 0x3C, 0x3C, 0xE0, 0xF0,
  0x07, 0x87, 0xBC, 0x3E, 0x01, 0xE0, 0xF7, 0x07, 0x80, 0x3C, 0x1F, 0xE0,
  0xF0, 0x07, 0x83, 0xF8, 0x1E, 0x01, 0xF0, 0x7F, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0xF8, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0x1E, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x07, 0xF0, 0x00, 0x1E, 0x00,
  0x7F, 0x00, 0x03, 0xE0, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x03,
  0xC0, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0xF7, 0xC0, 0x07, 0xC0, 0x0F, 0x3C,
  0x00, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x80, 0x0F, 0x3E, 0x00, 0x78, 0x01,
  0xE1, 0xE0, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0xF0, 0x01, 0xE1, 0xE0, 0x0F,
  0x00, 0x1E, 0x1F, 0x00, 0xF0, 0x03, 0xE0, 0xF0, 0x1F, 0x00, 0x3C, 0x0F,
  0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x81, 0xE0, 0x07,
  0xC0, 0x78, 0x1E, 0x00, 0x78, 0x07, 0x83, 0xE0, 0x07, 0x80, 0x78, 0x3C,
  0x00, 0x78, 0x07, 0xC3, 0xC0, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0x03,
  0xC7, 0xC0, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0x03, 0xC7, 0x80, 0x1F,
  0x00, 0x1C, 0x78, 0x01, 0xE0, 0x01, 0xEF, 0x80, 0x1E, 0x00, 0x1E, 0xF0,
  0x01, 0xE0, 0x01, 0xEF, 0x00, 0x1E, 0x00, 0x1E, 0xF0, 0x03, 0xE0, 0x00,
  0xFF, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x3C,
  0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x0F, 0xC0,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x0F,
  0x80, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01,
  0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x1F,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0x80, 0x1F, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x3F,
  0x00, 0x78, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0xFC, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x00,
  0x1F, 0x80, 0x78, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x7C,
  0x78, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x3C, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x1F, 0x81, 0xF0, 0x0F, 0x07, 0xF0, 0x3C, 0x01, 0xE0, 0xFE, 0x07, 0x80,
  0x78, 0x3D, 0xC0, 0xF0, 0x0F, 0x07, 0xB8, 0x3C, 0x01, 0xE1, 0xE7, 0x87,
  0x80, 0x3C, 0x38, 0xF0, 0xF0, 0x07, 0x8F, 0x1E, 0x3C, 0x00, 0xE3, 0xC3,
  0xC7, 0x80, 0x1C, 0x78, 0x78, 0xF0, 0x07, 0x9E, 0x07, 0x1C, 0x00, 0xF3,
  0xC0, 0xE7, 0x80, 0x1E, 0xF0, 0x1C, 0xF0, 0x03, 0x9E, 0x03, 0x9C, 0x00,
  0x77, 0x80, 0x77, 0x80, 0x0F, 0xE0, 0x0E, 0xF0, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x78, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F,
  0x80, 0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E,
  0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0xF8, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x07, 0x80, 0x0F, 0x81, 0xE0,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x03, 0xC0, 0xFC, 0x00,
  0xF0, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE7, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xC4, 0x00, 0x00, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x08, 0x07, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF0, 0x0F, 0x00, 0xFE, 0x00, 0x78, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00,
  0x3E, 0x0F, 0xC0, 0x01, 0xE0, 0xFC, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x3C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0,
  0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0x07,
  0xFE, 0x01, 0xFF, 0xFE, 0xF0, 0x07, 0xFF, 0xE7, 0x80, 0x1F, 0xFC, 0x3E,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x3C,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x7E, 0x0F, 0x80, 0x0F, 0xE0, 0x7C, 0x00, 0xFE, 0x03, 0xC0, 0x1F, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0,
  0x02, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x3F, 0xC0, 0x7E,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xE0,
  0x1E, 0x00, 0x3F, 0xC0, 0x0F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x07, 0x80, 0x1F, 0x80, 0x03, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x80,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0xF0, 0x00, 0x3F, 0xF8, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF0, 0xFC, 0x00, 0x0F, 0x1F, 0x80, 0x00,
  0xF1, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0x3C,
  0x00, 0x07, 0xE7, 0xC0, 0x01, 0xFC, 0x7C, 0x03, 0xFF, 0x87, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x10,
  0x3F, 0x00, 0x07, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x38, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x41, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xF0,
  0x0F, 0x80, 0x07, 0xF0, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x1F,
  0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFB, 0xE0, 0x00, 0x0F, 0xF0, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x20, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x7F,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x0F,
  0x80, 0x03, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x20, 0x01, 0xF8, 0x00, 0x3C, 0x03, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xC0,
  0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x7F, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x78, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x80, 0x03, 0xE0, 0xFC,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x1F, 0xC0, 0x00, 0x1E, 0x7F, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x3C, 0x1F, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0x1F, 0x83, 0x8F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x7F, 0xC3, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0xFC,
  0x3F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0,
  0x1E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0,
  0x7C, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03,
  0xE0, 0x0F, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x3C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0xFC,
  0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x3F, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xF8, 0x0F, 0x80,
  0x03, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xFC, 0x00, 0xF8,
  0x1F, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xF0,
  0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFD, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xC0, 0x0C, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x04, 0x00, 0x07, 0xC0, 0xC0, 0x01, 0xF8, 0x3F, 0x01, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x20,
  0x1F, 0xC7, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F,
  0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x01,
  0xFE, 0x07, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xDE, 0x01, 0xFF, 0xF9, 0xE0,
  0x0F, 0xFE, 0x1F, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x03,
  0xC0, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x3E, 0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xF0,
  0x01, 0xE1, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x7C, 0x3E, 0x01, 0xE0,
  0x3C, 0x1F, 0x01, 0xF0, 0x1E, 0x0F, 0x81, 0xF8, 0x1F, 0x07, 0xC0, 0xFC,
  0x0F, 0x03, 0xC0, 0xFE, 0x07, 0x81, 0xE0, 0x7F, 0x07, 0xC0, 0xF0, 0x7F,
  0x83, 0xC0, 0x78, 0x7B, 0xC3, 0xE0, 0x3C, 0x3C, 0xE1, 0xE0, 0x1E, 0x3C,
  0x78, 0xF0, 0x0F, 0x1E, 0x3C, 0xF0, 0x07, 0x9E, 0x1E, 0x78, 0x07, 0xDE,
  0x0F, 0x7C, 0x03, 0xEF, 0x07, 0xBC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x3F, 0x1E, 0x00, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x04, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x04, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x40, 0x3F, 0xC0, 0x03, 0xC7, 0xFF,
  0x80, 0x3C, 0x7F, 0xFE, 0x03, 0xE3, 0xE1, 0xFC, 0x3E, 0x3C, 0x07, 0xFF,
  0xE1, 0xE0, 0x1F, 0xFF, 0x1E, 0x00, 0x3F, 0xE0, 0x20, 0x00, 0xFE, 0x00,
};

const GFXglyph UbuntuSansMono_Italic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 15, 42, 33, 9, -41 },
  { 80, 17, 16, 33, 13, -45 },
  { 114, 35, 41, 33, 0, -41 },
  { 294, 30, 52, 33, 3, -46 },
  { 489, 39, 43, 33, -2, -42 },
  { 699, 27, 43, 33, 2, -42 },
  { 845, 8, 17, 33, 18, -45 },
  { 862, 25, 57, 33, 7, -46 },
  { 1041, 24, 57, 33, 2, -46 },
  { 1212, 25, 24, 33, 7, -41 },
  { 1287, 27, 29, 33, 4, -32 },
  { 1385, 14, 18, 33, 5, -9 },
  { 1417, 14, 4, 33, 10, -19 },
  { 1424, 9, 10, 33, 9, -9 },
  { 1436, 38, 57, 33, -4, -46 },
  { 1707, 29, 43, 33, 3, -42 },
  { 1863, 24, 41, 33, 4, -41 },
  { 1986, 29, 42, 33, 3, -42 },
  { 2139, 29, 43, 33, 2, -42 },
  { 2295, 30, 41, 33, 1, -41 },
  { 2449, 32, 42, 33, 2, -41 },
  { 2617, 30, 42, 33, 4, -41 },
  { 2775, 29, 41, 33, 7, -41 },
  { 2924, 30, 43, 33, 3, -42 },
  { 3086, 30, 42, 33, 3, -42 },
  { 3244, 15, 32, 33, 9, -31 },
  { 3304, 19, 40, 33, 5, -31 },
  { 3399, 28, 26, 33, 3, -30 },
  { 3490, 30, 17, 33, 2, -26 },
  { 3554, 28, 26, 33, 2, -30 },
  { 3645, 24, 43, 33, 8, -42 },
  { 3774, 32, 51, 33, 2, -42 },
  { 3978, 31, 41, 33, -3, -41 },
  { 4137, 31, 41, 33, 1, -41 },
  { 4296, 33, 43, 33, 3, -42 },
  { 4474, 32, 41, 33, 0, -41 },
  { 4638, 32, 41, 33, 3, -41 },
  { 4802, 32, 41, 33, 3, -41 },
  { 4966, 31, 43, 33, 3, -42 },
  { 5133, 35, 41, 33, 0, -41 },
  { 5313, 30, 41, 33, 3, -41 },
  { 5467, 31, 42, 33, 3, -41 },
  { 5630, 35, 41, 33, 1, -41 },
  { 5810, 24, 41, 33, 1, -41 },
  { 5933, 35, 41, 33, -1, -41 },
  { 6113, 36, 41, 33, 0, -41 },
  { 6298, 30, 43, 33, 3, -42 },
  { 6460, 32, 41, 33, 1, -41 },
  { 6624, 30, 53, 33, 3, -42 },
  { 6823, 31, 41, 33, 1, -41 },
  { 6982, 32, 43, 33, 2, -42 },
  { 7154, 28, 41, 33, 8, -41 },
  { 7298, 33, 42, 33, 3, -41 },
  { 7472, 32, 41, 33, 6, -41 },
  { 7636, 35, 41, 33, 2, -41 },
  { 7816, 40, 41, 33, -2, -41 },
  { 8021, 32, 41, 33, 7, -41 },
  { 8185, 35, 41, 33, 0, -41 },
  { 8365, 29, 57, 33, 4, -46 },
  { 8572, 9, 57, 33, 12, -46 },
  { 8637, 29, 57, 33, -1, -46 },
  { 8844, 26, 22, 33, 5, -41 },
  { 8916, 30, 4, 33, -4, 7 },
  { 8931, 11, 12, 33, 15, -46 },
  { 8948, 29, 32, 33, 2, -31 },
  { 9064, 29, 47, 33, 2, -46 },
  { 9235, 29, 32, 33, 2, -31 },
  { 9351, 33, 47, 33, 3, -46 },
  { 9545, 28, 32, 33, 2, -31 },
  { 9657, 38, 57, 33, -1, -46 },
  { 9928, 34, 42, 33, -1, -31 },
  { 10107, 29, 46, 33, 0, -46 },
  { 10274, 18, 45, 33, 7, -45 },
  { 10376, 32, 56, 33, -1, -45 },
  { 10600, 31, 46, 33, 2, -46 },
  { 10779, 17, 46, 33, 10, -45 },
  { 10877, 32, 31, 33, 0, -31 },
  { 11001, 28, 31, 33, 2, -31 },
  { 11110, 28, 32, 33, 3, -31 },
  { 11222, 32, 42, 33, -1, -31 },
  { 11390, 29, 42, 33, 3, -31 },
  { 11543, 28, 31, 33, 4, -31 },
  { 11652, 27, 32, 33, 3, -31 },
  { 11760, 24, 41, 33, 7, -40 },
  { 11883, 28, 32, 33, 3, -31 },
  { 11995, 25, 31, 33, 7, -31 },
  { 12092, 33, 31, 33, 3, -31 },
  { 12220, 34, 31, 33, -1, -31 },
  { 12352, 36, 42, 33, -3, -31 },
  { 12541, 29, 31, 33, 2, -31 },
  { 12654, 32, 57, 33, 3, -46 },
  { 12882, 18, 57, 33, 8, -46 },
  { 13011, 32, 57, 33, -3, -46 },
  { 13239, 29, 9, 33, 3, -22 },
};

const GFXfont UbuntuSansMono_Italic59pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic59pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic59pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _UBUNTUSANSMONO_ITALIC59PT7B_H_
