#ifndef _UBUNTUSANSMONO_ITALIC46PT7B_H_
#define _UBUNTUSANSMONO_ITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07,
  0x80, 0x20, 0x00, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0xF0, 0xE7, 0x07, 0x38,
  0x39, 0xC1, 0xCC, 0x0C, 0xE0, 0xE7, 0x07, 0x30, 0x31, 0x81, 0x80, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0xF0, 0x38, 0x00, 0x1C, 0x0F, 0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE0, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x38,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x1E, 0x00,
  0x0F, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x70, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x03,
  0xC0, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0xF0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xF0, 0x0C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x20, 0x03, 0xE0, 0x7C, 0x1F, 0xC0, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3C, 0x03, 0xFC,
  0x00, 0xF0, 0x0F, 0x3C, 0x01, 0xC0, 0x1C, 0x38, 0x07, 0x00, 0x70, 0x70,
  0x1C, 0x00, 0xE0, 0xE0, 0x70, 0x01, 0xC1, 0xC1, 0xE0, 0x07, 0x03, 0x87,
  0x80, 0x0E, 0x0E, 0x1E, 0x00, 0x1C, 0x1C, 0x38, 0x00, 0x38, 0x38, 0xE0,
  0x00, 0x70, 0xE3, 0x80, 0x00, 0x71, 0xCE, 0x00, 0x00, 0xFF, 0x3C, 0x00,
  0x00, 0xFC, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x7E, 0x00, 0x00, 0x71, 0xFC, 0x00, 0x01, 0xC7, 0x3C, 0x00,
  0x07, 0x9C, 0x38, 0x00, 0x1E, 0x38, 0x70, 0x00, 0x78, 0xE0, 0xE0, 0x00,
  0xE1, 0xC1, 0xC0, 0x03, 0x83, 0x83, 0x80, 0x0E, 0x07, 0x07, 0x00, 0x38,
  0x0E, 0x0E, 0x00, 0xF0, 0x1C, 0x38, 0x03, 0xC0, 0x38, 0x70, 0x07, 0x00,
  0x71, 0xC0, 0x1C, 0x00, 0xFF, 0x80, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x3E,
  0x7C, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0xF0, 0x03,
  0xC7, 0xC0, 0x07, 0xBE, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x3C, 0x1F, 0xE0, 0xE0, 0xF3, 0x83, 0x87, 0x8F, 0x1E, 0x3C, 0x1E, 0x70,
  0xE0, 0x79, 0xC7, 0x80, 0xFF, 0x1E, 0x01, 0xF8, 0xF0, 0x07, 0xE3, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF8, 0x0F, 0xE1, 0xF0, 0x7F,
  0x87, 0xFF, 0xCE, 0x0F, 0xFE, 0x3C, 0x1F, 0xE0, 0xF0, 0x3C, 0xF3, 0x9E,
  0x79, 0xE7, 0x1C, 0x73, 0x8E, 0x38, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x03, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x06, 0x07, 0x06, 0x78, 0x71, 0xE7, 0xF6,
  0x7E, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03,
  0xDC, 0x00, 0x79, 0xE0, 0x0F, 0x8F, 0x00, 0xF0, 0xF8, 0x1F, 0x07, 0x80,
  0xE0, 0x70, 0x04, 0x02, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x03, 0xF0, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF0, 0xFC, 0x0F, 0x07, 0x83, 0xE3, 0xF3, 0xF8, 0xF8, 0x38, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x18, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xE0, 0x78, 0x1F,
  0x01, 0xE0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x00,
  0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3D, 0xE1, 0xE0, 0xF7,
  0x8F, 0xC3, 0xDE, 0x3F, 0x0E, 0x70, 0xFC, 0x7B, 0xC3, 0xF1, 0xEF, 0x0F,
  0x87, 0xBC, 0x1C, 0x1C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCE, 0x00, 0x1E,
  0x38, 0x00, 0x78, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x0F, 0x00, 0x78, 0x3C,
  0x03, 0xE0, 0xF0, 0x1F, 0x03, 0xE0, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F,
  0x9E, 0x07, 0x87, 0x01, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x1F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3C, 0x03, 0xC0, 0x30, 0x03,
  0xC0, 0x40, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xC0, 0x7C, 0x04, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE1, 0x80, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0x2F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xCE,
  0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xC0,
  0x0F, 0x03, 0x80, 0x1C, 0x0F, 0x00, 0x70, 0x1E, 0x01, 0xE0, 0x38, 0x07,
  0x80, 0x70, 0x1E, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0xF0, 0x07, 0x03, 0xC0,
  0x0E, 0x07, 0x00, 0x3C, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x06, 0x00, 0x7E, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x9F, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7E, 0x01, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x3C,
  0x00, 0x1C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC1, 0xC0,
  0x07, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x7C, 0x07, 0xC3, 0xF0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFE, 0x01,
  0xF0, 0x1E, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x3C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0xF8, 0x01, 0xFB, 0xE0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0x87, 0xE0, 0x1F, 0x01, 0xF0, 0x3E,
  0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0x78, 0x03, 0xE0, 0x7E, 0x1F, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF8, 0x01, 0xFE, 0xFC, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x0E, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x7E, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0xFC, 0x1F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x83, 0xE0, 0x30, 0x00, 0x00, 0x38, 0x03, 0xF0, 0x0F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xE0, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00,
  0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x00, 0x06, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3C, 0x7E, 0x08, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x38,
  0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x87, 0x80, 0x03,
  0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x1F, 0xF1, 0xE0, 0x7F, 0xF1, 0xE0, 0x7F,
  0xF8, 0xF0, 0x7C, 0x3C, 0xF0, 0x78, 0x1E, 0x78, 0x78, 0x0E, 0x3C, 0x38,
  0x0F, 0x1C, 0x3C, 0x07, 0x9E, 0x1E, 0x03, 0xCF, 0x0E, 0x01, 0xC7, 0x87,
  0x01, 0xE3, 0xC7, 0x80, 0xF1, 0xE3, 0xC0, 0x78, 0xF0, 0xE0, 0x38, 0x78,
  0x78, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x8F, 0x0F, 0x07, 0xFF, 0x07,
  0x80, 0xFF, 0x83, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x60,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x1E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x1E, 0x00,
  0x07, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x38, 0x00,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0x80,
  0x00, 0xF3, 0xC0, 0x00, 0x79, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x1E,
  0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0x03, 0x81, 0xE0, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x38, 0x0F, 0xC0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0x00, 0x7E, 0x03, 0x80,
  0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x70,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0E,
  0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x3F, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0x70, 0x1F, 0x00,
  0x10, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xF0, 0x0E, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x38, 0x0F, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF8,
  0x0E, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x0F, 0x00,
  0x03, 0x87, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xE1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x78, 0x3C,
  0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0xFC, 0x07, 0x01, 0xFC, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0x80, 0x70, 0x1F, 0x00, 0x10,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x02, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x07, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x01,
  0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00,
  0x1C, 0x03, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0,
  0x78, 0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0x78, 0x00, 0x78, 0x07, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xE0,
  0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1C,
  0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x38, 0x07, 0x80, 0x07, 0x80, 0x70, 0x00, 0x78, 0x07, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x04, 0x00, 0xF0, 0x07, 0x00, 0xF8, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x07, 0x00, 0x3E, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x00, 0xE0, 0x3E, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x3C,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x3E, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0x80,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xF0, 0x0F, 0x00,
  0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x06,
  0xE0, 0x0D, 0xC0, 0xEE, 0x01, 0xDC, 0x1C, 0xE0, 0x1C, 0xE1, 0xDC, 0x01,
  0xCE, 0x39, 0xC0, 0x38, 0xE3, 0x9C, 0x03, 0x8E, 0x71, 0xC0, 0x38, 0xE6,
  0x1C, 0x07, 0x8E, 0xE3, 0xC0, 0x70, 0xFC, 0x38, 0x07, 0x0F, 0xC3, 0x80,
  0xF0, 0xF8, 0x38, 0x0E, 0x0F, 0x83, 0x80, 0xE0, 0xF0, 0x78, 0x1E, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x01,
  0xF8, 0x00, 0xE0, 0x1F, 0x80, 0x0E, 0x01, 0xF8, 0x01, 0xE0, 0x1F, 0x80,
  0x1E, 0x01, 0xFC, 0x01, 0xC0, 0x39, 0xC0, 0x1C, 0x03, 0x9C, 0x03, 0xC0,
  0x39, 0xE0, 0x3C, 0x03, 0x8E, 0x03, 0x80, 0x78, 0xE0, 0x38, 0x07, 0x0E,
  0x03, 0x80, 0x70, 0xF0, 0x78, 0x07, 0x07, 0x07, 0x00, 0xF0, 0x70, 0x70,
  0x0E, 0x07, 0x07, 0x00, 0xE0, 0x78, 0xF0, 0x0E, 0x03, 0x8E, 0x01, 0xE0,
  0x38, 0xE0, 0x1C, 0x03, 0x8E, 0x01, 0xC0, 0x39, 0xE0, 0x1C, 0x01, 0xDC,
  0x03, 0xC0, 0x1D, 0xC0, 0x38, 0x01, 0xDC, 0x03, 0x80, 0x1F, 0xC0, 0x38,
  0x01, 0xF8, 0x07, 0x80, 0x1F, 0x80, 0x78, 0x00, 0xF8, 0x07, 0x00, 0x0F,
  0x80, 0x70, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x78,
  0x00, 0x0E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x70,
  0x00, 0xF0, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x3F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x38, 0x07, 0xE0, 0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E,
  0x07, 0x80, 0x0F, 0x03, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xC0, 0xF0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0xF8, 0x1E, 0x00, 0xF8, 0x0E, 0x03, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x1E,
  0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x38, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E,
  0x70, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0,
  0x70, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x3F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x1F,
  0x03, 0x80, 0x0F, 0x03, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x07, 0x80, 0x07,
  0x07, 0x80, 0x07, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E,
  0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x1E, 0x01, 0xF8, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1C, 0x0F, 0x00, 0x3C, 0x07, 0x00,
  0x3C, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x78, 0x03, 0xC0,
  0x78, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0x80,
  0x30, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x04, 0x00, 0x0F, 0x03, 0x80, 0x1F, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x1E, 0x00,
  0x1E, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x3C,
  0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xE0,
  0x78, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x01,
  0xC0, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x07,
  0x00, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x38,
  0x07, 0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xCF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0x70, 0x01, 0xE0,
  0x70, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x07, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1C, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF0, 0x00,
  0x38, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x3B, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x1E, 0x0E, 0x07, 0x01, 0xC1, 0xE0,
  0x70, 0x1C, 0x1E, 0x0F, 0x01, 0xC3, 0xF0, 0xE0, 0x1C, 0x3F, 0x0E, 0x03,
  0x87, 0x70, 0xE0, 0x38, 0xE7, 0x1C, 0x03, 0x8E, 0x71, 0xC0, 0x39, 0xC7,
  0x1C, 0x03, 0x9C, 0x73, 0x80, 0x33, 0x87, 0x38, 0x07, 0x38, 0x33, 0x80,
  0x77, 0x03, 0x30, 0x07, 0xE0, 0x37, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03,
  0xE1, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x78, 0x70, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x3C, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x3C,
  0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x0E, 0x1C, 0x38, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x38, 0x78, 0xF1, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7B, 0x80, 0x0F, 0x38, 0x01,
  0xE3, 0x80, 0x3C, 0x1C, 0x03, 0xC1, 0xC0, 0x78, 0x1C, 0x0F, 0x01, 0xE1,
  0xE0, 0x0E, 0x3C, 0x00, 0xE3, 0xC0, 0x0F, 0x78, 0x00, 0x7F, 0x00, 0x07,
  0x20, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x20, 0x70, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x07,
  0x04, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFC, 0x0F,
  0x0F, 0xC0, 0x38, 0x7C, 0x00, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0x71, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00,
  0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xC3,
  0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0x78, 0x0F, 0xC1, 0xF9,
  0xFF, 0x03, 0xFF, 0xDC, 0x07, 0xFC, 0x78, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xBF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x83, 0xF0, 0x1E, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF0,
  0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x70, 0x00, 0xF1, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xE0, 0x01, 0xE3, 0x80, 0x07,
  0x9E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x00, 0x3E, 0x1C,
  0x03, 0xF0, 0xF0, 0x3F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xF0, 0x02,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xC0, 0x70, 0x07, 0xC0, 0x1C, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x03, 0xC0,
  0x78, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0x81, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x07, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x78, 0x07,
  0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x0F, 0xCF, 0xF8,
  0x01, 0xFF, 0xEE, 0x00, 0x3F, 0xE3, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x83, 0xF0, 0x1E, 0x0F, 0x80,
  0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0x79,
  0xE0, 0x03, 0xEF, 0x00, 0x3F, 0x3D, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF,
  0xF0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xDE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xBF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0x00, 0xFC,
  0x03, 0x80, 0x7C, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x07,
  0x80, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x3C,
  0x0F, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x38, 0x00,
  0x78, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x03, 0xC0, 0x3E,
  0x03, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xF3, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x20, 0x07, 0xC0, 0x1F, 0x9F, 0xF0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x81, 0xE0, 0x1F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x70,
  0x01, 0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xC0, 0x07, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x0F, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x87, 0xFE,
  0x1F, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC1,
  0x07, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x40, 0x1E, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x1C,
  0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x07, 0x81, 0xF0, 0x03,
  0x81, 0xF0, 0x01, 0xC3, 0xE0, 0x01, 0xE3, 0xE0, 0x00, 0xF7, 0xE0, 0x00,
  0x77, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF8, 0x00,
  0x0F, 0x3E, 0x00, 0x07, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0xF0,
  0x01, 0xE0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0x70, 0x07, 0x80, 0x78, 0x01,
  0xE0, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x00, 0xFF,
  0xE7, 0xFF, 0x3F, 0xF0, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0x01, 0x7E, 0xF9, 0xFF, 0xC7, 0xFC, 0x02, 0x00, 0x03, 0xFE,
  0x7E, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xE1, 0xF0, 0xF0, 0xF0,
  0x70, 0x78, 0x78, 0x38, 0x3C, 0x38, 0x1C, 0x1E, 0x1C, 0x1E, 0x0E, 0x0E,
  0x0F, 0x07, 0x0F, 0x07, 0x07, 0x87, 0x83, 0x83, 0xC3, 0x83, 0xC1, 0xC1,
  0xC1, 0xE0, 0xE1, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x70, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x00,
  0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x1E, 0x01, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00,
  0x38, 0xF0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x9E,
  0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07,
  0x1E, 0x00, 0x38, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0,
  0x07, 0x1C, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x81, 0xF8, 0x3E, 0x0F, 0x80, 0x3C, 0x7C, 0x00, 0xF1, 0xE0, 0x03, 0xCF,
  0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00,
  0x0F, 0x78, 0x00, 0x3D, 0xC0, 0x01, 0xE7, 0x00, 0x07, 0xBC, 0x00, 0x1E,
  0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xC7, 0x00, 0x1E, 0x1E, 0x00, 0xF0, 0x7C,
  0x0F, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3C,
  0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x3C,
  0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x03, 0x80, 0x1F,
  0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x3C, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x80, 0xE0, 0x7C, 0x03, 0xC1,
  0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78,
  0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0x87, 0x00, 0x0F, 0x0E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC1, 0xC0, 0x07, 0x83, 0xC0, 0x0E, 0x07, 0xC0, 0x7C, 0x07, 0xE7, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFD, 0xC0, 0x01, 0x87, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0x80,
  0x60, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x06, 0x00, 0xF8, 0x7F, 0x7F, 0x83,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x08, 0x3F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x38, 0xE0,
  0x01, 0xC7, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x1C, 0x00, 0x38,
  0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00,
  0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0x80, 0x0F, 0x1C,
  0x00, 0x78, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xE0, 0x0F,
  0x0F, 0x01, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xEF, 0x07, 0xFC, 0x78, 0x02,
  0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E,
  0x70, 0x01, 0xE7, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0x78, 0x07,
  0x87, 0x80, 0x70, 0x78, 0x0F, 0x07, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x83,
  0xC0, 0x38, 0x38, 0x03, 0x87, 0x80, 0x38, 0x70, 0x03, 0xCF, 0x00, 0x3D,
  0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38,
  0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x81, 0xC0,
  0xF1, 0xE0, 0x70, 0x38, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x07, 0x87,
  0xC1, 0xC1, 0xC3, 0xB0, 0xF0, 0x70, 0xEE, 0x38, 0x1C, 0x73, 0x9E, 0x07,
  0x1C, 0xE7, 0x01, 0xCE, 0x39, 0xC0, 0x77, 0x0E, 0xF0, 0x1D, 0xC3, 0xB8,
  0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00,
  0x0E, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x3C,
  0x03, 0x80, 0x07, 0x80, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x3C, 0x78, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0x70,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x08, 0x3F, 0xC0, 0x3C, 0xFF, 0xE0, 0x71, 0xC3, 0xE1,
  0xC7, 0x03, 0xFF, 0x9E, 0x01, 0xFE, 0x08, 0x01, 0xF0, 0x00,
};

const GFXglyph UbuntuSansMono_Italic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 12, 33, 26, 7, -32 },
  { 51, 13, 12, 26, 10, -35 },
  { 71, 27, 32, 26, 0, -32 },
  { 179, 24, 41, 26, 2, -36 },
  { 302, 31, 34, 26, -2, -33 },
  { 434, 22, 33, 26, 1, -33 },
  { 525, 6, 13, 26, 14, -35 },
  { 535, 19, 45, 26, 6, -36 },
  { 642, 19, 45, 26, 1, -36 },
  { 749, 20, 19, 26, 5, -32 },
  { 797, 21, 23, 26, 3, -25 },
  { 858, 10, 14, 26, 4, -7 },
  { 876, 11, 4, 26, 8, -15 },
  { 882, 7, 8, 26, 7, -7 },
  { 889, 29, 45, 26, -3, -36 },
  { 1053, 22, 34, 26, 3, -33 },
  { 1147, 18, 32, 26, 3, -32 },
  { 1219, 23, 33, 26, 2, -33 },
  { 1314, 22, 34, 26, 2, -33 },
  { 1408, 23, 32, 26, 1, -32 },
  { 1500, 25, 33, 26, 1, -32 },
  { 1604, 23, 33, 26, 3, -32 },
  { 1699, 22, 32, 26, 6, -32 },
  { 1787, 24, 34, 26, 2, -33 },
  { 1889, 24, 33, 26, 2, -33 },
  { 1988, 11, 25, 26, 7, -24 },
  { 2023, 14, 31, 26, 4, -24 },
  { 2078, 23, 20, 26, 2, -23 },
  { 2136, 23, 13, 26, 2, -20 },
  { 2174, 23, 20, 26, 1, -23 },
  { 2232, 18, 34, 26, 7, -33 },
  { 2309, 25, 40, 26, 2, -33 },
  { 2434, 25, 32, 26, -3, -32 },
  { 2534, 25, 32, 26, 0, -32 },
  { 2634, 25, 34, 26, 3, -33 },
  { 2741, 25, 32, 26, 0, -32 },
  { 2841, 25, 32, 26, 2, -32 },
  { 2941, 25, 32, 26, 2, -32 },
  { 3041, 25, 34, 26, 2, -33 },
  { 3148, 28, 32, 26, 0, -32 },
  { 3260, 23, 32, 26, 2, -32 },
  { 3352, 25, 33, 26, 2, -32 },
  { 3456, 27, 32, 26, 1, -32 },
  { 3564, 18, 32, 26, 1, -32 },
  { 3636, 28, 32, 26, -1, -32 },
  { 3748, 28, 32, 26, 0, -32 },
  { 3860, 24, 34, 26, 2, -33 },
  { 3962, 25, 32, 26, 1, -32 },
  { 4062, 24, 41, 26, 2, -33 },
  { 4185, 24, 32, 26, 1, -32 },
  { 4281, 25, 34, 26, 1, -33 },
  { 4388, 22, 32, 26, 6, -32 },
  { 4476, 26, 33, 26, 2, -32 },
  { 4584, 24, 32, 26, 5, -32 },
  { 4680, 28, 32, 26, 1, -32 },
  { 4792, 30, 32, 26, -1, -32 },
  { 4912, 24, 32, 26, 6, -32 },
  { 5008, 28, 32, 26, 0, -32 },
  { 5120, 23, 45, 26, 3, -36 },
  { 5250, 7, 45, 26, 10, -36 },
  { 5290, 23, 45, 26, -1, -36 },
  { 5420, 20, 17, 26, 4, -32 },
  { 5463, 24, 4, 26, -3, 5 },
  { 5475, 8, 10, 26, 12, -36 },
  { 5485, 22, 25, 26, 2, -24 },
  { 5554, 22, 36, 26, 2, -36 },
  { 5653, 22, 25, 26, 2, -24 },
  { 5722, 26, 37, 26, 2, -36 },
  { 5843, 22, 25, 26, 2, -24 },
  { 5912, 30, 45, 26, -1, -36 },
  { 6081, 26, 33, 26, -1, -24 },
  { 6189, 22, 36, 26, 0, -36 },
  { 6288, 15, 35, 26, 5, -35 },
  { 6354, 24, 44, 26, 0, -35 },
  { 6486, 25, 36, 26, 1, -36 },
  { 6599, 13, 36, 26, 8, -35 },
  { 6658, 25, 24, 26, 0, -24 },
  { 6733, 21, 24, 26, 2, -24 },
  { 6796, 22, 25, 26, 2, -24 },
  { 6865, 25, 33, 26, -1, -24 },
  { 6969, 23, 33, 26, 2, -24 },
  { 7064, 22, 24, 26, 3, -24 },
  { 7130, 21, 25, 26, 3, -24 },
  { 7196, 18, 32, 26, 6, -31 },
  { 7268, 21, 25, 26, 3, -24 },
  { 7334, 20, 24, 26, 5, -24 },
  { 7394, 26, 24, 26, 2, -24 },
  { 7472, 27, 24, 26, -1, -24 },
  { 7553, 27, 33, 26, -2, -24 },
  { 7665, 23, 24, 26, 1, -24 },
  { 7734, 24, 45, 26, 3, -36 },
  { 7869, 14, 45, 26, 6, -36 },
  { 7948, 25, 45, 26, -2, -36 },
  { 8089, 23, 7, 26, 2, -17 },
};

const GFXfont UbuntuSansMono_Italic46pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic46pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic46pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _UBUNTUSANSMONO_ITALIC46PT7B_H_
