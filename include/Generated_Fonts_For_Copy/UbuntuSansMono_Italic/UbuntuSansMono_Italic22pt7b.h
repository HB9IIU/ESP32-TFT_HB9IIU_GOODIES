#ifndef _UBUNTUSANSMONO_ITALIC22PT7B_H_
#define _UBUNTUSANSMONO_ITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x04, 0x30, 0x80, 0x00, 0x63, 0x8E,
  0x00, 0x45, 0x3C, 0xF2, 0x8A, 0x20, 0x01, 0x18, 0x18, 0x80, 0x8C, 0x0C,
  0x43, 0xFF, 0x86, 0x30, 0x33, 0x03, 0x18, 0x18, 0x83, 0xFF, 0xBF, 0xF8,
  0x46, 0x06, 0x20, 0x23, 0x03, 0x18, 0x00, 0x01, 0x80, 0x30, 0x06, 0x07,
  0xF1, 0x82, 0x20, 0x04, 0x00, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x0C, 0x01, 0x10, 0x67, 0xF8, 0x18, 0x03, 0x00, 0x60, 0x00, 0x06, 0x02,
  0x1E, 0x08, 0x64, 0x20, 0x88, 0xC1, 0x13, 0x02, 0x6C, 0x04, 0xB0, 0x0E,
  0xC0, 0x01, 0x00, 0x05, 0xE0, 0x1A, 0x40, 0x6C, 0xC1, 0x91, 0x06, 0x22,
  0x08, 0x6C, 0x60, 0xF0, 0x03, 0x03, 0xE1, 0x88, 0x42, 0x31, 0x8C, 0x41,
  0x70, 0x70, 0x3C, 0xDB, 0x2C, 0x7B, 0x0E, 0x83, 0x30, 0xCC, 0xF9, 0xE6,
  0x7B, 0x69, 0x20, 0x01, 0x81, 0x81, 0x81, 0x81, 0x81, 0x80, 0x80, 0xC0,
  0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x06, 0x01, 0x00, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x10, 0x18, 0x18, 0x18, 0x1C, 0x1C,
  0x1C, 0x08, 0x00, 0x18, 0x0C, 0x22, 0x5D, 0xF3, 0xC0, 0xE0, 0xD8, 0xCE,
  0x22, 0x00, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x3F, 0xF0, 0xC0, 0x30,
  0x0C, 0x02, 0x01, 0x80, 0x3B, 0xCE, 0x23, 0x72, 0x00, 0xFF, 0xC0, 0x7F,
  0x60, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x00, 0x03, 0x01, 0xF8, 0x71, 0x8C, 0x33, 0x06, 0x40, 0xD9, 0x1B,
  0x73, 0x4E, 0x58, 0x9B, 0x03, 0x60, 0x4C, 0x19, 0x86, 0x19, 0xC3, 0xE0,
  0x03, 0x07, 0x1F, 0x32, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x08,
  0x18, 0x18, 0xFF, 0x03, 0x03, 0xF8, 0x61, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x07,
  0xFC, 0x03, 0x03, 0xF8, 0x43, 0x00, 0x30, 0x06, 0x01, 0x80, 0x70, 0x78,
  0x0F, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x31, 0xC7, 0xF0, 0x00,
  0x60, 0x1C, 0x0F, 0x81, 0xB0, 0x64, 0x19, 0x86, 0x31, 0x86, 0x60, 0x8C,
  0x33, 0xFF, 0x80, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x07, 0xF0, 0xC0, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x3F, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x08, 0x01, 0x88, 0x70, 0xFE, 0x00, 0x03, 0xE1, 0xE0, 0x70, 0x18,
  0x03, 0x00, 0xC0, 0x3F, 0xC7, 0x0C, 0xC1, 0x90, 0x32, 0x06, 0x40, 0xCC,
  0x31, 0x8E, 0x1F, 0x80, 0x7F, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30,
  0x00, 0x03, 0x81, 0xFC, 0x61, 0x8C, 0x33, 0x06, 0x60, 0xCC, 0x30, 0xEC,
  0x1F, 0x06, 0x31, 0x83, 0x60, 0x6C, 0x0D, 0x83, 0x38, 0xE3, 0xF8, 0x03,
  0x01, 0xF8, 0x61, 0x98, 0x33, 0x06, 0x40, 0xC8, 0x19, 0x83, 0x3F, 0xE3,
  0xF8, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x3F, 0x07, 0x80, 0x1C, 0xF1, 0x80,
  0x00, 0x00, 0x00, 0x73, 0xC6, 0x00, 0x0E, 0x3C, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x38, 0xF0, 0xE0, 0x83, 0x1C, 0x20, 0x00, 0x00, 0x60, 0x3C, 0x3C,
  0x1E, 0x0E, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x10, 0x7F, 0xEF,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x20, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0xF1, 0xE1, 0xE0, 0xC0, 0x20, 0x00, 0x0C, 0x1F, 0x80,
  0x60, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x00, 0x00, 0x03,
  0x03, 0x81, 0xC0, 0x01, 0x80, 0x7E, 0x0C, 0x31, 0x83, 0x30, 0x36, 0x07,
  0x63, 0xE6, 0x62, 0xCC, 0x6C, 0xC6, 0xC8, 0x6C, 0x84, 0xCC, 0xCC, 0xFC,
  0xC7, 0x8C, 0x00, 0x60, 0x07, 0x20, 0x3E, 0x00, 0x00, 0xE0, 0x1E, 0x01,
  0x60, 0x36, 0x06, 0x60, 0x46, 0x0C, 0x60, 0x82, 0x18, 0x21, 0xFE, 0x3F,
  0xE2, 0x02, 0x60, 0x2C, 0x03, 0xC0, 0x30, 0x0F, 0xE1, 0x87, 0x18, 0x31,
  0x83, 0x10, 0x33, 0x06, 0x3F, 0xC3, 0xFC, 0x20, 0x66, 0x06, 0x60, 0x66,
  0x06, 0x40, 0xC4, 0x38, 0xFF, 0x00, 0x01, 0xC0, 0x7F, 0x0C, 0x11, 0x80,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x71, 0x83, 0xF8, 0x1F, 0xC1, 0x8E, 0x18, 0x61, 0x03,
  0x30, 0x33, 0x03, 0x30, 0x32, 0x03, 0x60, 0x26, 0x06, 0x60, 0x64, 0x0C,
  0x41, 0x8C, 0x70, 0xFC, 0x00, 0x0F, 0xF1, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x3F, 0xC3, 0xF8, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xFF, 0x80, 0x1F, 0xF1, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x3F, 0xC3, 0xF8, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x7F, 0x1C, 0x23, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0x86, 0x18,
  0x71, 0x83, 0xF8, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x20, 0x21, 0x03, 0x18,
  0x18, 0xFF, 0xC7, 0xFC, 0x20, 0x63, 0x03, 0x18, 0x18, 0xC0, 0x84, 0x0C,
  0x60, 0x63, 0x03, 0x00, 0x0F, 0xE2, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x3F,
  0xC0, 0x0F, 0xF0, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x0C, 0x70, 0x7E, 0x00,
  0x0C, 0x38, 0x41, 0x86, 0x38, 0x33, 0x81, 0xB0, 0x0B, 0x00, 0xF0, 0x07,
  0x80, 0x36, 0x01, 0x18, 0x18, 0xC0, 0xC3, 0x06, 0x18, 0x20, 0x63, 0x03,
  0x00, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18,
  0x08, 0x0C, 0x06, 0x03, 0x03, 0xFE, 0x0C, 0x18, 0x61, 0xC7, 0x0C, 0x28,
  0xA1, 0x6D, 0x1B, 0x58, 0xDE, 0xC4, 0xE6, 0x66, 0x23, 0x01, 0x18, 0x18,
  0x80, 0xCC, 0x06, 0x60, 0x22, 0x03, 0x00, 0x0C, 0x08, 0xE0, 0xC7, 0x06,
  0x2C, 0x21, 0x61, 0x19, 0x18, 0xCC, 0xC6, 0x64, 0x21, 0x23, 0x0B, 0x18,
  0x58, 0xC3, 0x84, 0x1C, 0x20, 0x63, 0x03, 0x00, 0x03, 0x01, 0xF8, 0x61,
  0x98, 0x33, 0x02, 0xC0, 0x58, 0x0A, 0x01, 0x40, 0x78, 0x0F, 0x01, 0x60,
  0x6C, 0x0D, 0x83, 0x18, 0xC1, 0xF0, 0x0F, 0xE0, 0x83, 0x18, 0x31, 0x81,
  0x18, 0x31, 0x03, 0x10, 0x63, 0x0C, 0x3F, 0x83, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x01, 0xF8, 0x61, 0x98, 0x33, 0x02,
  0xC0, 0x58, 0x0A, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0x60, 0x6C, 0x0D, 0x83,
  0x18, 0xC1, 0xF0, 0x18, 0x03, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0xE1, 0x87,
  0x18, 0x31, 0x83, 0x10, 0x31, 0x03, 0x30, 0x63, 0xFC, 0x3F, 0x02, 0x10,
  0x61, 0x86, 0x18, 0x60, 0x84, 0x0C, 0xC0, 0xC0, 0x01, 0x80, 0xFF, 0x18,
  0x21, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0x80, 0x0C, 0x00, 0x80, 0x18, 0xC3, 0x8F, 0xE0, 0xFF, 0xE1, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x00, 0x10, 0x33, 0x03, 0x30, 0x33, 0x02, 0x20,
  0x66, 0x06, 0x60, 0x66, 0x04, 0x40, 0xCC, 0x0C, 0xC0, 0xCC, 0x08, 0xC1,
  0x86, 0x30, 0x3E, 0x00, 0xC0, 0x3C, 0x06, 0x40, 0x64, 0x0C, 0x40, 0xC4,
  0x18, 0x41, 0x86, 0x30, 0x62, 0x06, 0x60, 0x64, 0x06, 0xC0, 0x68, 0x07,
  0x80, 0x70, 0x00, 0x30, 0x19, 0x80, 0x88, 0x0C, 0xC0, 0x66, 0x02, 0x30,
  0x11, 0x19, 0x89, 0xC8, 0x4A, 0x46, 0x96, 0x3C, 0xA1, 0x45, 0x0E, 0x28,
  0x61, 0x83, 0x0C, 0x00, 0x06, 0x0E, 0x0C, 0x18, 0x0C, 0x60, 0x19, 0x80,
  0x36, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0xC0, 0x0D, 0x80, 0x31,
  0x00, 0xC3, 0x03, 0x86, 0x06, 0x04, 0x38, 0x0C, 0x00, 0xC0, 0x78, 0x1B,
  0x03, 0x20, 0xC4, 0x30, 0xC4, 0x19, 0x81, 0x60, 0x38, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0x18, 0x00, 0x0F, 0xF8, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xC3, 0x00, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18,
  0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x10, 0xF8, 0x00, 0x93, 0x6D,
  0xB6, 0xDB, 0x64, 0x93, 0x6D, 0xB6, 0x07, 0xE0, 0x08, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x0F, 0xC0, 0x07,
  0x03, 0xC0, 0x90, 0x64, 0x31, 0x98, 0x2C, 0x09, 0x03, 0xFF, 0xF0, 0xCC,
  0x63, 0x03, 0xC1, 0xFC, 0xE1, 0x38, 0x66, 0x0D, 0x81, 0xB0, 0x26, 0x0C,
  0xC1, 0x98, 0x33, 0x8E, 0x3E, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x6E, 0x0F, 0xF1, 0x86, 0x20, 0x4C, 0x0D, 0x81, 0x30, 0x64, 0x0C,
  0x83, 0x30, 0xE6, 0x78, 0xFC, 0x00, 0x03, 0xA3, 0xF8, 0xC0, 0x30, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x86, 0x1F, 0xC0, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x3E, 0x0F, 0xE3, 0x86, 0x30,
  0x46, 0x0C, 0x40, 0xCC, 0x0C, 0xC0, 0x8C, 0x18, 0xC1, 0x86, 0x38, 0x7F,
  0x80, 0x07, 0x07, 0xF3, 0x0D, 0x81, 0x40, 0xF0, 0x7F, 0xF2, 0x00, 0xC0,
  0x30, 0x06, 0x18, 0xFE, 0x00, 0x7C, 0x03, 0x20, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x21, 0xFF, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x2C, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x7F, 0x0C, 0x31, 0x82, 0x30,
  0x63, 0x06, 0x60, 0x66, 0x04, 0x60, 0x46, 0x0C, 0x3F, 0xC0, 0xC8, 0x00,
  0x80, 0x18, 0xC7, 0x0F, 0xE0, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80,
  0x36, 0x07, 0xF1, 0x86, 0x30, 0x66, 0x0C, 0x81, 0x30, 0x26, 0x0C, 0xC1,
  0x90, 0x32, 0x04, 0xC1, 0x80, 0x08, 0x71, 0xC0, 0x00, 0x0F, 0x84, 0x10,
  0xC3, 0x0C, 0x21, 0x86, 0x0D, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x0C, 0xE0,
  0xFC, 0x00, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x39,
  0x8C, 0x27, 0x0D, 0xC1, 0xE0, 0x3E, 0x06, 0xC0, 0x8C, 0x30, 0xC6, 0x0C,
  0xC1, 0x80, 0xFB, 0xE1, 0x84, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x10, 0xC3,
  0x0C, 0x31, 0x7C, 0x0C, 0x63, 0xFF, 0x33, 0x33, 0x33, 0x22, 0x36, 0x22,
  0x66, 0x66, 0x66, 0x40, 0x64, 0x04, 0xC0, 0xCC, 0x0C, 0x07, 0x0F, 0xE3,
  0x0C, 0xC3, 0x20, 0x58, 0x36, 0x0D, 0x83, 0x40, 0xB0, 0x6C, 0x1B, 0x06,
  0x07, 0x03, 0xF8, 0xE3, 0x30, 0x26, 0x06, 0x80, 0xB0, 0x36, 0x06, 0xC0,
  0xD8, 0x31, 0x9C, 0x1F, 0x00, 0x07, 0x81, 0xFE, 0x18, 0x61, 0x02, 0x30,
  0x33, 0x02, 0x30, 0x22, 0x06, 0x60, 0x66, 0x0C, 0x63, 0x87, 0xE0, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0xC1, 0xFC, 0xE1, 0x98, 0x26, 0x0C,
  0x81, 0xB0, 0x36, 0x04, 0xC1, 0x98, 0x31, 0x8E, 0x3F, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x30, 0x03, 0xE3, 0xF8, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x00, 0x03, 0x87, 0xF1, 0x80,
  0xC0, 0x30, 0x07, 0x00, 0x70, 0x0E, 0x01, 0x80, 0x64, 0x33, 0xF8, 0x18,
  0x0C, 0x04, 0x02, 0x1F, 0xF1, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x08,
  0x04, 0x03, 0x11, 0xF8, 0x30, 0x6C, 0x09, 0x83, 0x30, 0x64, 0x0C, 0x81,
  0x30, 0x66, 0x0C, 0xC1, 0x8C, 0xF1, 0xF6, 0x00, 0x81, 0xC0, 0xA0, 0xD8,
  0x4C, 0x66, 0x23, 0x31, 0xB0, 0xD0, 0x38, 0x18, 0x00, 0x60, 0x34, 0x03,
  0x40, 0x24, 0x66, 0x4E, 0x6C, 0xA4, 0xDA, 0xCD, 0x28, 0xE3, 0x8E, 0x30,
  0xC3, 0x00, 0x18, 0x30, 0xC6, 0x0C, 0xC0, 0x78, 0x07, 0x00, 0x70, 0x0F,
  0x01, 0x98, 0x31, 0x86, 0x08, 0xC0, 0xC0, 0x08, 0x18, 0x60, 0xC3, 0x0C,
  0x18, 0x60, 0xC2, 0x06, 0x30, 0x11, 0x80, 0xD8, 0x06, 0xC0, 0x3C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x4E, 0x03, 0xC0, 0x00, 0x3F, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0F, 0xF0, 0x01, 0xF0,
  0x30, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0xF0, 0x03, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x03, 0x00, 0x3E, 0x00, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x02,
  0x0C, 0x18, 0x20, 0x41, 0x83, 0x04, 0x08, 0x30, 0x60, 0x81, 0x06, 0x0C,
  0x00, 0x07, 0xC0, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x0C, 0x00, 0xF0, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0xF8, 0x00, 0x38, 0x6D, 0xDB,
  0x0E, 0x00,
};

const GFXglyph UbuntuSansMono_Italic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 15, 12, 3, -15 },
  { 13, 6, 6, 12, 5, -17 },
  { 18, 13, 15, 12, 0, -15 },
  { 43, 11, 19, 12, 1, -17 },
  { 70, 15, 16, 12, -1, -16 },
  { 100, 10, 16, 12, 1, -16 },
  { 120, 3, 7, 12, 7, -17 },
  { 123, 9, 21, 12, 3, -17 },
  { 147, 9, 21, 12, 1, -17 },
  { 171, 9, 9, 12, 3, -15 },
  { 182, 10, 11, 12, 1, -12 },
  { 196, 5, 7, 12, 2, -3 },
  { 201, 5, 2, 12, 4, -7 },
  { 203, 4, 3, 12, 3, -3 },
  { 205, 14, 21, 12, -1, -17 },
  { 242, 11, 16, 12, 1, -16 },
  { 264, 8, 15, 12, 2, -15 },
  { 279, 11, 16, 12, 1, -16 },
  { 301, 11, 16, 12, 1, -16 },
  { 323, 11, 15, 12, 0, -15 },
  { 344, 12, 15, 12, 1, -15 },
  { 367, 11, 15, 12, 2, -15 },
  { 388, 11, 15, 12, 3, -15 },
  { 409, 11, 16, 12, 1, -16 },
  { 431, 11, 16, 12, 1, -16 },
  { 453, 6, 11, 12, 3, -11 },
  { 462, 7, 15, 12, 2, -11 },
  { 476, 11, 10, 12, 1, -11 },
  { 490, 11, 7, 12, 1, -10 },
  { 500, 10, 10, 12, 1, -11 },
  { 513, 9, 16, 12, 3, -16 },
  { 531, 12, 19, 12, 1, -16 },
  { 560, 12, 15, 12, -1, -15 },
  { 583, 12, 15, 12, 0, -15 },
  { 606, 12, 16, 12, 1, -16 },
  { 630, 12, 15, 12, 0, -15 },
  { 653, 12, 15, 12, 1, -15 },
  { 676, 12, 15, 12, 1, -15 },
  { 699, 12, 16, 12, 1, -16 },
  { 723, 13, 15, 12, 0, -15 },
  { 748, 11, 15, 12, 1, -15 },
  { 769, 12, 15, 12, 1, -15 },
  { 792, 13, 15, 12, 0, -15 },
  { 817, 9, 15, 12, 0, -15 },
  { 834, 13, 15, 12, 0, -15 },
  { 859, 13, 15, 12, 0, -15 },
  { 884, 11, 16, 12, 1, -16 },
  { 906, 12, 15, 12, 0, -15 },
  { 929, 11, 20, 12, 1, -16 },
  { 957, 12, 15, 12, 0, -15 },
  { 980, 12, 16, 12, 1, -16 },
  { 1004, 11, 15, 12, 3, -15 },
  { 1025, 12, 15, 12, 1, -15 },
  { 1048, 12, 15, 12, 2, -15 },
  { 1071, 13, 15, 12, 1, -15 },
  { 1096, 15, 15, 12, -1, -15 },
  { 1125, 11, 15, 12, 3, -15 },
  { 1146, 13, 15, 12, 0, -15 },
  { 1171, 10, 21, 12, 2, -17 },
  { 1198, 3, 21, 12, 5, -17 },
  { 1206, 11, 21, 12, 0, -17 },
  { 1235, 10, 8, 12, 2, -15 },
  { 1245, 12, 1, 12, -2, 3 },
  { 1247, 4, 4, 12, 6, -17 },
  { 1249, 11, 12, 12, 1, -12 },
  { 1266, 11, 17, 12, 1, -17 },
  { 1290, 11, 12, 12, 1, -12 },
  { 1307, 12, 17, 12, 1, -17 },
  { 1333, 10, 12, 12, 1, -12 },
  { 1348, 14, 21, 12, 0, -17 },
  { 1385, 12, 16, 12, 0, -12 },
  { 1409, 11, 17, 12, 0, -17 },
  { 1433, 6, 17, 12, 3, -17 },
  { 1446, 12, 21, 12, 0, -17 },
  { 1478, 11, 17, 12, 1, -17 },
  { 1502, 6, 17, 12, 4, -17 },
  { 1515, 12, 12, 12, 0, -12 },
  { 1533, 10, 12, 12, 1, -12 },
  { 1548, 11, 12, 12, 1, -12 },
  { 1565, 12, 16, 12, 0, -12 },
  { 1589, 11, 16, 12, 1, -12 },
  { 1611, 11, 12, 12, 1, -12 },
  { 1628, 10, 12, 12, 1, -12 },
  { 1643, 9, 15, 12, 3, -15 },
  { 1660, 11, 11, 12, 1, -11 },
  { 1676, 9, 11, 12, 3, -11 },
  { 1689, 12, 11, 12, 1, -11 },
  { 1706, 12, 11, 12, 0, -11 },
  { 1723, 13, 15, 12, -1, -11 },
  { 1748, 10, 11, 12, 1, -11 },
  { 1762, 12, 21, 12, 1, -17 },
  { 1794, 7, 21, 12, 3, -17 },
  { 1813, 12, 21, 12, -1, -17 },
  { 1845, 11, 3, 12, 1, -8 },
};

const GFXfont UbuntuSansMono_Italic22pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic22pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _UBUNTUSANSMONO_ITALIC22PT7B_H_
