#ifndef _UBUNTUSANSMONO_ITALIC49PT7B_H_
#define _UBUNTUSANSMONO_ITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0x70, 0x00, 0x38, 0x3C, 0xE0, 0xE7, 0x83, 0x9C,
  0x0E, 0x70, 0x79, 0xC1, 0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x63, 0x81, 0x8C,
  0x0E, 0x30, 0x30, 0xC0, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0E,
  0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0x80, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x78,
  0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80,
  0x78, 0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x7E, 0x03, 0x80, 0x7C, 0x00, 0x40, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x40, 0x01,
  0xF0, 0x30, 0x01, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x3F, 0xE0, 0x03,
  0xC0, 0x1C, 0x78, 0x03, 0xC0, 0x1C, 0x3C, 0x03, 0xC0, 0x0E, 0x0E, 0x03,
  0xC0, 0x0E, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x81, 0xC0, 0x03, 0x83, 0xC1,
  0xE0, 0x01, 0xC1, 0xE1, 0xE0, 0x01, 0xE0, 0xE1, 0xE0, 0x00, 0xF0, 0x71,
  0xE0, 0x00, 0x38, 0x79, 0xE0, 0x00, 0x1C, 0x38, 0xE0, 0x00, 0x0F, 0x3C,
  0xE0, 0x00, 0x07, 0xFC, 0xF0, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x71, 0xF8, 0x00, 0x00,
  0x71, 0xFE, 0x00, 0x00, 0x71, 0xE7, 0x00, 0x00, 0x79, 0xE3, 0xC0, 0x00,
  0x78, 0xE1, 0xE0, 0x00, 0x78, 0xE0, 0x70, 0x00, 0x78, 0x70, 0x78, 0x00,
  0x38, 0x38, 0x3C, 0x00, 0x38, 0x1C, 0x1E, 0x00, 0x38, 0x1E, 0x0E, 0x00,
  0x3C, 0x0F, 0x07, 0x00, 0x3C, 0x07, 0x87, 0x80, 0x3C, 0x03, 0xC3, 0x80,
  0x3C, 0x00, 0xE3, 0xC0, 0x1C, 0x00, 0x7F, 0xC0, 0x3C, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0xF0, 0x07, 0x01,
  0xE0, 0x0E, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x7B, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x1C, 0x1F, 0xF0, 0x78,
  0x7D, 0xE0, 0xF1, 0xF1, 0xE1, 0xC7, 0x83, 0xE7, 0x8F, 0x03, 0xCE, 0x3C,
  0x03, 0xFC, 0x78, 0x07, 0xF8, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0,
  0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x7E, 0x1E, 0x01, 0xFC, 0x3E, 0x0F,
  0xF8, 0x3F, 0xFE, 0x78, 0x7F, 0xF0, 0xF0, 0x3F, 0xC1, 0xF0, 0x3C, 0xF3,
  0xDE, 0x79, 0xE7, 0x9C, 0xF3, 0xCE, 0x38, 0xE3, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x20, 0x38, 0x11, 0xC1, 0xC3, 0xDF, 0xCE, 0x7E, 0xFF, 0xEF, 0xF3, 0xFF,
  0xFF, 0x41, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xEF, 0x00,
  0x1E, 0x7C, 0x01, 0xF1, 0xE0, 0x1F, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x81,
  0xC0, 0x08, 0x04, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x0F, 0x03, 0xC0, 0xF8,
  0x3E, 0x7F, 0x8F, 0xE1, 0xF0, 0x30, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xF8, 0x3E, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x0F,
  0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x3E,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x3C, 0x1E, 0x78, 0x7E, 0x1E, 0x78,
  0x7E, 0x1E, 0x78, 0xFE, 0x1E, 0x78, 0xFE, 0x3C, 0xF0, 0x7C, 0x3C, 0xF0,
  0x38, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0,
  0x03, 0xC0, 0xF0, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xE0,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xBC, 0x03, 0xE3, 0xC0, 0x30, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x1E, 0x01, 0xF0, 0x0E, 0x00, 0x78, 0x02, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0xE0, 0x3E, 0x00, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x40, 0x01, 0xF0, 0x70,
  0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xDE, 0x00,
  0x0F, 0x9E, 0x00, 0x1F, 0x1C, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x3C, 0x00,
  0xF8, 0x3C, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C,
  0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x0C, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x3D, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7E, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x03,
  0xE0, 0x78, 0x07, 0xC0, 0x7F, 0x3F, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xF0,
  0x1F, 0x03, 0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x80,
  0x1E, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xFB,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0x8F, 0xE0, 0x1F, 0x03,
  0xF0, 0x3C, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x07, 0xE0, 0x7F, 0x7F,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F,
  0x00, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x1F, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFD, 0xE0, 0x00, 0x41, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xE7, 0xE0,
  0x80, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xE1, 0xE0, 0x0F, 0xFC,
  0x3C, 0x07, 0xFF, 0x8F, 0x83, 0xFF, 0xF1, 0xE0, 0xF8, 0x1C, 0x3C, 0x3E,
  0x07, 0x8F, 0x07, 0x80, 0xF1, 0xE1, 0xE0, 0x1E, 0x3C, 0x3C, 0x03, 0x87,
  0x87, 0x80, 0xF1, 0xE1, 0xE0, 0x1E, 0x3C, 0x3C, 0x03, 0xC7, 0x87, 0x80,
  0x70, 0xF0, 0xF0, 0x1E, 0x1E, 0x1E, 0x03, 0xC3, 0xC3, 0xC0, 0x78, 0x78,
  0x7C, 0x0F, 0x0F, 0x07, 0xC3, 0xC1, 0xE0, 0x7F, 0xF8, 0x3C, 0x0F, 0xFF,
  0x07, 0x80, 0x7F, 0xC0, 0x78, 0x00, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xF0, 0x40, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x1C, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x3C,
  0x07, 0x80, 0x07, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0x1E, 0x00,
  0x3C, 0x03, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x1E, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xC0, 0x7F, 0x01, 0xE0,
  0x07, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x03,
  0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1E,
  0x07, 0x80, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0x78, 0x1F, 0xE0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xF0, 0x07, 0xE0, 0x3C,
  0x00, 0x7C, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x3E, 0x1E, 0x00, 0x3F, 0x07, 0x80,
  0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xC0, 0x38, 0x03, 0xE0, 0x01, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x08, 0x01, 0xF8, 0x07, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0xF0, 0x3F, 0x80, 0x1E, 0x01, 0xF8, 0x03, 0x80, 0x0F, 0x00, 0xF0,
  0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x1F, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3E,
  0x07, 0x80, 0x1F, 0x80, 0xF0, 0x07, 0xE0, 0x1C, 0x07, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFC, 0x03, 0x80, 0x7C, 0x00, 0x20, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x0F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x07,
  0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x1E,
  0x03, 0xE0, 0x0F, 0x00, 0xFC, 0x03, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x07, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x1E,
  0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x03, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xF0,
  0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x08, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x01,
  0xE0, 0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0x79, 0xF0, 0x00, 0x03, 0x9F, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0E, 0x0F, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x01,
  0xE0, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x17, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xB8, 0x0E, 0xE0,
  0x1D, 0xC0, 0xEE, 0x00, 0xEE, 0x07, 0x70, 0x07, 0x70, 0x73, 0x80, 0x73,
  0x83, 0x9C, 0x03, 0x9E, 0x38, 0xE0, 0x1C, 0x71, 0xCF, 0x01, 0xC3, 0x9C,
  0x70, 0x0E, 0x1C, 0xC3, 0x80, 0x70, 0xEE, 0x1C, 0x07, 0x87, 0xE0, 0xE0,
  0x38, 0x3F, 0x0F, 0x01, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0x80, 0xF0,
  0x78, 0x1C, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x78, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xE0, 0x0F, 0x80,
  0x07, 0x80, 0x3F, 0x00, 0x1E, 0x01, 0xFC, 0x00, 0x78, 0x07, 0xF0, 0x01,
  0xC0, 0x1D, 0xE0, 0x0F, 0x00, 0x77, 0x80, 0x3C, 0x01, 0xCE, 0x00, 0xF0,
  0x0F, 0x38, 0x03, 0x80, 0x3C, 0xF0, 0x0E, 0x00, 0xE3, 0xC0, 0x78, 0x03,
  0x87, 0x01, 0xE0, 0x1E, 0x1C, 0x07, 0x00, 0x78, 0x78, 0x1C, 0x01, 0xC0,
  0xE0, 0xF0, 0x07, 0x03, 0x83, 0xC0, 0x3C, 0x0E, 0x0E, 0x00, 0xF0, 0x3C,
  0x38, 0x03, 0x80, 0x71, 0xE0, 0x0E, 0x01, 0xC7, 0x80, 0x78, 0x07, 0x1C,
  0x01, 0xE0, 0x1C, 0x70, 0x07, 0x00, 0x79, 0xC0, 0x1C, 0x00, 0xEF, 0x00,
  0xF0, 0x03, 0xBC, 0x03, 0xC0, 0x0E, 0xE0, 0x0E, 0x00, 0x3B, 0x80, 0x38,
  0x00, 0xFE, 0x01, 0xE0, 0x01, 0xF8, 0x07, 0x80, 0x07, 0xC0, 0x1E, 0x00,
  0x1F, 0x00, 0x70, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF3,
  0xC0, 0x00, 0x79, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x1E,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01,
  0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xC0, 0x00,
  0x78, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x0F, 0x00, 0xF8,
  0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x07, 0x80, 0x7E, 0x01, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x1E,
  0x00, 0x3C, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01,
  0xE0, 0x78, 0x00, 0xF8, 0x1C, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x03, 0xC0,
  0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x8F, 0x00,
  0x03, 0xC7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x3C,
  0x70, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x0F, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x1F, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0x80,
  0x7E, 0x01, 0xC0, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x0F,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x01, 0xF0, 0x03,
  0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x78,
  0x07, 0x80, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1C, 0x00,
  0x3C, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x38,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x08, 0x00, 0x3E, 0x03,
  0xC0, 0x1F, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x38,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x38,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x03, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x01, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0xF0,
  0x1E, 0x00, 0x38, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x0F, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0xF0, 0x00,
  0x38, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x0F, 0x03, 0xC0,
  0xF0, 0x78, 0x1C, 0x07, 0x87, 0xE0, 0xE0, 0x38, 0x3F, 0x0F, 0x01, 0xC3,
  0xB8, 0x70, 0x0E, 0x1D, 0xC3, 0x80, 0xF1, 0xCE, 0x1C, 0x07, 0x0E, 0x71,
  0xE0, 0x38, 0xE3, 0x8E, 0x01, 0xCF, 0x1C, 0x70, 0x0E, 0x70, 0xE7, 0x80,
  0x77, 0x07, 0x38, 0x03, 0x38, 0x19, 0xC0, 0x3B, 0x80, 0xEC, 0x01, 0xDC,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0xF9, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x87, 0x80, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x00,
  0x7C, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0x81, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x0F,
  0x0F, 0x0F, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3D,
  0xC0, 0x01, 0xE7, 0x00, 0x0F, 0x1E, 0x00, 0x7C, 0x38, 0x01, 0xE0, 0xE0,
  0x0F, 0x03, 0xC0, 0x78, 0x07, 0x03, 0xC0, 0x1C, 0x1F, 0x00, 0x78, 0x78,
  0x01, 0xE3, 0xC0, 0x03, 0x9E, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0xC0, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x20,
  0x70, 0xF8, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x02, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0x1E, 0x03, 0xF0, 0x1E,
  0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x1C, 0x3E, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xE0,
  0x78, 0x01, 0xE0, 0x7C, 0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFE, 0xF0,
  0x0F, 0xF8, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xCF, 0xE0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x7C,
  0x78, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xF0, 0x70, 0x07, 0xE0,
  0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x1E,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x10, 0x7E, 0x00, 0x60, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xF0, 0xF0, 0x07, 0xE0, 0x1E, 0x01, 0xF8, 0x03, 0x80, 0x7C, 0x00,
  0x70, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x1E,
  0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0x38, 0x07, 0x80, 0x07, 0x00, 0xF0, 0x01, 0xE0,
  0x1E, 0x00, 0x7C, 0x01, 0xE0, 0x1F, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xCE, 0x00, 0x3F, 0xF1, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xC3, 0xF0, 0x7C, 0x01, 0xE1,
  0xF0, 0x03, 0xC7, 0xC0, 0x07, 0x9F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF8,
  0x00, 0x7D, 0xE0, 0x01, 0xF3, 0xC0, 0x0F, 0xCF, 0x07, 0xFF, 0x9F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x02,
  0x1F, 0x80, 0x38, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x43, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0x1E, 0x00, 0x7F, 0x01, 0xE0, 0x0F, 0xC0, 0x1E, 0x00, 0xF8, 0x01, 0xE0,
  0x1F, 0x00, 0x1C, 0x03, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x07, 0x80,
  0x03, 0xC0, 0x78, 0x00, 0x38, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x0F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x20, 0x01, 0xF0, 0x07,
  0x80, 0x7E, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xCF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x38, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x84,
  0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x10, 0x03, 0xC0, 0x0F, 0x03,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0xF8, 0x07, 0x80, 0xF8, 0x03, 0xC1, 0xF8, 0x01,
  0xE1, 0xF0, 0x00, 0xF3, 0xF0, 0x00, 0xF3, 0xF0, 0x00, 0x7B, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0xF8, 0x00, 0x0F, 0x3E, 0x00,
  0x07, 0x8F, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xC0, 0xF8, 0x01, 0xE0, 0x3E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x38, 0x01, 0xF0, 0x3C, 0x00,
  0x78, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x07, 0xC0, 0x7F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x3F, 0xFC, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0,
  0x4F, 0xFF, 0x3F, 0xFC, 0x7F, 0xF0, 0x18, 0x00, 0x00, 0xFE, 0x1F, 0x00,
  0xFF, 0xDF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0x3F, 0xDF, 0x07, 0x87, 0xC3,
  0xC1, 0xC0, 0xE0, 0xF0, 0xF0, 0x78, 0x1C, 0x3C, 0x1E, 0x0F, 0x0F, 0x07,
  0x83, 0xC3, 0x81, 0xE0, 0xF0, 0xE0, 0x70, 0x38, 0x78, 0x3C, 0x1E, 0x1E,
  0x0F, 0x07, 0x87, 0x03, 0xC1, 0xE1, 0xC0, 0xE0, 0x70, 0xF0, 0x78, 0x3C,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE1, 0xE0, 0x00,
  0x38, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x70, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x78, 0x03, 0xC0,
  0xE0, 0x07, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xC3, 0xC0,
  0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x78, 0x00,
  0xF0, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E,
  0x1C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC0,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFC, 0x07, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x1F, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x3E,
  0x1F, 0x00, 0xFC, 0x1F, 0x07, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x0E, 0x00, 0x7C, 0x03,
  0xC0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01,
  0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x3C, 0x01, 0xF8, 0x07, 0x80, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xF3, 0x40,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xC1, 0xE0, 0x3F, 0x00, 0xF0, 0x3E, 0x00, 0x78,
  0x3E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0,
  0x0F, 0x81, 0xF0, 0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07,
  0xFE, 0xF0, 0x00, 0x30, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xC0, 0x60, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0x3E, 0x07, 0xC0, 0x08,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE1, 0x00, 0x0F, 0x87, 0x00,
  0x7C, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x30, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x70, 0xE0,
  0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0E, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xC3, 0xC0, 0x07,
  0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F,
  0x00, 0x7E, 0x1F, 0x01, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFE, 0xF0, 0x1F,
  0xF0, 0xE0, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xBC, 0x00,
  0x3D, 0xE0, 0x01, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xC0, 0xE0, 0x1E,
  0x07, 0x81, 0xE0, 0x3C, 0x0E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x78,
  0x78, 0x03, 0xC7, 0x80, 0x0E, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1C, 0x07, 0x01, 0xC3, 0x80,
  0xE0, 0x78, 0x70, 0x3C, 0x0E, 0x1E, 0x0F, 0x83, 0xC3, 0xC1, 0xF0, 0x78,
  0x78, 0x7E, 0x0E, 0x0F, 0x0F, 0xE3, 0xC1, 0xE3, 0x9C, 0x70, 0x3C, 0xF3,
  0x9E, 0x07, 0x9C, 0x73, 0xC0, 0xE7, 0x0E, 0x70, 0x1C, 0xE1, 0xDE, 0x03,
  0xB8, 0x3B, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x78, 0x07, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x07,
  0x80, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3C,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F,
  0x38, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x02,
  0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x06,
  0x0F, 0xF0, 0x07, 0x1F, 0xFC, 0x0F, 0x3C, 0x7E, 0x1E, 0x78, 0x1F, 0xFC,
  0x70, 0x0F, 0xF8, 0xF0, 0x03, 0xF0,
};

const GFXglyph UbuntuSansMono_Italic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 12, 35, 27, 8, -34 },
  { 54, 14, 13, 27, 11, -37 },
  { 77, 29, 34, 27, 0, -34 },
  { 201, 25, 43, 27, 2, -38 },
  { 336, 33, 36, 27, -2, -35 },
  { 485, 23, 35, 27, 1, -35 },
  { 586, 6, 14, 27, 15, -37 },
  { 597, 20, 47, 27, 6, -38 },
  { 715, 21, 47, 27, 1, -38 },
  { 839, 21, 20, 27, 6, -34 },
  { 892, 22, 24, 27, 3, -26 },
  { 958, 11, 15, 27, 4, -7 },
  { 979, 12, 4, 27, 8, -16 },
  { 985, 7, 8, 27, 8, -7 },
  { 992, 31, 47, 27, -3, -38 },
  { 1175, 24, 36, 27, 3, -35 },
  { 1283, 20, 34, 27, 3, -34 },
  { 1368, 25, 35, 27, 2, -35 },
  { 1478, 24, 36, 27, 2, -35 },
  { 1586, 24, 34, 27, 1, -34 },
  { 1688, 27, 35, 27, 1, -34 },
  { 1807, 24, 35, 27, 4, -34 },
  { 1912, 24, 34, 27, 6, -34 },
  { 2014, 24, 36, 27, 3, -35 },
  { 2122, 25, 35, 27, 2, -35 },
  { 2232, 12, 26, 27, 8, -25 },
  { 2271, 16, 33, 27, 4, -25 },
  { 2337, 24, 22, 27, 2, -25 },
  { 2403, 25, 13, 27, 2, -21 },
  { 2444, 24, 22, 27, 1, -25 },
  { 2510, 19, 36, 27, 7, -35 },
  { 2596, 27, 42, 27, 2, -35 },
  { 2738, 27, 34, 27, -3, -34 },
  { 2853, 26, 34, 27, 0, -34 },
  { 2964, 27, 36, 27, 3, -35 },
  { 3086, 27, 34, 27, 0, -34 },
  { 3201, 27, 34, 27, 2, -34 },
  { 3316, 27, 34, 27, 2, -34 },
  { 3431, 26, 36, 27, 2, -35 },
  { 3548, 29, 34, 27, 0, -34 },
  { 3672, 25, 34, 27, 2, -34 },
  { 3779, 26, 35, 27, 2, -34 },
  { 3893, 29, 34, 27, 1, -34 },
  { 4017, 20, 34, 27, 1, -34 },
  { 4102, 29, 34, 27, -1, -34 },
  { 4226, 30, 34, 27, 0, -34 },
  { 4354, 25, 36, 27, 3, -35 },
  { 4467, 26, 34, 27, 1, -34 },
  { 4578, 25, 44, 27, 3, -35 },
  { 4716, 26, 34, 27, 1, -34 },
  { 4827, 27, 36, 27, 1, -35 },
  { 4949, 23, 34, 27, 7, -34 },
  { 5047, 27, 35, 27, 3, -34 },
  { 5166, 26, 34, 27, 5, -34 },
  { 5277, 29, 34, 27, 2, -34 },
  { 5401, 32, 34, 27, -1, -34 },
  { 5537, 26, 34, 27, 6, -34 },
  { 5648, 29, 34, 27, 0, -34 },
  { 5772, 25, 47, 27, 3, -38 },
  { 5919, 8, 47, 27, 10, -38 },
  { 5966, 24, 47, 27, -1, -38 },
  { 6107, 22, 18, 27, 4, -34 },
  { 6157, 25, 3, 27, -3, 6 },
  { 6167, 8, 10, 27, 13, -38 },
  { 6177, 24, 27, 27, 2, -26 },
  { 6258, 24, 38, 27, 2, -38 },
  { 6372, 24, 27, 27, 2, -26 },
  { 6453, 27, 39, 27, 3, -38 },
  { 6585, 23, 27, 27, 2, -26 },
  { 6663, 32, 47, 27, -1, -38 },
  { 6851, 28, 35, 27, -1, -26 },
  { 6974, 24, 38, 27, 0, -38 },
  { 7088, 15, 37, 27, 6, -37 },
  { 7158, 26, 46, 27, 0, -37 },
  { 7308, 25, 38, 27, 2, -38 },
  { 7427, 14, 39, 27, 8, -38 },
  { 7496, 26, 26, 27, 0, -26 },
  { 7581, 23, 26, 27, 2, -26 },
  { 7656, 23, 27, 27, 3, -26 },
  { 7734, 27, 35, 27, -1, -26 },
  { 7853, 25, 35, 27, 2, -26 },
  { 7963, 23, 26, 27, 3, -26 },
  { 8038, 22, 27, 27, 3, -26 },
  { 8113, 20, 34, 27, 6, -33 },
  { 8198, 23, 26, 27, 3, -25 },
  { 8273, 21, 25, 27, 6, -25 },
  { 8339, 27, 25, 27, 3, -25 },
  { 8424, 29, 25, 27, -1, -25 },
  { 8515, 30, 34, 27, -3, -25 },
  { 8643, 25, 25, 27, 1, -25 },
  { 8722, 26, 47, 27, 3, -38 },
  { 8875, 15, 47, 27, 7, -38 },
  { 8964, 26, 47, 27, -2, -38 },
  { 9117, 24, 7, 27, 2, -18 },
};

const GFXfont UbuntuSansMono_Italic49pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic49pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic49pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _UBUNTUSANSMONO_ITALIC49PT7B_H_
