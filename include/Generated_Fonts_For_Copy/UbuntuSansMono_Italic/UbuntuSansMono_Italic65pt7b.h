#ifndef _UBUNTUSANSMONO_ITALIC65PT7B_H_
#define _UBUNTUSANSMONO_ITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xE0,
  0x01, 0xE0, 0x00, 0x1F, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x1F, 0x01,
  0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x3C, 0x78, 0x07,
  0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x38, 0x07, 0x87, 0x00, 0xE1, 0xE0, 0x1C,
  0x38, 0x03, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xBF, 0xE0, 0x03, 0xF8, 0x00, 0x70, 0x03, 0xF0, 0x00, 0x10, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x10, 0x00, 0x03, 0xF0, 0x0E, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0x7C, 0x00, 0x3C, 0x07, 0x80, 0x1F, 0x00, 0x07, 0x80,
  0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xC0,
  0x3E, 0x00, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x03, 0xE0,
  0x00, 0x1E, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC0, 0x78, 0x3E, 0x00, 0x00,
  0x78, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x7C, 0x00, 0x00, 0x3C, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xC7,
  0xC0, 0x00, 0x00, 0xFF, 0xF1, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x7C, 0x00,
  0x00, 0x00, 0xFF, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x06, 0x00, 0x00, 0x00,
  0x0F, 0x87, 0xF8, 0x00, 0x00, 0x03, 0xE3, 0xFF, 0x80, 0x00, 0x00, 0x78,
  0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x1F, 0x00, 0x00, 0x07, 0xC7, 0x81,
  0xE0, 0x00, 0x01, 0xF0, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x3C, 0x07, 0x80,
  0x00, 0x1F, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x1E, 0x00, 0x00,
  0xF0, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x80,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xC0,
  0x78, 0x00, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x00, 0x07, 0xEF, 0xC0, 0x07, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0,
  0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xC0,
  0x7F, 0xE0, 0x1F, 0x03, 0xFF, 0xC0, 0x7C, 0x1F, 0x9F, 0x01, 0xE0, 0xFC,
  0x7E, 0x0F, 0x87, 0xC0, 0xFC, 0x3C, 0x3F, 0x01, 0xF1, 0xF0, 0xF8, 0x07,
  0xE7, 0xC7, 0xC0, 0x0F, 0x9E, 0x1F, 0x00, 0x1F, 0xF8, 0xFC, 0x00, 0x7F,
  0xC3, 0xF0, 0x00, 0xFF, 0x0F, 0x80, 0x03, 0xF8, 0x3E, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x3F,
  0x00, 0x1F, 0xF0, 0xFE, 0x01, 0xFF, 0xC1, 0xFC, 0x1F, 0xDF, 0x87, 0xFF,
  0xFE, 0x7E, 0x0F, 0xFF, 0xF0, 0xF8, 0x1F, 0xFF, 0x03, 0xF0, 0x3F, 0xF0,
  0x0F, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x00, 0xF8, 0x06, 0x7C, 0x1E, 0x07,
  0xDF, 0xE1, 0xC3, 0xFB, 0xFF, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x03, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x20, 0x06, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x30,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F,
  0x01, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xF8, 0x03, 0x80, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0E, 0x0F,
  0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x9F, 0xC1, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0xFC, 0x1F, 0x01,
  0xF9, 0xF0, 0x7F, 0x03, 0xF3, 0xE0, 0xFF, 0x07, 0xEF, 0xC3, 0xFE, 0x0F,
  0x9F, 0x07, 0xFC, 0x1F, 0x3E, 0x0F, 0xF8, 0x3E, 0x7C, 0x1F, 0xF0, 0xFD,
  0xF8, 0x1F, 0xC1, 0xF3, 0xF0, 0x1F, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x9F, 0x00, 0x7F, 0x0F,
  0x80, 0x3E, 0x0F, 0xC0, 0x1C, 0x07, 0xC0, 0x08, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x20, 0x00, 0x3F, 0x00, 0x20, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xE0,
  0x00, 0xF0, 0x03, 0xF8, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x30, 0x00, 0x1F, 0xE0, 0x1E, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0,
  0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x01, 0x00, 0x01, 0xFE, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x40, 0x00, 0x1F, 0x9F, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x83, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x1F, 0xE0,
  0x01, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0x03, 0xFC, 0x07, 0xFE, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xDF, 0x80, 0x03, 0xFF, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x23, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xC0, 0x3F, 0x80, 0x80, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xFE, 0x0F, 0x80, 0x1F, 0xFF, 0xC3, 0xF0,
  0x07, 0xFF, 0xF8, 0x7E, 0x03, 0xFF, 0xFF, 0x1F, 0x80, 0xFF, 0x07, 0xE3,
  0xF0, 0x3F, 0x80, 0xF8, 0x7C, 0x0F, 0xC0, 0x1F, 0x1F, 0x81, 0xF0, 0x03,
  0xE3, 0xF0, 0x7E, 0x00, 0xFC, 0x7C, 0x0F, 0x80, 0x1F, 0x0F, 0x83, 0xF0,
  0x03, 0xE3, 0xF0, 0x7C, 0x00, 0x7C, 0x7E, 0x0F, 0x80, 0x1F, 0x8F, 0x81,
  0xF0, 0x03, 0xE1, 0xF0, 0x3E, 0x00, 0x7C, 0x3E, 0x0F, 0xC0, 0x0F, 0x87,
  0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x07, 0xE0, 0x0F,
  0x83, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x81, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xFE, 0xFE, 0x07, 0xC0,
  0x3F, 0xFF, 0xC0, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0x80, 0x1F, 0xFE, 0x03,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x20, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x01, 0xFC,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x0F, 0xF0,
  0x1F, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0x80, 0x1F, 0xC0, 0x00, 0x60, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0x80, 0x03, 0xF8, 0x01,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xF8,
  0x03, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xF0, 0x0F, 0x80,
  0x01, 0xFC, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x0F,
  0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x1F,
  0xC0, 0x00, 0x60, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x08, 0x00, 0x0F, 0xE0, 0x03, 0xC0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x00,
  0x07, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x00, 0x3E, 0x07,
  0xF0, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x0F, 0xBF,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x07, 0xBC, 0x00, 0x39, 0xE0,
  0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0xF3, 0xC0,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0x0F, 0x1E, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0xF0, 0xF0,
  0x01, 0xE1, 0xE1, 0xE1, 0xE0, 0x03, 0xC3, 0xC7, 0x83, 0xC0, 0x0F, 0x83,
  0xCF, 0x0F, 0x80, 0x1F, 0x07, 0xBC, 0x1F, 0x00, 0x3C, 0x0F, 0x70, 0x3E,
  0x00, 0xF8, 0x1F, 0xE0, 0x78, 0x01, 0xF0, 0x3F, 0x80, 0xF0, 0x03, 0xC0,
  0x7F, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x00, 0x1E,
  0x00, 0x7F, 0x80, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x07, 0xFC,
  0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0xFB, 0xC0, 0x01, 0xF0,
  0x03, 0xEF, 0x80, 0x07, 0xC0, 0x0F, 0x3E, 0x00, 0x1F, 0x00, 0x3C, 0xF8,
  0x00, 0x7C, 0x01, 0xF1, 0xE0, 0x01, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x80,
  0x1E, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0xF8,
  0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x7C, 0x00,
  0xF0, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x1F, 0x01, 0xF0,
  0x3E, 0x00, 0x7C, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x0F, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x03, 0xE1,
  0xF0, 0x03, 0xC0, 0x07, 0x87, 0xC0, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x7C,
  0x00, 0x78, 0x78, 0x01, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0x80, 0x03, 0xCF,
  0x80, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0xF8, 0x00, 0x3C, 0xF0, 0x03, 0xE0,
  0x00, 0xF7, 0xC0, 0x0F, 0x00, 0x03, 0xFF, 0x00, 0x3C, 0x00, 0x07, 0xFC,
  0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0x00,
  0x01, 0xFE, 0x00, 0x78, 0x00, 0x07, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0xC0,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x1F,
  0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00,
  0x7F, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xF0,
  0x07, 0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x3E, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0x00, 0x0F, 0xC0, 0x00, 0x20, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x30, 0x00, 0x0F,
  0xE0, 0x0F, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x07, 0xFD,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0x78,
  0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x3F, 0x80, 0xF8, 0x03, 0xE0, 0x7F, 0x01,
  0xE0, 0x07, 0xC1, 0xEE, 0x03, 0xC0, 0x0F, 0x03, 0xDE, 0x0F, 0x80, 0x1E,
  0x0F, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x78, 0x3C, 0x00, 0xF8, 0x78, 0xF0,
  0xF8, 0x01, 0xF1, 0xF1, 0xE1, 0xE0, 0x03, 0xC3, 0xC3, 0xC3, 0xC0, 0x07,
  0x8F, 0x87, 0x87, 0x80, 0x0F, 0x1E, 0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x1E,
  0x3C, 0x00, 0x38, 0xF0, 0x3C, 0x78, 0x00, 0xF3, 0xC0, 0x39, 0xE0, 0x01,
  0xEF, 0x80, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x01,
  0xEE, 0x00, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x78, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x3F, 0x0F, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x80, 0x78, 0x01, 0xF8, 0x07, 0x80, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x07,
  0xC0, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x3F,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0xE1, 0x00, 0x00, 0x08, 0x7F, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFE, 0x18, 0x0F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C,
  0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFC, 0x03, 0xE0, 0x3F, 0xC0, 0x0F, 0x80, 0xFE, 0x00, 0x1F, 0x03, 0xF8,
  0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF8, 0x0F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xF1, 0xFF, 0xF0, 0x1F, 0xFF, 0xFB, 0xE0, 0x1F,
  0xFF, 0xE7, 0xC0, 0x0F, 0xFF, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x0C, 0x00, 0x00, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xF0, 0x3E,
  0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x7F, 0x80, 0x7C,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x0E, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x40, 0x1F,
  0xC0, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x1E, 0x00, 0x0F, 0xF0,
  0x03, 0xE0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x07,
  0xF0, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x07,
  0xFC, 0x00, 0x3F, 0xE7, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xBE, 0x00, 0x0F,
  0xFF, 0xF3, 0xE0, 0x00, 0x3F, 0xFC, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x0F,
  0xC0, 0xFE, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3F, 0x8F, 0x80, 0x00, 0xFE, 0x3F,
  0x00, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x04, 0x07, 0xFC, 0x00, 0x78, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x03, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x10, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x07, 0xF8, 0x00, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x03,
  0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xDF, 0x00, 0x00,
  0x0F, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x04, 0x00, 0x01, 0xF8, 0x00,
  0x30, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFB, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFC, 0x0F, 0xF8, 0x0F,
  0xC0, 0x07, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC3, 0x03, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x00, 0x03, 0xF0, 0x00, 0x30, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0,
  0x03, 0xF8, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x1F,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x03, 0xE0, 0x3F, 0x80, 0x00,
  0xF8, 0x3F, 0xC0, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x1F, 0x1F, 0xE0, 0x00,
  0x07, 0xCF, 0xF0, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xEF, 0xE0,
  0x00, 0x00, 0xF9, 0xFC, 0x00, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0x1F, 0x07,
  0xF0, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF,
  0x1F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x33, 0xFE, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0x00, 0x08, 0x00, 0x0F, 0xFE,
  0x1F, 0xE0, 0x03, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0xFF, 0x0F, 0xC0, 0x78, 0x0F, 0x81, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x7C,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x07, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0x3E,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0x80, 0x7F,
  0x80, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x03, 0xF0, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7D, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0x00, 0xFF, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x3E, 0x03, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0xF3, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xDF, 0x00, 0x00, 0xFE, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xE0, 0x00, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x40, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x60, 0x00, 0x1F, 0x01, 0xE0, 0x01,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xFC,
  0x0F, 0xC0, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF7, 0xC0, 0x1F, 0xFF, 0xCF, 0x80, 0x1F, 0xFE, 0x0F, 0x80,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x07, 0x83, 0xE0, 0x0F, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x01, 0xF0, 0x3C, 0x03, 0xF0,
  0x1F, 0x03, 0xC0, 0x7F, 0x01, 0xF0, 0x7C, 0x07, 0xF0, 0x3E, 0x07, 0xC0,
  0xFF, 0x03, 0xE0, 0x7C, 0x0F, 0xF0, 0x3C, 0x07, 0xC1, 0xEF, 0x07, 0xC0,
  0x7C, 0x3E, 0xF0, 0x7C, 0x07, 0xC3, 0xCF, 0x8F, 0x80, 0x7C, 0x78, 0x78,
  0xF8, 0x07, 0xC7, 0x87, 0x8F, 0x00, 0x7C, 0xF0, 0x79, 0xF0, 0x07, 0xDF,
  0x07, 0x9E, 0x00, 0x79, 0xE0, 0x7B, 0xE0, 0x07, 0xBC, 0x07, 0xBE, 0x00,
  0x7B, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xBE, 0x00, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x20, 0x07, 0xE0, 0x00, 0x00, 0x30, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x08, 0x07, 0xFE, 0x00, 0x1F, 0x0F, 0xFF,
  0x80, 0x1E, 0x1F, 0xFF, 0xC0, 0x3E, 0x3F, 0x1F, 0xE0, 0x7C, 0x3E, 0x07,
  0xFD, 0xFC, 0x7C, 0x03, 0xFF, 0xF8, 0x78, 0x00, 0xFF, 0xF0, 0xF0, 0x00,
  0x7F, 0xE0, 0x10, 0x00, 0x1F, 0x00,
};

const GFXglyph UbuntuSansMono_Italic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 17, 46, 36, 10, -45 },
  { 99, 19, 17, 36, 14, -49 },
  { 140, 39, 45, 36, 0, -45 },
  { 360, 33, 57, 36, 3, -50 },
  { 596, 43, 47, 36, -2, -46 },
  { 849, 30, 47, 36, 2, -46 },
  { 1026, 8, 18, 36, 20, -49 },
  { 1044, 27, 63, 36, 8, -51 },
  { 1257, 27, 63, 36, 2, -51 },
  { 1470, 27, 26, 36, 8, -45 },
  { 1558, 30, 32, 36, 4, -35 },
  { 1678, 15, 20, 36, 5, -10 },
  { 1716, 16, 5, 36, 11, -21 },
  { 1726, 10, 11, 36, 10, -10 },
  { 1740, 41, 63, 36, -4, -51 },
  { 2063, 31, 47, 36, 4, -46 },
  { 2246, 25, 45, 36, 5, -45 },
  { 2387, 32, 46, 36, 3, -46 },
  { 2571, 33, 47, 36, 2, -46 },
  { 2765, 33, 45, 36, 1, -45 },
  { 2951, 35, 46, 36, 2, -45 },
  { 3153, 32, 46, 36, 5, -45 },
  { 3337, 32, 45, 36, 8, -45 },
  { 3517, 33, 47, 36, 3, -46 },
  { 3711, 33, 46, 36, 3, -46 },
  { 3901, 16, 35, 36, 10, -34 },
  { 3971, 21, 44, 36, 5, -34 },
  { 4087, 32, 29, 36, 3, -33 },
  { 4203, 33, 18, 36, 2, -28 },
  { 4278, 31, 29, 36, 2, -33 },
  { 4391, 26, 47, 36, 9, -46 },
  { 4544, 35, 56, 36, 3, -46 },
  { 4789, 35, 45, 36, -4, -45 },
  { 4986, 34, 46, 36, 1, -46 },
  { 5182, 35, 47, 36, 4, -46 },
  { 5388, 35, 46, 36, 0, -46 },
  { 5590, 36, 45, 36, 3, -45 },
  { 5793, 36, 45, 36, 3, -45 },
  { 5996, 35, 47, 36, 3, -46 },
  { 6202, 39, 45, 36, 0, -45 },
  { 6422, 33, 45, 36, 3, -45 },
  { 6608, 35, 46, 36, 3, -45 },
  { 6810, 39, 45, 36, 1, -45 },
  { 7030, 26, 45, 36, 1, -45 },
  { 7177, 39, 45, 36, -1, -45 },
  { 7397, 38, 45, 36, 1, -45 },
  { 7611, 34, 47, 36, 3, -46 },
  { 7811, 35, 46, 36, 1, -46 },
  { 8013, 34, 58, 36, 3, -46 },
  { 8260, 35, 46, 36, 1, -46 },
  { 8462, 35, 47, 36, 2, -46 },
  { 8668, 31, 45, 36, 9, -45 },
  { 8843, 35, 46, 36, 4, -45 },
  { 9045, 35, 45, 36, 7, -45 },
  { 9242, 39, 45, 36, 2, -45 },
  { 9462, 43, 45, 36, -2, -45 },
  { 9704, 35, 45, 36, 8, -45 },
  { 9901, 39, 45, 36, 0, -45 },
  { 10121, 32, 63, 36, 5, -51 },
  { 10373, 11, 63, 36, 13, -51 },
  { 10460, 32, 63, 36, -1, -51 },
  { 10712, 28, 24, 36, 6, -45 },
  { 10796, 34, 4, 36, -5, 8 },
  { 10813, 11, 13, 36, 17, -50 },
  { 10831, 31, 35, 36, 3, -34 },
  { 10967, 32, 51, 36, 2, -50 },
  { 11171, 32, 36, 36, 2, -35 },
  { 11315, 36, 51, 36, 3, -50 },
  { 11545, 31, 35, 36, 2, -34 },
  { 11681, 42, 62, 36, -1, -50 },
  { 12007, 37, 46, 36, -1, -34 },
  { 12220, 30, 50, 36, 1, -50 },
  { 12408, 20, 50, 36, 8, -50 },
  { 12533, 35, 62, 36, -1, -50 },
  { 12805, 34, 50, 36, 2, -50 },
  { 13018, 18, 51, 36, 11, -50 },
  { 13133, 35, 35, 36, 0, -35 },
  { 13287, 31, 34, 36, 2, -34 },
  { 13419, 31, 35, 36, 3, -34 },
  { 13555, 35, 46, 36, -1, -34 },
  { 13757, 32, 46, 36, 3, -34 },
  { 13941, 31, 34, 36, 4, -34 },
  { 14073, 30, 35, 36, 4, -34 },
  { 14205, 26, 45, 36, 8, -44 },
  { 14352, 31, 35, 36, 4, -34 },
  { 14488, 28, 34, 36, 8, -34 },
  { 14607, 36, 34, 36, 3, -34 },
  { 14760, 38, 34, 36, -1, -34 },
  { 14922, 40, 46, 36, -4, -34 },
  { 15152, 32, 34, 36, 2, -34 },
  { 15288, 35, 63, 36, 4, -51 },
  { 15564, 20, 63, 36, 9, -51 },
  { 15722, 35, 63, 36, -3, -51 },
  { 15998, 32, 10, 36, 3, -24 },
};

const GFXfont UbuntuSansMono_Italic65pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic65pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic65pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _UBUNTUSANSMONO_ITALIC65PT7B_H_
