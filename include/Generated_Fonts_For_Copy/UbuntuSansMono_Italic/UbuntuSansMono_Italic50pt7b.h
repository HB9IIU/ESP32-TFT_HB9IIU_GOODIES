#ifndef _UBUNTUSANSMONO_ITALIC50PT7B_H_
#define _UBUNTUSANSMONO_ITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0x60, 0x00,
  0x3C, 0x1C, 0xE0, 0x73, 0x83, 0xDE, 0x0E, 0x78, 0x39, 0xC0, 0xE7, 0x07,
  0x9C, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x06, 0x30, 0x18, 0xC0, 0xE0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0xF0, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x70, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xC3, 0xE0, 0x1F, 0x80, 0x10, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x20, 0x00, 0xF8, 0x0E, 0x00,
  0x7C, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x03, 0xC0, 0x1F, 0xE0, 0x01, 0xE0, 0x0F, 0x3C, 0x00, 0xF0, 0x07,
  0x87, 0x00, 0x78, 0x01, 0xC1, 0xC0, 0x3C, 0x00, 0xF0, 0x70, 0x1E, 0x00,
  0x38, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC1, 0xE0,
  0x00, 0xE0, 0xF0, 0xF0, 0x00, 0x38, 0x38, 0x78, 0x00, 0x0E, 0x0E, 0x3C,
  0x00, 0x03, 0x87, 0x9E, 0x00, 0x00, 0xE1, 0xC7, 0x00, 0x00, 0x3F, 0xE3,
  0x80, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x00, 0x1E, 0x3F, 0x80, 0x00,
  0x07, 0x1F, 0xF0, 0x00, 0x03, 0x8F, 0x3C, 0x00, 0x01, 0xE7, 0x87, 0x00,
  0x00, 0xF1, 0xC1, 0xC0, 0x00, 0x78, 0x70, 0x70, 0x00, 0x3C, 0x38, 0x1C,
  0x00, 0x1E, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x81, 0xC0, 0x03, 0x80, 0xE0,
  0xF0, 0x01, 0xE0, 0x38, 0x3C, 0x00, 0xF0, 0x0E, 0x0E, 0x00, 0x78, 0x03,
  0x87, 0x80, 0x3C, 0x00, 0xF1, 0xC0, 0x0E, 0x00, 0x3F, 0xE0, 0x0F, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x1E, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0,
  0x7C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xF0, 0x01, 0xE7,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x0C, 0x03, 0xFC,
  0x0F, 0x07, 0xFC, 0x0E, 0x0F, 0x9E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x0F,
  0x1C, 0x3C, 0x0F, 0xBC, 0x78, 0x07, 0xB8, 0x78, 0x03, 0xF8, 0x78, 0x03,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x03,
  0xF0, 0x78, 0x07, 0xF8, 0x7E, 0x1F, 0x78, 0x3F, 0xFE, 0x78, 0x3F, 0xFC,
  0x7C, 0x0F, 0xF0, 0x3C, 0x1E, 0x78, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0x70,
  0xE1, 0xC7, 0x8E, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x01,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x01, 0x81, 0xC0, 0xCF,
  0x8E, 0x3E, 0xFF, 0x77, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x01, 0xEE, 0x00, 0x0F, 0x78, 0x00, 0xF1, 0xE0, 0x0F,
  0x8F, 0x80, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x0C, 0x06, 0x00, 0x40, 0x20,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xE0,
  0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x8F, 0xF0, 0xFE, 0x0F, 0x80, 0xE0, 0x00,
  0x7F, 0xFB, 0xFF, 0x9F, 0xFD, 0xFF, 0xE0, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFE, 0x7C, 0x30, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0x1E,
  0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F,
  0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F,
  0x3C, 0x08, 0x0F, 0x3C, 0x7E, 0x0F, 0x78, 0x7E, 0x1F, 0x78, 0x7F, 0x1E,
  0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0xF0, 0x7C, 0x3E, 0xF0, 0x10, 0x3C,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0,
  0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xDE, 0x03, 0xF3, 0xC0, 0x3C, 0x3C, 0x02, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0x03, 0xE0, 0x1C, 0x00, 0xF8, 0x04, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x10, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x1E, 0x07, 0xE0, 0x0C, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC1, 0x00, 0x07, 0xC0, 0xE0, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xB8, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x9E,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x83,
  0xC0, 0x0F, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x0F, 0x03, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x20, 0x01, 0xF8, 0x03, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF1, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF3, 0xF8,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x0F, 0x83, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x7F, 0x3F, 0x80, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x03, 0xE0,
  0x3E, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0x78, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x07, 0xE1,
  0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xF0,
  0x7E, 0x01, 0xE0, 0x1F, 0x81, 0xE0, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x07, 0xC1,
  0xF0, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0xF8, 0x01, 0xE0,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x01, 0xF0, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x81,
  0xF8, 0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x9F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0x3F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x7C, 0x03,
  0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0xFF,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0,
  0x02, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x40, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xF0, 0x7C, 0x01, 0xF8, 0x07, 0xC0,
  0x7E, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0xF8, 0x00,
  0x3C, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF1, 0xF0, 0x03, 0xFE, 0x3C,
  0x03, 0xFF, 0xC7, 0x81, 0xFF, 0xF1, 0xF0, 0x7F, 0x3E, 0x3C, 0x1F, 0x03,
  0xC7, 0x87, 0xC0, 0x79, 0xF0, 0xF0, 0x1E, 0x3C, 0x3C, 0x03, 0xC7, 0x87,
  0x80, 0x78, 0xF0, 0xF0, 0x0F, 0x3E, 0x3E, 0x03, 0xC7, 0x87, 0x80, 0x78,
  0xF0, 0xF0, 0x0F, 0x1E, 0x1E, 0x01, 0xE3, 0xC3, 0xC0, 0x38, 0x78, 0x3C,
  0x0F, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0xF8, 0x3C, 0x3C, 0x0F, 0xFF, 0x87,
  0x80, 0xFF, 0xE0, 0xF8, 0x0F, 0xFC, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFE, 0x08, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x70, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x00,
  0x38, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x00,
  0xE0, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x78, 0x3F, 0xE0, 0x0F, 0x00, 0x7E, 0x03, 0xC0, 0x07,
  0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0x80, 0x0F, 0x80,
  0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1F,
  0x03, 0xC0, 0x1F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0x03, 0xE0, 0x1F, 0x80, 0x0C, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x08, 0x01,
  0xF8, 0x07, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0xF8, 0xFF, 0x80, 0x1E, 0x01, 0xF8, 0x03, 0xC0,
  0x0F, 0x80, 0x78, 0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x1E, 0x00,
  0xFC, 0x03, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x01, 0xE0,
  0x0F, 0x80, 0x08, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80,
  0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0x80, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x1E,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x40, 0x03, 0xC0, 0x08,
  0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFC,
  0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x01,
  0xE0, 0x0F, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF0,
  0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x38, 0x3E,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x1E, 0x7C, 0x00,
  0x00, 0x77, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x1B, 0x80, 0xEE, 0x00, 0xEF, 0x03, 0xB8, 0x03, 0xBC,
  0x1C, 0xE0, 0x0E, 0xF0, 0xF7, 0x80, 0x71, 0xC3, 0x9C, 0x01, 0xC7, 0x1C,
  0x70, 0x07, 0x1C, 0x71, 0xC0, 0x3C, 0x73, 0x87, 0x00, 0xE1, 0xCE, 0x3C,
  0x03, 0x87, 0x70, 0xF0, 0x1E, 0x1F, 0xC3, 0x80, 0x70, 0x7E, 0x0E, 0x01,
  0xC1, 0xF0, 0x38, 0x0F, 0x07, 0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0x80, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xC0,
  0x3F, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0x38, 0x07, 0xF0, 0x01, 0xE0, 0x1F,
  0xE0, 0x07, 0x80, 0x7F, 0x80, 0x1E, 0x01, 0xCE, 0x00, 0x70, 0x07, 0x3C,
  0x03, 0xC0, 0x3C, 0xF0, 0x0F, 0x00, 0xF1, 0xC0, 0x3C, 0x03, 0x87, 0x00,
  0xE0, 0x0E, 0x1E, 0x07, 0x80, 0x78, 0x78, 0x1E, 0x01, 0xE0, 0xE0, 0x78,
  0x07, 0x03, 0x81, 0xC0, 0x1C, 0x0F, 0x07, 0x00, 0xF0, 0x3C, 0x3C, 0x03,
  0xC0, 0x70, 0xF0, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0x07, 0x0E, 0x01, 0xE0,
  0x1E, 0x78, 0x07, 0x80, 0x39, 0xE0, 0x1E, 0x00, 0xE7, 0x00, 0x70, 0x03,
  0x9C, 0x03, 0xC0, 0x0E, 0xF0, 0x0F, 0x00, 0x3F, 0xC0, 0x3C, 0x00, 0x7E,
  0x00, 0xE0, 0x01, 0xF8, 0x07, 0x80, 0x07, 0xE0, 0x1E, 0x00, 0x1F, 0x80,
  0x78, 0x00, 0x7E, 0x01, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x07,
  0xE0, 0x3E, 0x00, 0xF0, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0x80,
  0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79,
  0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x0F,
  0x80, 0xF8, 0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x78, 0x1F, 0xE0, 0x1E, 0x00, 0x7C, 0x03, 0xC0,
  0x07, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x38, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07,
  0x00, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x1E, 0x00, 0x7C, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7,
  0x80, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3D,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x0F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xC1, 0xFE, 0x01,
  0xE0, 0x0F, 0xC0, 0x78, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0x81, 0xF0, 0x01, 0xE0, 0x3C,
  0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0x01, 0xE0, 0x0F, 0x80, 0x04, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x08, 0x00, 0x3F,
  0x03, 0xC0, 0x0F, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x3E, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x78, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07,
  0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xE0, 0x00,
  0x1E, 0x38, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x07, 0x83,
  0xE0, 0xF0, 0x3C, 0x3F, 0x07, 0x81, 0xC1, 0xF8, 0x38, 0x0E, 0x1F, 0xC1,
  0xC0, 0x70, 0xEE, 0x1E, 0x07, 0x8E, 0x70, 0xE0, 0x3C, 0x73, 0x87, 0x01,
  0xC7, 0x0C, 0x78, 0x0E, 0x78, 0x73, 0x80, 0x73, 0x83, 0x9C, 0x03, 0xBC,
  0x1C, 0xE0, 0x19, 0xC0, 0xEE, 0x01, 0xDC, 0x07, 0x70, 0x0E, 0xE0, 0x3B,
  0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0,
  0x07, 0x80, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x0F,
  0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x1E, 0x3C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x81, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3D,
  0xE0, 0x03, 0xC7, 0x00, 0x3C, 0x38, 0x03, 0xE1, 0xE0, 0x3E, 0x0F, 0x01,
  0xE0, 0x38, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x39, 0xF0, 0x01,
  0xEF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xC8, 0x00, 0x08, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0x38, 0x3E,
  0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0x07, 0xE0, 0x0F,
  0x0F, 0xC0, 0x0E, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF0,
  0x78, 0x01, 0xF0, 0x7C, 0x07, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFE, 0x70,
  0x0F, 0xF8, 0x78, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0x80, 0x03, 0xDF, 0xF0,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xE0, 0x3E, 0x07, 0x80, 0x1F,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x1C, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x38, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x01, 0xF0,
  0x70, 0x07, 0xE0, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xF0, 0x06, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x10, 0x7E, 0x00, 0x70, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x04, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x03, 0xF8, 0x0E, 0x00, 0xFC, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x0F, 0x80,
  0x0F, 0x03, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x3C,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1C,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFD, 0xE0, 0x07, 0xFE, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x3E,
  0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x0F, 0x1F, 0x00, 0x0F, 0x3E, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x7E, 0x78, 0x01, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x10, 0x7F, 0x00, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x04, 0x3E,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0x81, 0xE0, 0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00,
  0xF0, 0x07, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0,
  0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x38, 0x03, 0xC0, 0x03, 0xC0,
  0x1E, 0x00, 0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x7F, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xDF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x1F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x08, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x04,
  0x00, 0xF8, 0x03, 0xC0, 0x7C, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x01, 0xF0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x01,
  0xE0, 0x3E, 0x00, 0xF0, 0x3F, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x0F, 0x80,
  0x03, 0xCF, 0xC0, 0x00, 0xE7, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x3C,
  0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x3E, 0x00,
  0x78, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x07,
  0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x80, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x23, 0xFF, 0xC3, 0xFF, 0x83, 0xFF,
  0x80, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x7F, 0xE7, 0xF0, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x78, 0x7E, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xC0,
  0xF0, 0x78, 0x78, 0x1C, 0x0F, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0xF0, 0x38,
  0x3C, 0x1E, 0x0F, 0x07, 0x03, 0xC1, 0xE1, 0xE0, 0x70, 0x3C, 0x3C, 0x1E,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x78, 0x3C, 0x3C, 0x1E, 0x07, 0x87,
  0x80, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0x80, 0x7E, 0x07, 0x80,
  0x3E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7E, 0x07, 0xC1, 0xF0, 0x07, 0xC7, 0xC0, 0x07,
  0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE7, 0x80,
  0x07, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3E, 0x01, 0xF8, 0x3E, 0x0F,
  0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00,
  0xF8, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x01, 0xF0,
  0x1E, 0x00, 0x7C, 0x03, 0x80, 0x3F, 0x00, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1E, 0x60, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xF8, 0x1F, 0x07, 0xE0, 0x1E, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x1E,
  0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFB, 0xC0, 0x01, 0x83, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xE0, 0x02, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3E, 0x01, 0xC0,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x10, 0x00, 0x78, 0x38, 0x03, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xC0, 0x00, 0x1F, 0x00,
  0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0xF0, 0x07, 0xE0, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFC,
  0xE0, 0x1F, 0xF0, 0xF0, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xC0,
  0x07, 0x9E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x1C, 0x01, 0xE0,
  0xF0, 0x0E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x07,
  0x80, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x0E, 0x3C, 0x00, 0x79, 0xE0, 0x03,
  0xDE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07,
  0x1E, 0x00, 0x01, 0xE3, 0xC0, 0xE0, 0x3C, 0x70, 0x1E, 0x07, 0x0E, 0x07,
  0xC1, 0xE3, 0xC1, 0xF8, 0x38, 0x78, 0x3F, 0x0F, 0x0F, 0x0F, 0xE1, 0xE1,
  0xE1, 0xDC, 0x38, 0x3C, 0x73, 0x8F, 0x07, 0x9E, 0x71, 0xC0, 0xF3, 0x8E,
  0x78, 0x1E, 0xF1, 0xCF, 0x03, 0xDC, 0x3D, 0xC0, 0x77, 0x07, 0xF8, 0x0F,
  0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x1C, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0x80, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x07,
  0xC0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x07, 0xC0,
  0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x3C,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0,
  0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x20, 0x7E, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x40, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xC7, 0xFE, 0x01,
  0xC7, 0xFF, 0xC1, 0xE3, 0xC3, 0xF1, 0xE3, 0xC0, 0xFF, 0xE3, 0xC0, 0x1F,
  0xE0, 0x40, 0x07, 0xE0,
};

const GFXglyph UbuntuSansMono_Italic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 13, 36, 28, 8, -35 },
  { 60, 14, 13, 28, 11, -38 },
  { 83, 30, 35, 28, 0, -35 },
  { 215, 26, 44, 28, 2, -39 },
  { 358, 34, 36, 28, -2, -35 },
  { 511, 24, 35, 28, 1, -35 },
  { 616, 7, 14, 28, 15, -38 },
  { 629, 21, 48, 28, 6, -39 },
  { 755, 21, 48, 28, 1, -39 },
  { 881, 21, 21, 28, 6, -35 },
  { 937, 23, 25, 28, 3, -27 },
  { 1009, 12, 15, 28, 4, -7 },
  { 1032, 13, 4, 28, 8, -16 },
  { 1039, 8, 8, 28, 8, -7 },
  { 1047, 31, 48, 28, -3, -39 },
  { 1233, 24, 36, 28, 3, -35 },
  { 1341, 20, 35, 28, 3, -35 },
  { 1429, 25, 35, 28, 2, -35 },
  { 1539, 25, 36, 28, 2, -35 },
  { 1652, 25, 35, 28, 1, -35 },
  { 1762, 28, 36, 28, 1, -35 },
  { 1888, 25, 36, 28, 4, -35 },
  { 2001, 25, 35, 28, 6, -35 },
  { 2111, 25, 36, 28, 3, -35 },
  { 2224, 26, 35, 28, 2, -35 },
  { 2338, 12, 26, 28, 8, -25 },
  { 2377, 16, 33, 28, 4, -25 },
  { 2443, 25, 22, 28, 2, -25 },
  { 2512, 25, 14, 28, 2, -22 },
  { 2556, 25, 22, 28, 1, -25 },
  { 2625, 20, 36, 28, 7, -35 },
  { 2715, 27, 43, 28, 2, -36 },
  { 2861, 27, 35, 28, -3, -35 },
  { 2980, 27, 35, 28, 0, -35 },
  { 3099, 27, 36, 28, 3, -35 },
  { 3221, 27, 35, 28, 0, -35 },
  { 3340, 28, 35, 28, 2, -35 },
  { 3463, 28, 35, 28, 2, -35 },
  { 3586, 27, 36, 28, 2, -35 },
  { 3708, 30, 35, 28, 0, -35 },
  { 3840, 26, 35, 28, 2, -35 },
  { 3954, 27, 36, 28, 2, -35 },
  { 4076, 30, 35, 28, 1, -35 },
  { 4208, 20, 35, 28, 1, -35 },
  { 4296, 30, 35, 28, -1, -35 },
  { 4428, 30, 35, 28, 0, -35 },
  { 4560, 25, 36, 28, 3, -35 },
  { 4673, 27, 35, 28, 1, -35 },
  { 4792, 25, 44, 28, 3, -35 },
  { 4930, 26, 35, 28, 1, -35 },
  { 5044, 27, 36, 28, 1, -35 },
  { 5166, 24, 35, 28, 7, -35 },
  { 5271, 27, 36, 28, 3, -35 },
  { 5393, 27, 35, 28, 5, -35 },
  { 5512, 29, 35, 28, 2, -35 },
  { 5639, 34, 35, 28, -2, -35 },
  { 5788, 27, 35, 28, 6, -35 },
  { 5907, 30, 35, 28, 0, -35 },
  { 6039, 24, 48, 28, 4, -39 },
  { 6183, 8, 48, 28, 10, -39 },
  { 6231, 25, 48, 28, -1, -39 },
  { 6381, 21, 19, 28, 5, -35 },
  { 6431, 26, 3, 28, -4, 6 },
  { 6441, 9, 10, 28, 13, -39 },
  { 6453, 24, 27, 28, 2, -26 },
  { 6534, 24, 40, 28, 2, -39 },
  { 6654, 24, 28, 28, 2, -27 },
  { 6738, 27, 40, 28, 3, -39 },
  { 6873, 24, 28, 28, 2, -27 },
  { 6957, 33, 48, 28, -1, -39 },
  { 7155, 29, 35, 28, -1, -26 },
  { 7282, 24, 39, 28, 0, -39 },
  { 7399, 15, 38, 28, 6, -38 },
  { 7471, 26, 47, 28, 0, -38 },
  { 7624, 26, 39, 28, 2, -39 },
  { 7751, 15, 40, 28, 8, -39 },
  { 7826, 27, 27, 28, 0, -27 },
  { 7918, 24, 26, 28, 2, -26 },
  { 7996, 23, 28, 28, 3, -27 },
  { 8077, 27, 36, 28, -1, -27 },
  { 8199, 24, 35, 28, 3, -26 },
  { 8304, 24, 27, 28, 3, -27 },
  { 8385, 23, 28, 28, 3, -27 },
  { 8466, 20, 35, 28, 6, -34 },
  { 8554, 24, 27, 28, 3, -26 },
  { 8635, 21, 26, 28, 6, -26 },
  { 8704, 27, 26, 28, 3, -26 },
  { 8792, 29, 26, 28, -1, -26 },
  { 8887, 31, 35, 28, -3, -26 },
  { 9023, 25, 26, 28, 1, -26 },
  { 9105, 27, 48, 28, 3, -39 },
  { 9267, 15, 48, 28, 7, -39 },
  { 9357, 27, 48, 28, -2, -39 },
  { 9519, 25, 8, 28, 2, -19 },
};

const GFXfont UbuntuSansMono_Italic50pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic50pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic50pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _UBUNTUSANSMONO_ITALIC50PT7B_H_
