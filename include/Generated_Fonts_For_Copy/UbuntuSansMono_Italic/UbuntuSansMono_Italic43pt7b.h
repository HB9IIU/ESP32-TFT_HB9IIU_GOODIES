#ifndef _UBUNTUSANSMONO_ITALIC43PT7B_H_
#define _UBUNTUSANSMONO_ITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x18, 0x00, 0x38, 0x39, 0xC1, 0xCE,
  0x1C, 0x70, 0xE7, 0x07, 0x38, 0x31, 0xC1, 0x8C, 0x1C, 0x60, 0xE3, 0x06,
  0x30, 0x31, 0x81, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x70, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x78,
  0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x78, 0x3C, 0x01, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x70,
  0x38, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xC0, 0x08, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x10, 0x00, 0xF0, 0x70,
  0x0F, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x38, 0x07, 0xF0, 0x03, 0x80, 0x71,
  0xC0, 0x38, 0x07, 0x0E, 0x03, 0x80, 0x38, 0x70, 0x3C, 0x01, 0x83, 0x83,
  0xC0, 0x1C, 0x1C, 0x1C, 0x00, 0xE0, 0xE1, 0xC0, 0x07, 0x06, 0x1C, 0x00,
  0x38, 0x71, 0xC0, 0x01, 0xC3, 0x9C, 0x00, 0x0E, 0x39, 0xE0, 0x00, 0x3F,
  0x9E, 0x00, 0x01, 0xF8, 0xE0, 0x00, 0x01, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0xE7, 0xF8, 0x00, 0x0F, 0x39, 0xC0,
  0x00, 0xF3, 0x86, 0x00, 0x07, 0x18, 0x38, 0x00, 0x71, 0xC1, 0xC0, 0x07,
  0x0E, 0x0E, 0x00, 0x70, 0x70, 0x60, 0x07, 0x03, 0x87, 0x00, 0x78, 0x18,
  0x38, 0x07, 0x80, 0xE1, 0xC0, 0x38, 0x07, 0x1C, 0x03, 0x80, 0x3F, 0xC0,
  0x38, 0x00, 0xFC, 0x02, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFE, 0x00, 0xF3, 0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1E, 0x03, 0x81, 0xC0, 0x38, 0x3C, 0x03, 0x87, 0x80,
  0x3D, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x70, 0x7F, 0x07,
  0x1E, 0x78, 0x73, 0xC7, 0x8E, 0x38, 0x3C, 0xE7, 0x81, 0xDE, 0x70, 0x1F,
  0xCF, 0x00, 0xFC, 0xF0, 0x0F, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00,
  0xF8, 0x78, 0x3F, 0xC7, 0xFF, 0xBC, 0x3F, 0xF1, 0xC1, 0xFC, 0x1E, 0x3C,
  0xE3, 0x9E, 0x79, 0xC7, 0x1C, 0x73, 0x8E, 0x38, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x38, 0x67, 0x8C, 0x7F, 0xFF,
  0x7F, 0x7F, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0x3C,
  0x03, 0xCF, 0x01, 0xE1, 0xE0, 0xF8, 0x7C, 0x0C, 0x0C, 0x01, 0x02, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0x80, 0xF0,
  0x1C, 0x07, 0x87, 0xE3, 0xF8, 0x3C, 0x04, 0x00, 0x7F, 0xEF, 0xFB, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F,
  0xFC, 0x03, 0xC1, 0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x00, 0xE1,
  0xE0, 0x07, 0x1E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x0E, 0x78, 0x20,
  0xF3, 0x87, 0x87, 0x9C, 0x7E, 0x3D, 0xE3, 0xF1, 0xEF, 0x1F, 0x8E, 0x70,
  0xF8, 0x73, 0x81, 0x07, 0x9C, 0x00, 0x3D, 0xE0, 0x01, 0xCF, 0x00, 0x1E,
  0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0x70, 0x07, 0x83, 0xC0,
  0x78, 0x1E, 0x07, 0x80, 0xFD, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xBC, 0x0F, 0x1C, 0x06, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x0F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0x00, 0xF0, 0x30, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x30,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x82, 0x00, 0x7C, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xB8, 0x00, 0x7B, 0xC0, 0x07,
  0x9E, 0x00, 0x78, 0xE0, 0x07, 0x87, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0,
  0x78, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x03, 0xC0, 0x78, 0x3C, 0x03,
  0x81, 0xC0, 0x1C, 0x1E, 0x00, 0xE1, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x40, 0x0F, 0xC0, 0x7E, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x1F, 0x00, 0xF0, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x3C,
  0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x07, 0x80, 0xF0, 0x1F, 0x0F,
  0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xC0, 0x1F, 0x8F, 0x80, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x1E,
  0x00, 0xF0, 0x70, 0x01, 0xC1, 0xC0, 0x0F, 0x07, 0x00, 0x3C, 0x3C, 0x00,
  0xE0, 0x70, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0xC1, 0xE0, 0x0F, 0xCF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0x0F, 0x80, 0x78, 0x0F, 0x03, 0xC0,
  0x1E, 0x1E, 0x00, 0x78, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8F, 0x00, 0x0E,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x07, 0x80, 0x7C, 0x1F,
  0x07, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0x9F, 0x80, 0xF0, 0x1E, 0x07, 0x80,
  0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78,
  0x00, 0xE0, 0xF0, 0x0F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFB,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x83,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3E, 0x02, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3F, 0x00, 0xFC,
  0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0xFC,
  0x0F, 0xE0, 0x1E, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x04, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x83,
  0x87, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0x01, 0xC0, 0x7C, 0x03, 0xC1, 0xF0, 0x03, 0x83, 0xC0, 0x07,
  0x0F, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0xF9, 0xE0, 0x3F, 0xF3,
  0xC1, 0xFF, 0xC7, 0x07, 0xC3, 0x9E, 0x1E, 0x07, 0x3C, 0x78, 0x1E, 0x70,
  0xF0, 0x39, 0xE3, 0xC0, 0x73, 0xC7, 0x80, 0xE7, 0x8E, 0x03, 0xCE, 0x1C,
  0x07, 0x1C, 0x38, 0x0E, 0x38, 0x70, 0x1C, 0x70, 0xF0, 0x78, 0xE1, 0xE0,
  0xE1, 0xC1, 0xE1, 0xC3, 0x83, 0xFF, 0x87, 0x83, 0xFF, 0x0F, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xDC,
  0x00, 0x03, 0xDC, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x38, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x0E, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xC0,
  0xE0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x38, 0x1C,
  0x00, 0x70, 0x38, 0x03, 0xC0, 0xF0, 0x1F, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x0E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x70, 0x00,
  0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x80, 0x07, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xC0, 0x0F, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xF0, 0x06, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x1F, 0x8F, 0x80, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x1E, 0x07, 0xC0, 0x38, 0x07, 0xC0, 0x70, 0x07, 0x81,
  0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x3C,
  0x00, 0x38, 0x78, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x8F, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x38, 0x70, 0x00,
  0x71, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x3C,
  0x3C, 0x00, 0xF8, 0x78, 0x03, 0xE0, 0xE0, 0x0F, 0x81, 0xC0, 0x7E, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0x00, 0x60, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0xF1, 0xE0, 0x01,
  0xE3, 0xC0, 0x03, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x70, 0x78, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xF0, 0x07, 0x80,
  0xF0, 0x0E, 0x01, 0xF8, 0x7C, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x1C, 0x00,
  0x38, 0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x38,
  0x00, 0x70, 0x1E, 0x00, 0x1C, 0x07, 0x80, 0x0F, 0x01, 0xC0, 0x03, 0xC0,
  0x70, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x0E, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1E, 0x00, 0x1C, 0x07, 0x00,
  0x0F, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x0E,
  0x00, 0x1E, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x70,
  0x1C, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0x80, 0xF0, 0x00,
  0xE0, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x04, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x80, 0x1E, 0x01, 0x80, 0x7C, 0x07, 0xE3, 0xF0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x07, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x70, 0x07, 0x80, 0x38,
  0x07, 0x80, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0E, 0x0F, 0x80, 0x07,
  0x0F, 0x80, 0x07, 0x8F, 0x80, 0x03, 0xCF, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1D, 0xF0, 0x00, 0x0E, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x07, 0x80,
  0x03, 0x81, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x3C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x1E, 0x00,
  0x38, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xE0,
  0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x36, 0x03, 0x60, 0x1D, 0x81, 0xF8, 0x07,
  0x70, 0xEE, 0x01, 0x9C, 0x3B, 0x80, 0xE7, 0x1C, 0xE0, 0x39, 0xC6, 0x30,
  0x0E, 0x73, 0x9C, 0x07, 0x1C, 0xC7, 0x01, 0xC7, 0x71, 0xC0, 0x71, 0xD8,
  0x70, 0x38, 0x7E, 0x1C, 0x0E, 0x0F, 0x0E, 0x03, 0x83, 0x83, 0x80, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x0F,
  0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x1F, 0x00, 0x38,
  0x07, 0xC0, 0x0E, 0x03, 0xF0, 0x03, 0x80, 0xEE, 0x00, 0xE0, 0x3B, 0x80,
  0x70, 0x0E, 0xE0, 0x1C, 0x03, 0xBC, 0x07, 0x01, 0xC7, 0x01, 0xC0, 0x71,
  0xC0, 0xF0, 0x1C, 0x70, 0x38, 0x07, 0x0E, 0x0E, 0x03, 0x83, 0x83, 0x80,
  0xE0, 0xE1, 0xE0, 0x38, 0x38, 0x70, 0x0E, 0x07, 0x1C, 0x07, 0x01, 0xC7,
  0x01, 0xC0, 0x71, 0xC0, 0x70, 0x1C, 0xE0, 0x1C, 0x07, 0x38, 0x0E, 0x00,
  0xCE, 0x03, 0x80, 0x3B, 0x80, 0xE0, 0x0F, 0xC0, 0x38, 0x03, 0xF0, 0x1E,
  0x00, 0xFC, 0x07, 0x00, 0x1F, 0x01, 0xC0, 0x07, 0x80, 0x70, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0xF8, 0x1E, 0x03, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x01, 0xC3,
  0x80, 0x07, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0x73, 0xC0, 0x01, 0xCE, 0x00,
  0x07, 0x38, 0x00, 0x1D, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xDC, 0x00, 0x0E,
  0x70, 0x00, 0x39, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1C, 0xF0,
  0x00, 0x73, 0xC0, 0x03, 0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x70, 0x70, 0x03,
  0xC1, 0xE0, 0x1E, 0x07, 0x80, 0xF0, 0x0F, 0x8F, 0x80, 0x3F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x1E, 0x03, 0xE0, 0x38, 0x01, 0xE0, 0x70, 0x03, 0xC0,
  0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x3C, 0x1C,
  0x00, 0x78, 0x78, 0x00, 0xE0, 0xF0, 0x03, 0xC1, 0xC0, 0x0F, 0x03, 0x80,
  0x3C, 0x0F, 0x03, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0x80,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xF8, 0x1E, 0x03, 0x80, 0x3C, 0x1C,
  0x00, 0xF0, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x70, 0x00,
  0x73, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1D, 0xE0, 0x00, 0xF7,
  0x00, 0x03, 0xDC, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xEF, 0x00,
  0x07, 0xBC, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0xC0, 0x03, 0x8F, 0x00, 0x0E,
  0x3C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xE0, 0x1E, 0x07, 0x80, 0xF0, 0x0F,
  0x8F, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1C, 0x03, 0xE0, 0x38, 0x03, 0xC0, 0xF0, 0x03, 0x81,
  0xC0, 0x07, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x3C,
  0x00, 0x70, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0xC0, 0x0E, 0x07, 0x80,
  0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xF0, 0x78,
  0x01, 0xC0, 0x70, 0x03, 0x80, 0xF0, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x38, 0x03, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07,
  0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0x80, 0x20, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC1,
  0x80, 0x1F, 0x03, 0xF1, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F,
  0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E,
  0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x3C,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x78,
  0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x78, 0x00, 0x70, 0x70, 0x00, 0xF0,
  0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xE7,
  0x00, 0x03, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x38, 0x70,
  0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0E, 0x07, 0x80,
  0x3C, 0x0F, 0x00, 0x70, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x38, 0x0F,
  0x00, 0x70, 0x1C, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80,
  0x07, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x38, 0xE0, 0x00,
  0x73, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0xF0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x83, 0x80,
  0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x1C, 0x1C,
  0x07, 0x0F, 0x07, 0x03, 0x87, 0xC1, 0xC0, 0xE1, 0xF8, 0xE0, 0x38, 0xEE,
  0x38, 0x0E, 0x3B, 0x8E, 0x03, 0x9C, 0xE3, 0x00, 0xC6, 0x39, 0xC0, 0x33,
  0x8E, 0x70, 0x1D, 0xC1, 0x98, 0x07, 0x70, 0x6E, 0x01, 0xF8, 0x1B, 0x80,
  0x6E, 0x06, 0xC0, 0x1F, 0x01, 0xB0, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF0,
  0x07, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x38,
  0x07, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x39, 0xC0,
  0x00, 0xF3, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x0F, 0x00, 0x1E, 0x0E, 0x00,
  0x78, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x78, 0x0F, 0x00, 0x70, 0x3C,
  0x00, 0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x9E, 0x00,
  0x07, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xC3, 0x87, 0x0E,
  0x1E, 0x3C, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xCE, 0x00, 0xF1, 0xC0, 0x3C, 0x38,
  0x07, 0x03, 0x81, 0xE0, 0x70, 0x78, 0x0E, 0x1E, 0x00, 0xE7, 0x80, 0x1C,
  0xE0, 0x03, 0xBC, 0x00, 0x39, 0x00, 0x04, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x06,
  0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xE0, 0xE0, 0xF8,
  0x07, 0x0F, 0x80, 0x78, 0x78, 0x03, 0x87, 0x80, 0x1C, 0x78, 0x00, 0xE3,
  0xC0, 0x0F, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x01,
  0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x3C,
  0x01, 0xE1, 0xE0, 0x1F, 0x07, 0xC3, 0xF8, 0x1F, 0xFD, 0xC0, 0x7F, 0x8E,
  0x00, 0x20, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC7, 0xC0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xE0, 0xF8, 0x3C, 0x03, 0xC1, 0xC0, 0x0E, 0x1E, 0x00, 0x70,
  0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00,
  0x38, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x1C,
  0x00, 0xF0, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x70, 0x1F, 0x83, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7E, 0x03, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x08, 0x7F, 0x0F, 0x83, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0x38,
  0x07, 0xC0, 0x70, 0x0F, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x3C, 0x00, 0x70,
  0x3C, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x70, 0x01, 0xE0,
  0x70, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0xF0, 0x01, 0xC0,
  0xF0, 0x03, 0xC0, 0xF0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x78, 0x0F, 0x80,
  0x7C, 0x3F, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xF1, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0xFC, 0x1F, 0x1F, 0x00,
  0xF1, 0xE0, 0x07, 0x3C, 0x00, 0x77, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x00,
  0x1E, 0xF0, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x18, 0x7F, 0xBF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x0E,
  0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x1C, 0x07, 0x80, 0x1C,
  0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0x70,
  0x3C, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFD, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x80, 0x07, 0x80, 0xE0, 0x1F, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE7, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xE1, 0xF8, 0x1C, 0x03,
  0xC0, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0x80, 0x1E, 0x1C,
  0x00, 0xF1, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1E,
  0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0xC7, 0x80,
  0x1E, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0xC0,
  0x00, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x7F, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x3F, 0xE0, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x1C, 0x07, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x01, 0xF0, 0x78, 0x07, 0x80, 0xE0, 0x1E, 0x01, 0xC0, 0xF8, 0x03,
  0x83, 0xE0, 0x0F, 0x0F, 0x00, 0x1C, 0x7C, 0x00, 0x39, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x7C, 0x00, 0x0E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x38, 0x01, 0xE0,
  0xF0, 0x01, 0xE0, 0x7F, 0xE7, 0xFC, 0xFF, 0xC0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x81,
  0x7C, 0x73, 0xFF, 0x1F, 0xF0, 0x10, 0x00, 0xF0, 0x78, 0x0F, 0xFB, 0xF8,
  0x1F, 0xFF, 0xF8, 0x38, 0xFC, 0xF0, 0xE0, 0xE0, 0xE1, 0xC1, 0xC1, 0xC3,
  0x83, 0x83, 0x87, 0x0F, 0x0F, 0x1E, 0x1E, 0x1C, 0x38, 0x38, 0x38, 0x70,
  0x70, 0x70, 0xE0, 0xE0, 0xE3, 0xC3, 0xC3, 0xC7, 0x07, 0x07, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x78, 0xE0, 0x00, 0xE1, 0xC0, 0x01,
  0xC3, 0x80, 0x03, 0x8F, 0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x00, 0x00, 0x3E, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0xF8, 0x7E, 0x0E,
  0x00, 0xE0, 0xE0, 0x0F, 0x1E, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0x71,
  0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x1E,
  0x38, 0x01, 0xE7, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03,
  0xCF, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xC7, 0xC0, 0xF8, 0x0F,
  0x0F, 0x80, 0x38, 0x78, 0x01, 0xC7, 0x80, 0x0F, 0x38, 0x00, 0x7B, 0xC0,
  0x03, 0x9E, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x78, 0x00, 0x7B,
  0xC0, 0x03, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x1C, 0x01,
  0xE0, 0xF0, 0x1F, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xE0, 0x7C,
  0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x0F,
  0x03, 0x80, 0x0F, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x1E, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x3C,
  0x0E, 0x00, 0x78, 0x0E, 0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x1C, 0x03, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x39, 0x80, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xE0, 0xF0, 0x7C, 0x07, 0x87, 0x80,
  0x38, 0x78, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0x1E,
  0x00, 0x38, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x07,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x00, 0xE0, 0xF0,
  0x1F, 0x07, 0xC3, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xDC, 0x00, 0x21, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xF8, 0x02, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3E, 0x06, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x82, 0x00, 0x78, 0x7C, 0x3F, 0x0F, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE0, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x83, 0xF7, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x20,
  0x00, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1,
  0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x78,
  0x01, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x03, 0x83, 0x80, 0x3C,
  0x1E, 0x03, 0xE0, 0xF8, 0xFF, 0x03, 0xFF, 0xB8, 0x0F, 0xF1, 0xE0, 0xE0,
  0x01, 0xFE, 0x00, 0x3B, 0xC0, 0x0F, 0x78, 0x01, 0xCF, 0x00, 0x79, 0xE0,
  0x0E, 0x3C, 0x03, 0xC7, 0x80, 0x70, 0x70, 0x1E, 0x0E, 0x03, 0x81, 0xC0,
  0xF0, 0x38, 0x1C, 0x07, 0x07, 0x80, 0xF0, 0xE0, 0x1E, 0x38, 0x01, 0xCF,
  0x00, 0x39, 0xC0, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x78, 0x18, 0x1C, 0x70, 0x38,
  0x3C, 0x70, 0x78, 0x38, 0x70, 0x78, 0x38, 0x70, 0xF8, 0x70, 0x70, 0xD8,
  0x70, 0x71, 0xDC, 0xF0, 0x73, 0x9C, 0xE0, 0x73, 0x9C, 0xE0, 0x77, 0x1D,
  0xC0, 0xF6, 0x1D, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0xF0, 0x07, 0x80, 0x38, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x07,
  0x07, 0x80, 0x03, 0xC7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xCE, 0x00, 0x03, 0xC7, 0x80,
  0x03, 0xC1, 0xC0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x1E,
  0x03, 0xC0, 0x0F, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x78,
  0x00, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x00, 0xF0, 0x1E,
  0x00, 0x3C, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x08, 0x1F, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xBF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0x80, 0x20, 0xFF, 0x01, 0xCF, 0xFC, 0x1C, 0xF1, 0xF1, 0xE7, 0x03, 0xFE,
  0x70, 0x0F, 0xE0, 0x00, 0x18, 0x00,
};

const GFXglyph UbuntuSansMono_Italic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 11, 31, 24, 7, -30 },
  { 44, 13, 12, 24, 9, -33 },
  { 64, 26, 30, 24, 0, -30 },
  { 162, 22, 38, 24, 2, -33 },
  { 267, 29, 31, 24, -2, -30 },
  { 380, 20, 30, 24, 1, -30 },
  { 455, 6, 13, 24, 13, -33 },
  { 465, 18, 42, 24, 5, -34 },
  { 560, 18, 42, 24, 1, -34 },
  { 655, 18, 18, 24, 5, -30 },
  { 696, 19, 21, 24, 3, -23 },
  { 746, 11, 13, 24, 3, -6 },
  { 764, 11, 3, 24, 7, -14 },
  { 769, 6, 7, 24, 7, -6 },
  { 775, 27, 42, 24, -3, -34 },
  { 917, 21, 31, 24, 2, -30 },
  { 999, 17, 30, 24, 3, -30 },
  { 1063, 21, 30, 24, 2, -30 },
  { 1142, 22, 31, 24, 1, -30 },
  { 1228, 21, 30, 24, 1, -30 },
  { 1307, 24, 31, 24, 1, -30 },
  { 1400, 22, 31, 24, 3, -30 },
  { 1486, 22, 30, 24, 5, -30 },
  { 1569, 22, 31, 24, 2, -30 },
  { 1655, 22, 30, 24, 2, -30 },
  { 1738, 10, 23, 24, 7, -22 },
  { 1767, 14, 29, 24, 3, -22 },
  { 1818, 21, 19, 24, 2, -22 },
  { 1868, 22, 12, 24, 1, -19 },
  { 1901, 21, 19, 24, 1, -22 },
  { 1951, 17, 31, 24, 6, -30 },
  { 2017, 23, 37, 24, 2, -31 },
  { 2124, 24, 30, 24, -3, -30 },
  { 2214, 23, 30, 24, 0, -30 },
  { 2301, 24, 31, 24, 2, -30 },
  { 2394, 23, 30, 24, 0, -30 },
  { 2481, 24, 30, 24, 2, -30 },
  { 2571, 24, 30, 24, 2, -30 },
  { 2661, 23, 31, 24, 2, -30 },
  { 2751, 26, 30, 24, 0, -30 },
  { 2849, 22, 30, 24, 2, -30 },
  { 2932, 23, 31, 24, 2, -30 },
  { 3022, 25, 30, 24, 1, -30 },
  { 3116, 17, 30, 24, 1, -30 },
  { 3180, 26, 30, 24, -1, -30 },
  { 3278, 26, 30, 24, 0, -30 },
  { 3376, 22, 31, 24, 2, -30 },
  { 3462, 23, 30, 24, 1, -30 },
  { 3549, 22, 38, 24, 2, -30 },
  { 3654, 23, 30, 24, 1, -30 },
  { 3741, 23, 31, 24, 1, -30 },
  { 3831, 20, 30, 24, 6, -30 },
  { 3906, 24, 31, 24, 2, -30 },
  { 3999, 23, 30, 24, 5, -30 },
  { 4086, 26, 30, 24, 1, -30 },
  { 4184, 28, 30, 24, -1, -30 },
  { 4289, 23, 30, 24, 5, -30 },
  { 4376, 26, 30, 24, 0, -30 },
  { 4474, 21, 42, 24, 3, -34 },
  { 4585, 7, 42, 24, 9, -34 },
  { 4622, 21, 42, 24, 0, -34 },
  { 4733, 19, 16, 24, 4, -30 },
  { 4771, 22, 3, 24, -3, 5 },
  { 4780, 8, 8, 24, 11, -33 },
  { 4788, 21, 24, 24, 2, -23 },
  { 4851, 21, 33, 24, 2, -33 },
  { 4938, 20, 24, 24, 2, -23 },
  { 4998, 24, 34, 24, 2, -33 },
  { 5100, 20, 24, 24, 2, -23 },
  { 5160, 28, 41, 24, -1, -33 },
  { 5304, 24, 31, 24, 0, -23 },
  { 5397, 21, 33, 24, 0, -33 },
  { 5484, 13, 33, 24, 5, -33 },
  { 5538, 23, 41, 24, 0, -33 },
  { 5656, 23, 33, 24, 1, -33 },
  { 5751, 12, 34, 24, 7, -33 },
  { 5802, 23, 23, 24, 0, -23 },
  { 5869, 20, 23, 24, 2, -23 },
  { 5927, 21, 23, 24, 2, -23 },
  { 5988, 24, 31, 24, -1, -23 },
  { 6081, 21, 31, 24, 2, -23 },
  { 6163, 20, 23, 24, 3, -23 },
  { 6221, 20, 24, 24, 2, -23 },
  { 6281, 18, 30, 24, 5, -29 },
  { 6349, 21, 22, 24, 2, -22 },
  { 6407, 19, 22, 24, 5, -22 },
  { 6460, 24, 22, 24, 2, -22 },
  { 6526, 25, 22, 24, -1, -22 },
  { 6595, 26, 30, 24, -2, -22 },
  { 6693, 21, 22, 24, 1, -22 },
  { 6751, 24, 42, 24, 2, -34 },
  { 6877, 13, 42, 24, 6, -34 },
  { 6946, 23, 42, 24, -2, -34 },
  { 7067, 21, 7, 24, 2, -16 },
};

const GFXfont UbuntuSansMono_Italic43pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic43pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic43pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _UBUNTUSANSMONO_ITALIC43PT7B_H_
