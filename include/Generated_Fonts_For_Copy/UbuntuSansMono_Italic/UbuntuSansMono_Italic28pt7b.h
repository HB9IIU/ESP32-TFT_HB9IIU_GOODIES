#ifndef _UBUNTUSANSMONO_ITALIC28PT7B_H_
#define _UBUNTUSANSMONO_ITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18,
  0x10, 0x10, 0x00, 0x00, 0x20, 0x70, 0xF0, 0x70, 0x63, 0x63, 0x62, 0x46,
  0xC6, 0xC6, 0x84, 0x00, 0xE3, 0x80, 0x61, 0x80, 0x71, 0x80, 0x30, 0xC0,
  0x18, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC, 0x0C, 0x30, 0x06, 0x18, 0x06, 0x18,
  0x03, 0x0C, 0x03, 0x8C, 0x07, 0xFF, 0xE7, 0xFF, 0xE0, 0xC3, 0x00, 0x61,
  0x80, 0x61, 0x80, 0x30, 0xC0, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x3F, 0xE0, 0xF3, 0x83, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x61, 0x01, 0xC7, 0xFF, 0x07, 0xFC, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x20, 0xF8, 0x18,
  0x33, 0x06, 0x04, 0x61, 0x81, 0x8C, 0x60, 0x31, 0x9C, 0x06, 0x33, 0x00,
  0xCC, 0xC0, 0x1F, 0xB0, 0x01, 0xCC, 0x00, 0x03, 0x00, 0x00, 0xCF, 0x00,
  0x3B, 0x70, 0x06, 0xC6, 0x01, 0x98, 0xC0, 0x63, 0x18, 0x18, 0x42, 0x06,
  0x08, 0xC1, 0x81, 0x98, 0x70, 0x3E, 0x00, 0x01, 0xE0, 0x3F, 0x83, 0x8C,
  0x18, 0x61, 0xC3, 0x0E, 0x38, 0x71, 0x81, 0x98, 0x0F, 0x80, 0x78, 0x07,
  0x86, 0x66, 0x66, 0x3B, 0x70, 0xDB, 0x07, 0x98, 0x1C, 0xC0, 0xE7, 0x0F,
  0x3F, 0xD8, 0xFC, 0xE0, 0x37, 0x66, 0x66, 0x4C, 0x00, 0x20, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x06, 0x06, 0x67, 0xFB, 0xF1, 0xF8, 0x0F, 0x01, 0xD8,
  0x19, 0xC3, 0x8E, 0x10, 0x80, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x87, 0xFF, 0xDF, 0xFE, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x1C, 0x7C, 0xF8, 0xF0, 0xC3, 0xBE, 0x70, 0xFF,
  0xF8, 0x77, 0xFE, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x83, 0x8E, 0x38, 0x73,
  0x81, 0x98, 0x0D, 0xC0, 0x6C, 0x03, 0x67, 0x1F, 0x39, 0xF1, 0xCF, 0x8E,
  0x6C, 0x03, 0x60, 0x3B, 0x01, 0x98, 0x1C, 0xC1, 0xC6, 0x0C, 0x3F, 0xC0,
  0xFC, 0x00, 0x00, 0x60, 0x3C, 0x1F, 0x0F, 0x61, 0xCC, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30,
  0x06, 0x1F, 0xFB, 0xFF, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xE1, 0xC2, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0xFF, 0x3F, 0xF8, 0x01, 0xE0, 0x3F, 0xE0, 0x63, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x72, 0x03, 0xCF,
  0xFE, 0x3F, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x19,
  0x80, 0x63, 0x01, 0xC6, 0x07, 0x1C, 0x1C, 0x30, 0x30, 0x60, 0xC0, 0xC3,
  0x83, 0x87, 0xFF, 0xDF, 0xFF, 0x80, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0xFE, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x80, 0xE1, 0xFF,
  0x83, 0xFE, 0x00, 0x00, 0x04, 0x01, 0xF0, 0x1F, 0x81, 0xE0, 0x0E, 0x00,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0x77, 0xC1, 0xFF, 0x87, 0x07, 0x38, 0x0C,
  0xE0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x1C, 0xC0, 0x63, 0x83, 0x87, 0x3C,
  0x0F, 0xE0, 0x3F, 0xFC, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x07, 0xF8, 0x1C, 0x70, 0x60, 0x70, 0xC0, 0xE3, 0x81, 0xC7,
  0x03, 0x0E, 0x0E, 0x0E, 0x38, 0x1F, 0xE0, 0x3F, 0x81, 0xC3, 0x83, 0x03,
  0x8C, 0x07, 0x18, 0x06, 0x70, 0x1C, 0xE0, 0x30, 0xC0, 0xE1, 0xE7, 0x81,
  0xFE, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x38, 0x70, 0xE0, 0x61, 0x80, 0xE3,
  0x01, 0xCE, 0x03, 0x9C, 0x06, 0x38, 0x0C, 0x30, 0x18, 0x7F, 0xF0, 0x7F,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x01,
  0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC7, 0xCF, 0x8E, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x07, 0xC3, 0xE0, 0xF0, 0x30, 0x38, 0xF8,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x18, 0x3F,
  0xFD, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xBF,
  0xFC, 0x10, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x01,
  0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x01, 0x80, 0x00, 0x2F, 0x83, 0xF8,
  0x83, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x1E, 0x03, 0xC0, 0x70,
  0x00, 0x00, 0xF8, 0x07, 0xF8, 0x1E, 0x38, 0x70, 0x31, 0xC0, 0x63, 0x00,
  0xCE, 0x01, 0x98, 0x7F, 0x71, 0xEE, 0xC7, 0x1D, 0x9C, 0x37, 0x30, 0x6E,
  0x60, 0xDC, 0xC3, 0xB1, 0x86, 0x63, 0x0C, 0xC7, 0x19, 0xC7, 0xF3, 0x81,
  0x83, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xB0, 0x03, 0x70, 0x0C, 0xE0, 0x18, 0xC0, 0x61, 0x81,
  0xC3, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x60, 0x30, 0xFF, 0xE3, 0xFF,
  0xC6, 0x01, 0x98, 0x03, 0x30, 0x06, 0xC0, 0x0F, 0x80, 0x18, 0x01, 0xC0,
  0x0F, 0xF8, 0x38, 0x78, 0x60, 0x70, 0xC0, 0x61, 0x80, 0xC7, 0x01, 0x8C,
  0x06, 0x18, 0x38, 0x3F, 0xE0, 0xFF, 0xE1, 0x80, 0xC3, 0x00, 0xC6, 0x01,
  0x8C, 0x03, 0x30, 0x0E, 0x60, 0x18, 0xC0, 0xE1, 0xFF, 0x87, 0xFC, 0x00,
  0x00, 0xF8, 0x07, 0xFC, 0x3C, 0x30, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x41, 0xFF, 0x81,
  0xFE, 0x00, 0x01, 0x80, 0x1F, 0xE0, 0x30, 0xF0, 0x60, 0xE0, 0xC0, 0xE3,
  0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x70, 0x0C, 0xC0, 0x19, 0x80,
  0x73, 0x00, 0xCE, 0x01, 0x98, 0x07, 0x30, 0x1C, 0x60, 0x70, 0xC1, 0xC3,
  0xFF, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1F, 0xF8, 0x1F, 0xF0,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xFC,
  0x1C, 0x18, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0xCE, 0x01, 0x9C, 0x07, 0x38, 0x0C,
  0x30, 0x18, 0x60, 0x30, 0xE0, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0x0E, 0x03,
  0x86, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x61, 0xC0, 0x70, 0xC0, 0x30, 0x60,
  0x18, 0x30, 0x0C, 0x1F, 0xFE, 0x1F, 0xFE, 0x0C, 0x03, 0x06, 0x01, 0x83,
  0x00, 0xC3, 0x80, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x70, 0x1C,
  0x30, 0x0C, 0x00, 0x07, 0xFC, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x40, 0xE1, 0xFF, 0x81, 0xFE,
  0x00, 0x06, 0x07, 0x83, 0x07, 0x03, 0x87, 0x01, 0x87, 0x00, 0xC7, 0x00,
  0x67, 0x00, 0x77, 0x00, 0x37, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0E, 0xE0,
  0x06, 0x30, 0x03, 0x0C, 0x01, 0x87, 0x01, 0xC1, 0x80, 0xC0, 0xE0, 0x60,
  0x30, 0x30, 0x1C, 0x38, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0x81, 0x81,
  0xC1, 0xC0, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0xD8, 0x2C, 0x48, 0x32, 0x6C,
  0x19, 0x26, 0x0C, 0xB3, 0x0C, 0x71, 0x86, 0x38, 0xC3, 0x18, 0xC3, 0x00,
  0x61, 0x80, 0x30, 0xC0, 0x18, 0xE0, 0x1C, 0x60, 0x0C, 0x30, 0x06, 0x38,
  0x03, 0x00, 0x06, 0x01, 0x87, 0x81, 0x83, 0xC0, 0xC1, 0xE0, 0x60, 0xD8,
  0x30, 0xCC, 0x38, 0x66, 0x18, 0x33, 0x0C, 0x18, 0xC6, 0x08, 0x63, 0x0C,
  0x33, 0x06, 0x19, 0x83, 0x06, 0xC1, 0x83, 0x61, 0x81, 0xE0, 0xC0, 0xF0,
  0x60, 0x78, 0x30, 0x1C, 0x30, 0x0C, 0x00, 0x00, 0xF0, 0x07, 0xF0, 0x1C,
  0x70, 0x60, 0x61, 0xC0, 0xE3, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x70, 0x0E,
  0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0xDC, 0x03, 0x38, 0x06, 0x30,
  0x18, 0x60, 0x70, 0xE1, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xC0, 0x1F,
  0xF0, 0x30, 0xF0, 0x60, 0x61, 0xC0, 0xE3, 0x01, 0xC6, 0x03, 0x8C, 0x06,
  0x38, 0x0C, 0x60, 0x30, 0xC3, 0xC1, 0xFF, 0x07, 0xF0, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xF0, 0x07, 0xF0, 0x1C, 0x70, 0x60, 0x61, 0xC0, 0xE3, 0x00, 0xCC, 0x01,
  0x98, 0x03, 0x70, 0x0E, 0xC0, 0x1D, 0x80, 0x33, 0x00, 0x66, 0x00, 0xDC,
  0x03, 0x38, 0x06, 0x30, 0x18, 0x60, 0x70, 0xE1, 0xC0, 0xFF, 0x01, 0xFC,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xC0, 0x01, 0xC0,
  0x0F, 0xF8, 0x18, 0x78, 0x60, 0x30, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x8E,
  0x03, 0x18, 0x0C, 0x30, 0x38, 0x7F, 0xE1, 0xFF, 0x03, 0x0C, 0x06, 0x0C,
  0x0C, 0x18, 0x38, 0x38, 0x60, 0x30, 0xC0, 0x61, 0x80, 0xC7, 0x01, 0xC0,
  0x01, 0xF8, 0x0F, 0xFC, 0x3C, 0x10, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x31, 0x00, 0xE3, 0xFF, 0x87,
  0xFC, 0x00, 0xFF, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0x38, 0x0E, 0x60,
  0x18, 0xC0, 0x31, 0x80, 0x63, 0x01, 0xCE, 0x03, 0x18, 0x06, 0x30, 0x0C,
  0x60, 0x19, 0xC0, 0x73, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x30,
  0x18, 0x60, 0x70, 0xC0, 0xC1, 0xEF, 0x81, 0xFC, 0x00, 0xC0, 0x0F, 0x80,
  0x1B, 0x00, 0x66, 0x00, 0xCE, 0x03, 0x1C, 0x06, 0x38, 0x18, 0x70, 0x30,
  0x60, 0xC0, 0xC1, 0x81, 0x86, 0x03, 0x1C, 0x06, 0x30, 0x0C, 0xE0, 0x19,
  0x80, 0x36, 0x00, 0x6C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x18, 0x03, 0x8C,
  0x01, 0x8E, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18,
  0x63, 0x18, 0x63, 0x8C, 0x33, 0x46, 0x19, 0xA6, 0x0D, 0x93, 0x04, 0xC9,
  0x82, 0xC4, 0x83, 0x43, 0xC1, 0xE1, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x30,
  0x38, 0x00, 0x03, 0x00, 0xE0, 0x70, 0x30, 0x06, 0x0E, 0x00, 0xC3, 0x80,
  0x1C, 0x60, 0x01, 0x98, 0x00, 0x36, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x01, 0xD8, 0x00, 0x33, 0x80, 0x0C, 0x30, 0x03,
  0x86, 0x00, 0xE0, 0xE0, 0x38, 0x0C, 0x0E, 0x01, 0x83, 0x80, 0x38, 0x00,
  0xE0, 0x0E, 0xC0, 0x19, 0x80, 0x63, 0x01, 0xC7, 0x03, 0x06, 0x0C, 0x0C,
  0x30, 0x18, 0xE0, 0x19, 0x80, 0x36, 0x00, 0x78, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xCC, 0xCC, 0xCE, 0xEE, 0xE6, 0x66, 0x66,
  0x66, 0x66, 0x67, 0x77, 0x73, 0x33, 0x30, 0x03, 0xF8, 0x1F, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x07,
  0xF0, 0x3F, 0x80, 0x03, 0x80, 0x78, 0x06, 0xC0, 0xCC, 0x18, 0xC3, 0x86,
  0x70, 0x66, 0x06, 0xC0, 0x38, 0x02, 0xFF, 0xFF, 0xFF, 0xF0, 0x27, 0x1C,
  0x61, 0x8C, 0x00, 0xF8, 0x1F, 0xF0, 0xE1, 0x87, 0x06, 0x30, 0x19, 0xC0,
  0x66, 0x03, 0x38, 0x0C, 0xC0, 0x33, 0x01, 0xCC, 0x06, 0x38, 0x18, 0xE0,
  0xE1, 0xEF, 0x83, 0xF7, 0x00, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x78, 0x1F, 0xF0, 0x70, 0xE1, 0x81,
  0x8E, 0x07, 0x30, 0x1C, 0xC0, 0x73, 0x01, 0x9C, 0x06, 0x60, 0x39, 0x80,
  0xC6, 0x07, 0x38, 0x78, 0xFF, 0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xE1,
  0xE0, 0x8E, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x11, 0xFF, 0x81, 0xFE, 0x00, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0xFC, 0x07, 0xFC, 0x0F, 0x0C, 0x1C, 0x1C, 0x38, 0x18, 0x30,
  0x18, 0x70, 0x18, 0x60, 0x38, 0x60, 0x30, 0xE0, 0x30, 0xE0, 0x30, 0x60,
  0x30, 0x60, 0x70, 0x7B, 0xF0, 0x3F, 0x30, 0x03, 0xE0, 0x7F, 0xC7, 0x8E,
  0x70, 0x37, 0x01, 0xB0, 0x0D, 0x81, 0xFF, 0xFE, 0xFF, 0x86, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x02, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x0F,
  0xE0, 0x03, 0x88, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x07,
  0xFC, 0x1E, 0x18, 0x70, 0x31, 0xC0, 0xE3, 0x01, 0x8E, 0x03, 0x18, 0x06,
  0x30, 0x1C, 0x60, 0x30, 0xC0, 0x61, 0x81, 0xC3, 0x8F, 0x03, 0xFE, 0x01,
  0x8C, 0x00, 0x18, 0x00, 0x61, 0x01, 0xC3, 0xFF, 0x07, 0xF8, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x78, 0x1F, 0xF0, 0x70, 0xE1, 0x81, 0x86, 0x07, 0x38, 0x1C, 0xE0, 0x63,
  0x01, 0x8C, 0x06, 0x30, 0x39, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x33,
  0x81, 0xC0, 0x07, 0x07, 0x81, 0xC0, 0x40, 0x00, 0x01, 0xF9, 0xFC, 0x0E,
  0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0xF0, 0xF8, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x04, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x40, 0xC0, 0xFF,
  0x81, 0xFC, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x07, 0x18, 0x1C, 0x30, 0x60, 0x63, 0x81,
  0xCE, 0x03, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0x3B, 0x80, 0x63, 0x80, 0xC3,
  0x01, 0x83, 0x07, 0x07, 0x0C, 0x06, 0x18, 0x0E, 0x00, 0xFE, 0xFC, 0x0C,
  0x0C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60,
  0x60, 0x60, 0xE0, 0xE0, 0xE0, 0x7E, 0x7F, 0x0F, 0x9C, 0x3F, 0xFC, 0x67,
  0x18, 0xC6, 0x33, 0x8C, 0x66, 0x30, 0xCC, 0x63, 0x18, 0xC6, 0x71, 0x8C,
  0xC4, 0x19, 0x80, 0x63, 0x00, 0xCE, 0x01, 0x98, 0x03, 0x30, 0x0E, 0x00,
  0x03, 0xE0, 0xFF, 0x86, 0x0E, 0x30, 0x33, 0x81, 0x98, 0x0C, 0xC0, 0x66,
  0x03, 0x30, 0x3B, 0x81, 0x98, 0x0C, 0xC0, 0x66, 0x07, 0x70, 0x33, 0x01,
  0x80, 0x01, 0xE0, 0x3F, 0xC1, 0xE3, 0x8E, 0x06, 0x30, 0x1D, 0xC0, 0x76,
  0x01, 0xD8, 0x06, 0x60, 0x1B, 0x80, 0xEE, 0x03, 0x98, 0x1C, 0x60, 0xE1,
  0xFF, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x30, 0x70, 0x60, 0x61,
  0xC0, 0xE3, 0x01, 0xC6, 0x03, 0x8C, 0x06, 0x38, 0x0C, 0x60, 0x38, 0xC0,
  0x61, 0x81, 0xC7, 0x07, 0x0F, 0xFC, 0x1F, 0xE0, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0xF0, 0xF1, 0xC7,
  0x07, 0x38, 0x18, 0xC0, 0x66, 0x01, 0x98, 0x0E, 0x60, 0x33, 0x80, 0xCE,
  0x03, 0x38, 0x1C, 0x60, 0x61, 0xEF, 0x83, 0xFE, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x03, 0xF8, 0xFF, 0xC6, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03, 0xE0, 0xFF, 0x1C, 0x11, 0x80,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0xF8, 0x03, 0xC0, 0x0C, 0x00, 0xE0, 0x0E,
  0x80, 0xCF, 0xFC, 0xFF, 0x00, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x7F,
  0xF7, 0xFF, 0x9C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x43, 0xF8, 0x1F, 0x80, 0x30, 0x1B,
  0x81, 0xD8, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x3B, 0x81, 0x98, 0x0C, 0xC0,
  0x66, 0x03, 0x30, 0x39, 0x81, 0x8C, 0x1C, 0x7F, 0xE1, 0xF9, 0x80, 0xE0,
  0x3E, 0x03, 0xE0, 0x7E, 0x06, 0xE0, 0x66, 0x0C, 0x60, 0xC6, 0x18, 0x63,
  0x86, 0x30, 0x66, 0x07, 0xE0, 0x3C, 0x03, 0x80, 0x38, 0x00, 0x30, 0x03,
  0x70, 0x07, 0x60, 0x06, 0x60, 0x06, 0x61, 0x8E, 0x63, 0x8C, 0x63, 0x8C,
  0x67, 0x98, 0x67, 0x98, 0x6D, 0xB8, 0x78, 0xB0, 0x78, 0xB0, 0x70, 0xE0,
  0x60, 0xE0, 0xE0, 0xC0, 0x0E, 0x03, 0x83, 0x03, 0x81, 0xC1, 0x80, 0x61,
  0x80, 0x39, 0x80, 0x0D, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xCC, 0x01, 0xC6, 0x01, 0xC3, 0x81, 0xC0, 0xC3, 0xC0, 0x70,
  0x07, 0x01, 0xC1, 0xC0, 0x60, 0x70, 0x18, 0x0C, 0x0E, 0x03, 0x03, 0x00,
  0xC0, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x8E, 0x00, 0x63, 0x00, 0x19,
  0xC0, 0x06, 0x60, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0x7E, 0x03, 0xF8, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x03, 0x80,
  0x1E, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF,
  0x00, 0xFC, 0x00, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x0C,
  0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x70,
  0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3E, 0x0D, 0xFC,
  0x66, 0x1F, 0xB0, 0x38,
};

const GFXglyph UbuntuSansMono_Italic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 8, 19, 16, 4, -19 },
  { 20, 8, 7, 16, 6, -21 },
  { 27, 17, 19, 16, 0, -19 },
  { 68, 15, 25, 16, 1, -22 },
  { 115, 19, 20, 16, -1, -20 },
  { 163, 13, 20, 16, 1, -20 },
  { 196, 4, 8, 16, 8, -21 },
  { 200, 11, 27, 16, 4, -22 },
  { 238, 11, 27, 16, 1, -22 },
  { 276, 12, 11, 16, 3, -19 },
  { 293, 13, 14, 16, 2, -15 },
  { 316, 7, 8, 16, 2, -4 },
  { 323, 7, 2, 16, 5, -9 },
  { 325, 5, 4, 16, 4, -4 },
  { 328, 18, 27, 16, -2, -22 },
  { 389, 13, 20, 16, 2, -20 },
  { 422, 11, 19, 16, 2, -19 },
  { 449, 14, 20, 16, 1, -20 },
  { 484, 14, 20, 16, 1, -20 },
  { 519, 15, 19, 16, 0, -19 },
  { 555, 15, 19, 16, 1, -19 },
  { 591, 14, 20, 16, 2, -20 },
  { 626, 14, 19, 16, 3, -19 },
  { 660, 15, 20, 16, 1, -20 },
  { 698, 15, 20, 16, 1, -20 },
  { 736, 7, 14, 16, 4, -14 },
  { 749, 9, 18, 16, 2, -14 },
  { 770, 14, 12, 16, 1, -14 },
  { 791, 14, 8, 16, 1, -12 },
  { 805, 13, 12, 16, 1, -14 },
  { 825, 11, 20, 16, 4, -20 },
  { 853, 15, 24, 16, 1, -20 },
  { 898, 15, 19, 16, -2, -19 },
  { 934, 15, 20, 16, 0, -20 },
  { 972, 15, 20, 16, 2, -20 },
  { 1010, 15, 20, 16, 0, -20 },
  { 1048, 16, 19, 16, 1, -19 },
  { 1086, 16, 19, 16, 1, -19 },
  { 1124, 15, 20, 16, 1, -20 },
  { 1162, 17, 19, 16, 0, -19 },
  { 1203, 14, 19, 16, 1, -19 },
  { 1237, 15, 19, 16, 1, -19 },
  { 1273, 17, 19, 16, 0, -19 },
  { 1314, 11, 19, 16, 1, -19 },
  { 1341, 17, 19, 16, -1, -19 },
  { 1382, 17, 19, 16, 0, -19 },
  { 1423, 15, 20, 16, 1, -20 },
  { 1461, 15, 20, 16, 1, -20 },
  { 1499, 15, 25, 16, 1, -20 },
  { 1546, 15, 20, 16, 0, -20 },
  { 1584, 15, 20, 16, 1, -20 },
  { 1622, 13, 19, 16, 4, -19 },
  { 1653, 15, 19, 16, 2, -19 },
  { 1689, 15, 19, 16, 3, -19 },
  { 1725, 17, 19, 16, 1, -19 },
  { 1766, 19, 19, 16, -1, -19 },
  { 1812, 15, 19, 16, 3, -19 },
  { 1848, 17, 19, 16, 0, -19 },
  { 1889, 14, 27, 16, 2, -22 },
  { 1937, 4, 27, 16, 6, -22 },
  { 1951, 13, 27, 16, 0, -22 },
  { 1995, 12, 10, 16, 3, -19 },
  { 2010, 14, 2, 16, -2, 3 },
  { 2014, 5, 6, 16, 7, -22 },
  { 2018, 14, 15, 16, 1, -15 },
  { 2045, 14, 22, 16, 1, -22 },
  { 2084, 14, 15, 16, 1, -15 },
  { 2111, 16, 22, 16, 1, -22 },
  { 2155, 13, 15, 16, 1, -15 },
  { 2180, 18, 27, 16, 0, -22 },
  { 2241, 15, 20, 16, 0, -15 },
  { 2279, 14, 22, 16, 0, -22 },
  { 2318, 9, 21, 16, 3, -21 },
  { 2342, 15, 26, 16, 0, -21 },
  { 2391, 15, 22, 16, 1, -22 },
  { 2433, 8, 22, 16, 5, -22 },
  { 2455, 15, 15, 16, 0, -15 },
  { 2484, 13, 15, 16, 1, -15 },
  { 2509, 14, 15, 16, 1, -15 },
  { 2536, 15, 20, 16, 0, -15 },
  { 2574, 14, 20, 16, 1, -15 },
  { 2609, 13, 15, 16, 2, -15 },
  { 2634, 12, 15, 16, 2, -15 },
  { 2657, 12, 19, 16, 3, -19 },
  { 2686, 13, 15, 16, 2, -15 },
  { 2711, 12, 15, 16, 3, -15 },
  { 2734, 16, 15, 16, 1, -15 },
  { 2764, 17, 15, 16, -1, -15 },
  { 2796, 18, 20, 16, -2, -15 },
  { 2841, 14, 15, 16, 1, -15 },
  { 2868, 15, 27, 16, 2, -22 },
  { 2919, 8, 27, 16, 4, -22 },
  { 2946, 15, 27, 16, -1, -22 },
  { 2997, 14, 4, 16, 1, -10 },
};

const GFXfont UbuntuSansMono_Italic28pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic28pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic28pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _UBUNTUSANSMONO_ITALIC28PT7B_H_
