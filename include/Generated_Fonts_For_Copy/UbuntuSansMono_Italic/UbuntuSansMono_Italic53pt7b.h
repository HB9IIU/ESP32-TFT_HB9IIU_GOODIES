#ifndef _UBUNTUSANSMONO_ITALIC53PT7B_H_
#define _UBUNTUSANSMONO_ITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0xC0, 0x00, 0x1E, 0x0F, 0x1C, 0x0E,
  0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x1C,
  0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0x60, 0x38, 0x60, 0x30, 0xE0, 0x30,
  0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0x80, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x30, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0x80, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x7F,
  0xC0, 0x03, 0xC0, 0x0F, 0x9E, 0x00, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x80,
  0x1E, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0xE0, 0x1E, 0x00, 0x3C, 0x0E, 0x03,
  0xC0, 0x03, 0xC0, 0xE0, 0x78, 0x00, 0x38, 0x1E, 0x0F, 0x00, 0x03, 0x81,
  0xE0, 0xF0, 0x00, 0x38, 0x1E, 0x1E, 0x00, 0x03, 0x81, 0xC3, 0xC0, 0x00,
  0x38, 0x3C, 0x78, 0x00, 0x03, 0x83, 0x8F, 0x00, 0x00, 0x3C, 0x79, 0xE0,
  0x00, 0x01, 0xFF, 0x3C, 0x00, 0x00, 0x1F, 0xE3, 0xC0, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xC0, 0x00,
  0x00, 0x3C, 0x7F, 0x00, 0x00, 0x07, 0x8F, 0xF8, 0x00, 0x00, 0x71, 0xE3,
  0x80, 0x00, 0x0F, 0x3C, 0x3C, 0x00, 0x01, 0xE3, 0x83, 0xC0, 0x00, 0x3C,
  0x38, 0x3C, 0x00, 0x07, 0x87, 0x83, 0xC0, 0x00, 0xF0, 0x70, 0x3C, 0x00,
  0x1E, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0x70, 0x3C, 0x00, 0x3C, 0x0F, 0x03,
  0x80, 0x07, 0x80, 0xF0, 0x78, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x70, 0x03, 0xC0, 0x07, 0x8E, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0x0F,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xC1,
  0xF0, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x1E,
  0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x03, 0xC7, 0xC0, 0x01, 0xE7, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x81, 0xC0, 0x3F, 0xC0, 0xF0,
  0x7F, 0xE0, 0x78, 0x7C, 0xF8, 0x38, 0x7C, 0x3C, 0x3C, 0x3C, 0x1F, 0x1E,
  0x3C, 0x07, 0xDE, 0x1E, 0x01, 0xEF, 0x1E, 0x00, 0xFF, 0x0F, 0x00, 0x3F,
  0x87, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03,
  0xF0, 0x78, 0x03, 0xFC, 0x3E, 0x03, 0xFE, 0x1F, 0xC7, 0xEF, 0x07, 0xFF,
  0xE7, 0xC1, 0xFF, 0xE3, 0xE0, 0x7F, 0xC0, 0xF0, 0x1E, 0x7C, 0xF1, 0xE3,
  0xCF, 0x9E, 0x3C, 0x78, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x18, 0x0E, 0x02,
  0x3E, 0x1C, 0x3E, 0x7F, 0x39, 0xFD, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7B, 0xC0, 0x01,
  0xF7, 0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x78,
  0x0F, 0x00, 0x70, 0x1C, 0x00, 0x40, 0x10, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x17, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0x81, 0xFC, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0xFE, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x0F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xE0, 0x1C, 0x3F, 0x9F, 0xDF, 0xEF, 0xFF, 0xF9, 0xFC, 0xFC,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x3C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0x7C, 0xF8, 0x78, 0x1E, 0x3C, 0x3F, 0x07, 0x9F, 0x0F, 0xC1, 0xE7,
  0xC7, 0xF8, 0x79, 0xE1, 0xFE, 0x3E, 0x78, 0x7F, 0x0F, 0x1E, 0x0F, 0xC3,
  0xCF, 0x81, 0xC1, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x3C, 0x00,
  0x0F, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x07, 0xE1, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xBC, 0x07, 0xF9, 0xE0, 0x1F, 0x1F, 0x00, 0xC0,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xC0, 0xFC, 0x01, 0xC0, 0x0F, 0x80, 0x30, 0x00, 0xF8, 0x04, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x78, 0x1F, 0x80,
  0x18, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x18, 0x00, 0x7F, 0x07, 0x80, 0x7F,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF1, 0xE0,
  0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x03,
  0xC0, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x7F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x20, 0x00, 0xFC, 0x01, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF9, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07,
  0xFE, 0x3F, 0xC1, 0xF8, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0x78, 0x01, 0xF0,
  0x1F, 0x01, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x78, 0x00, 0xF0, 0x1F, 0x00,
  0x1F, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x83,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x03,
  0xE0, 0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x87, 0xF0,
  0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0xFE, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x01, 0xF0, 0x01, 0xE0, 0x3E,
  0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F,
  0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7F, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xEF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7E,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x81, 0xFC,
  0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x1F, 0xC0, 0xFC, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F,
  0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x20, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x80, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x06, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFC, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x3F,
  0x00, 0x0F, 0x03, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0x87, 0x80, 0x3F, 0xF8,
  0x7C, 0x07, 0xFF, 0xC3, 0xC0, 0x7F, 0xFE, 0x3E, 0x07, 0xE0, 0xF1, 0xF0,
  0x7C, 0x0F, 0x8F, 0x07, 0xC0, 0x78, 0xF8, 0x7C, 0x03, 0xC7, 0xC3, 0xC0,
  0x1E, 0x3C, 0x1E, 0x01, 0xF1, 0xE1, 0xF0, 0x0F, 0x0F, 0x0F, 0x00, 0x78,
  0xF8, 0x78, 0x03, 0xC7, 0xC3, 0xC0, 0x3E, 0x3E, 0x1E, 0x01, 0xE1, 0xE0,
  0xF0, 0x0F, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x3E, 0x07, 0xC3, 0xC0, 0xF0,
  0x3C, 0x1F, 0x07, 0xE1, 0xE0, 0xF8, 0x1F, 0xFF, 0x07, 0xC0, 0x7F, 0xF8,
  0x1E, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFE, 0x02, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0,
  0x0F, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x78, 0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x78, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xC7,
  0xFE, 0x01, 0xE0, 0x07, 0xE0, 0x1E, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x7C,
  0x07, 0x80, 0x0F, 0x80, 0x78, 0x07, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x3F,
  0x01, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x3E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x78, 0x7C, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x00, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0x30, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xC0,
  0x0F, 0xE0, 0x3E, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0x00,
  0xFC, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3E, 0x07,
  0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF8, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x0F,
  0x00, 0x1F, 0x80, 0x78, 0x03, 0xF8, 0x03, 0xE1, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0x03, 0xE0, 0x1F, 0x80, 0x0C, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x80,
  0x7C, 0x00, 0x78, 0x07, 0xE0, 0x07, 0x80, 0x3F, 0x80, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x04, 0x00,
  0x1F, 0x00, 0x30, 0x01, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x1E, 0x1F, 0x80, 0x00, 0x3C,
  0x7E, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x80,
  0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x37, 0x00, 0xEE, 0x00, 0x77, 0x00, 0xEE, 0x00, 0x77,
  0x01, 0xDE, 0x00, 0xF7, 0x03, 0xDC, 0x00, 0xE7, 0x83, 0x9C, 0x00, 0xE7,
  0x87, 0x9C, 0x01, 0xE7, 0x87, 0x1C, 0x01, 0xE7, 0x8E, 0x3C, 0x01, 0xC3,
  0x8E, 0x3C, 0x03, 0xC3, 0x9C, 0x3C, 0x03, 0xC3, 0x9C, 0x38, 0x03, 0x83,
  0xB8, 0x38, 0x07, 0x83, 0xF8, 0x78, 0x07, 0x83, 0xF0, 0x78, 0x07, 0x83,
  0xE0, 0x78, 0x07, 0x03, 0xE0, 0x70, 0x0F, 0x03, 0xC0, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0xFE,
  0x00, 0x1E, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0xEF, 0x00, 0x1E, 0x00, 0xEF,
  0x00, 0x3C, 0x01, 0xEF, 0x00, 0x3C, 0x01, 0xE7, 0x00, 0x3C, 0x01, 0xE7,
  0x80, 0x3C, 0x01, 0xC7, 0x80, 0x78, 0x03, 0xC7, 0x80, 0x78, 0x03, 0xC3,
  0x80, 0x78, 0x03, 0xC3, 0xC0, 0x78, 0x03, 0x83, 0xC0, 0x70, 0x07, 0x81,
  0xC0, 0xF0, 0x07, 0x81, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0xF0, 0x07, 0x01,
  0xE0, 0xE0, 0x0F, 0x00, 0xE1, 0xE0, 0x0F, 0x00, 0xE1, 0xE0, 0x0F, 0x00,
  0xF1, 0xE0, 0x0E, 0x00, 0xF1, 0xC0, 0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0x00,
  0x73, 0xC0, 0x1E, 0x00, 0x73, 0xC0, 0x1E, 0x00, 0x7B, 0xC0, 0x3C, 0x00,
  0x7B, 0x80, 0x3C, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0x3F, 0x80, 0x3C, 0x00,
  0x3F, 0x80, 0x78, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x78, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x1E, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x0F, 0x3C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F,
  0xBC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x00,
  0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xF8, 0x7F,
  0xC0, 0x0F, 0x00, 0x3F, 0x00, 0x78, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xC0,
  0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x7E, 0x01, 0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x00,
  0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3C,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D,
  0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0x9E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x03,
  0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF7, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x1E, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x01, 0xF8, 0x0F, 0x01,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xE0,
  0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0x78,
  0x07, 0xC0, 0x07, 0x80, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0x78,
  0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xF8, 0x1F, 0x00,
  0x3E, 0x00, 0x10, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x01, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x7F, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x1F, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0x80, 0xF8,
  0x00, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x07,
  0x80, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x38, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0xC0, 0xF0, 0x1C, 0x0F,
  0x81, 0xC0, 0x78, 0x3F, 0x07, 0x80, 0xF0, 0x7E, 0x0F, 0x01, 0xE1, 0xDC,
  0x1C, 0x03, 0x87, 0xB8, 0x38, 0x07, 0x0E, 0x70, 0xF0, 0x0E, 0x3C, 0xE1,
  0xE0, 0x3C, 0x71, 0xE3, 0x80, 0x79, 0xE1, 0xCF, 0x00, 0xE3, 0x83, 0x9C,
  0x01, 0xCE, 0x07, 0x38, 0x03, 0xBC, 0x0E, 0x70, 0x07, 0x70, 0x1D, 0xC0,
  0x1D, 0xE0, 0x3B, 0x80, 0x3B, 0x80, 0x77, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x78, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0x78,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xF0, 0xF0,
  0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0x38, 0x00,
  0x7C, 0x78, 0x01, 0xF0, 0xF0, 0x07, 0xC0, 0xE0, 0x0F, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0xF8, 0x03, 0x83, 0xE0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00,
  0x1E, 0x78, 0x00, 0x1D, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0x79, 0x00, 0x00,
  0x40, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0x30, 0x38, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x81, 0x80, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0x3E, 0x03, 0xF8, 0x07, 0x81, 0xFC, 0x01, 0xE0,
  0xFC, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x03,
  0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x3E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xF0, 0x07, 0xE0, 0x7E, 0x07,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xF3, 0xC0, 0x3F, 0xF0, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF1, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x7F, 0x01, 0xF8,
  0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC3,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xC7, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x3C,
  0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x87, 0x80, 0x0F, 0xC1, 0xE0, 0x07, 0xE0,
  0x78, 0x07, 0xF0, 0x1E, 0x0F, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFC, 0x3E, 0x03, 0xF0, 0x01,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x20, 0x3F, 0x00, 0x78, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xCF, 0x80, 0x1F, 0xC0, 0x3C,
  0x01, 0xF8, 0x01, 0xE0, 0x1F, 0x80, 0x1E, 0x01, 0xF8, 0x00, 0xF0, 0x0F,
  0x80, 0x07, 0x80, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x7C, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00,
  0x1E, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x1F, 0x80, 0x3E, 0x03, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xEF, 0x00, 0x0F, 0xFC, 0x3C, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x7F, 0xEF, 0xF0, 0x7F, 0x00, 0xF8, 0x7E, 0x00, 0x3C, 0x3E,
  0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9F, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x07, 0xE7, 0x80, 0x0F, 0xE3, 0xC7, 0xFF, 0xE3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x10, 0x3F, 0x80, 0xF8, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x0F,
  0xC0, 0x07, 0x80, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x80,
  0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x1E, 0x00, 0x7C,
  0x01, 0xF8, 0x01, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xF8, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x20, 0x00, 0xF8, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x79, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xF0, 0x07, 0xE0, 0x3C, 0x00,
  0x78, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1E,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x08, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xDC, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x04, 0x00, 0x7C, 0x00, 0x60, 0x0F,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0xFC,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0xFC, 0x00, 0x78,
  0x1F, 0x80, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0xFC, 0x00, 0x0F, 0x1F, 0x80,
  0x00, 0xF7, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0x7E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x07, 0xC0, 0x07,
  0xC0, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x00,
  0xF0, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x81, 0xCF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFC, 0x03, 0x80, 0x00,
  0xFF, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x83,
  0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x1E, 0x0F, 0x03,
  0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03,
  0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0x7C,
  0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xE0,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x7C,
  0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7E, 0x03,
  0xF0, 0x7E, 0x00, 0x78, 0x7E, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0x9F, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xF7, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0,
  0x00, 0x1F, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0xCF,
  0x00, 0x07, 0xC7, 0x80, 0x07, 0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x07, 0xE0,
  0x7F, 0x1F, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0x00, 0x3F, 0x00, 0x78,
  0x00, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0,
  0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0xF8, 0x0F, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0,
  0x3C, 0x00, 0xFC, 0x01, 0xE0, 0x0F, 0xC0, 0x1F, 0x03, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xEE, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x7E, 0x03,
  0xF8, 0x07, 0x81, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x07, 0xC0, 0x7C, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xF7, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xE0, 0x02,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x60, 0x01, 0xF0, 0x78, 0x03, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x03, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE3,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x7C,
  0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x0F,
  0x8F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xE0, 0x01,
  0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xE0,
  0x0F, 0xC0, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0x70, 0x1F, 0xFF, 0x3C, 0x07,
  0xFE, 0x1E, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7B,
  0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0,
  0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1F, 0x03,
  0xC0, 0x3E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x07, 0x8F, 0x01, 0xE0, 0x78, 0x78, 0x1F, 0x03, 0xC3, 0xC0, 0xF8, 0x1C,
  0x1E, 0x0F, 0xC1, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0x07, 0xF0, 0xF0, 0x78,
  0x7B, 0x87, 0x83, 0xC3, 0x9C, 0x38, 0x1E, 0x3C, 0xE3, 0xC0, 0xF1, 0xC7,
  0x1E, 0x07, 0x9E, 0x3D, 0xE0, 0x3D, 0xE1, 0xEF, 0x01, 0xEE, 0x0F, 0xF0,
  0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFC, 0xF0, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x3F, 0x03, 0xC0, 0x00,
  0xFC, 0x03, 0xC0, 0x03, 0xF0, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x0F, 0x00, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x40, 0x3E, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x07, 0xF8, 0x01, 0xC7, 0xFE, 0x01, 0xE7, 0xFF,
  0x80, 0xE7, 0x83, 0xF1, 0xF7, 0x80, 0xFF, 0xF3, 0xC0, 0x3F, 0xF1, 0xC0,
  0x07, 0xF0,
};

const GFXglyph UbuntuSansMono_Italic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 14, 38, 30, 8, -37 },
  { 68, 16, 14, 30, 11, -40 },
  { 96, 32, 37, 30, 0, -37 },
  { 244, 28, 47, 30, 2, -41 },
  { 409, 36, 39, 30, -2, -38 },
  { 585, 25, 38, 30, 1, -38 },
  { 704, 7, 15, 30, 16, -40 },
  { 718, 22, 51, 30, 7, -41 },
  { 859, 22, 51, 30, 1, -41 },
  { 1000, 23, 22, 30, 6, -37 },
  { 1064, 25, 26, 30, 3, -29 },
  { 1146, 13, 16, 30, 4, -8 },
  { 1172, 13, 4, 30, 9, -17 },
  { 1179, 9, 9, 30, 8, -8 },
  { 1190, 33, 52, 30, -3, -42 },
  { 1405, 26, 39, 30, 3, -38 },
  { 1532, 21, 37, 30, 4, -37 },
  { 1630, 27, 38, 30, 2, -38 },
  { 1759, 26, 39, 30, 2, -38 },
  { 1886, 27, 37, 30, 1, -37 },
  { 2011, 29, 38, 30, 1, -37 },
  { 2149, 26, 38, 30, 4, -37 },
  { 2273, 27, 37, 30, 6, -37 },
  { 2398, 27, 39, 30, 3, -38 },
  { 2530, 28, 38, 30, 2, -38 },
  { 2663, 13, 29, 30, 8, -28 },
  { 2711, 17, 36, 30, 4, -28 },
  { 2788, 26, 24, 30, 2, -27 },
  { 2866, 27, 15, 30, 2, -23 },
  { 2917, 26, 24, 30, 1, -27 },
  { 2995, 20, 39, 30, 8, -38 },
  { 3093, 29, 46, 30, 2, -38 },
  { 3260, 29, 37, 30, -3, -37 },
  { 3395, 28, 37, 30, 1, -37 },
  { 3525, 29, 39, 30, 3, -38 },
  { 3667, 29, 37, 30, 0, -37 },
  { 3802, 29, 37, 30, 2, -37 },
  { 3937, 30, 37, 30, 2, -37 },
  { 4076, 28, 39, 30, 3, -38 },
  { 4213, 32, 37, 30, 0, -37 },
  { 4361, 26, 37, 30, 3, -37 },
  { 4482, 29, 38, 30, 2, -37 },
  { 4620, 31, 37, 30, 1, -37 },
  { 4764, 21, 37, 30, 1, -37 },
  { 4862, 32, 37, 30, -1, -37 },
  { 5010, 32, 37, 30, 0, -37 },
  { 5158, 27, 39, 30, 3, -38 },
  { 5290, 29, 37, 30, 1, -37 },
  { 5425, 27, 48, 30, 3, -38 },
  { 5587, 28, 37, 30, 1, -37 },
  { 5717, 29, 39, 30, 1, -38 },
  { 5859, 26, 37, 30, 7, -37 },
  { 5980, 29, 38, 30, 3, -37 },
  { 6118, 28, 37, 30, 6, -37 },
  { 6248, 31, 37, 30, 2, -37 },
  { 6392, 36, 37, 30, -2, -37 },
  { 6559, 28, 37, 30, 7, -37 },
  { 6689, 32, 37, 30, 0, -37 },
  { 6837, 26, 52, 30, 4, -42 },
  { 7006, 8, 52, 30, 11, -42 },
  { 7058, 26, 52, 30, -1, -42 },
  { 7227, 23, 20, 30, 5, -37 },
  { 7285, 28, 4, 30, -4, 6 },
  { 7299, 9, 11, 30, 14, -41 },
  { 7312, 26, 29, 30, 2, -28 },
  { 7407, 26, 42, 30, 2, -41 },
  { 7544, 26, 29, 30, 2, -28 },
  { 7639, 29, 42, 30, 3, -41 },
  { 7792, 25, 29, 30, 2, -28 },
  { 7883, 34, 51, 30, -1, -41 },
  { 8100, 30, 38, 30, -1, -28 },
  { 8243, 26, 41, 30, 0, -41 },
  { 8377, 17, 41, 30, 6, -41 },
  { 8465, 28, 51, 30, 0, -41 },
  { 8644, 28, 41, 30, 2, -41 },
  { 8788, 15, 42, 30, 9, -41 },
  { 8867, 29, 28, 30, 0, -28 },
  { 8969, 25, 28, 30, 2, -28 },
  { 9057, 25, 29, 30, 3, -28 },
  { 9148, 29, 38, 30, -1, -28 },
  { 9286, 26, 38, 30, 3, -28 },
  { 9410, 26, 28, 30, 3, -28 },
  { 9501, 24, 29, 30, 3, -28 },
  { 9588, 21, 37, 30, 7, -36 },
  { 9686, 25, 28, 30, 3, -27 },
  { 9774, 23, 27, 30, 6, -27 },
  { 9852, 29, 27, 30, 3, -27 },
  { 9950, 31, 27, 30, -1, -27 },
  { 10055, 32, 37, 30, -3, -27 },
  { 10203, 27, 27, 30, 1, -27 },
  { 10295, 29, 52, 30, 3, -42 },
  { 10484, 17, 52, 30, 7, -42 },
  { 10595, 28, 52, 30, -2, -42 },
  { 10777, 25, 8, 30, 3, -20 },
};

const GFXfont UbuntuSansMono_Italic53pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic53pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic53pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _UBUNTUSANSMONO_ITALIC53PT7B_H_
