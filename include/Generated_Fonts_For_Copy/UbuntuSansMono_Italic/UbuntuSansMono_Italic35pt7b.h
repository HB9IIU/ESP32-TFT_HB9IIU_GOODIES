#ifndef _UBUNTUSANSMONO_ITALIC35PT7B_H_
#define _UBUNTUSANSMONO_ITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x00, 0x00, 0x00, 0x04, 0x07,
  0x87, 0xC3, 0xE0, 0xF0, 0x71, 0xD8, 0x66, 0x19, 0x86, 0xE3, 0xB0, 0xCC,
  0x33, 0x0C, 0x82, 0x20, 0x80, 0x00, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x0C,
  0x1C, 0x00, 0xE0, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x60, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x06, 0x0E,
  0x00, 0x70, 0xE0, 0x03, 0x07, 0x00, 0x38, 0x30, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC0, 0xE1, 0xC0, 0x06, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x07, 0x00,
  0x38, 0x30, 0x01, 0x83, 0x80, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7C, 0x38,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x04, 0x01, 0xC3,
  0xC3, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x1C,
  0x1C, 0xC0, 0x70, 0x71, 0x81, 0xC0, 0xC3, 0x07, 0x01, 0x86, 0x1C, 0x03,
  0x0C, 0x30, 0x0E, 0x18, 0xC0, 0x1C, 0x73, 0x00, 0x18, 0xCE, 0x00, 0x3B,
  0xB8, 0x00, 0x7C, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x30, 0x00, 0x19,
  0xF8, 0x00, 0x67, 0x30, 0x01, 0xCC, 0x60, 0x07, 0x30, 0xC0, 0x1C, 0x61,
  0x80, 0x70, 0xC3, 0x00, 0xC1, 0x86, 0x03, 0x03, 0x1C, 0x0C, 0x06, 0x30,
  0x38, 0x0E, 0xE0, 0xE0, 0x1F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x01,
  0xFE, 0x03, 0xDE, 0x07, 0x06, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x1C, 0x07, 0x38, 0x07, 0xF0, 0x03, 0xE0, 0x0F, 0x83, 0x1F,
  0xC7, 0x39, 0xC7, 0x70, 0xE6, 0x70, 0x7E, 0xE0, 0x7C, 0xE0, 0x3C, 0xE0,
  0x38, 0xE0, 0x3C, 0xE0, 0x7C, 0xF1, 0xFC, 0x7F, 0xCE, 0x3F, 0x0E, 0x77,
  0x76, 0xEE, 0xEC, 0xCC, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0x60, 0x01, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x02, 0x1C, 0x27, 0x39, 0xDF, 0xAF, 0xDF, 0xFF, 0x01, 0xC0, 0x07,
  0xC0, 0x1D, 0xC0, 0x79, 0xC1, 0xE3, 0xC3, 0x83, 0x81, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x1F, 0x3F,
  0x1F, 0x1F, 0x0E, 0x0E, 0x3C, 0xF8, 0xF0, 0x80, 0xFF, 0xFF, 0x79, 0xFF,
  0xDF, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0xF0, 0xE0, 0xF0, 0x38, 0xF0, 0x1C, 0x70, 0x0E,
  0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xDC, 0x70, 0xEE, 0x7C, 0x77, 0x3E,
  0x77, 0x1F, 0x3B, 0x87, 0x1D, 0xC0, 0x0E, 0xE0, 0x0E, 0x70, 0x07, 0x38,
  0x07, 0x1C, 0x03, 0x8E, 0x03, 0x87, 0x03, 0xC1, 0xC3, 0xC0, 0xFF, 0xC0,
  0x3F, 0x80, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0xC0, 0x7E,
  0x07, 0xF8, 0x3C, 0xE0, 0xC3, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x17, 0xFF, 0xBF, 0xFE, 0x00,
  0x78, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xC0, 0xF0, 0x40, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x0C, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x86, 0x07, 0xC3, 0xFF, 0xE0, 0x7F,
  0xE0, 0x00, 0x80, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0x60, 0x07, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x07, 0x0C, 0x07, 0x0E, 0x07,
  0x07, 0x03, 0x83, 0x83, 0x81, 0x83, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0x71,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x04, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0xC0, 0xF8, 0x3F,
  0xFE, 0x03, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0,
  0x7E, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x38, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x8F, 0x01, 0xC7, 0x00,
  0x73, 0x80, 0x39, 0x80, 0x1C, 0xC0, 0x0E, 0x60, 0x06, 0x30, 0x07, 0x18,
  0x03, 0x8E, 0x03, 0x87, 0x03, 0xC1, 0xFF, 0xC0, 0x7F, 0x80, 0x06, 0x00,
  0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x1C, 0x0E, 0x0E, 0x01, 0x83, 0x80, 0x71, 0xC0, 0x1C, 0x70,
  0x0E, 0x1C, 0x03, 0x87, 0x01, 0xC0, 0xE0, 0xF0, 0x3E, 0x78, 0x07, 0xF8,
  0x07, 0xFE, 0x03, 0xC3, 0xC1, 0xE0, 0x78, 0x70, 0x0E, 0x38, 0x03, 0x8E,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x0F, 0x03, 0xC1, 0xFF,
  0xE0, 0x3F, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x3C, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0x61, 0xC0, 0x1C, 0xE0, 0x06,
  0x38, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x1C, 0x0F, 0x87,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF1, 0xF8, 0x7C, 0x3C, 0x00,
  0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xC1, 0xF8, 0x1F, 0x03,
  0xE0, 0x38, 0x07, 0x03, 0xC1, 0xF0, 0x3C, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x01,
  0xF0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x10, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x03,
  0x80, 0x01, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xC1, 0xEF, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x01, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xE0, 0x70, 0x78, 0x0E,
  0x0E, 0x00, 0xC3, 0x80, 0x18, 0xF0, 0x03, 0x1C, 0x07, 0xE7, 0x87, 0xFC,
  0xE1, 0xFF, 0x9C, 0x70, 0x67, 0x1C, 0x1C, 0xE3, 0x83, 0x9C, 0x60, 0x73,
  0x9C, 0x0E, 0x63, 0x83, 0x9C, 0x70, 0x73, 0x8E, 0x0E, 0x71, 0xC1, 0xCE,
  0x1C, 0x30, 0xC1, 0xFE, 0x1C, 0x1F, 0xC3, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x08, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x36, 0x00, 0x0E, 0xE0, 0x01, 0x9C,
  0x00, 0x73, 0x80, 0x1C, 0x70, 0x03, 0x0E, 0x00, 0xE1, 0xC0, 0x18, 0x38,
  0x07, 0x07, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x0E, 0x01, 0x81, 0x80, 0x30,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0x80, 0x1C, 0x60, 0x03, 0x9C, 0x00, 0x73,
  0x00, 0x0E, 0xE0, 0x01, 0xD8, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x10, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0x80, 0xF0, 0x70, 0x0E, 0x0E, 0x01, 0xC1,
  0x80, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x30, 0x1E, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x38, 0x7E, 0x06, 0x00, 0xE0, 0xC0, 0x1C, 0x38,
  0x01, 0x87, 0x00, 0x30, 0xE0, 0x0E, 0x18, 0x01, 0xC7, 0x00, 0x78, 0xE0,
  0x1E, 0x1C, 0x0F, 0x83, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0x83, 0xC0, 0x20, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x07, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x70, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0x83, 0xC0, 0x60, 0x1C, 0x0C,
  0x03, 0x83, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0x80, 0x1C, 0x70,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x30, 0x01, 0xCE, 0x00, 0x31, 0xC0,
  0x0E, 0x38, 0x01, 0xC6, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0x87, 0x00,
  0xE0, 0xC0, 0x78, 0x38, 0x3E, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0xFF, 0xF8, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xF0, 0x3F, 0xFC, 0x1E, 0x02, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x18, 0xC0, 0x0E, 0x38, 0x03,
  0x8E, 0x00, 0xE3, 0x80, 0x30, 0xE0, 0x1C, 0x1C, 0x07, 0x07, 0x81, 0xC0,
  0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x40, 0x00, 0x03, 0x80, 0x38, 0x38, 0x01,
  0xC1, 0xC0, 0x0C, 0x0E, 0x00, 0xE0, 0x60, 0x07, 0x07, 0x00, 0x38, 0x38,
  0x01, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0C, 0x00, 0xE0, 0xE0, 0x06, 0x07, 0x00,
  0x30, 0x38, 0x03, 0x81, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x06, 0x07,
  0x00, 0x70, 0x30, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x02, 0x01, 0xC0, 0xE0, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x78, 0x1C, 0x07, 0x80, 0xC0, 0x78, 0x0E, 0x07, 0x80,
  0x70, 0x78, 0x03, 0x87, 0x00, 0x18, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x70,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0E,
  0xF0, 0x00, 0x63, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xC0,
  0x0E, 0x07, 0x00, 0x60, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x81, 0xC0,
  0x1C, 0x1C, 0x00, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0,
  0x38, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0xC1, 0xF0, 0x36, 0x0D, 0x81,
  0xB0, 0xF8, 0x0D, 0x86, 0xC0, 0xEC, 0x66, 0x06, 0x63, 0x30, 0x33, 0x31,
  0x83, 0x9D, 0x9C, 0x18, 0xF8, 0xE0, 0xC3, 0xC6, 0x0E, 0x1C, 0x30, 0x70,
  0xC3, 0x83, 0x00, 0x1C, 0x18, 0x00, 0xE1, 0xC0, 0x06, 0x0E, 0x00, 0x30,
  0x60, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0x80, 0x07, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x1E, 0x01, 0xC1, 0xF0, 0x0C, 0x0F, 0x80, 0x60,
  0x6C, 0x07, 0x03, 0x70, 0x38, 0x3B, 0x81, 0xC1, 0xCC, 0x0C, 0x0C, 0x70,
  0x60, 0x63, 0x87, 0x03, 0x0C, 0x38, 0x38, 0x61, 0x81, 0xC3, 0x8C, 0x0C,
  0x1C, 0xE0, 0x60, 0x67, 0x07, 0x03, 0x30, 0x38, 0x19, 0x81, 0x80, 0xFC,
  0x0C, 0x07, 0xE0, 0xE0, 0x1E, 0x07, 0x00, 0xF0, 0x30, 0x07, 0x81, 0x80,
  0x3C, 0x1C, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1C,
  0x0E, 0x0E, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x01,
  0xDC, 0x00, 0x77, 0x00, 0x1D, 0x80, 0x06, 0x60, 0x03, 0xB8, 0x00, 0xEE,
  0x00, 0x3B, 0x80, 0x0C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE3, 0x80,
  0x38, 0xE0, 0x1C, 0x38, 0x0E, 0x07, 0x07, 0x81, 0xFF, 0xC0, 0x1F, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0x81,
  0xE0, 0x60, 0x1C, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x06, 0x0C, 0x00,
  0xC1, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xC1, 0xC0, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1C, 0x0E,
  0x0E, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xDC,
  0x00, 0x77, 0x00, 0x1D, 0x80, 0x06, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00,
  0x3B, 0x80, 0x0C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x38,
  0xE0, 0x1C, 0x38, 0x0E, 0x07, 0x07, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0x00, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0x80, 0xF0, 0x70,
  0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x30, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x07, 0x06, 0x01, 0xC1, 0xC0, 0xF8, 0x3F, 0xFC, 0x07, 0xFE,
  0x00, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x18, 0x07,
  0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x00, 0x38, 0xE0, 0x07,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xC0, 0x20, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x18, 0x0F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x0E, 0x00,
  0xE1, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x61, 0xC0, 0x1C, 0x38, 0x03,
  0x86, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x70, 0xC0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x30, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x30,
  0x70, 0x0E, 0x0E, 0x03, 0xC0, 0xE0, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00,
  0x04, 0x00, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x0E,
  0xE0, 0x07, 0x38, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x30, 0xE0, 0x1C, 0x38,
  0x06, 0x0E, 0x03, 0x83, 0x80, 0xC0, 0x60, 0x70, 0x18, 0x38, 0x06, 0x0E,
  0x01, 0x87, 0x00, 0x61, 0xC0, 0x1C, 0xE0, 0x07, 0x30, 0x01, 0xDC, 0x00,
  0x76, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x38,
  0x60, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00,
  0x30, 0x60, 0x03, 0x83, 0x00, 0x1C, 0x38, 0x00, 0xC1, 0xC3, 0x06, 0x0C,
  0x38, 0x70, 0x63, 0xE3, 0x03, 0x1B, 0x18, 0x39, 0xD9, 0xC1, 0xCC, 0xCC,
  0x0C, 0xC6, 0x60, 0x66, 0x33, 0x03, 0x61, 0xB0, 0x1F, 0x0D, 0x80, 0xF0,
  0x6C, 0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x00,
  0x01, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x03, 0xC0,
  0x0E, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xE3, 0x80, 0x03, 0xC7,
  0x00, 0x0F, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x30, 0x1E, 0x00, 0x70, 0x78, 0x00, 0xE0, 0xE0, 0x01, 0xEC,
  0x00, 0x39, 0x80, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x70, 0x60, 0x1C, 0x0C,
  0x07, 0x01, 0xC0, 0xC0, 0x38, 0x38, 0x03, 0x0E, 0x00, 0x73, 0x80, 0x0E,
  0x60, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0xE3, 0x8E, 0x18, 0x61, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x30, 0xC3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE1, 0x87,
  0x1C, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x70, 0x00, 0xF0, 0x01, 0xF8, 0x03, 0xB8, 0x03, 0x98, 0x07, 0x1C,
  0x0E, 0x1C, 0x1C, 0x0C, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x06, 0xE0, 0x07,
  0x20, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x63, 0x87, 0x0E, 0x18, 0x70,
  0x80, 0x00, 0x04, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x1E, 0x0E, 0x0E, 0x03,
  0x87, 0x00, 0xC3, 0x80, 0x30, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC6,
  0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xC1, 0xC0,
  0x70, 0x70, 0x3C, 0x0F, 0xFF, 0x01, 0xFC, 0xE0, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x18, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xE0, 0xF0, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x06, 0x38, 0x03, 0x18, 0x03, 0x9C, 0x01, 0xCE, 0x00,
  0xE7, 0x00, 0x63, 0x00, 0x73, 0x80, 0x79, 0xC0, 0x78, 0xE0, 0x78, 0x60,
  0xF8, 0x7F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xC1, 0xFF,
  0xE1, 0xE0, 0x11, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x0C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x3F, 0xF0, 0x1F,
  0xFE, 0x07, 0xC1, 0x81, 0xE0, 0x30, 0x78, 0x0E, 0x0E, 0x01, 0xC3, 0x80,
  0x30, 0x70, 0x06, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x06, 0x0E, 0x01,
  0xC1, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x7C, 0x0F, 0xFF,
  0x80, 0xFF, 0x30, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xE0,
  0xF1, 0xE0, 0x39, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0x70, 0x0F, 0x37,
  0xFF, 0x3F, 0xFE, 0x1F, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x7C, 0x0C, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1E, 0x10, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xF0, 0x70, 0x78, 0x0E, 0x1E,
  0x03, 0x83, 0x80, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0x83, 0x00, 0x30, 0xE0,
  0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x30, 0x70, 0x06, 0x0E, 0x01, 0xC1, 0xE0,
  0xF8, 0x1F, 0xFE, 0x01, 0xFE, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x30, 0x1E, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x30, 0x07, 0xFF, 0x03, 0xFF,
  0xC1, 0xC0, 0xE0, 0xE0, 0x38, 0x60, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C,
  0x03, 0x8C, 0x01, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0x80, 0x39,
  0xC0, 0x18, 0xE0, 0x1C, 0x70, 0x0E, 0x30, 0x07, 0x38, 0x07, 0x00, 0x01,
  0x80, 0x78, 0x1F, 0x03, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF3, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x21, 0xFC, 0x1F,
  0x80, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x0C, 0x0E, 0x03, 0xFF,
  0x80, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x21, 0xC0, 0x38, 0x38, 0x1E, 0x07, 0x07, 0x80, 0xC1,
  0xC0, 0x38, 0xF0, 0x07, 0x3C, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xEF, 0x00, 0x1C, 0xF0, 0x03, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x0E,
  0x03, 0x81, 0xC0, 0x60, 0x1C, 0x1C, 0x03, 0xC3, 0x80, 0x38, 0x00, 0xFF,
  0xBF, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0x70, 0x5F, 0xF3, 0xFC, 0x00, 0x81, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0x86, 0x3C, 0x71, 0xC3, 0x0E, 0x38, 0x61, 0xC6,
  0x1C, 0x30, 0xC3, 0x86, 0x38, 0x71, 0xC7, 0x0C, 0x38, 0xE3, 0x87, 0x18,
  0x70, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x00, 0x18, 0xE0,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x00, 0x00, 0x30, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xC0, 0xE0, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07,
  0x1C, 0x03, 0x9C, 0x01, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0x80,
  0x31, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x30, 0x07, 0x38, 0x07, 0x00,
  0x00, 0x60, 0x03, 0xFC, 0x0F, 0xFE, 0x1E, 0x0F, 0x3C, 0x07, 0x38, 0x07,
  0x70, 0x03, 0x70, 0x03, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x3C, 0x70, 0xF8, 0x7F, 0xF0,
  0x3F, 0xC0, 0x00, 0x08, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xC0, 0xF0,
  0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x18, 0x38, 0x03, 0x06, 0x00, 0xE1,
  0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xC0, 0x1C, 0x38, 0x07, 0x87,
  0x00, 0xE0, 0xE0, 0x78, 0x18, 0x3E, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xC1, 0xFF, 0xE1, 0xE0, 0x71, 0xE0,
  0x71, 0xC0, 0x39, 0xE0, 0x1C, 0xE0, 0x0E, 0x60, 0x0E, 0x70, 0x07, 0x38,
  0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38,
  0xF0, 0x78, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x03, 0xFF,
  0xC3, 0xFF, 0xC1, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x10, 0x03, 0xFF, 0x07, 0xFF, 0x0E, 0x02, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x60, 0x78, 0xFF,
  0xF0, 0x7F, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xE0, 0xC3, 0xFF, 0x07, 0xFC, 0x38, 0x03, 0x9C,
  0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x00, 0x73, 0x80, 0x31, 0xC0, 0x38,
  0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x06, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0xC3, 0x80, 0xE1, 0xE1, 0xF0, 0x7F, 0xFC, 0x1F, 0xCE, 0x00,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x77, 0x00, 0xEE, 0x01, 0x9C, 0x07, 0x38,
  0x0C, 0x30, 0x38, 0x60, 0x60, 0xE1, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x38,
  0x0E, 0xE0, 0x0D, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xEE, 0x00, 0x1D, 0xC0, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x1C, 0xC1, 0x83,
  0x38, 0x70, 0xE7, 0x1E, 0x18, 0xE3, 0xC7, 0x1C, 0xFC, 0xE3, 0x9B, 0x98,
  0x76, 0x37, 0x0F, 0xC6, 0xC1, 0xF0, 0xF8, 0x3E, 0x1E, 0x07, 0x83, 0xC0,
  0xE0, 0x78, 0x1C, 0x0E, 0x00, 0x07, 0x80, 0x78, 0x1C, 0x07, 0x00, 0x70,
  0x70, 0x03, 0x87, 0x80, 0x0E, 0x78, 0x00, 0x73, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xB8,
  0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x38,
  0x07, 0x07, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0,
  0x0E, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x03, 0x80,
  0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x30, 0x60, 0x01, 0xC7,
  0x00, 0x0E, 0x30, 0x00, 0x73, 0x80, 0x01, 0x98, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x20, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x07,
  0xFF, 0x87, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x1E, 0x01, 0x1F, 0xC1, 0xDD, 0xF1, 0xDC, 0x3F, 0xCC, 0x07,
  0xC0,
};

const GFXglyph UbuntuSansMono_Italic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 9, 24, 20, 5, -24 },
  { 28, 10, 10, 20, 8, -27 },
  { 41, 21, 24, 20, 0, -24 },
  { 104, 18, 31, 20, 2, -27 },
  { 174, 23, 26, 20, -1, -25 },
  { 249, 16, 25, 20, 1, -25 },
  { 299, 4, 10, 20, 11, -27 },
  { 304, 15, 34, 20, 4, -27 },
  { 368, 14, 34, 20, 1, -27 },
  { 428, 15, 14, 20, 4, -24 },
  { 455, 16, 17, 20, 2, -19 },
  { 489, 8, 11, 20, 3, -5 },
  { 500, 8, 2, 20, 6, -11 },
  { 502, 6, 5, 20, 5, -5 },
  { 506, 22, 33, 20, -2, -27 },
  { 597, 17, 26, 20, 2, -25 },
  { 653, 14, 24, 20, 2, -24 },
  { 695, 17, 25, 20, 2, -25 },
  { 749, 18, 26, 20, 1, -25 },
  { 808, 17, 24, 20, 1, -24 },
  { 859, 19, 25, 20, 1, -24 },
  { 919, 17, 25, 20, 3, -24 },
  { 973, 18, 24, 20, 4, -24 },
  { 1027, 18, 26, 20, 2, -25 },
  { 1086, 18, 25, 20, 2, -25 },
  { 1143, 9, 18, 20, 5, -18 },
  { 1164, 11, 24, 20, 3, -18 },
  { 1197, 17, 16, 20, 2, -18 },
  { 1231, 18, 10, 20, 1, -15 },
  { 1254, 17, 16, 20, 1, -18 },
  { 1288, 14, 25, 20, 5, -25 },
  { 1332, 19, 30, 20, 1, -25 },
  { 1404, 19, 24, 20, -2, -24 },
  { 1461, 19, 25, 20, 0, -25 },
  { 1521, 19, 26, 20, 2, -25 },
  { 1583, 19, 25, 20, 0, -25 },
  { 1643, 19, 24, 20, 2, -24 },
  { 1700, 20, 24, 20, 1, -24 },
  { 1760, 18, 26, 20, 2, -25 },
  { 1819, 21, 24, 20, 0, -24 },
  { 1882, 17, 24, 20, 2, -24 },
  { 1933, 19, 25, 20, 1, -24 },
  { 1993, 21, 24, 20, 0, -24 },
  { 2056, 14, 24, 20, 1, -24 },
  { 2098, 21, 24, 20, -1, -24 },
  { 2161, 21, 24, 20, 0, -24 },
  { 2224, 18, 26, 20, 2, -25 },
  { 2283, 19, 25, 20, 1, -25 },
  { 2343, 18, 31, 20, 2, -25 },
  { 2413, 19, 25, 20, 0, -25 },
  { 2473, 19, 26, 20, 1, -25 },
  { 2535, 16, 24, 20, 5, -24 },
  { 2583, 19, 25, 20, 2, -24 },
  { 2643, 18, 24, 20, 4, -24 },
  { 2697, 21, 24, 20, 1, -24 },
  { 2760, 23, 24, 20, -1, -24 },
  { 2829, 19, 24, 20, 4, -24 },
  { 2886, 21, 24, 20, 0, -24 },
  { 2949, 18, 33, 20, 2, -27 },
  { 3024, 6, 33, 20, 7, -27 },
  { 3049, 17, 33, 20, 0, -27 },
  { 3120, 16, 13, 20, 3, -24 },
  { 3146, 18, 2, 20, -2, 4 },
  { 3151, 6, 7, 20, 9, -27 },
  { 3157, 18, 19, 20, 1, -19 },
  { 3200, 17, 27, 20, 1, -27 },
  { 3258, 17, 19, 20, 1, -19 },
  { 3299, 19, 27, 20, 2, -27 },
  { 3364, 17, 19, 20, 1, -19 },
  { 3405, 23, 34, 20, -1, -27 },
  { 3503, 19, 26, 20, 0, -19 },
  { 3565, 17, 27, 20, 0, -27 },
  { 3623, 11, 27, 20, 4, -27 },
  { 3661, 18, 34, 20, 0, -27 },
  { 3738, 19, 27, 20, 1, -27 },
  { 3803, 10, 27, 20, 6, -27 },
  { 3837, 19, 19, 20, 0, -19 },
  { 3883, 17, 19, 20, 1, -19 },
  { 3924, 16, 19, 20, 2, -19 },
  { 3962, 19, 25, 20, -1, -19 },
  { 4022, 17, 25, 20, 2, -19 },
  { 4076, 17, 19, 20, 2, -19 },
  { 4117, 16, 19, 20, 2, -19 },
  { 4155, 14, 24, 20, 4, -24 },
  { 4197, 17, 18, 20, 2, -18 },
  { 4236, 15, 18, 20, 4, -18 },
  { 4270, 19, 18, 20, 2, -18 },
  { 4313, 21, 18, 20, -1, -18 },
  { 4361, 21, 25, 20, -2, -18 },
  { 4427, 17, 18, 20, 1, -18 },
  { 4466, 19, 33, 20, 2, -27 },
  { 4545, 11, 33, 20, 5, -27 },
  { 4591, 19, 33, 20, -2, -27 },
  { 4670, 17, 5, 20, 2, -13 },
};

const GFXfont UbuntuSansMono_Italic35pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic35pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic35pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _UBUNTUSANSMONO_ITALIC35PT7B_H_
