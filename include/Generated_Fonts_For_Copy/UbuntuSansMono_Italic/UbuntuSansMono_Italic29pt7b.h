#ifndef _UBUNTUSANSMONO_ITALIC29PT7B_H_
#define _UBUNTUSANSMONO_ITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x00, 0x00, 0x00, 0x20, 0x70, 0xF0, 0x70, 0x31, 0xB1, 0x98,
  0xCC, 0x64, 0x22, 0x13, 0x19, 0x08, 0x00, 0x61, 0x80, 0x71, 0xC0, 0x30,
  0xC0, 0x38, 0x60, 0x18, 0x60, 0xFF, 0xFC, 0xFF, 0xFE, 0x06, 0x18, 0x06,
  0x18, 0x03, 0x0C, 0x03, 0x8E, 0x01, 0x86, 0x01, 0xC7, 0x03, 0xFF, 0xF3,
  0xFF, 0xF8, 0x61, 0x80, 0x30, 0xC0, 0x30, 0xE0, 0x18, 0x60, 0x1C, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x1F, 0xC0, 0xFF,
  0xC3, 0x81, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE2, 0x03, 0x8F, 0xFE, 0x0F, 0xF8, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0xF8, 0x0C, 0x33, 0x03, 0x06, 0x60, 0xC1,
  0x8C, 0x30, 0x31, 0x8C, 0x06, 0x33, 0x80, 0xC6, 0x60, 0x19, 0x98, 0x01,
  0xE6, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x19, 0xF0, 0x07, 0x66, 0x00,
  0xC8, 0xC0, 0x33, 0x18, 0x0C, 0x63, 0x03, 0x0C, 0x60, 0xC1, 0x8C, 0x30,
  0x33, 0x0E, 0x03, 0xC0, 0x00, 0x40, 0x1F, 0x81, 0xDE, 0x1C, 0x70, 0xC3,
  0x8E, 0x18, 0x71, 0xC1, 0x8C, 0x0D, 0xC0, 0x7C, 0x03, 0x86, 0x7E, 0x37,
  0x39, 0xB0, 0xDB, 0x87, 0xD8, 0x1C, 0xC0, 0xE6, 0x07, 0x38, 0x7D, 0xFE,
  0xE7, 0xE3, 0x00, 0x76, 0x6E, 0xCC, 0xC8, 0x00, 0x20, 0x06, 0x00, 0xF0,
  0x3C, 0x03, 0x80, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x3C, 0x01,
  0x80, 0x01, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00,
  0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x0C, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0xC4, 0x27, 0xAF, 0x7F, 0xFC, 0x1C, 0x01, 0xB0, 0x1D, 0xC1, 0xC7, 0x0E,
  0x38, 0x20, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01,
  0x83, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0x1E, 0x3C, 0x78, 0xF0, 0xE3, 0x9E, 0x78, 0x80,
  0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0x0F, 0xC0, 0xFF,
  0x87, 0x06, 0x18, 0x1C, 0xE0, 0x73, 0x01, 0xDC, 0x07, 0x62, 0x1D, 0x9E,
  0x6E, 0x79, 0xB1, 0xE6, 0xC2, 0x3B, 0x00, 0xCC, 0x03, 0x30, 0x1C, 0xC0,
  0xE3, 0x03, 0x0E, 0x1C, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0x70, 0x0E, 0x03,
  0xE0, 0xFE, 0x1E, 0xC1, 0x8C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0xFF,
  0xEF, 0xFE, 0x00, 0x40, 0x07, 0xF0, 0x3E, 0xF0, 0x20, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0xE0, 0x1F, 0xE0, 0x7F, 0xC1,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x0F, 0xC0,
  0x3E, 0x01, 0x3C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE4, 0x07, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x60, 0x0C, 0xC0, 0x33, 0x80, 0xC6, 0x03, 0x0C, 0x0C, 0x18,
  0x38, 0x70, 0x60, 0xE1, 0x81, 0x87, 0x03, 0x0F, 0xFF, 0xBF, 0xFF, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x03, 0xFF, 0x03,
  0xFE, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x80, 0xF0, 0xFF, 0xE0, 0xFF,
  0x80, 0x00, 0x3E, 0x01, 0xF8, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x7F, 0xE0, 0xFF, 0xE1, 0xC0, 0xC7, 0x01, 0xCE,
  0x03, 0x98, 0x07, 0x30, 0x0E, 0x60, 0x18, 0xE0, 0x71, 0xC1, 0xC1, 0xEF,
  0x01, 0xFC, 0x00, 0x3F, 0xFD, 0xFF, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x1F, 0xE0, 0xF3, 0xC7, 0x07, 0x18, 0x0C, 0x60,
  0x33, 0x80, 0xCE, 0x07, 0x18, 0x38, 0x71, 0xC0, 0xFE, 0x0F, 0xF8, 0x70,
  0xF1, 0x81, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0xCC, 0x0E, 0x3F,
  0xF0, 0x7F, 0x80, 0x00, 0x40, 0x07, 0xF0, 0x1E, 0x70, 0x70, 0x71, 0xC0,
  0x63, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x38, 0x06, 0x30, 0x1C, 0x70, 0x78,
  0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0x1C, 0x7C, 0xF9, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x1E, 0x38, 0x00, 0x03, 0x81, 0xF0,
  0x7C, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x38, 0x1C, 0x1E, 0x0F, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x30, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x07, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x30, 0x3F, 0xFE, 0x7F,
  0xFD, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0xFF, 0xF8, 0x10, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xC0, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x3C, 0x00, 0x80,
  0x00, 0x02, 0x03, 0xF8, 0x63, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x00, 0x30, 0x01, 0xFC, 0x03, 0xFE,
  0x07, 0x07, 0x0E, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x38, 0x3F, 0x30, 0xFE,
  0x71, 0xC6, 0x63, 0x86, 0x63, 0x0E, 0xE7, 0x0E, 0xE6, 0x0C, 0xE6, 0x0C,
  0xE6, 0x1C, 0xE7, 0x1C, 0xE3, 0x98, 0xE1, 0xF8, 0x60, 0x40, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3F, 0xC0, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x36, 0x00, 0x66, 0x00, 0x66, 0x00, 0xC6, 0x00, 0xC6, 0x01, 0x86,
  0x03, 0x86, 0x03, 0x06, 0x06, 0x06, 0x06, 0x07, 0x0C, 0x07, 0x0F, 0xFF,
  0x1F, 0xFF, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x03, 0xE0, 0x03,
  0x07, 0xFC, 0x07, 0xFE, 0x0E, 0x0F, 0x0C, 0x07, 0x0C, 0x07, 0x0C, 0x06,
  0x1C, 0x06, 0x18, 0x0C, 0x18, 0xF8, 0x1F, 0xF0, 0x38, 0xF8, 0x38, 0x1C,
  0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0x78,
  0x7F, 0xF0, 0xFF, 0x80, 0x00, 0x20, 0x07, 0xFC, 0x1F, 0xF8, 0x70, 0x11,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x83, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xFC,
  0x0C, 0x1E, 0x0C, 0x0E, 0x0C, 0x06, 0x1C, 0x07, 0x18, 0x07, 0x18, 0x07,
  0x18, 0x07, 0x38, 0x07, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x70, 0x0C,
  0x60, 0x1C, 0x60, 0x18, 0x60, 0x78, 0x60, 0xF0, 0xFF, 0xC0, 0xFF, 0x00,
  0x07, 0xFF, 0x07, 0xFF, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x1F, 0xF8, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x7F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x1F, 0xF8,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x01, 0xFE,
  0x03, 0xFF, 0x0E, 0x02, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x60, 0x1C, 0xE0, 0x18,
  0xE0, 0x18, 0xE0, 0x18, 0x60, 0x38, 0x70, 0x30, 0x70, 0x30, 0x3F, 0xF0,
  0x1F, 0xF0, 0x06, 0x01, 0x87, 0x00, 0xC3, 0x80, 0x61, 0x80, 0x70, 0xC0,
  0x30, 0xE0, 0x18, 0x70, 0x0C, 0x30, 0x0E, 0x18, 0x06, 0x0F, 0xFF, 0x0E,
  0x01, 0x86, 0x01, 0xC3, 0x00, 0xC1, 0x80, 0x61, 0xC0, 0x30, 0xC0, 0x38,
  0x60, 0x18, 0x30, 0x0C, 0x38, 0x06, 0x18, 0x07, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x40, 0xE0, 0xFF,
  0xC0, 0x7F, 0x80, 0x06, 0x03, 0xC1, 0x81, 0xC0, 0x60, 0xE0, 0x38, 0x70,
  0x0C, 0x38, 0x03, 0x1C, 0x00, 0xCE, 0x00, 0x77, 0x00, 0x1B, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xEE, 0x00, 0x31, 0xC0, 0x0C, 0x30, 0x03, 0x06,
  0x01, 0xC1, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x06, 0x01, 0x83, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x0E,
  0x0A, 0x06, 0x87, 0x81, 0xB3, 0x60, 0x4C, 0xD8, 0x33, 0x66, 0x0C, 0xD9,
  0x83, 0x3C, 0xC1, 0x8E, 0x30, 0x63, 0x8C, 0x18, 0x03, 0x0C, 0x00, 0xC3,
  0x00, 0x70, 0xC0, 0x18, 0x70, 0x06, 0x18, 0x01, 0x86, 0x00, 0xE3, 0x80,
  0x38, 0x07, 0x01, 0xC1, 0xC0, 0x60, 0xF0, 0x18, 0x3E, 0x06, 0x0D, 0x83,
  0x03, 0x60, 0xC1, 0xD8, 0x30, 0x63, 0x0C, 0x18, 0xC6, 0x06, 0x31, 0x81,
  0x8C, 0x60, 0xC1, 0x98, 0x30, 0x6E, 0x0C, 0x1B, 0x03, 0x06, 0xC1, 0x81,
  0xB0, 0x60, 0x3C, 0x18, 0x0E, 0x06, 0x03, 0x83, 0x00, 0xE0, 0x00, 0x40,
  0x0F, 0xC0, 0xF7, 0x87, 0x07, 0x18, 0x0C, 0xC0, 0x37, 0x00, 0xD8, 0x03,
  0x60, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1B, 0x00, 0x6C, 0x01,
  0xB0, 0x0C, 0xC0, 0x73, 0x01, 0x8E, 0x0C, 0x1F, 0xF0, 0x3F, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x30, 0x38, 0x60, 0x31, 0xC0, 0x63, 0x00, 0xC6, 0x01,
  0x8C, 0x07, 0x38, 0x0C, 0x60, 0x70, 0xFF, 0xC1, 0xFF, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x0F, 0xC0, 0xF7, 0x87, 0x07, 0x18, 0x0C, 0xC0, 0x37,
  0x00, 0xD8, 0x03, 0x60, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x6C, 0x01, 0xB0, 0x0C, 0xC0, 0x73, 0x01, 0x8E, 0x0C, 0x1F, 0xF0,
  0x3F, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0xC0, 0x0F, 0x00, 0x07,
  0xFC, 0x07, 0xFE, 0x06, 0x07, 0x0E, 0x07, 0x0C, 0x03, 0x0C, 0x03, 0x0C,
  0x07, 0x1C, 0x06, 0x18, 0x0E, 0x18, 0x1C, 0x1F, 0xF8, 0x3F, 0xE0, 0x30,
  0xE0, 0x30, 0x60, 0x30, 0x70, 0x70, 0x30, 0x60, 0x30, 0x60, 0x38, 0x60,
  0x38, 0xE0, 0x18, 0x00, 0x20, 0x07, 0xFC, 0x1F, 0xF8, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x71, 0x01, 0xC7, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x18, 0x06, 0x70, 0x0C, 0xE0, 0x19,
  0x80, 0x73, 0x00, 0xC6, 0x01, 0x9C, 0x03, 0x30, 0x0E, 0x60, 0x18, 0xC0,
  0x33, 0x80, 0x66, 0x01, 0xCC, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x38,
  0xC0, 0x61, 0xC1, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x0E,
  0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x30, 0x60, 0x70,
  0x60, 0x60, 0x60, 0xE0, 0x60, 0xC0, 0x61, 0x80, 0x61, 0x80, 0x63, 0x00,
  0x63, 0x00, 0x66, 0x00, 0x6E, 0x00, 0x6C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x18, 0x01, 0x8C, 0x01, 0xC6, 0x00, 0xC7, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x38, 0xC0, 0x18, 0x60, 0x0C, 0x31, 0x86, 0x31, 0xC6, 0x19, 0xA3, 0x0C,
  0xD9, 0x86, 0xCD, 0x83, 0x66, 0xC1, 0x63, 0x61, 0xB1, 0xA0, 0xF0, 0xF0,
  0x70, 0x78, 0x38, 0x38, 0x18, 0x1C, 0x00, 0x03, 0x80, 0xF0, 0x38, 0x0C,
  0x01, 0x81, 0xC0, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xEC,
  0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0x98, 0x00, 0x31, 0x80, 0x07, 0x1C, 0x00, 0xE0, 0xC0, 0x1C,
  0x0C, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0x60, 0xC0, 0x0F, 0x80,
  0x3B, 0x00, 0x66, 0x01, 0xC6, 0x07, 0x0C, 0x0C, 0x18, 0x30, 0x38, 0xE0,
  0x33, 0x80, 0x66, 0x00, 0xD8, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x3F, 0xC0, 0xC6, 0x39, 0xCE, 0x73, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8E, 0x73, 0x9C, 0xE3, 0x18, 0xC6, 0x31, 0x8C,
  0x70, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x3F, 0x80, 0x01, 0x80, 0x3C, 0x07, 0xC0, 0xEC, 0x0C, 0x61, 0x86, 0x38,
  0x67, 0x03, 0xE0, 0x3C, 0x03, 0x40, 0x20, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1,
  0xC3, 0x06, 0x0C, 0x03, 0xFC, 0x3F, 0xF1, 0xE0, 0xCE, 0x07, 0x30, 0x19,
  0xC0, 0x66, 0x01, 0xB8, 0x0E, 0xE0, 0x33, 0x00, 0xCC, 0x03, 0x38, 0x0C,
  0x60, 0x71, 0xFF, 0xC3, 0xF3, 0x00, 0x01, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1F, 0xF0, 0x7F, 0xE1,
  0xC1, 0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x70, 0x1D,
  0x80, 0x66, 0x03, 0x98, 0x1C, 0x61, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x3F, 0xF1, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x11, 0xFF, 0xC1,
  0xFE, 0x00, 0x00, 0x01, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x03, 0xFC, 0x0F, 0xF8, 0x1C, 0x18,
  0x38, 0x18, 0x70, 0x38, 0x60, 0x30, 0xE0, 0x30, 0xC0, 0x30, 0xC0, 0x70,
  0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0xE0, 0xE0, 0xFF, 0xE0, 0x7F, 0x60,
  0x07, 0xF8, 0x3F, 0xE1, 0xC1, 0xCE, 0x03, 0x70, 0x1D, 0x80, 0x76, 0x07,
  0xBF, 0xFC, 0xFF, 0x83, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x11, 0xFF,
  0xC1, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0x03, 0xFF, 0x07, 0x06, 0x0E, 0x06, 0x1C, 0x06, 0x18, 0x0E, 0x38, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x30, 0x1C, 0x30, 0x18, 0x30, 0x18, 0x3C, 0xF8,
  0x1F, 0xF8, 0x02, 0x30, 0x00, 0x30, 0x00, 0x70, 0x80, 0xE0, 0xF7, 0xC0,
  0xFF, 0x80, 0x01, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0xF0, 0x7F, 0xE1, 0xC1, 0xC6, 0x03, 0x18,
  0x0C, 0x60, 0x33, 0x80, 0xCC, 0x07, 0x30, 0x18, 0xC0, 0x67, 0x01, 0x98,
  0x0E, 0x60, 0x31, 0x80, 0xCE, 0x03, 0x00, 0x07, 0x03, 0xC1, 0xE0, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0xFE, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x81, 0xF8, 0x3C, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x81, 0xC1, 0xFF, 0x03, 0xFC, 0x00, 0x01,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x0E, 0x30, 0x38, 0x61, 0xC0, 0xC7, 0x03, 0x9C, 0x06,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x77, 0x00, 0xE7, 0x01, 0x87, 0x03, 0x07,
  0x06, 0x06, 0x1C, 0x0E, 0x30, 0x0C, 0x00, 0xFE, 0xFE, 0x0C, 0x0C, 0x0C,
  0x1C, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x7F, 0x7F, 0x1F, 0xFE, 0x1F, 0xFF, 0x18, 0xC7, 0x18,
  0xC7, 0x38, 0xC6, 0x30, 0xC6, 0x31, 0x86, 0x31, 0x8E, 0x71, 0x8C, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x1C, 0xE0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0x1F,
  0xF0, 0x7F, 0xE1, 0x81, 0x86, 0x07, 0x18, 0x0C, 0xE0, 0x73, 0x01, 0xCC,
  0x06, 0x30, 0x19, 0xC0, 0x66, 0x03, 0x98, 0x0C, 0x60, 0x33, 0x80, 0xCC,
  0x07, 0x00, 0x0F, 0xE0, 0xFF, 0x8E, 0x0E, 0xE0, 0x36, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xB0, 0x1D, 0x81, 0xCE, 0x1E, 0x7F,
  0xE0, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x30, 0x38, 0x60, 0x31, 0xC0,
  0x63, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x38, 0x0E, 0x60, 0x18, 0xC0, 0x71,
  0x81, 0xC7, 0x07, 0x0F, 0xFC, 0x1F, 0xE0, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xFC, 0x38, 0x30, 0xE0,
  0x63, 0x81, 0xCE, 0x03, 0x98, 0x06, 0x30, 0x0C, 0x60, 0x39, 0xC0, 0x73,
  0x80, 0xC3, 0x01, 0x86, 0x07, 0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x0F, 0xFC, 0x7F, 0xE1, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x07, 0xF8,
  0x7F, 0x86, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xC8, 0x0E, 0x7F, 0xE3, 0xFE, 0x00, 0x06,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC1, 0xFF, 0xFF, 0xF8, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0xFE, 0x1F, 0xC0, 0x30, 0x1B, 0x80, 0xDC, 0x06, 0xC0, 0x76, 0x03, 0x30,
  0x1B, 0x80, 0xD8, 0x0E, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x1E,
  0x7F, 0xF1, 0xF9, 0x80, 0xE0, 0x3F, 0x01, 0xB8, 0x0C, 0xC0, 0xE6, 0x06,
  0x30, 0x71, 0x83, 0x0C, 0x38, 0x61, 0x83, 0x18, 0x1D, 0xC0, 0x6C, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x60, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xC0,
  0x0C, 0xC3, 0x0C, 0xC7, 0x1C, 0xC7, 0x18, 0xCD, 0x18, 0xCD, 0xB0, 0xD9,
  0xB0, 0xD1, 0xF0, 0xF1, 0xE0, 0xE1, 0xE0, 0xC1, 0xC0, 0xC1, 0xC0, 0x0E,
  0x03, 0x83, 0x83, 0x80, 0xC1, 0x80, 0x71, 0x80, 0x19, 0x80, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xCC, 0x01, 0xC7,
  0x01, 0xC1, 0x81, 0xC0, 0xE3, 0xC0, 0x30, 0x07, 0x00, 0xC0, 0xC0, 0x70,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x80, 0xC0, 0xC0, 0x38, 0x70, 0x0E,
  0x18, 0x01, 0x86, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x07, 0x60, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x1E, 0x01, 0xFC, 0x07,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xFC, 0x00,
  0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01,
  0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x00, 0x03, 0xE0, 0x07, 0xF0,
  0x00, 0x70, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0xC0, 0x07,
  0x80, 0x3C, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x7C, 0x07, 0xF0,
  0x00, 0x0C, 0x08, 0xFC, 0x37, 0x3D, 0xF8, 0x7E, 0x20, 0x60,
};

const GFXglyph UbuntuSansMono_Italic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 8, 20, 16, 4, -20 },
  { 21, 9, 8, 16, 6, -22 },
  { 30, 17, 20, 16, 0, -20 },
  { 73, 15, 26, 16, 1, -23 },
  { 122, 19, 21, 16, -1, -21 },
  { 172, 13, 21, 16, 1, -21 },
  { 207, 4, 8, 16, 9, -22 },
  { 211, 12, 28, 16, 4, -23 },
  { 253, 12, 28, 16, 1, -23 },
  { 295, 13, 12, 16, 3, -20 },
  { 315, 13, 15, 16, 2, -16 },
  { 340, 7, 9, 16, 2, -4 },
  { 348, 7, 2, 16, 5, -9 },
  { 350, 4, 4, 16, 5, -4 },
  { 352, 18, 28, 16, -2, -23 },
  { 415, 14, 21, 16, 2, -21 },
  { 452, 12, 20, 16, 2, -20 },
  { 482, 15, 21, 16, 1, -21 },
  { 522, 14, 21, 16, 1, -21 },
  { 559, 15, 20, 16, 0, -20 },
  { 597, 16, 20, 16, 1, -20 },
  { 637, 15, 20, 16, 2, -20 },
  { 675, 14, 20, 16, 4, -20 },
  { 710, 14, 21, 16, 2, -21 },
  { 747, 15, 21, 16, 1, -21 },
  { 787, 7, 15, 16, 5, -15 },
  { 801, 10, 20, 16, 2, -15 },
  { 826, 14, 13, 16, 1, -15 },
  { 849, 15, 9, 16, 1, -13 },
  { 866, 14, 13, 16, 1, -15 },
  { 889, 11, 21, 16, 4, -21 },
  { 918, 16, 25, 16, 1, -21 },
  { 968, 16, 20, 16, -2, -20 },
  { 1008, 16, 20, 16, 0, -20 },
  { 1048, 15, 21, 16, 2, -21 },
  { 1088, 16, 20, 16, 0, -20 },
  { 1128, 16, 20, 16, 1, -20 },
  { 1168, 16, 20, 16, 1, -20 },
  { 1208, 16, 21, 16, 1, -21 },
  { 1250, 17, 20, 16, 0, -20 },
  { 1293, 15, 20, 16, 1, -20 },
  { 1331, 16, 20, 16, 1, -20 },
  { 1371, 18, 20, 16, 0, -20 },
  { 1416, 11, 20, 16, 1, -20 },
  { 1444, 18, 20, 16, -1, -20 },
  { 1489, 18, 20, 16, 0, -20 },
  { 1534, 14, 21, 16, 2, -21 },
  { 1571, 15, 20, 16, 1, -20 },
  { 1609, 14, 26, 16, 2, -21 },
  { 1655, 16, 20, 16, 0, -20 },
  { 1695, 15, 21, 16, 1, -21 },
  { 1735, 14, 20, 16, 4, -20 },
  { 1770, 15, 20, 16, 2, -20 },
  { 1808, 16, 20, 16, 3, -20 },
  { 1848, 17, 20, 16, 1, -20 },
  { 1891, 20, 20, 16, -1, -20 },
  { 1941, 15, 20, 16, 4, -20 },
  { 1979, 17, 20, 16, 0, -20 },
  { 2022, 14, 28, 16, 2, -23 },
  { 2071, 5, 28, 16, 6, -23 },
  { 2089, 14, 28, 16, 0, -23 },
  { 2138, 12, 11, 16, 3, -20 },
  { 2155, 15, 2, 16, -2, 3 },
  { 2159, 6, 5, 16, 7, -22 },
  { 2163, 14, 15, 16, 1, -15 },
  { 2190, 14, 23, 16, 1, -23 },
  { 2231, 14, 15, 16, 1, -15 },
  { 2258, 16, 23, 16, 2, -23 },
  { 2304, 14, 15, 16, 1, -15 },
  { 2331, 19, 28, 16, -1, -23 },
  { 2398, 16, 20, 16, 0, -15 },
  { 2438, 14, 23, 16, 0, -23 },
  { 2479, 9, 22, 16, 3, -22 },
  { 2504, 15, 27, 16, 0, -22 },
  { 2555, 15, 23, 16, 1, -23 },
  { 2599, 8, 22, 16, 5, -22 },
  { 2621, 16, 15, 16, 0, -15 },
  { 2651, 14, 15, 16, 1, -15 },
  { 2678, 13, 15, 16, 2, -15 },
  { 2703, 15, 20, 16, 0, -15 },
  { 2741, 15, 20, 16, 1, -15 },
  { 2779, 14, 15, 16, 2, -15 },
  { 2806, 13, 15, 16, 2, -15 },
  { 2831, 11, 20, 16, 4, -20 },
  { 2859, 13, 15, 16, 2, -15 },
  { 2884, 13, 15, 16, 3, -15 },
  { 2909, 16, 15, 16, 2, -15 },
  { 2939, 17, 15, 16, -1, -15 },
  { 2971, 18, 20, 16, -2, -15 },
  { 3016, 14, 15, 16, 1, -15 },
  { 3043, 15, 28, 16, 2, -23 },
  { 3096, 9, 28, 16, 4, -23 },
  { 3128, 15, 28, 16, -1, -23 },
  { 3181, 14, 5, 16, 1, -11 },
};

const GFXfont UbuntuSansMono_Italic29pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic29pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic29pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _UBUNTUSANSMONO_ITALIC29PT7B_H_
