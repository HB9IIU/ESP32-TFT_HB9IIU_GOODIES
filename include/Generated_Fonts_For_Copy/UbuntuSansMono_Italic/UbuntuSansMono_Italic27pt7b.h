#ifndef _UBUNTUSANSMONO_ITALIC27PT7B_H_
#define _UBUNTUSANSMONO_ITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x40, 0x83,
  0x00, 0x00, 0x00, 0xF1, 0xE3, 0x80, 0x63, 0x62, 0x66, 0xC6, 0xC6, 0xC4,
  0x84, 0x84, 0x00, 0xC3, 0x00, 0xC7, 0x01, 0x86, 0x01, 0x86, 0x01, 0x8C,
  0x3F, 0xFF, 0x3F, 0xFF, 0x06, 0x18, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x70,
  0x18, 0x60, 0x7F, 0xFC, 0xFF, 0xFC, 0x30, 0xC0, 0x31, 0x80, 0x61, 0x80,
  0x63, 0x00, 0xC3, 0x00, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x7E, 0x07,
  0xFC, 0x38, 0x20, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x31, 0x01, 0x87,
  0xFE, 0x3F, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x07, 0x80,
  0xC3, 0x60, 0x60, 0x8C, 0x30, 0x63, 0x18, 0x18, 0xCC, 0x06, 0x23, 0x01,
  0x99, 0x80, 0x66, 0xC0, 0x0F, 0x60, 0x00, 0x30, 0x00, 0x19, 0xC0, 0x0C,
  0xD8, 0x03, 0x66, 0x01, 0x91, 0x80, 0xC4, 0x60, 0x63, 0x18, 0x30, 0xC6,
  0x18, 0x13, 0x0C, 0x07, 0x80, 0x03, 0xE0, 0x7E, 0x0C, 0x31, 0xC3, 0x18,
  0x61, 0x86, 0x18, 0xC0, 0xD8, 0x0F, 0x01, 0xE3, 0x36, 0x36, 0x33, 0xE3,
  0xEC, 0x1E, 0xC0, 0xCC, 0x0C, 0xC3, 0xEF, 0xF6, 0x7C, 0x60, 0x37, 0x66,
  0x6C, 0xCC, 0x00, 0x20, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0x80, 0x02, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x10, 0x00, 0x06, 0x00, 0x60, 0x06, 0x04, 0x62, 0xF6,
  0xE7, 0xFF, 0x06, 0x00, 0xF0, 0x19, 0x83, 0x9C, 0x10, 0x80, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x1C, 0x78, 0xF8, 0xE0, 0xC3,
  0x3C, 0x70, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0x0C, 0x30, 0x63, 0x03, 0xB8, 0x1D,
  0x80, 0xEC, 0xC6, 0xEF, 0x36, 0x79, 0xB1, 0xCD, 0x80, 0xEC, 0x06, 0x60,
  0x33, 0x03, 0x18, 0x38, 0xC3, 0x87, 0xF8, 0x1F, 0x80, 0x00, 0x60, 0x18,
  0x0F, 0x07, 0xE1, 0xDC, 0x23, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x1F, 0xFB, 0xFF, 0x00,
  0x03, 0xF0, 0x3F, 0xE0, 0xC1, 0x82, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x03, 0xF0,
  0x7F, 0xC1, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x0E, 0x07,
  0xC0, 0x3E, 0x00, 0x38, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x80, 0xE7, 0xFE, 0x3F, 0xE0, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0x80, 0x3E,
  0x01, 0xD8, 0x0E, 0x60, 0x73, 0x83, 0x8C, 0x0C, 0x30, 0x60, 0xC3, 0x07,
  0x1C, 0x18, 0x7F, 0xFB, 0xFF, 0xE0, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE1, 0xFF,
  0x83, 0xFE, 0x00, 0x00, 0x38, 0x0F, 0xC0, 0xF0, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x7F, 0xC3, 0xFF, 0x38, 0x1D, 0x80, 0x6C, 0x03,
  0x60, 0x3B, 0x01, 0x98, 0x0C, 0xE0, 0xC3, 0x9E, 0x0F, 0xC0, 0x3F, 0xFC,
  0xFF, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0,
  0xE1, 0xC3, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x81, 0xC7, 0x0E, 0x0E, 0x70,
  0x3F, 0x01, 0xCE, 0x0C, 0x1C, 0x60, 0x31, 0x80, 0xCE, 0x03, 0x38, 0x0C,
  0x60, 0x61, 0xE7, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xE1, 0xC7,
  0x03, 0x18, 0x0C, 0xE0, 0x33, 0x00, 0xCC, 0x03, 0x38, 0x1C, 0x71, 0xE0,
  0xFF, 0x80, 0xCE, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x81,
  0xF8, 0x0F, 0x80, 0x00, 0x1C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC7, 0x8F, 0x1E, 0x00, 0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x07, 0x83, 0xE0, 0xE0, 0x30, 0x30, 0xF0,
  0x70, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xC0, 0x3F, 0xFD,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x3F, 0xFC,
  0x20, 0x01, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xE0,
  0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x01, 0x80, 0x00, 0x1F, 0x8F, 0xF0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x0E, 0x00, 0x01, 0xF8, 0x07, 0xF8,
  0x3C, 0x30, 0x60, 0x31, 0xC0, 0x67, 0x00, 0xCC, 0x1F, 0xB8, 0xFE, 0x63,
  0x8C, 0xCE, 0x19, 0x98, 0x77, 0x30, 0xCC, 0x61, 0x98, 0xC3, 0x31, 0x8E,
  0x63, 0x98, 0xC3, 0xF1, 0xC1, 0x81, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xB0, 0x03, 0x60,
  0x0C, 0xC0, 0x19, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0x60, 0x30, 0xFF, 0xE3, 0xFF, 0xC6, 0x01, 0x98, 0x03, 0x30, 0x06,
  0xC0, 0x0F, 0x80, 0x18, 0x07, 0xF0, 0x1F, 0xF8, 0x30, 0x70, 0x60, 0x70,
  0xC0, 0xE3, 0x81, 0x86, 0x03, 0x0C, 0x0C, 0x1F, 0xF0, 0x7F, 0xE0, 0xC0,
  0xE1, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x18, 0x06, 0x30, 0x1C, 0x60, 0x70,
  0xFF, 0xC3, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xE0, 0x86, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x41, 0xFF, 0x03,
  0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x30, 0xE0, 0x60, 0xE1, 0x80, 0xC3,
  0x01, 0xC6, 0x03, 0x8C, 0x07, 0x38, 0x0E, 0x60, 0x18, 0xC0, 0x31, 0x80,
  0x67, 0x01, 0xCC, 0x03, 0x18, 0x0E, 0x30, 0x38, 0x60, 0xE1, 0xFF, 0x83,
  0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xE3,
  0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x38, 0x10, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x66, 0x01,
  0x8C, 0x03, 0x1C, 0x06, 0x38, 0x0C, 0x30, 0x38, 0x70, 0x60, 0x7B, 0xC0,
  0x7F, 0x80, 0x0E, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x06, 0x1C, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x18, 0x0E, 0x1F, 0xFC, 0x3F, 0xFC, 0x30, 0x0C,
  0x30, 0x1C, 0x30, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x38, 0x60, 0x30,
  0xC0, 0x30, 0xC0, 0x30, 0x07, 0xFC, 0x3F, 0xF0, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x40, 0xC1, 0xFF, 0x81,
  0xFC, 0x00, 0x06, 0x03, 0x83, 0x03, 0x03, 0x03, 0x01, 0x83, 0x00, 0xC7,
  0x00, 0x67, 0x00, 0x67, 0x00, 0x37, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0D,
  0xC0, 0x06, 0x70, 0x03, 0x18, 0x01, 0x86, 0x01, 0xC3, 0x80, 0xC0, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x38, 0x0E, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18,
  0x06, 0x03, 0x80, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0x07, 0x07, 0x06, 0x07,
  0x0E, 0x0F, 0x0A, 0x0F, 0x1E, 0x0B, 0x16, 0x1B, 0x36, 0x1B, 0x26, 0x13,
  0x64, 0x31, 0xCC, 0x31, 0x8C, 0x31, 0x8C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x18, 0xE0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0x06, 0x03, 0x0E,
  0x03, 0x0F, 0x03, 0x0F, 0x03, 0x0F, 0x06, 0x19, 0x86, 0x19, 0x86, 0x19,
  0x86, 0x19, 0x8C, 0x30, 0xCC, 0x30, 0xCC, 0x30, 0xCC, 0x30, 0xD8, 0x20,
  0x58, 0x60, 0x78, 0x60, 0x78, 0x60, 0x70, 0x60, 0x70, 0xC0, 0x70, 0x01,
  0xF0, 0x1F, 0xE0, 0xE1, 0xC7, 0x03, 0x18, 0x0C, 0xC0, 0x33, 0x00, 0xDC,
  0x03, 0x60, 0x0D, 0x80, 0x36, 0x01, 0xD8, 0x06, 0xE0, 0x1B, 0x80, 0xEE,
  0x03, 0x18, 0x18, 0x60, 0xE1, 0xEF, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0xE0, 0xC1, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xCC, 0x06, 0x30,
  0x18, 0xC1, 0xC3, 0xFE, 0x1F, 0xE0, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xE1,
  0xC7, 0x03, 0x18, 0x0C, 0xC0, 0x33, 0x00, 0xDC, 0x03, 0x60, 0x0D, 0x80,
  0x36, 0x01, 0xD8, 0x06, 0xE0, 0x1B, 0x80, 0xEE, 0x03, 0x18, 0x18, 0x60,
  0xE1, 0xEF, 0x03, 0xF8, 0x03, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x70, 0x07, 0xF0, 0x1F, 0xF8, 0x30, 0x70, 0x60, 0x70, 0xC0, 0x61, 0x80,
  0xC6, 0x03, 0x8C, 0x06, 0x18, 0x1C, 0x31, 0xF0, 0xFF, 0x81, 0xFE, 0x03,
  0x0C, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x30, 0x60, 0x70, 0xC0, 0x63, 0x80,
  0xC0, 0x03, 0xF8, 0x1F, 0xF0, 0xE0, 0x47, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x80, 0xE3, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x81, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0x1C, 0x06, 0x30, 0x0C, 0x60, 0x18,
  0xC0, 0x71, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x30, 0x18, 0xC0,
  0x31, 0x80, 0x63, 0x01, 0xC6, 0x03, 0x1C, 0x06, 0x38, 0x0C, 0x30, 0x30,
  0x60, 0xE0, 0xF7, 0x80, 0xFE, 0x00, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xB0,
  0x0E, 0xC0, 0x33, 0x01, 0xCC, 0x06, 0x30, 0x38, 0xC0, 0xC3, 0x86, 0x06,
  0x18, 0x18, 0xC0, 0x63, 0x01, 0x98, 0x06, 0x60, 0x1B, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x18, 0x03, 0x18, 0x07, 0x38, 0x06, 0x30, 0x06,
  0x30, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x0C, 0x63, 0x88, 0x67, 0x98,
  0x67, 0x98, 0x6D, 0x98, 0x49, 0xB0, 0xD9, 0xB0, 0xD0, 0xB0, 0xF0, 0xA0,
  0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0x07, 0x00, 0xC0, 0xC0, 0x60, 0x38,
  0x38, 0x06, 0x1C, 0x01, 0x86, 0x00, 0x73, 0x00, 0x0D, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x01,
  0x8E, 0x00, 0xE1, 0x80, 0x70, 0x60, 0x38, 0x1C, 0x1C, 0x03, 0x0E, 0x00,
  0xC0, 0xC0, 0x0E, 0xC0, 0x19, 0x80, 0x63, 0x01, 0xC6, 0x03, 0x0C, 0x0C,
  0x0C, 0x30, 0x18, 0xE0, 0x31, 0x80, 0x36, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCE, 0xEE, 0x66, 0x66, 0x66, 0x66, 0x66, 0x77, 0x73, 0x03,
  0xF8, 0x1F, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0x80, 0x1C, 0x03, 0xC0, 0x64,
  0x0E, 0x61, 0xC6, 0x18, 0x63, 0x03, 0x60, 0x3E, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x47, 0x18, 0x61, 0x88, 0x03, 0xF8, 0x7D, 0xC7, 0x06, 0x70, 0x77,
  0x03, 0x30, 0x1B, 0x80, 0xD8, 0x0E, 0xC0, 0x66, 0x03, 0x30, 0x19, 0xC1,
  0xC7, 0xBE, 0x1F, 0xB0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0xFC, 0x1F, 0xF0, 0xC1, 0xCC, 0x06, 0x60, 0x33,
  0x01, 0x98, 0x0D, 0x80, 0x6C, 0x06, 0x60, 0x73, 0x03, 0x38, 0x71, 0xFF,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0xF9, 0xCE, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x47, 0xDE,
  0x1F, 0xF0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x01, 0xFE, 0x0F, 0xF8, 0x38, 0x30, 0xE0, 0x61, 0x80,
  0xC7, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x70, 0x18, 0xE0, 0x61, 0xC0, 0xC1,
  0x83, 0x83, 0xDF, 0x03, 0xF7, 0x00, 0x07, 0xF0, 0xFF, 0x8E, 0x06, 0x60,
  0x36, 0x03, 0xB0, 0x1B, 0x8F, 0xDF, 0xF8, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xC0, 0x47, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1C, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x1F, 0xFE, 0x0F, 0xFE,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xFE, 0x0F, 0xFC, 0x3C, 0x30, 0xE0, 0x61, 0x80, 0xC7, 0x03,
  0x8C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x30, 0xC0, 0xC1, 0xC7, 0x81,
  0xFF, 0x00, 0x46, 0x00, 0x18, 0x00, 0x30, 0x80, 0xC1, 0xFF, 0x01, 0xFC,
  0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0xFC, 0x1F, 0xF0, 0xC1, 0xC6, 0x06, 0x70, 0x33, 0x01, 0x98, 0x0C,
  0xC0, 0xE6, 0x06, 0x60, 0x33, 0x01, 0x98, 0x1C, 0xC0, 0xCC, 0x06, 0x00,
  0x06, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x0C, 0x0C, 0x0C,
  0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x18, 0x1F, 0x0F, 0x00, 0x08, 0x00,
  0x70, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x20, 0x60, 0xFF, 0x01, 0xF8, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x07, 0x18, 0x38, 0x63,
  0x83, 0x1C, 0x0C, 0xE0, 0x3E, 0x00, 0xF0, 0x07, 0xE0, 0x19, 0xC0, 0x63,
  0x81, 0x87, 0x0E, 0x0C, 0x30, 0x38, 0xC0, 0x60, 0xFD, 0xF8, 0x30, 0xC1,
  0x83, 0x06, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xC1, 0x83,
  0x07, 0xB7, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x67, 0x39, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x31, 0xCE, 0x63, 0x18, 0xC0, 0x31, 0x80, 0x67,
  0x01, 0xCC, 0x03, 0x18, 0x06, 0x00, 0x1F, 0xE0, 0xFF, 0x86, 0x0E, 0x70,
  0x33, 0x01, 0x98, 0x0C, 0xC0, 0xCE, 0x06, 0x60, 0x33, 0x01, 0x98, 0x1C,
  0xC0, 0xCC, 0x06, 0x60, 0x30, 0x07, 0xE0, 0x7F, 0x87, 0x0E, 0x70, 0x37,
  0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x03, 0xE0, 0x37, 0x01, 0xB8, 0x1C, 0xC1,
  0xC7, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0xC1, 0xC6, 0x03, 0x18,
  0x0C, 0x60, 0x31, 0x80, 0xCC, 0x03, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x1C,
  0x3C, 0x7F, 0xE1, 0xFE, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xFC, 0x3F, 0xE1, 0xC1, 0x8E, 0x06, 0x30, 0x39, 0x80,
  0xC6, 0x03, 0x18, 0x0C, 0xE0, 0x73, 0x81, 0x8E, 0x06, 0x18, 0x38, 0x7B,
  0xE0, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x0F, 0xF8, 0xFF, 0x8E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x0F,
  0xF1, 0xFE, 0x38, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x0C, 0x00, 0xC8, 0x0C, 0xF7, 0x8F, 0xF0, 0x06, 0x01, 0x80, 0x30,
  0x06, 0x07, 0xFF, 0xFF, 0xC6, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x3F, 0x87, 0xF0, 0x38, 0x19, 0x80,
  0xCC, 0x06, 0x60, 0x77, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0E, 0x60, 0x67,
  0x03, 0x18, 0x18, 0xC1, 0xC7, 0xFE, 0x1F, 0xB0, 0xC0, 0x3C, 0x06, 0xC0,
  0x6C, 0x0C, 0xE0, 0xCE, 0x18, 0x61, 0x86, 0x30, 0x63, 0x06, 0x60, 0x6C,
  0x06, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0xC0, 0x0D, 0x80, 0x33, 0x00,
  0x66, 0x30, 0xCC, 0x73, 0x19, 0xE6, 0x32, 0xCC, 0x6D, 0xB0, 0xF3, 0x61,
  0x67, 0x87, 0x87, 0x0E, 0x0C, 0x1C, 0x18, 0x00, 0x0E, 0x07, 0x06, 0x06,
  0x07, 0x0C, 0x03, 0x18, 0x01, 0xB0, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0x60, 0x0E, 0x30, 0x1C, 0x30, 0x38, 0x38, 0xF0, 0x18,
  0x0C, 0x03, 0x0C, 0x07, 0x0E, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x06, 0x0C,
  0x06, 0x1C, 0x06, 0x18, 0x07, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60,
  0x03, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x07,
  0x80, 0x1F, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0x80,
  0x1F, 0x00, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C,
  0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60,
  0x60, 0xC0, 0xC0, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x3C, 0x01, 0xF0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0xFE, 0x03,
  0xF0, 0x00, 0x1C, 0x0B, 0xF8, 0xD8, 0xFD, 0x83, 0xC0,
};

const GFXglyph UbuntuSansMono_Italic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 19, 15, 4, -19 },
  { 18, 8, 8, 15, 6, -21 },
  { 26, 16, 19, 15, 0, -19 },
  { 64, 14, 24, 15, 1, -21 },
  { 106, 18, 19, 15, -1, -19 },
  { 149, 12, 19, 15, 1, -19 },
  { 178, 4, 8, 15, 8, -21 },
  { 182, 12, 26, 15, 3, -21 },
  { 221, 11, 26, 15, 1, -21 },
  { 257, 12, 11, 15, 3, -19 },
  { 274, 12, 14, 15, 2, -15 },
  { 295, 7, 8, 15, 2, -4 },
  { 302, 6, 2, 15, 5, -9 },
  { 304, 4, 4, 15, 4, -4 },
  { 306, 17, 26, 15, -2, -21 },
  { 362, 13, 19, 15, 2, -19 },
  { 393, 11, 19, 15, 2, -19 },
  { 420, 14, 19, 15, 1, -19 },
  { 454, 13, 19, 15, 1, -19 },
  { 485, 14, 19, 15, 0, -19 },
  { 519, 15, 19, 15, 1, -19 },
  { 555, 13, 19, 15, 2, -19 },
  { 586, 14, 19, 15, 3, -19 },
  { 620, 14, 19, 15, 1, -19 },
  { 654, 14, 19, 15, 1, -19 },
  { 688, 7, 14, 15, 4, -14 },
  { 701, 9, 18, 15, 2, -14 },
  { 722, 13, 12, 15, 1, -14 },
  { 742, 14, 8, 15, 1, -12 },
  { 756, 13, 12, 15, 1, -14 },
  { 776, 10, 19, 15, 4, -19 },
  { 800, 15, 23, 15, 1, -19 },
  { 844, 15, 19, 15, -2, -19 },
  { 880, 15, 19, 15, 0, -19 },
  { 916, 14, 19, 15, 2, -19 },
  { 950, 15, 19, 15, 0, -19 },
  { 986, 15, 19, 15, 1, -19 },
  { 1022, 15, 19, 15, 1, -19 },
  { 1058, 15, 19, 15, 1, -19 },
  { 1094, 16, 19, 15, 0, -19 },
  { 1132, 14, 19, 15, 1, -19 },
  { 1166, 15, 19, 15, 1, -19 },
  { 1202, 17, 19, 15, 0, -19 },
  { 1243, 10, 19, 15, 1, -19 },
  { 1267, 16, 19, 15, 0, -19 },
  { 1305, 16, 19, 15, 0, -19 },
  { 1343, 14, 19, 15, 1, -19 },
  { 1377, 14, 19, 15, 1, -19 },
  { 1411, 14, 24, 15, 1, -19 },
  { 1453, 15, 19, 15, 0, -19 },
  { 1489, 14, 19, 15, 1, -19 },
  { 1523, 13, 19, 15, 4, -19 },
  { 1554, 15, 19, 15, 1, -19 },
  { 1590, 14, 19, 15, 3, -19 },
  { 1624, 16, 19, 15, 1, -19 },
  { 1662, 18, 19, 15, -1, -19 },
  { 1705, 15, 19, 15, 3, -19 },
  { 1741, 16, 19, 15, 0, -19 },
  { 1779, 13, 26, 15, 2, -21 },
  { 1822, 4, 26, 15, 6, -21 },
  { 1835, 13, 26, 15, 0, -21 },
  { 1878, 12, 10, 15, 2, -19 },
  { 1893, 14, 2, 15, -2, 3 },
  { 1897, 5, 6, 15, 7, -21 },
  { 1901, 13, 14, 15, 1, -14 },
  { 1924, 13, 21, 15, 1, -21 },
  { 1959, 13, 14, 15, 1, -14 },
  { 1982, 15, 21, 15, 1, -21 },
  { 2022, 13, 14, 15, 1, -14 },
  { 2045, 17, 26, 15, 0, -21 },
  { 2101, 15, 19, 15, 0, -14 },
  { 2137, 13, 21, 15, 0, -21 },
  { 2172, 8, 21, 15, 3, -21 },
  { 2193, 14, 26, 15, 0, -21 },
  { 2239, 14, 21, 15, 1, -21 },
  { 2276, 7, 21, 15, 5, -21 },
  { 2295, 15, 14, 15, 0, -14 },
  { 2322, 13, 14, 15, 1, -14 },
  { 2345, 13, 14, 15, 1, -14 },
  { 2368, 14, 19, 15, 0, -14 },
  { 2402, 14, 19, 15, 1, -14 },
  { 2436, 13, 14, 15, 2, -14 },
  { 2459, 12, 14, 15, 2, -14 },
  { 2480, 11, 18, 15, 3, -18 },
  { 2505, 13, 14, 15, 1, -14 },
  { 2528, 12, 14, 15, 3, -14 },
  { 2549, 15, 14, 15, 1, -14 },
  { 2576, 16, 14, 15, -1, -14 },
  { 2604, 16, 19, 15, -1, -14 },
  { 2642, 13, 14, 15, 1, -14 },
  { 2665, 15, 26, 15, 1, -21 },
  { 2714, 8, 26, 15, 4, -21 },
  { 2740, 14, 26, 15, -1, -21 },
  { 2786, 13, 4, 15, 1, -10 },
};

const GFXfont UbuntuSansMono_Italic27pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic27pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _UBUNTUSANSMONO_ITALIC27PT7B_H_
