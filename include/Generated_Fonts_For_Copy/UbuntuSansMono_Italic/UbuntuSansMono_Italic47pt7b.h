#ifndef _UBUNTUSANSMONO_ITALIC47PT7B_H_
#define _UBUNTUSANSMONO_ITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0x7C, 0x03, 0x00, 0x3C, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x0E, 0x78,
  0x39, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x60, 0x71, 0x81, 0x8E, 0x06, 0x30,
  0x38, 0xC0, 0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0x81, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFC, 0x0E, 0x01, 0xE0, 0x02, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x30, 0x03, 0xE0, 0x7E, 0x3F, 0xC0, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0xE7,
  0x80, 0x3C, 0x01, 0xC3, 0x80, 0x38, 0x01, 0x83, 0x80, 0x70, 0x03, 0x83,
  0x80, 0xE0, 0x03, 0x83, 0x81, 0xE0, 0x03, 0x83, 0x83, 0xC0, 0x07, 0x03,
  0x87, 0x80, 0x07, 0x03, 0x8F, 0x00, 0x07, 0x07, 0x0E, 0x00, 0x07, 0x07,
  0x1C, 0x00, 0x03, 0x8E, 0x38, 0x00, 0x03, 0xDE, 0x78, 0x00, 0x03, 0xFC,
  0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x07, 0x1F, 0x80, 0x00, 0x0E, 0x3F, 0xC0, 0x00, 0x1E,
  0x71, 0xC0, 0x00, 0x3C, 0xE1, 0xE0, 0x00, 0x78, 0xE0, 0xE0, 0x00, 0xF1,
  0xC0, 0xE0, 0x00, 0xE1, 0xC0, 0xE0, 0x01, 0xC1, 0xC1, 0xE0, 0x03, 0x81,
  0xC1, 0xC0, 0x07, 0x81, 0xC1, 0xC0, 0x0F, 0x01, 0xC1, 0xC0, 0x1E, 0x01,
  0xC3, 0x80, 0x3C, 0x01, 0xC3, 0x80, 0x38, 0x01, 0xFF, 0x00, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xE0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0F, 0x03, 0xC0, 0x3C, 0x1E,
  0x00, 0xF0, 0xF8, 0x01, 0xE7, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x04, 0x03, 0xF8, 0x1C, 0x1F, 0xE0, 0xF0, 0xF3, 0xC3, 0x87, 0x87,
  0x8E, 0x3C, 0x1E, 0x79, 0xE0, 0x3D, 0xC7, 0x80, 0xFF, 0x1E, 0x01, 0xF8,
  0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xF8, 0xF8,
  0x0F, 0xE1, 0xF0, 0x7B, 0xC7, 0xFF, 0xCF, 0x0F, 0xFE, 0x3C, 0x1F, 0xE0,
  0x78, 0x1C, 0xF3, 0xCF, 0x39, 0xE7, 0x9E, 0x71, 0xC7, 0x38, 0xE3, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x04, 0x07, 0x01,
  0x78, 0x70, 0xF7, 0xE7, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFE,
  0x00, 0x0F, 0x80, 0x01, 0xDC, 0x00, 0x3D, 0xE0, 0x07, 0x8F, 0x00, 0xF8,
  0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x78, 0x06, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x81,
  0xF8, 0x3F, 0x8F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF0, 0x1E, 0x03, 0xC0, 0xF0,
  0x7C, 0x7F, 0x0F, 0xC1, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3C,
  0x7E, 0x7F, 0xFF, 0xFF, 0x7E, 0x7C, 0x18, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7C, 0x3E, 0x03,
  0xE0, 0x3C, 0x1F, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x1F, 0x00,
  0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3D,
  0xE1, 0xE0, 0xF7, 0x8F, 0xC3, 0xDE, 0x3F, 0x0F, 0x70, 0xFC, 0x3F, 0xC3,
  0xF1, 0xEF, 0x07, 0x87, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x73, 0xC0, 0x03,
  0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F,
  0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x03, 0xE0, 0xFC, 0x07, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0x9C, 0x07, 0xC7, 0x80, 0x60, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xE0, 0x3E, 0x01, 0x80, 0x1E, 0x01, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0x03, 0xE0, 0x08, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x0C, 0x01, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x17, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7B, 0x80, 0x01, 0xEF, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x38,
  0x00, 0x78, 0x70, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x1E, 0x07, 0x00,
  0x78, 0x0E, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x3C,
  0x01, 0xC0, 0x70, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x18, 0x01, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x3F, 0x00, 0x3D, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xF7, 0xF0, 0x7C, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x70, 0x00, 0x78, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x01, 0xE0,
  0x78, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x3F, 0x1F, 0x80, 0x1F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0xF8, 0x1F, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0x03,
  0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x7C, 0x03,
  0xF0, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0x83, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3F,
  0x1F, 0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x1F, 0x07, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x07,
  0xC0, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E,
  0x07, 0xC0, 0x18, 0x00, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x20, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xC1, 0xF0, 0x1F, 0x80, 0x78, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x0F,
  0x80, 0x07, 0x0F, 0x80, 0x03, 0x87, 0x80, 0x01, 0xC7, 0xC0, 0x00, 0xE3,
  0xC0, 0x3F, 0xF3, 0xE0, 0x7F, 0xF9, 0xE0, 0xFF, 0xFC, 0xF0, 0xF8, 0x1C,
  0xF0, 0x78, 0x1E, 0x78, 0x78, 0x0F, 0x3C, 0x3C, 0x07, 0x9E, 0x3C, 0x03,
  0x9E, 0x1E, 0x03, 0xCF, 0x0F, 0x01, 0xE7, 0x87, 0x00, 0xF3, 0xC3, 0x80,
  0x71, 0xE1, 0xC0, 0x78, 0xF0, 0xF0, 0x3C, 0x78, 0x78, 0x1E, 0x3C, 0x3E,
  0x0E, 0x1E, 0x0F, 0xCF, 0x0F, 0x03, 0xFF, 0x87, 0x80, 0xFF, 0xC3, 0xC0,
  0x0E, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x20, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0x87, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x07,
  0x80, 0x07, 0x01, 0xE0, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x1E, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01,
  0xC0, 0x07, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x39, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x3C, 0x0F, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x00,
  0x3C, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x03, 0x81, 0xE0,
  0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x3C,
  0x01, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0x87, 0xFE, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0x70, 0x78, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x87, 0x80, 0x0F,
  0x83, 0xC0, 0x1F, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0x81, 0xE0, 0x1F, 0x00, 0x10, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x04, 0x01, 0xF0, 0x0E, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3C,
  0x3F, 0xC0, 0x1C, 0x03, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3E, 0x07,
  0x80, 0x0F, 0x03, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xE0,
  0xF0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x0E,
  0x1E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC7, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x3E, 0x1E, 0x00,
  0x3E, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x7E, 0x03, 0x80, 0xFE, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0xE0, 0x1F, 0x00,
  0x10, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E,
  0x03, 0xC0, 0x0E, 0x01, 0xF0, 0x0F, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x70,
  0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x3C, 0x07, 0x80, 0x03, 0x80, 0x70, 0x00, 0x78, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0E,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xE0, 0x1C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1C, 0x03,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00,
  0x38, 0x07, 0x80, 0x03, 0x80, 0x70, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x02, 0x00,
  0x7C, 0x03, 0x80, 0x7C, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x1E, 0x00,
  0x3E, 0x01, 0xE0, 0x07, 0xC0, 0x1C, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x71, 0xF0, 0x00,
  0x07, 0x3E, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x38, 0x07, 0x80, 0x07, 0x80, 0x3C,
  0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xE0, 0x0F,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0x60, 0x0E, 0xE0,
  0x7E, 0x00, 0xCE, 0x0E, 0xE0, 0x1C, 0xE0, 0xCE, 0x01, 0xCE, 0x1C, 0xE0,
  0x1C, 0xE3, 0x8E, 0x03, 0x8E, 0x39, 0xE0, 0x38, 0xE7, 0x1C, 0x03, 0x8E,
  0x71, 0xC0, 0x78, 0xEE, 0x1C, 0x07, 0x0E, 0xC1, 0xC0, 0x70, 0xFC, 0x3C,
  0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x38, 0x0E, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x07,
  0x00, 0xF8, 0x00, 0xF0, 0x1F, 0x80, 0x0F, 0x01, 0xF8, 0x00, 0xE0, 0x1F,
  0xC0, 0x0E, 0x01, 0xDC, 0x00, 0xE0, 0x1D, 0xC0, 0x1E, 0x03, 0xDE, 0x01,
  0xC0, 0x39, 0xE0, 0x1C, 0x03, 0x8E, 0x01, 0xC0, 0x38, 0xE0, 0x3C, 0x07,
  0x8F, 0x03, 0xC0, 0x70, 0x70, 0x38, 0x07, 0x07, 0x03, 0x80, 0x70, 0x70,
  0x78, 0x0F, 0x07, 0x87, 0x80, 0xE0, 0x38, 0x70, 0x0E, 0x03, 0x87, 0x00,
  0xE0, 0x38, 0xF0, 0x1E, 0x03, 0x8F, 0x01, 0xC0, 0x3C, 0xE0, 0x1C, 0x01,
  0xCE, 0x01, 0xC0, 0x1C, 0xE0, 0x3C, 0x01, 0xDE, 0x03, 0xC0, 0x1D, 0xC0,
  0x38, 0x01, 0xFC, 0x03, 0x80, 0x0F, 0xC0, 0x78, 0x00, 0xFC, 0x07, 0x80,
  0x0F, 0x80, 0x70, 0x00, 0xF8, 0x07, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE3,
  0x80, 0x00, 0xE3, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3C,
  0x70, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03,
  0x8E, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xE3, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x3E, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3C, 0x0F,
  0xE0, 0x1E, 0x00, 0xF8, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x07, 0x03, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x07, 0xC0, 0x1E, 0x01, 0xF0,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x07,
  0x07, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0x71, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1E, 0x78, 0x00,
  0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0x8E, 0x00, 0x03, 0xC7, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x3E, 0x01, 0xE0, 0x3E, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x38, 0x0F, 0xE0, 0x3C, 0x01, 0xF0,
  0x1E, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0xF8, 0x1E, 0x03,
  0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xC0,
  0xF8, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xF0, 0x0E, 0x01, 0xF0, 0x01, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x20,
  0x00, 0xF0, 0x1C, 0x00, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x03, 0x83, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x70, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x0E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xE0,
  0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x38, 0x3C,
  0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xF0,
  0x70, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C,
  0x03, 0xC0, 0x7C, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x78, 0x38, 0x00, 0x38,
  0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x0E,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x07,
  0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x78, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x03, 0xBC, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C,
  0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0x81, 0xE0,
  0xF0, 0x78, 0x1C, 0x1F, 0x07, 0x01, 0xC1, 0xF0, 0x70, 0x1C, 0x3F, 0x0F,
  0x01, 0xC3, 0xF0, 0xE0, 0x3C, 0x77, 0x0E, 0x03, 0x8F, 0x70, 0xE0, 0x38,
  0xE3, 0x1C, 0x03, 0x9C, 0x31, 0xC0, 0x39, 0xC3, 0x1C, 0x03, 0x38, 0x3B,
  0x80, 0x73, 0x83, 0xB8, 0x07, 0x70, 0x3B, 0x80, 0x7F, 0x03, 0xB0, 0x07,
  0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x03,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x07,
  0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xBC,
  0x00, 0x07, 0xDE, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xC3, 0x80, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x1C, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x70,
  0x00, 0x78, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x07, 0xB8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x40, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x38, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xB8, 0x00, 0x3D,
  0xC0, 0x03, 0xCF, 0x00, 0x3C, 0x38, 0x03, 0xC1, 0xC0, 0x3C, 0x0F, 0x01,
  0xE0, 0x38, 0x1E, 0x01, 0xC1, 0xE0, 0x0F, 0x1E, 0x00, 0x39, 0xE0, 0x01,
  0xDF, 0x00, 0x0F, 0x70, 0x00, 0x39, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x30, 0x7C, 0x1E, 0x07, 0x83, 0xE0,
  0xF0, 0x3C, 0x0F, 0x02, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xF8, 0x1F, 0xE0, 0xE0, 0x7E, 0x01, 0xC1, 0xF0, 0x07, 0x87, 0xC0,
  0x0F, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0xF8, 0x00, 0xF1, 0xE0, 0x01,
  0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0xFC, 0x1F, 0xDF, 0xF8, 0x1F,
  0xFE, 0xF0, 0x1F, 0xF8, 0xE0, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFC, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x3C,
  0x38, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7,
  0x00, 0x07, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xE0,
  0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1C, 0x00,
  0xF8, 0x38, 0x03, 0xE0, 0xF0, 0x3F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x3F, 0x80, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x18, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x07, 0x80, 0x1F, 0x80,
  0xF0, 0x07, 0xC0, 0x1C, 0x01, 0xF0, 0x03, 0x80, 0x7C, 0x00, 0xF0, 0x0F,
  0x00, 0x1E, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x1E,
  0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0,
  0x1E, 0x00, 0x38, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xF7,
  0xFC, 0x00, 0x7F, 0xFB, 0xC0, 0x07, 0xFC, 0x78, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFC, 0x3F, 0x0F,
  0xC0, 0x3C, 0x7C, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x7C, 0x00,
  0x3D, 0xE0, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x01, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x03,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x8F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xE1, 0xE0, 0x07, 0xE0, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x1C, 0x03, 0xC0,
  0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80,
  0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x00,
  0x70, 0x0E, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xF9, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x40, 0x07, 0xC0,
  0x1F, 0x0F, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x7E,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFE, 0xFF, 0x03, 0xC0, 0x1E,
  0x07, 0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x00, 0x00, 0x78,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xFE,
  0x3F, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x40,
  0x1E, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x0E,
  0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x07, 0x81, 0xF0, 0x03, 0xC3, 0xE0, 0x01,
  0xC3, 0xE0, 0x01, 0xE7, 0xE0, 0x00, 0xF7, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x3E, 0x00,
  0x07, 0x0F, 0x80, 0x03, 0x83, 0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x3C,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00,
  0xF8, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x00, 0x7F, 0xF7, 0xFF, 0x3F,
  0xF8, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x0B, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0x10, 0x00, 0x00, 0xFC, 0x3E,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xF9, 0xFD, 0xF0, 0x70, 0x78,
  0x78, 0x38, 0x3C, 0x1C, 0x3C, 0x1C, 0x0E, 0x1E, 0x0E, 0x0F, 0x0E, 0x0F,
  0x07, 0x87, 0x07, 0x83, 0x87, 0x83, 0xC1, 0xC3, 0xC1, 0xC1, 0xE1, 0xC1,
  0xE0, 0xF0, 0xE0, 0xF0, 0x78, 0xF0, 0x78, 0x38, 0x78, 0x38, 0x1C, 0x38,
  0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87,
  0x00, 0x03, 0xC3, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x01, 0xF8, 0xFE, 0x07, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80,
  0x0F, 0x1C, 0x00, 0x38, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x38, 0x00, 0x71, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x70,
  0x00, 0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xE0, 0x01,
  0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xDF,
  0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x07, 0x87, 0xC0, 0x07, 0x0F, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xE7,
  0x80, 0x03, 0xCF, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0xF0,
  0x00, 0x79, 0xE0, 0x01, 0xF1, 0xC0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80,
  0x3E, 0x0F, 0x81, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xE0, 0x0F, 0x80, 0x78, 0x01, 0xE0,
  0x1E, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x81, 0xE0,
  0x01, 0xE0, 0x78, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03,
  0xC0, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x38, 0x01, 0xF0, 0x1E, 0x00, 0xF8,
  0x07, 0x80, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0x20, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x1E, 0x03, 0xE0, 0x1E, 0x07, 0xC0,
  0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x38, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70, 0x00,
  0x78, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x7C, 0x07,
  0xE0, 0x3F, 0xBF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFB, 0xC0, 0x00, 0x83,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFC, 0x06,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xE1, 0xE0, 0x78, 0x01, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x30, 0x03, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x20, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x80, 0x00, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xC0, 0x03, 0x8F, 0x00,
  0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0x80, 0x07, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03,
  0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF8, 0x1F, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0x9C, 0x07, 0xFC, 0x70, 0x03, 0x00, 0x00, 0xF0,
  0x00, 0x7B, 0x80, 0x07, 0x9C, 0x00, 0x3C, 0xE0, 0x01, 0xC7, 0x00, 0x1E,
  0x3C, 0x00, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0,
  0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x1C, 0x0E, 0x00,
  0xE0, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x70, 0x01, 0xE7, 0x80, 0x0F, 0x78,
  0x00, 0x3B, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x38,
  0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0x81, 0xC0,
  0x71, 0xE0, 0x78, 0x3C, 0x78, 0x3E, 0x0E, 0x1E, 0x0F, 0x87, 0x87, 0x87,
  0xE1, 0xC1, 0xE3, 0xF8, 0x70, 0x78, 0xEE, 0x3C, 0x1C, 0x73, 0x8E, 0x07,
  0x1C, 0xE7, 0x81, 0xCE, 0x39, 0xC0, 0x77, 0x8E, 0x70, 0x1D, 0xC3, 0xFC,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x0F, 0x00,
  0x0F, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x03, 0x80, 0x03,
  0xC0, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x38, 0x00, 0x78,
  0x03, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x38, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x39, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x0E, 0x3F, 0xE0, 0x1C, 0xFF,
  0xF0, 0x73, 0xC1, 0xF3, 0xE7, 0x01, 0xFF, 0x9E, 0x01, 0xFE, 0x08, 0x00,
  0xF0, 0x00,
};

const GFXglyph UbuntuSansMono_Italic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 12, 34, 26, 7, -33 },
  { 52, 14, 13, 26, 10, -36 },
  { 75, 28, 33, 26, 0, -33 },
  { 191, 24, 41, 26, 2, -36 },
  { 314, 32, 34, 26, -2, -33 },
  { 450, 22, 33, 26, 1, -33 },
  { 541, 6, 14, 26, 14, -36 },
  { 552, 19, 46, 26, 6, -37 },
  { 662, 20, 46, 26, 1, -37 },
  { 777, 20, 19, 26, 5, -33 },
  { 825, 21, 23, 26, 3, -25 },
  { 886, 11, 14, 26, 4, -7 },
  { 906, 11, 3, 26, 8, -15 },
  { 911, 8, 8, 26, 7, -7 },
  { 919, 30, 46, 26, -3, -37 },
  { 1092, 22, 34, 26, 3, -33 },
  { 1186, 19, 33, 26, 3, -33 },
  { 1265, 24, 33, 26, 2, -33 },
  { 1364, 23, 34, 26, 2, -33 },
  { 1462, 23, 33, 26, 1, -33 },
  { 1557, 26, 34, 26, 1, -33 },
  { 1668, 24, 34, 26, 3, -33 },
  { 1770, 23, 33, 26, 6, -33 },
  { 1865, 24, 34, 26, 2, -33 },
  { 1967, 24, 33, 26, 2, -33 },
  { 2066, 12, 25, 26, 7, -24 },
  { 2104, 15, 31, 26, 4, -24 },
  { 2163, 23, 21, 26, 2, -24 },
  { 2224, 24, 13, 26, 2, -20 },
  { 2263, 23, 21, 26, 1, -24 },
  { 2324, 18, 34, 26, 7, -33 },
  { 2401, 25, 40, 26, 2, -33 },
  { 2526, 26, 33, 26, -3, -33 },
  { 2634, 25, 33, 26, 0, -33 },
  { 2738, 25, 34, 26, 3, -33 },
  { 2845, 25, 33, 26, 0, -33 },
  { 2949, 26, 33, 26, 2, -33 },
  { 3057, 26, 33, 26, 2, -33 },
  { 3165, 25, 34, 26, 2, -33 },
  { 3272, 28, 33, 26, 0, -33 },
  { 3388, 24, 33, 26, 2, -33 },
  { 3487, 25, 34, 26, 2, -33 },
  { 3594, 28, 33, 26, 1, -33 },
  { 3710, 19, 33, 26, 1, -33 },
  { 3789, 28, 33, 26, -1, -33 },
  { 3905, 28, 33, 26, 0, -33 },
  { 4021, 25, 34, 26, 2, -33 },
  { 4128, 25, 33, 26, 1, -33 },
  { 4232, 25, 42, 26, 2, -33 },
  { 4364, 25, 33, 26, 1, -33 },
  { 4468, 26, 34, 26, 1, -33 },
  { 4579, 23, 33, 26, 6, -33 },
  { 4674, 25, 34, 26, 3, -33 },
  { 4781, 25, 33, 26, 5, -33 },
  { 4885, 28, 33, 26, 1, -33 },
  { 5001, 31, 33, 26, -1, -33 },
  { 5129, 25, 33, 26, 6, -33 },
  { 5233, 28, 33, 26, 0, -33 },
  { 5349, 23, 46, 26, 3, -37 },
  { 5482, 7, 46, 26, 10, -37 },
  { 5523, 24, 46, 26, -1, -37 },
  { 5661, 21, 18, 26, 4, -33 },
  { 5709, 24, 3, 26, -3, 6 },
  { 5718, 9, 9, 26, 12, -36 },
  { 5729, 23, 26, 26, 2, -25 },
  { 5804, 23, 36, 26, 2, -36 },
  { 5908, 23, 26, 26, 2, -25 },
  { 5983, 27, 37, 26, 2, -36 },
  { 6108, 22, 26, 26, 2, -25 },
  { 6180, 31, 45, 26, -1, -36 },
  { 6355, 27, 34, 26, -1, -25 },
  { 6470, 23, 36, 26, 0, -36 },
  { 6574, 15, 36, 26, 5, -36 },
  { 6642, 25, 45, 26, 0, -36 },
  { 6783, 25, 36, 26, 1, -36 },
  { 6896, 13, 37, 26, 8, -36 },
  { 6957, 25, 25, 26, 0, -25 },
  { 7036, 22, 25, 26, 2, -25 },
  { 7105, 23, 26, 26, 2, -25 },
  { 7180, 26, 34, 26, -1, -25 },
  { 7291, 24, 34, 26, 2, -25 },
  { 7393, 22, 25, 26, 3, -25 },
  { 7462, 21, 26, 26, 3, -25 },
  { 7531, 19, 33, 26, 6, -32 },
  { 7610, 22, 25, 26, 3, -24 },
  { 7679, 21, 24, 26, 5, -24 },
  { 7742, 26, 24, 26, 2, -24 },
  { 7820, 27, 24, 26, -1, -24 },
  { 7901, 29, 33, 26, -3, -24 },
  { 8021, 23, 24, 26, 1, -24 },
  { 8090, 25, 46, 26, 3, -37 },
  { 8234, 15, 46, 26, 6, -37 },
  { 8321, 25, 46, 26, -2, -37 },
  { 8465, 23, 7, 26, 2, -17 },
};

const GFXfont UbuntuSansMono_Italic47pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic47pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic47pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _UBUNTUSANSMONO_ITALIC47PT7B_H_
