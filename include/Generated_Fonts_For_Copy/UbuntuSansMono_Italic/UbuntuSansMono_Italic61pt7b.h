#ifndef _UBUNTUSANSMONO_ITALIC61PT7B_H_
#define _UBUNTUSANSMONO_ITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0x1E, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1E,
  0x3C, 0x07, 0x8F, 0x03, 0xC3, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E,
  0x03, 0x87, 0x01, 0xE1, 0xC0, 0x78, 0x70, 0x1C, 0x38, 0x07, 0x0E, 0x01,
  0xC3, 0x80, 0x60, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xE0, 0x0F,
  0xC0, 0x00, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x10, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x80,
  0x0F, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x0F, 0x8F,
  0x00, 0x07, 0x80, 0x07, 0x87, 0x80, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x07,
  0x80, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x07, 0xC0, 0x01,
  0xE0, 0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x1E, 0x07, 0xC0, 0x00, 0x70, 0x1E,
  0x03, 0xC0, 0x00, 0x78, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x83, 0xC0,
  0x00, 0x1E, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x03, 0xC3, 0xE0, 0x00, 0x07,
  0x81, 0xE3, 0xE0, 0x00, 0x01, 0xE1, 0xE3, 0xE0, 0x00, 0x00, 0xF9, 0xF1,
  0xE0, 0x00, 0x00, 0x7F, 0xF1, 0xE0, 0x00, 0x00, 0x1F, 0xF1, 0xE0, 0x00,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0xF1,
  0xFF, 0x80, 0x00, 0x00, 0xF1, 0xFF, 0xC0, 0x00, 0x00, 0xF1, 0xF1, 0xF0,
  0x00, 0x00, 0xF8, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0xF0, 0x3C, 0x00, 0x00,
  0xF8, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x0F, 0x00, 0x00, 0x78, 0x3C,
  0x07, 0x80, 0x00, 0x78, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x01, 0xE0,
  0x00, 0x7C, 0x07, 0x80, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0xF0, 0x00, 0x7C,
  0x01, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x00, 0x1F, 0x3E, 0x00,
  0x3E, 0x00, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0xF8, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0xC0, 0x1F, 0xF0, 0x0F, 0x03, 0xFF, 0x01,
  0xF0, 0x7E, 0xF8, 0x1E, 0x0F, 0x8F, 0xC1, 0xE1, 0xF0, 0x7C, 0x3E, 0x3E,
  0x03, 0xE3, 0xC7, 0xC0, 0x3E, 0x3C, 0x7C, 0x01, 0xF7, 0x87, 0xC0, 0x1F,
  0xF8, 0xF8, 0x00, 0xFF, 0x8F, 0x80, 0x07, 0xF0, 0xF8, 0x00, 0x7F, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xF0, 0xF8, 0x00,
  0xFF, 0x0F, 0xC0, 0x1F, 0xF0, 0xFE, 0x07, 0xEF, 0x87, 0xFF, 0xFC, 0xF8,
  0x3F, 0xFF, 0x8F, 0x81, 0xFF, 0xE0, 0xFC, 0x0F, 0xF8, 0x07, 0xC0, 0x08,
  0x00, 0x00, 0x1F, 0x8F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C,
  0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x02, 0x01, 0xE0, 0x09, 0xE0, 0x78, 0x1E, 0x7E, 0x1E,
  0x1F, 0x9F, 0xF3, 0x9F, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x78, 0x07, 0x80, 0x0C,
  0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x03, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x3F, 0x8F,
  0xFC, 0x3F, 0xE0, 0xFE, 0x03, 0xE0, 0x08, 0x00, 0x00, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xC7, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x7C,
  0x1F, 0x01, 0xF3, 0xF0, 0xFE, 0x0F, 0x8F, 0x87, 0xF8, 0x3E, 0x3E, 0x1F,
  0xF0, 0xF8, 0xF8, 0x7F, 0xC3, 0xE7, 0xC1, 0xFE, 0x0F, 0x9F, 0x03, 0xF8,
  0x7C, 0x7C, 0x0F, 0xC1, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3F,
  0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0x3C, 0x01, 0xFC, 0x7C, 0x01, 0xF0,
  0x7C, 0x01, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x06, 0x00, 0x0F,
  0xC0, 0x10, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x60, 0x03, 0xF0, 0x02, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x80,
  0x00, 0xFE, 0x07, 0x80, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x03, 0xF1, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0x80, 0x07,
  0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x7E, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x7C, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xF8, 0x7F,
  0x80, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x7C, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F,
  0x80, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE3, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x03, 0xF8, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xC0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x07, 0xE0,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x07, 0x81, 0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x7F, 0xF8, 0x3F, 0x00,
  0x7F, 0xFE, 0x0F, 0x80, 0x7F, 0xFF, 0x87, 0xE0, 0x3F, 0xFF, 0xC1, 0xF0,
  0x1F, 0x81, 0xF0, 0x7C, 0x0F, 0xC0, 0x7C, 0x3F, 0x07, 0xE0, 0x1F, 0x0F,
  0x83, 0xF0, 0x07, 0x83, 0xE0, 0xF8, 0x03, 0xE1, 0xF8, 0x3E, 0x00, 0xF8,
  0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x07, 0xC0, 0x0F, 0x07, 0xC1, 0xF0, 0x07,
  0xC1, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x1E, 0x00, 0x7C, 0x1F, 0x07, 0x80,
  0x1F, 0x0F, 0x81, 0xE0, 0x0F, 0x83, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x1F,
  0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x81, 0xF8, 0x0F, 0x01, 0xF0,
  0x3F, 0x07, 0xC0, 0x7C, 0x07, 0xFF, 0xF0, 0x1F, 0x00, 0xFF, 0xFC, 0x07,
  0xC0, 0x1F, 0xFE, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01, 0xE0,
  0x0F, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x07, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7E, 0x0F,
  0xFE, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0xF8, 0x03, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x0F, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x1F,
  0xC0, 0x78, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x70, 0x03, 0xF0,
  0x00, 0x08, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x10, 0x00, 0xFE, 0x00,
  0x38, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xF3, 0xFF, 0x80, 0x03, 0xC0, 0x0F, 0xE0,
  0x03, 0xE0, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x07,
  0x80, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xFC, 0x03, 0xE0, 0x03, 0xF8, 0x01,
  0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xC0, 0x3E, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0xFC, 0x00,
  0x04, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x0F, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x20,
  0x00, 0x7E, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xFC, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF0,
  0x07, 0xC0, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x00, 0x3E, 0x7F, 0x00, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x00,
  0x3D, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7B, 0xF0, 0x00, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xE0,
  0x01, 0xDE, 0x01, 0xEE, 0x00, 0x3D, 0xE0, 0x1F, 0xE0, 0x03, 0x9E, 0x03,
  0xDE, 0x00, 0x39, 0xE0, 0x39, 0xE0, 0x07, 0x9E, 0x07, 0x9E, 0x00, 0x79,
  0xE0, 0xF1, 0xE0, 0x07, 0x1E, 0x0F, 0x3C, 0x00, 0xF1, 0xE1, 0xE3, 0xC0,
  0x0F, 0x1E, 0x1E, 0x3C, 0x00, 0xF1, 0xE3, 0xC3, 0xC0, 0x1E, 0x0E, 0x38,
  0x3C, 0x01, 0xE0, 0xE7, 0x87, 0xC0, 0x1E, 0x0E, 0x70, 0x78, 0x03, 0xC0,
  0xFF, 0x07, 0x80, 0x3C, 0x0F, 0xE0, 0x78, 0x03, 0xC0, 0xFE, 0x07, 0x80,
  0x7C, 0x0F, 0xC0, 0xF8, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x0F, 0x80,
  0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x0F,
  0xE0, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0x1F,
  0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0x80, 0x0F, 0x78,
  0x00, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x00,
  0x3C, 0xF8, 0x00, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x80, 0x0F, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0x07, 0x83, 0xC0, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0xF0, 0x01, 0xE0, 0xF8, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x7C,
  0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x3C, 0x07,
  0xC0, 0xF0, 0x03, 0xE0, 0x1E, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x07, 0x83, 0xC0, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x7C, 0x01, 0xF1,
  0xF0, 0x03, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF0,
  0x01, 0xE3, 0xC0, 0x0F, 0x80, 0x0F, 0x3E, 0x00, 0x7C, 0x00, 0x39, 0xE0,
  0x03, 0xC0, 0x01, 0xEF, 0x00, 0x1E, 0x00, 0x0F, 0x78, 0x00, 0xF0, 0x00,
  0x7F, 0xC0, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x03,
  0xC0, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x1F,
  0xC0, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F,
  0xE1, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xF0, 0x3F, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x1E, 0x00,
  0x1F, 0xC0, 0x1F, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x3E, 0x78, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x80,
  0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0x8F, 0xFE, 0x00, 0x78, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF8, 0x07,
  0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x03, 0xE0,
  0x03, 0xF8, 0x00, 0x30, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x01,
  0x00, 0x00, 0xFE, 0x01, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x3F,
  0x01, 0xE0, 0x1F, 0x03, 0xF0, 0x3E, 0x01, 0xE0, 0x7F, 0x03, 0xC0, 0x1E,
  0x07, 0xF0, 0x3C, 0x01, 0xE0, 0xF7, 0x03, 0xC0, 0x1E, 0x1E, 0x70, 0x78,
  0x03, 0xC1, 0xE7, 0x07, 0x80, 0x3C, 0x3C, 0x70, 0x78, 0x03, 0xC3, 0xC7,
  0x0F, 0x00, 0x3C, 0x78, 0x70, 0xF0, 0x03, 0xC7, 0x87, 0x8F, 0x00, 0x38,
  0xF0, 0x78, 0xE0, 0x07, 0x9E, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x79, 0xE0,
  0x07, 0xBC, 0x07, 0x9C, 0x00, 0x7B, 0xC0, 0x7B, 0xC0, 0x07, 0x78, 0x07,
  0xBC, 0x00, 0x77, 0x80, 0x3B, 0x80, 0x07, 0xF0, 0x03, 0xB8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xE3, 0xC0, 0x01,
  0xF8, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0x01, 0xE0,
  0x0F, 0x80, 0x78, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0xF8, 0x00,
  0xF0, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE7, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xCC, 0x00, 0x00, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0x0F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0x80, 0x78, 0x07, 0xF8, 0x01, 0xE0, 0x3F, 0x80, 0x0F, 0x81,
  0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF0, 0x3F, 0x00, 0x03, 0xC1, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8, 0x1E,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xE0,
  0x03, 0xF8, 0x0F, 0x80, 0x1F, 0xE0, 0x3F, 0x83, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x78, 0x01, 0xFF, 0xE1, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xE0,
  0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x81, 0xF0,
  0x03, 0xFC, 0x07, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x08, 0x0F, 0xE0, 0x00, 0xE0, 0x1F, 0xF8,
  0x7F, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFE, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x0F,
  0x80, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF3, 0xE0, 0x00, 0x7F, 0xF8, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0x81,
  0xFC, 0x00, 0x7C, 0x1F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x0F, 0xC0,
  0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF9, 0xF0, 0x00, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x20, 0x7F, 0x00, 0x0F, 0x01, 0xFF,
  0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x40, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x10,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x3F,
  0xC0, 0x0F, 0x80, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFB, 0xC0, 0x00,
  0x07, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x40, 0x00, 0x7E, 0x00, 0x1E, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7E, 0x01, 0xFC,
  0x01, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x02, 0x00, 0x0F, 0x80,
  0x01, 0xC0, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xE0, 0x07, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xE0,
  0x1F, 0x80, 0x03, 0xE0, 0x7F, 0x00, 0x03, 0xC0, 0xFE, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x07, 0xBF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0x7F, 0x00, 0x00, 0x1F, 0x3F, 0x80, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF,
  0x9F, 0xFF, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x27, 0xF0, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x01, 0xE0,
  0x00, 0x7F, 0xE1, 0xFC, 0x00, 0xFF, 0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3E, 0x0F, 0xE1, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1F, 0x07, 0xC0, 0x78,
  0x0F, 0x83, 0xE0, 0x7C, 0x07, 0x81, 0xE0, 0x3E, 0x03, 0xC0, 0xF0, 0x1F,
  0x03, 0xE0, 0xF8, 0x0F, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0xF0, 0x3E, 0x07,
  0xC0, 0x78, 0x1E, 0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xE0, 0x3E, 0x0F, 0x80,
  0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xE0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x0F, 0x80,
  0x01, 0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE0, 0x7F, 0x01, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E,
  0x7E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x1F, 0x83, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x03,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0x80, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xF8, 0x03, 0xE0, 0x03, 0xF8, 0x01,
  0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E,
  0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x1F, 0xC0, 0x3F, 0x83, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xEF, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x02, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFE,
  0x00, 0xE0, 0x1F, 0x80, 0x02, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x20, 0x00, 0x1F, 0x03, 0x80, 0x07, 0xE0, 0x7F, 0x87,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x1F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFA,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x80, 0x7F, 0xDF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x3E,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C,
  0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0xC0, 0xFC, 0x03, 0xFE,
  0x03, 0xF8, 0xFF, 0xF0, 0x1F, 0xFF, 0xF7, 0x80, 0x7F, 0xFE, 0x3C, 0x01,
  0xFF, 0xE1, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x78, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x7C, 0x00, 0xF8, 0x1E, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x1E, 0x7C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0xF0, 0x0F, 0x87, 0xC0, 0x3C,
  0x03, 0xC1, 0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0x7C, 0x1F, 0x03,
  0xF8, 0x1E, 0x07, 0xC1, 0xFE, 0x0F, 0x81, 0xF0, 0x7F, 0x83, 0xC0, 0x78,
  0x3D, 0xE1, 0xF0, 0x1E, 0x0F, 0x78, 0x7C, 0x07, 0x87, 0x9E, 0x1E, 0x01,
  0xE3, 0xC7, 0x8F, 0x80, 0x78, 0xF1, 0xE3, 0xC0, 0x1E, 0x78, 0x3D, 0xF0,
  0x07, 0x9E, 0x0F, 0x78, 0x03, 0xEF, 0x03, 0xDE, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0xFF,
  0xE0, 0x07, 0x87, 0xFF, 0xC0, 0x1E, 0x3F, 0xFF, 0xC0, 0xF1, 0xF0, 0x3F,
  0xCF, 0xC7, 0x80, 0x7F, 0xFE, 0x3E, 0x00, 0x7F, 0xF0, 0x70, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00,
};

const GFXglyph UbuntuSansMono_Italic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 16, 43, 34, 9, -42 },
  { 87, 18, 16, 34, 13, -46 },
  { 123, 36, 42, 34, 0, -42 },
  { 312, 31, 54, 34, 3, -47 },
  { 522, 41, 44, 34, -2, -43 },
  { 748, 28, 44, 34, 2, -43 },
  { 902, 9, 17, 34, 18, -46 },
  { 922, 25, 59, 34, 8, -48 },
  { 1107, 25, 59, 34, 2, -48 },
  { 1292, 26, 24, 34, 7, -42 },
  { 1370, 28, 30, 34, 4, -33 },
  { 1475, 14, 19, 34, 5, -9 },
  { 1509, 15, 5, 34, 10, -20 },
  { 1519, 9, 10, 34, 10, -9 },
  { 1531, 39, 59, 34, -4, -48 },
  { 1819, 30, 44, 34, 3, -43 },
  { 1984, 24, 42, 34, 4, -42 },
  { 2110, 30, 43, 34, 3, -43 },
  { 2272, 30, 44, 34, 2, -43 },
  { 2437, 31, 42, 34, 1, -42 },
  { 2600, 33, 43, 34, 2, -42 },
  { 2778, 31, 44, 34, 4, -43 },
  { 2949, 31, 42, 34, 7, -42 },
  { 3112, 31, 44, 34, 3, -43 },
  { 3283, 31, 43, 34, 3, -43 },
  { 3450, 14, 32, 34, 10, -31 },
  { 3506, 19, 41, 34, 5, -31 },
  { 3604, 30, 27, 34, 3, -31 },
  { 3706, 31, 17, 34, 2, -26 },
  { 3772, 29, 27, 34, 2, -31 },
  { 3870, 24, 44, 34, 9, -43 },
  { 4002, 34, 52, 34, 2, -43 },
  { 4223, 33, 42, 34, -4, -42 },
  { 4397, 32, 43, 34, 1, -43 },
  { 4569, 33, 44, 34, 4, -43 },
  { 4751, 33, 43, 34, 0, -43 },
  { 4929, 33, 42, 34, 3, -42 },
  { 5103, 33, 42, 34, 3, -42 },
  { 5277, 32, 44, 34, 3, -43 },
  { 5453, 37, 42, 34, 0, -42 },
  { 5648, 31, 42, 34, 3, -42 },
  { 5811, 32, 43, 34, 3, -42 },
  { 5983, 36, 42, 34, 1, -42 },
  { 6172, 25, 42, 34, 1, -42 },
  { 6304, 36, 42, 34, -1, -42 },
  { 6493, 37, 42, 34, 0, -42 },
  { 6688, 31, 44, 34, 3, -43 },
  { 6859, 33, 43, 34, 1, -43 },
  { 7037, 31, 54, 34, 3, -43 },
  { 7247, 32, 43, 34, 1, -43 },
  { 7419, 33, 44, 34, 2, -43 },
  { 7601, 29, 42, 34, 8, -42 },
  { 7754, 34, 43, 34, 3, -42 },
  { 7937, 32, 42, 34, 7, -42 },
  { 8105, 36, 42, 34, 2, -42 },
  { 8294, 41, 42, 34, -2, -42 },
  { 8510, 32, 42, 34, 8, -42 },
  { 8678, 37, 42, 34, 0, -42 },
  { 8873, 30, 59, 34, 4, -48 },
  { 9095, 9, 59, 34, 13, -48 },
  { 9162, 30, 59, 34, -1, -48 },
  { 9384, 26, 22, 34, 6, -42 },
  { 9456, 31, 4, 34, -4, 7 },
  { 9472, 11, 12, 34, 16, -47 },
  { 9489, 30, 33, 34, 2, -32 },
  { 9613, 30, 48, 34, 2, -47 },
  { 9793, 30, 33, 34, 2, -32 },
  { 9917, 34, 48, 34, 3, -47 },
  { 10121, 29, 33, 34, 2, -32 },
  { 10241, 39, 58, 34, -1, -47 },
  { 10524, 35, 43, 34, -1, -32 },
  { 10713, 30, 47, 34, 0, -47 },
  { 10890, 19, 47, 34, 7, -47 },
  { 11002, 33, 58, 34, -1, -47 },
  { 11242, 32, 47, 34, 2, -47 },
  { 11430, 17, 48, 34, 10, -47 },
  { 11532, 33, 32, 34, 0, -32 },
  { 11664, 29, 32, 34, 2, -32 },
  { 11780, 29, 33, 34, 3, -32 },
  { 11900, 33, 43, 34, -1, -32 },
  { 12078, 30, 43, 34, 3, -32 },
  { 12240, 29, 32, 34, 4, -32 },
  { 12356, 28, 33, 34, 3, -32 },
  { 12472, 25, 43, 34, 7, -42 },
  { 12607, 29, 33, 34, 3, -32 },
  { 12727, 26, 32, 34, 7, -32 },
  { 12831, 34, 32, 34, 3, -32 },
  { 12967, 35, 32, 34, -1, -32 },
  { 13107, 37, 43, 34, -3, -32 },
  { 13306, 30, 32, 34, 2, -32 },
  { 13426, 33, 59, 34, 3, -48 },
  { 13670, 19, 59, 34, 8, -48 },
  { 13811, 33, 59, 34, -3, -48 },
  { 14055, 30, 10, 34, 3, -23 },
};

const GFXfont UbuntuSansMono_Italic61pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic61pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic61pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _UBUNTUSANSMONO_ITALIC61PT7B_H_
