#ifndef _UBUNTUSANSMONO_ITALIC34PT7B_H_
#define _UBUNTUSANSMONO_ITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x07, 0xC3, 0xE0, 0xE0, 0x30, 0xCC, 0x37, 0x1D, 0xC6, 0x61, 0x98, 0x66,
  0x19, 0x0C, 0xC3, 0x00, 0x00, 0x18, 0x30, 0x03, 0x87, 0x00, 0x30, 0x60,
  0x07, 0x0E, 0x00, 0x60, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x38, 0x30, 0x03, 0x87, 0x00, 0x30, 0x60, 0x07, 0x0E,
  0x00, 0x60, 0xC0, 0x0E, 0x1C, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xF8, 0x18, 0x30, 0x03, 0x87, 0x00, 0x30, 0x60, 0x07, 0x0E, 0x00, 0x60,
  0xE0, 0x0E, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x38, 0x08, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x10, 0x03, 0x87, 0x03, 0xC3, 0xFF, 0xE0, 0x3F, 0xE0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xE0, 0x0C, 0x1F, 0xC0, 0x70, 0x63, 0x03, 0x83, 0x0C, 0x1C, 0x0C,
  0x30, 0xE0, 0x30, 0xC3, 0x01, 0xC3, 0x18, 0x07, 0x18, 0xC0, 0x1C, 0x67,
  0x00, 0x33, 0xB8, 0x00, 0xFD, 0xC0, 0x01, 0xCE, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x9F, 0x00, 0x0C, 0xEC, 0x00, 0x77, 0x38, 0x03, 0x98, 0x60, 0x1C,
  0x61, 0x80, 0xE3, 0x8E, 0x03, 0x0C, 0x38, 0x18, 0x30, 0xC0, 0xC0, 0xE3,
  0x07, 0x01, 0x98, 0x38, 0x07, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xF8, 0x01,
  0xFC, 0x03, 0x8E, 0x07, 0x0E, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0E,
  0x1C, 0x0E, 0x38, 0x07, 0x70, 0x07, 0xE0, 0x07, 0x86, 0x1F, 0x87, 0x3D,
  0xC6, 0x70, 0xCE, 0x70, 0xEE, 0xE0, 0x7C, 0xE0, 0x7C, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x7C, 0xF1, 0xFC, 0x7F, 0xDC, 0x3F, 0x0E, 0x39, 0x9C, 0xE7,
  0x31, 0x8C, 0xC6, 0x00, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x04, 0x00, 0x00, 0x80, 0x03, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x40, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x43, 0x0F, 0xCC, 0xFF, 0xFF,
  0xC7, 0xFC, 0x07, 0x80, 0x3F, 0x01, 0xCE, 0x07, 0x3C, 0x38, 0x78, 0x60,
  0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x1E, 0x1E, 0x3F,
  0x3F, 0x1F, 0x0E, 0x0E, 0x3C, 0xF8, 0xE0, 0xFF, 0xFF, 0xFF, 0x79, 0xEF,
  0xFE, 0x78, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFE, 0x07, 0xDF, 0x0F,
  0x07, 0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x03, 0x38, 0x03, 0x38, 0x07, 0x71,
  0x87, 0x73, 0xC7, 0x73, 0xE7, 0xE3, 0xC7, 0xE3, 0xC6, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xF0,
  0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x03,
  0x80, 0x3E, 0x03, 0xF8, 0x3E, 0xE0, 0xE3, 0x02, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x07, 0xFF, 0xBF,
  0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xF1, 0xE0, 0xC0, 0x70, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0xE3, 0xE0, 0x40,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE3, 0x03, 0xE3, 0xFF, 0xE0, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x30, 0x07,
  0x18, 0x07, 0x1C, 0x07, 0x0E, 0x03, 0x06, 0x03, 0x83, 0x03, 0x83, 0x83,
  0x81, 0xC1, 0x80, 0xC1, 0xC0, 0x61, 0xC0, 0x70, 0xFF, 0xFF, 0x7F, 0xFF,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x80, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x87, 0xC1, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x0C, 0x60,
  0x06, 0x70, 0x07, 0x38, 0x03, 0x8C, 0x03, 0x87, 0x01, 0xC3, 0x81, 0xC0,
  0xFF, 0xC0, 0x3F, 0xC0, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0x81, 0xE1, 0xC1, 0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0x70,
  0x0E, 0x38, 0x07, 0x1C, 0x07, 0x0F, 0x07, 0x03, 0xC7, 0x80, 0xFF, 0x00,
  0xFF, 0x81, 0xE3, 0xE1, 0xE0, 0x70, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07,
  0x30, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x03, 0xC1, 0xFF, 0xC0, 0x7F,
  0xC0, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xE3, 0xC1, 0xC0,
  0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C,
  0x01, 0xCE, 0x00, 0xE7, 0x80, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x0E, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0x07, 0x87, 0xE3, 0xE0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xE1,
  0xF8, 0xF8, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x1F, 0x83, 0xE0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07,
  0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x38, 0x07, 0x03, 0xC1, 0xF0, 0x38, 0x00,
  0x00, 0x01, 0x00, 0x0F, 0x00, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x38, 0x00, 0x08, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0x18, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0x00, 0x02, 0x00,
  0x00, 0x0F, 0xE0, 0xFF, 0x84, 0x1E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xCF, 0x01,
  0xC0, 0x70, 0x70, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xE0, 0x07, 0x38,
  0x1F, 0xE7, 0x0F, 0xF8, 0xE3, 0xC7, 0x38, 0xE0, 0xE7, 0x1C, 0x1C, 0xE7,
  0x03, 0x1C, 0xE0, 0xE3, 0x1C, 0x1C, 0xE3, 0x83, 0x9C, 0x70, 0x63, 0x8E,
  0x1C, 0x70, 0xE3, 0x8E, 0x1F, 0xF0, 0xC1, 0xFC, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1B,
  0x80, 0x0E, 0x60, 0x07, 0x18, 0x01, 0x86, 0x00, 0xE1, 0xC0, 0x30, 0x70,
  0x1C, 0x1C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x70, 0x60, 0x1C, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0x80, 0x1C, 0xE0, 0x03, 0x30, 0x00,
  0xDC, 0x00, 0x76, 0x00, 0x1F, 0x80, 0x03, 0x01, 0xFC, 0x00, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0x80, 0x30, 0xE0, 0x0C, 0x38,
  0x07, 0x0E, 0x01, 0x83, 0x00, 0xE1, 0xC7, 0xF0, 0x7F, 0xF0, 0x1F, 0xFE,
  0x06, 0x01, 0xC1, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8C, 0x00, 0xE3,
  0x00, 0x39, 0xC0, 0x1C, 0x70, 0x0F, 0x18, 0x0F, 0x87, 0xFF, 0x83, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x0F, 0x8F, 0x03, 0x80, 0x40, 0xE0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x30, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0x00,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x18, 0x1E, 0x06, 0x03,
  0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x30, 0x03, 0x0C, 0x00, 0xC7, 0x00, 0x31,
  0xC0, 0x0C, 0x70, 0x03, 0x18, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x0E, 0x30, 0x03, 0x9C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x38, 0x60, 0x3C,
  0x38, 0x3E, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x83, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0xFF, 0x87, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x04, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x7C, 0x38, 0x3C, 0x02, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x01, 0x8C, 0x00, 0xE3, 0x00,
  0x38, 0xC0, 0x0E, 0x30, 0x03, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xF0, 0x1C,
  0x1E, 0x06, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x30, 0x70, 0x03, 0x07, 0x00, 0x70, 0x70, 0x07, 0x06, 0x00, 0x60, 0xE0,
  0x06, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0C, 0x00, 0xE1, 0xC0, 0x0C, 0x1C,
  0x01, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0x80, 0x18, 0x38, 0x03, 0x83,
  0x80, 0x38, 0x30, 0x03, 0x83, 0x00, 0x30, 0x70, 0x07, 0x07, 0x00, 0x70,
  0x70, 0x07, 0x06, 0x00, 0x60, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x03, 0xFF, 0xC1, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x04, 0x03, 0x80, 0xE0, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x78, 0x18, 0x07, 0x80, 0xC0, 0x78, 0x0E, 0x07, 0x80,
  0x70, 0x78, 0x03, 0x87, 0x80, 0x18, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x70,
  0x00, 0x77, 0x00, 0x03, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E,
  0xE0, 0x00, 0x63, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC1, 0xC0,
  0x0C, 0x07, 0x00, 0x60, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0x80,
  0x1C, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x38, 0x07, 0x01,
  0xC0, 0x78, 0x1C, 0x03, 0xC1, 0xE0, 0x36, 0x0F, 0x01, 0xB0, 0xD8, 0x0D,
  0x86, 0xC0, 0xEC, 0x66, 0x06, 0x63, 0x70, 0x33, 0x33, 0x03, 0x9B, 0x18,
  0x18, 0xD8, 0xC0, 0xC7, 0x86, 0x0E, 0x3C, 0x70, 0x71, 0xC3, 0x83, 0x00,
  0x18, 0x18, 0x00, 0xC1, 0xC0, 0x0E, 0x0C, 0x00, 0x70, 0x60, 0x03, 0x87,
  0x00, 0x18, 0x38, 0x00, 0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x1C, 0x01, 0x81, 0xE0, 0x0C, 0x0F, 0x80, 0xE0, 0x7C, 0x07, 0x03,
  0x60, 0x30, 0x3B, 0x81, 0x81, 0xDC, 0x1C, 0x0C, 0x60, 0xE0, 0x63, 0x06,
  0x03, 0x1C, 0x30, 0x38, 0xE3, 0x81, 0x83, 0x1C, 0x0C, 0x18, 0xC0, 0x60,
  0xE6, 0x07, 0x07, 0x70, 0x38, 0x1B, 0x81, 0x80, 0xD8, 0x0C, 0x06, 0xC0,
  0xE0, 0x36, 0x07, 0x01, 0xF0, 0x30, 0x07, 0x81, 0x80, 0x38, 0x1C, 0x01,
  0xC0, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xE3, 0xC1, 0xC0, 0x71, 0xC0, 0x38,
  0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xD8, 0x00,
  0xEC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1B, 0x80, 0x1D, 0xC0, 0x0E, 0xC0,
  0x06, 0x70, 0x07, 0x38, 0x03, 0x1C, 0x03, 0x8E, 0x03, 0x83, 0x83, 0x81,
  0xFF, 0x80, 0x7F, 0x80, 0x06, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0,
  0x79, 0xF8, 0x18, 0x0F, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x30,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0x61, 0xC0, 0x38, 0x60, 0x1C, 0x18, 0x3E,
  0x0F, 0xFF, 0x03, 0xFE, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xE3, 0xC1, 0xC0, 0x71, 0xC0, 0x38,
  0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xD8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1B, 0x80, 0x1D, 0xC0, 0x0E, 0xC0,
  0x06, 0x70, 0x07, 0x38, 0x03, 0x1C, 0x03, 0x8E, 0x03, 0x83, 0x83, 0x81,
  0xFF, 0x80, 0x7F, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x03, 0x80, 0xE0, 0x70, 0x0C, 0x0C, 0x01, 0xC1, 0x80, 0x38, 0x70, 0x06,
  0x0E, 0x00, 0xC1, 0xC0, 0x38, 0x30, 0x0E, 0x0E, 0x03, 0xC1, 0xFF, 0xE0,
  0x3F, 0xF8, 0x07, 0xFC, 0x01, 0xC1, 0xC0, 0x38, 0x18, 0x07, 0x03, 0x80,
  0xC0, 0x70, 0x38, 0x06, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x18, 0x03, 0x87,
  0x00, 0x38, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3E, 0x3C, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x18, 0x0F, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0xC7, 0x00, 0x31, 0xC0, 0x1C, 0x70, 0x07, 0x18, 0x01, 0xC6, 0x00,
  0x63, 0x80, 0x38, 0xE0, 0x0E, 0x30, 0x03, 0x8C, 0x00, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0x70, 0x07, 0x18, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0,
  0x0E, 0x38, 0x03, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x38, 0x1C, 0x1E,
  0x07, 0xFF, 0x00, 0xFF, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x01, 0xF8, 0x00,
  0xEE, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8E, 0x00, 0xE3,
  0x80, 0x70, 0xE0, 0x1C, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x81, 0xC0, 0xE0,
  0x60, 0x38, 0x38, 0x0E, 0x0C, 0x01, 0x87, 0x00, 0x61, 0x80, 0x18, 0xE0,
  0x06, 0x70, 0x01, 0x9C, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x30, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x06,
  0x1C, 0x00, 0x61, 0x80, 0x0E, 0x18, 0x00, 0xE1, 0x80, 0x0C, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x30, 0xE1, 0x83, 0x1E, 0x18, 0x31, 0xE3, 0x87, 0x36,
  0x30, 0x73, 0x63, 0x06, 0x63, 0x30, 0x66, 0x36, 0x06, 0xC3, 0x60, 0x7C,
  0x36, 0x05, 0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x07,
  0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x39,
  0xC0, 0x00, 0x77, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x00,
  0x03, 0xC6, 0x00, 0x0F, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x18, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x70, 0x1E, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0xE0,
  0x01, 0xF8, 0x00, 0x76, 0x00, 0x39, 0x80, 0x1C, 0x70, 0x07, 0x1C, 0x03,
  0x87, 0x01, 0xC0, 0xC0, 0x60, 0x38, 0x38, 0x0E, 0x1C, 0x01, 0x8E, 0x00,
  0x63, 0x00, 0x1D, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x10,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0xE7, 0x39, 0xCE, 0x73, 0x8C, 0x63, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE3, 0x18, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x38, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x60, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3B, 0x80, 0xE3, 0x03, 0x86, 0x0E, 0x0E, 0x1C, 0x0C,
  0x70, 0x19, 0xC0, 0x3F, 0x00, 0x74, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x63, 0x87, 0x0E, 0x38, 0x70, 0x80, 0x00, 0x7F, 0x01, 0xFF, 0xC1,
  0xF0, 0xE1, 0xE0, 0x61, 0xC0, 0x31, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x0C,
  0x70, 0x0E, 0x30, 0x07, 0x38, 0x03, 0x9C, 0x01, 0x8E, 0x00, 0xC7, 0x00,
  0xE1, 0xC0, 0x70, 0xE0, 0xF8, 0x3F, 0xFC, 0x0F, 0xE6, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0xFC, 0x07, 0xFF, 0x03, 0xE3, 0xC1, 0x80, 0xE1,
  0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x30, 0x07, 0x38, 0x03, 0x9C, 0x01,
  0x8C, 0x01, 0xC6, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0xF1, 0xC0, 0xF0, 0xC1,
  0xF0, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC3, 0xE0,
  0xC3, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x18, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0x1C, 0x0F,
  0x03, 0x83, 0xC0, 0x70, 0x70, 0x0C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0xE0,
  0x0E, 0x1C, 0x01, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0,
  0x30, 0x38, 0x0E, 0x07, 0x83, 0xC0, 0x7F, 0xF8, 0x07, 0xF3, 0x80, 0x00,
  0xFC, 0x07, 0xFE, 0x0F, 0x8F, 0x1E, 0x03, 0x3C, 0x03, 0x38, 0x03, 0x70,
  0x07, 0x70, 0x0F, 0x60, 0xFE, 0xFF, 0xF8, 0xFF, 0x80, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x0C, 0x3F, 0xFC, 0x1F, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xFC, 0x0F, 0xC3, 0x03, 0xC0,
  0xE0, 0x70, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0x60, 0xE0, 0x1C, 0x18, 0x03,
  0x87, 0x00, 0x70, 0xE0, 0x0C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E,
  0x0F, 0x07, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x03, 0x81, 0x80, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0xFC, 0x0F, 0xFE, 0x0F, 0x1F, 0x0C, 0x07,
  0x0C, 0x03, 0x1C, 0x03, 0x1C, 0x03, 0x1C, 0x03, 0x18, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x06, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C,
  0x60, 0x1C, 0xE0, 0x1C, 0x03, 0x81, 0xF0, 0x7C, 0x1E, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x3F, 0xCF, 0xF0, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0xC0, 0x78, 0x0F, 0xC1,
  0xF0, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x30, 0x38, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x01, 0xC3, 0x81, 0xE0,
  0xC0, 0xF0, 0x30, 0x78, 0x1C, 0x38, 0x07, 0x3C, 0x01, 0x9E, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0x9C, 0x00, 0xC3, 0x80, 0x70, 0xF0,
  0x1C, 0x1C, 0x07, 0x03, 0x81, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x03, 0x80,
  0xFF, 0x7F, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07,
  0x03, 0x80, 0xE1, 0x7F, 0x9F, 0xC0, 0x07, 0xE7, 0x83, 0xFF, 0xF0, 0xEF,
  0x9C, 0x71, 0xC3, 0x1C, 0x70, 0xC6, 0x1C, 0x71, 0x86, 0x1C, 0xE1, 0x87,
  0x38, 0xE1, 0x8C, 0x38, 0xE3, 0x0E, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x1C,
  0x00, 0xC6, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x06, 0x38, 0x03, 0x80, 0x03,
  0xF8, 0x0F, 0xFE, 0x0F, 0x1F, 0x0C, 0x07, 0x1C, 0x03, 0x1C, 0x03, 0x1C,
  0x03, 0x18, 0x03, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x06, 0x30,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0C, 0x60, 0x1C, 0xE0, 0x1C, 0x01,
  0xF8, 0x07, 0xFC, 0x1F, 0xBE, 0x1C, 0x0E, 0x38, 0x07, 0x78, 0x07, 0x70,
  0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xF0, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0x1F, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x0E,
  0x01, 0xC1, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x18, 0x30,
  0x07, 0x06, 0x00, 0xE1, 0xC0, 0x38, 0x38, 0x0F, 0x07, 0x03, 0xC0, 0xC1,
  0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF,
  0x83, 0xE1, 0xC3, 0xC0, 0xE3, 0xC0, 0x71, 0xC0, 0x31, 0xC0, 0x38, 0xC0,
  0x1C, 0xE0, 0x0E, 0x70, 0x06, 0x38, 0x07, 0x18, 0x03, 0x8C, 0x01, 0xC7,
  0x00, 0xC3, 0x80, 0xE1, 0xE0, 0xF0, 0x7F, 0xF8, 0x1F, 0xD8, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xFF, 0x0F, 0xFF, 0x0F, 0x82, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x01,
  0xFF, 0x07, 0xFE, 0x0F, 0x8E, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x60, 0x78, 0xFF, 0xF0, 0x7F, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x20,
  0xFF, 0x81, 0xFE, 0x00, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x06,
  0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0xF8,
  0x7F, 0xD8, 0x3F, 0x98, 0xE0, 0x0F, 0xC0, 0x1B, 0x80, 0x77, 0x00, 0xCE,
  0x03, 0x9C, 0x07, 0x38, 0x1C, 0x70, 0x38, 0x60, 0xE0, 0xC1, 0xC1, 0x87,
  0x03, 0x8C, 0x07, 0x38, 0x0E, 0xE0, 0x1D, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xEE, 0x00, 0x19, 0x80, 0x07, 0x30, 0x00, 0xC6,
  0x00, 0x18, 0xC1, 0x87, 0x38, 0x70, 0xC7, 0x1E, 0x38, 0xE3, 0xC7, 0x1C,
  0xD8, 0xC3, 0x9B, 0x38, 0x76, 0x66, 0x0D, 0xCF, 0xC1, 0xB0, 0xF8, 0x3C,
  0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x00, 0x07, 0x00, 0x70,
  0x38, 0x0E, 0x03, 0x81, 0xC0, 0x1C, 0x38, 0x01, 0xC7, 0x80, 0x0E, 0x70,
  0x00, 0xEE, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1D, 0xC0, 0x03, 0x9C, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x01, 0xC0,
  0x70, 0x38, 0x07, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x06, 0x03,
  0x80, 0x38, 0x18, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x01,
  0x87, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0xB8, 0x00, 0x0D, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x21, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x87,
  0xFF, 0x83, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38,
  0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x08, 0x00, 0x3F, 0x03, 0x7F, 0x87, 0xE1, 0xFE, 0xC0, 0xFC, 0x00, 0x10,
};

const GFXglyph UbuntuSansMono_Italic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 9, 24, 19, 5, -24 },
  { 28, 10, 9, 19, 7, -26 },
  { 40, 20, 24, 19, 0, -24 },
  { 100, 18, 30, 19, 1, -26 },
  { 168, 22, 25, 19, -1, -24 },
  { 237, 16, 24, 19, 1, -24 },
  { 285, 5, 10, 19, 10, -26 },
  { 292, 14, 33, 19, 4, -27 },
  { 350, 14, 33, 19, 1, -27 },
  { 408, 14, 14, 19, 4, -24 },
  { 433, 16, 16, 19, 2, -18 },
  { 465, 8, 10, 19, 3, -5 },
  { 475, 8, 3, 19, 6, -11 },
  { 478, 6, 5, 19, 5, -5 },
  { 482, 21, 33, 19, -2, -27 },
  { 569, 16, 25, 19, 2, -24 },
  { 619, 14, 24, 19, 2, -24 },
  { 661, 17, 24, 19, 1, -24 },
  { 712, 17, 25, 19, 1, -24 },
  { 766, 17, 24, 19, 1, -24 },
  { 817, 19, 25, 19, 1, -24 },
  { 877, 17, 25, 19, 2, -24 },
  { 931, 17, 24, 19, 4, -24 },
  { 982, 17, 25, 19, 2, -24 },
  { 1036, 17, 24, 19, 2, -24 },
  { 1087, 9, 18, 19, 5, -18 },
  { 1108, 11, 23, 19, 3, -18 },
  { 1140, 16, 15, 19, 2, -17 },
  { 1170, 18, 10, 19, 1, -15 },
  { 1193, 17, 15, 19, 1, -17 },
  { 1225, 13, 24, 19, 5, -24 },
  { 1264, 19, 29, 19, 1, -24 },
  { 1333, 18, 24, 19, -2, -24 },
  { 1387, 18, 24, 19, 0, -24 },
  { 1441, 19, 25, 19, 2, -24 },
  { 1501, 18, 24, 19, 0, -24 },
  { 1555, 19, 24, 19, 1, -24 },
  { 1612, 19, 24, 19, 1, -24 },
  { 1669, 18, 25, 19, 2, -24 },
  { 1726, 20, 24, 19, 0, -24 },
  { 1786, 17, 24, 19, 2, -24 },
  { 1837, 19, 25, 19, 1, -24 },
  { 1897, 21, 24, 19, 0, -24 },
  { 1960, 13, 24, 19, 1, -24 },
  { 1999, 21, 24, 19, -1, -24 },
  { 2062, 21, 24, 19, 0, -24 },
  { 2125, 17, 25, 19, 2, -24 },
  { 2179, 18, 24, 19, 1, -24 },
  { 2233, 17, 30, 19, 2, -24 },
  { 2297, 19, 24, 19, 0, -24 },
  { 2354, 18, 25, 19, 1, -24 },
  { 2411, 16, 24, 19, 5, -24 },
  { 2459, 18, 25, 19, 2, -24 },
  { 2516, 18, 24, 19, 4, -24 },
  { 2570, 20, 24, 19, 1, -24 },
  { 2630, 23, 24, 19, -1, -24 },
  { 2699, 18, 24, 19, 4, -24 },
  { 2753, 20, 24, 19, 0, -24 },
  { 2813, 17, 33, 19, 2, -27 },
  { 2884, 5, 33, 19, 7, -27 },
  { 2905, 16, 33, 19, 0, -27 },
  { 2971, 15, 13, 19, 3, -24 },
  { 2996, 17, 2, 19, -2, 4 },
  { 3001, 6, 7, 19, 9, -26 },
  { 3007, 17, 18, 19, 1, -18 },
  { 3046, 17, 26, 19, 1, -26 },
  { 3102, 17, 18, 19, 1, -18 },
  { 3141, 19, 26, 19, 2, -26 },
  { 3203, 16, 18, 19, 1, -18 },
  { 3239, 22, 32, 19, -1, -26 },
  { 3327, 19, 24, 19, 0, -18 },
  { 3384, 16, 26, 19, 0, -26 },
  { 3436, 10, 26, 19, 4, -26 },
  { 3469, 18, 32, 19, 0, -26 },
  { 3541, 18, 26, 19, 1, -26 },
  { 3600, 9, 26, 19, 6, -26 },
  { 3630, 18, 18, 19, 0, -18 },
  { 3671, 16, 18, 19, 1, -18 },
  { 3707, 16, 18, 19, 2, -18 },
  { 3743, 19, 24, 19, -1, -18 },
  { 3800, 17, 24, 19, 2, -18 },
  { 3851, 16, 18, 19, 2, -18 },
  { 3887, 16, 18, 19, 2, -18 },
  { 3923, 14, 23, 19, 4, -23 },
  { 3964, 16, 18, 19, 2, -18 },
  { 4000, 15, 18, 19, 4, -18 },
  { 4034, 19, 18, 19, 2, -18 },
  { 4077, 20, 18, 19, -1, -18 },
  { 4122, 21, 24, 19, -2, -18 },
  { 4185, 17, 18, 19, 1, -18 },
  { 4224, 18, 33, 19, 2, -27 },
  { 4299, 10, 33, 19, 5, -27 },
  { 4341, 18, 33, 19, -1, -27 },
  { 4416, 16, 6, 19, 2, -13 },
};

const GFXfont UbuntuSansMono_Italic34pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic34pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic34pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _UBUNTUSANSMONO_ITALIC34PT7B_H_
