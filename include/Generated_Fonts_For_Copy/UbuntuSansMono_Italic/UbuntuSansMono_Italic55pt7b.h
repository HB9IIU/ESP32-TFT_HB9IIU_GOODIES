#ifndef _UBUNTUSANSMONO_ITALIC55PT7B_H_
#define _UBUNTUSANSMONO_ITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0x00, 0x00, 0x1C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1C,
  0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0xF0, 0x38, 0xE0, 0x38, 0xE0, 0x30,
  0xC0, 0x30, 0xC0, 0x70, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x7C, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF9, 0xFC, 0x00, 0xF8, 0x00,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x03, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xC0, 0x1F, 0xF8, 0x00, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0xC0, 0x0E, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x07, 0x03, 0xC0, 0x3C, 0x00,
  0x38, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x83,
  0xC0, 0x00, 0xE0, 0x38, 0x3E, 0x00, 0x07, 0x01, 0xC1, 0xE0, 0x00, 0x38,
  0x1E, 0x1E, 0x00, 0x01, 0xC0, 0xF1, 0xE0, 0x00, 0x0F, 0x0F, 0x1E, 0x00,
  0x00, 0x78, 0x79, 0xE0, 0x00, 0x01, 0xFF, 0x9E, 0x00, 0x00, 0x0F, 0xF9,
  0xF0, 0x00, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF1, 0xFC, 0x00, 0x00, 0x0F, 0x1F,
  0xF0, 0x00, 0x00, 0xF1, 0xFF, 0x80, 0x00, 0x0F, 0x9E, 0x1E, 0x00, 0x00,
  0x78, 0xE0, 0xF0, 0x00, 0x07, 0x8F, 0x07, 0x80, 0x00, 0x78, 0x70, 0x3C,
  0x00, 0x07, 0x83, 0x81, 0xE0, 0x00, 0x78, 0x3C, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x1C, 0x00,
  0x3C, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xC0, 0x07, 0xCF, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x03, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x01, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0x3C, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x7C, 0x00,
  0xF0, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE7, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x20, 0x07, 0xF8,
  0x0F, 0x03, 0xFF, 0x03, 0xC1, 0xF7, 0xC0, 0xE0, 0xF8, 0xF8, 0x78, 0x7C,
  0x1E, 0x1E, 0x3E, 0x07, 0xCF, 0x0F, 0x00, 0xFB, 0xC7, 0xC0, 0x1E, 0xF1,
  0xF0, 0x07, 0xF8, 0x78, 0x00, 0xFE, 0x1E, 0x00, 0x3F, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x7F, 0x87, 0xC0,
  0x7F, 0xE1, 0xFE, 0x7F, 0x78, 0x3F, 0xFF, 0x1F, 0x07, 0xFF, 0x87, 0xC0,
  0xFF, 0x80, 0xF0, 0x02, 0x00, 0x00, 0x3E, 0x7C, 0xF1, 0xE7, 0xCF, 0x9E,
  0x3C, 0x79, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x30, 0x3C, 0x0E, 0x7C,
  0x1C, 0x3E, 0x7F, 0x9C, 0xFE, 0x7F, 0xFB, 0xFE, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF7, 0x80, 0x01,
  0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC1, 0xF0, 0x1F,
  0x81, 0xF8, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0x7F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x0F, 0xC1, 0xFC, 0x7F, 0xC1, 0xF8,
  0x0F, 0x00, 0x40, 0x00, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0x3C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x38, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xE0, 0xFC, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF9, 0xF0, 0x70, 0x1E,
  0x3E, 0x1F, 0x83, 0xC7, 0x87, 0xF0, 0x79, 0xF0, 0xFE, 0x1F, 0x3E, 0x1F,
  0xC3, 0xE7, 0xC3, 0xF8, 0x7C, 0xF0, 0x7F, 0x0F, 0x1E, 0x07, 0xC3, 0xE7,
  0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x0F, 0x00, 0x7E,
  0x01, 0xF0, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xF9, 0xF0, 0x0F, 0x87,
  0x80, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x0E, 0x00, 0x3E, 0x00, 0x40, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0x80, 0xFC, 0x00, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0x80, 0x03, 0xF0, 0x3F, 0x03, 0xFE,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7C,
  0x78, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xE0,
  0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xE0,
  0x1F, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x07, 0xC0,
  0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x01, 0x00, 0x07, 0xF0, 0x07, 0x80,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF1, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0x80,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x7C, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x3E,
  0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x3C,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xF0, 0x1F, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7E, 0x3F, 0xC0, 0x0F, 0x80, 0xFE, 0x01,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFC, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0,
  0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F,
  0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x01, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xF7, 0x80, 0x03, 0xF0, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0xFF,
  0x83, 0xFC, 0x1F, 0xC0, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81,
  0xFC, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x07, 0xE0, 0x01, 0xE0,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x40, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xF8,
  0x01, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0xF0, 0x7E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0xFF, 0xF1, 0xF0, 0x0F, 0xFF, 0x87,
  0xC0, 0x7F, 0xFE, 0x1E, 0x07, 0xF0, 0xF8, 0xF8, 0x3F, 0x03, 0xE3, 0xE0,
  0xF8, 0x0F, 0x0F, 0x07, 0xC0, 0x3C, 0x7C, 0x1E, 0x00, 0xF1, 0xF0, 0xF8,
  0x07, 0xC7, 0xC3, 0xC0, 0x1E, 0x1E, 0x0F, 0x00, 0x78, 0x78, 0x7C, 0x01,
  0xE3, 0xE1, 0xF0, 0x0F, 0x8F, 0x87, 0xC0, 0x3E, 0x3E, 0x1F, 0x00, 0xF0,
  0xF8, 0x7C, 0x03, 0xC3, 0xE0, 0xF0, 0x1F, 0x0F, 0x83, 0xC0, 0x7C, 0x3E,
  0x0F, 0x81, 0xE0, 0xF8, 0x1F, 0x8F, 0x83, 0xE0, 0x3F, 0xFE, 0x07, 0x80,
  0x7F, 0xF8, 0x1E, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xE0,
  0x3C, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x3C, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x40, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0xFF,
  0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x3C, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0x80,
  0x1F, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x3F,
  0x81, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0xF8, 0x03,
  0xF0, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x80, 0x07, 0xF0, 0x1F, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xF0, 0x3F, 0xE0, 0x03, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xE0,
  0x1E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C, 0x0F,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x3F, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0x80, 0x3F, 0xC0, 0x1F, 0xDF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xF0, 0x0F, 0x00, 0x7E, 0x00, 0x10, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0,
  0x0F, 0x80, 0x0F, 0x00, 0x7F, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x1F,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x03,
  0xC0, 0x1F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x00,
  0x01, 0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x20, 0x00, 0xF8, 0x00,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x01, 0xE0, 0x3F, 0x00,
  0x00, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x3C, 0x3E, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x0F, 0x7E, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x1F,
  0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xF0,
  0x03, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFE,
  0x01, 0xDC, 0x00, 0xFF, 0x01, 0xEE, 0x00, 0x77, 0x80, 0xEF, 0x00, 0x3B,
  0xC0, 0xF7, 0x80, 0x3C, 0xE0, 0x73, 0x80, 0x1C, 0x70, 0x79, 0xC0, 0x0E,
  0x38, 0x38, 0xE0, 0x0F, 0x1C, 0x38, 0xF0, 0x07, 0x8E, 0x3C, 0x78, 0x03,
  0x87, 0x9C, 0x3C, 0x03, 0xC3, 0xDE, 0x1C, 0x01, 0xE1, 0xEE, 0x1E, 0x00,
  0xF0, 0xFF, 0x0F, 0x00, 0xF0, 0x7F, 0x07, 0x80, 0x78, 0x3F, 0x03, 0xC0,
  0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x1E, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x3F, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x01, 0xE0, 0x0F,
  0xC0, 0x01, 0xE0, 0x07, 0xF0, 0x00, 0xF0, 0x07, 0xF8, 0x00, 0x78, 0x03,
  0xFC, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0xE7, 0x80, 0x1E, 0x00,
  0xF3, 0xC0, 0x0F, 0x00, 0x79, 0xE0, 0x07, 0x80, 0x3C, 0x78, 0x07, 0x80,
  0x1C, 0x3C, 0x03, 0xC0, 0x1E, 0x1E, 0x01, 0xE0, 0x0F, 0x0F, 0x00, 0xF0,
  0x07, 0x83, 0xC0, 0x78, 0x03, 0x81, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x3C,
  0x01, 0xE0, 0x38, 0x1E, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x78, 0x0F, 0x0F,
  0x00, 0x78, 0x07, 0x87, 0x80, 0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x00, 0xE1,
  0xE0, 0x0F, 0x00, 0x79, 0xE0, 0x0F, 0x00, 0x3C, 0xF0, 0x07, 0x80, 0x1E,
  0x78, 0x03, 0xC0, 0x07, 0x3C, 0x01, 0xE0, 0x03, 0xBC, 0x01, 0xE0, 0x01,
  0xFE, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x3C, 0x00,
  0x3F, 0x80, 0x1C, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x07, 0xE0, 0x0F, 0x00,
  0x03, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x01, 0xE0, 0x01, 0xE0,
  0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xF8,
  0x07, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF0, 0x1F,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0x80,
  0x7F, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x01, 0xE0, 0x01, 0xE0, 0x3E,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x03, 0xF0, 0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0xFF, 0x00, 0x78, 0x00, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xF0, 0x1F,
  0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x80,
  0x07, 0x80, 0x3C, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0x78, 0x00,
  0x3C, 0x03, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3C,
  0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x78, 0x01, 0xF0, 0x00, 0x20, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x03, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78,
  0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x3E,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x3F, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x3E,
  0x7C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xF0,
  0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01,
  0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xF0,
  0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x0F, 0xC0, 0xF0, 0x1C, 0x0F, 0xC1, 0xE0,
  0x3C, 0x1F, 0xC1, 0xE0, 0x3C, 0x1D, 0xC1, 0xE0, 0x3C, 0x3D, 0xC1, 0xC0,
  0x3C, 0x79, 0xC3, 0xC0, 0x38, 0x71, 0xC3, 0xC0, 0x38, 0xF1, 0xC3, 0x80,
  0x78, 0xE1, 0xC7, 0x80, 0x79, 0xE1, 0xC7, 0x80, 0x79, 0xC1, 0xE7, 0x00,
  0x73, 0xC1, 0xE7, 0x00, 0x77, 0x81, 0xEF, 0x00, 0x77, 0x81, 0xEE, 0x00,
  0x7F, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xBC, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x7C, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1E,
  0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x01, 0xF0, 0x01,
  0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0,
  0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x04, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78,
  0x01, 0xF0, 0x78, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x3C,
  0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x0E,
  0xF8, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x30, 0x00, 0x04, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0,
  0x10, 0x0E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x38, 0x04, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xC0, 0x3C, 0x07, 0xE0, 0x07, 0x81,
  0xF8, 0x00, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0x83, 0xE0, 0x00,
  0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF0, 0xF8,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1E,
  0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xDF, 0x00, 0xFF, 0xE1, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x79, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xC0,
  0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x7C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07, 0x80,
  0x07, 0xE0, 0xF0, 0x03, 0xF8, 0x1E, 0x00, 0xFE, 0x03, 0xC1, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xC7, 0xE0, 0x3F, 0x80, 0x08, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x04, 0x07, 0xF0, 0x07, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xBF, 0x00, 0x1F, 0xC0, 0x3C, 0x01, 0xFC, 0x00, 0xF0, 0x07,
  0xC0, 0x07, 0x80, 0x3E, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x78,
  0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x3C, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0x1F, 0x81,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0xF0, 0x00, 0xFF, 0xE3,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x07, 0xC1, 0xF8, 0x00,
  0xF0, 0xFC, 0x00, 0x3C, 0x7E, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xCF, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x9E,
  0x00, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0x3F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x0C, 0x0F, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x40, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x06,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFC,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x7E, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xE0,
  0x1F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xDE, 0x00, 0x03, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x40, 0x00, 0xF8, 0x00, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x7F,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7D, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07,
  0x80, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0xF8,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C,
  0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x40, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x7E, 0x3F,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x20, 0x7C, 0x00, 0x7E, 0x03,
  0xC0, 0x07, 0xE0, 0x1E, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0xFC, 0x00, 0x78, 0x0F, 0xC0, 0x03, 0xC0, 0xFC, 0x00, 0x1E, 0x1F, 0x80,
  0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x3F, 0x80, 0x00, 0x7B, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x3F,
  0x00, 0x00, 0x78, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F,
  0x80, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x01, 0x3E, 0x06, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFE, 0x02, 0xD0, 0x00, 0x7F, 0x87, 0xE0, 0x0F, 0xFF, 0x7F, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0x81, 0xF0, 0x78, 0x1E, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3E, 0x07, 0x81, 0xE0, 0xF0, 0x3E, 0x07, 0x83, 0xC0, 0xF0, 0x3E,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x7C, 0x0F, 0x07,
  0x81, 0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xC0, 0x1F, 0x80, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x87,
  0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x1F,
  0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x03, 0xE0, 0xF8,
  0x00, 0x78, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xBC, 0x00,
  0x03, 0xEF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0x3C,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0x7C, 0x03, 0xF8,
  0x1F, 0xE7, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0,
  0x3E, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0xFC, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0x00, 0x7F, 0x00, 0x7E, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xC0,
  0x3C, 0x0F, 0xE0, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x1F,
  0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0x00, 0x30, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x20, 0x00,
  0xF8, 0x3E, 0x01, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x00, 0x17, 0x80, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x40,
  0xFC, 0x0F, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x3E, 0x00,
  0x1E, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x0F, 0xE0, 0x7E, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xF3, 0xC0, 0x3F, 0xF0, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x7C, 0x01,
  0xE0, 0x7C, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x0F,
  0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x3C,
  0x00, 0x3E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x0F, 0x1E, 0x01, 0xC0, 0x78, 0x78, 0x0F, 0x01, 0xE1, 0xE0,
  0x3C, 0x07, 0x87, 0x81, 0xF0, 0x3C, 0x1E, 0x0F, 0xC0, 0xF0, 0x78, 0x3F,
  0x87, 0x81, 0xE1, 0xFE, 0x1E, 0x07, 0x87, 0x78, 0x78, 0x3E, 0x3D, 0xE3,
  0xC0, 0xF1, 0xE7, 0x8F, 0x03, 0xC7, 0x0E, 0x78, 0x0F, 0x3C, 0x39, 0xE0,
  0x3C, 0xE0, 0xE7, 0x80, 0xF7, 0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0,
  0x1E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x3F, 0x00, 0x07, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0xC0, 0x0F,
  0x00, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x1F, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x20, 0x1F, 0x80, 0x00, 0x1C, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x01, 0x87, 0xFE, 0x00, 0xF3, 0xFF, 0xE0, 0x3D, 0xF1, 0xFC, 0x1E,
  0x78, 0x1F, 0xFF, 0x3C, 0x03, 0xFF, 0xCF, 0x00, 0x3F, 0xE0, 0x80, 0x07,
  0xE0,
};

const GFXglyph UbuntuSansMono_Italic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 14, 39, 31, 9, -38 },
  { 70, 16, 15, 31, 12, -42 },
  { 100, 33, 38, 31, 0, -38 },
  { 257, 29, 49, 31, 2, -43 },
  { 435, 37, 40, 31, -2, -39 },
  { 620, 26, 40, 31, 1, -39 },
  { 750, 7, 16, 31, 17, -42 },
  { 764, 23, 53, 31, 7, -43 },
  { 917, 23, 53, 31, 1, -43 },
  { 1070, 24, 22, 31, 6, -38 },
  { 1136, 26, 27, 31, 3, -30 },
  { 1224, 13, 17, 31, 4, -8 },
  { 1252, 14, 4, 31, 9, -18 },
  { 1259, 8, 9, 31, 9, -8 },
  { 1268, 34, 53, 31, -3, -43 },
  { 1494, 27, 40, 31, 3, -39 },
  { 1629, 22, 38, 31, 4, -38 },
  { 1734, 28, 39, 31, 2, -39 },
  { 1871, 27, 40, 31, 2, -39 },
  { 2006, 28, 38, 31, 1, -38 },
  { 2139, 30, 39, 31, 2, -38 },
  { 2286, 27, 39, 31, 4, -38 },
  { 2418, 27, 38, 31, 7, -38 },
  { 2547, 28, 40, 31, 3, -39 },
  { 2687, 28, 39, 31, 3, -39 },
  { 2824, 13, 29, 31, 9, -28 },
  { 2872, 18, 37, 31, 4, -28 },
  { 2956, 27, 24, 31, 2, -28 },
  { 3037, 28, 16, 31, 2, -24 },
  { 3093, 27, 24, 31, 1, -28 },
  { 3174, 21, 40, 31, 8, -39 },
  { 3279, 30, 47, 31, 2, -39 },
  { 3456, 29, 38, 31, -3, -38 },
  { 3594, 29, 39, 31, 1, -39 },
  { 3736, 30, 40, 31, 3, -39 },
  { 3886, 30, 39, 31, 0, -39 },
  { 4033, 31, 38, 31, 2, -38 },
  { 4181, 31, 38, 31, 2, -38 },
  { 4329, 29, 40, 31, 3, -39 },
  { 4474, 33, 38, 31, 0, -38 },
  { 4631, 27, 38, 31, 3, -38 },
  { 4760, 30, 39, 31, 2, -38 },
  { 4907, 33, 38, 31, 1, -38 },
  { 5064, 22, 38, 31, 1, -38 },
  { 5169, 33, 38, 31, -1, -38 },
  { 5326, 33, 38, 31, 0, -38 },
  { 5483, 28, 40, 31, 3, -39 },
  { 5623, 30, 39, 31, 1, -39 },
  { 5770, 28, 49, 31, 3, -39 },
  { 5942, 29, 39, 31, 1, -39 },
  { 6084, 30, 40, 31, 1, -39 },
  { 6234, 27, 38, 31, 7, -38 },
  { 6363, 30, 39, 31, 3, -38 },
  { 6510, 29, 38, 31, 6, -38 },
  { 6648, 32, 38, 31, 2, -38 },
  { 6800, 37, 38, 31, -2, -38 },
  { 6976, 29, 38, 31, 7, -38 },
  { 7114, 33, 38, 31, 0, -38 },
  { 7271, 27, 53, 31, 4, -43 },
  { 7450, 9, 53, 31, 11, -43 },
  { 7510, 27, 53, 31, -1, -43 },
  { 7689, 24, 20, 31, 5, -38 },
  { 7749, 29, 4, 31, -4, 6 },
  { 7764, 10, 12, 31, 14, -43 },
  { 7779, 27, 30, 31, 2, -29 },
  { 7881, 27, 44, 31, 2, -43 },
  { 8030, 27, 30, 31, 2, -29 },
  { 8132, 30, 44, 31, 3, -43 },
  { 8297, 26, 30, 31, 2, -29 },
  { 8395, 36, 53, 31, -1, -43 },
  { 8634, 31, 39, 31, -1, -29 },
  { 8786, 27, 43, 31, 0, -43 },
  { 8932, 17, 42, 31, 6, -42 },
  { 9022, 30, 52, 31, -1, -42 },
  { 9217, 29, 43, 31, 2, -43 },
  { 9373, 16, 43, 31, 9, -42 },
  { 9459, 30, 29, 31, 0, -29 },
  { 9568, 26, 29, 31, 2, -29 },
  { 9663, 26, 30, 31, 3, -29 },
  { 9761, 30, 39, 31, -1, -29 },
  { 9908, 27, 39, 31, 3, -29 },
  { 10040, 26, 29, 31, 4, -29 },
  { 10135, 25, 30, 31, 3, -29 },
  { 10229, 22, 38, 31, 7, -37 },
  { 10334, 26, 29, 31, 3, -28 },
  { 10429, 24, 28, 31, 6, -28 },
  { 10513, 30, 28, 31, 3, -28 },
  { 10618, 32, 28, 31, -1, -28 },
  { 10730, 33, 38, 31, -3, -28 },
  { 10887, 28, 28, 31, 1, -28 },
  { 10985, 30, 53, 31, 3, -43 },
  { 11184, 16, 53, 31, 8, -43 },
  { 11290, 29, 53, 31, -2, -43 },
  { 11483, 26, 8, 31, 3, -20 },
};

const GFXfont UbuntuSansMono_Italic55pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic55pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic55pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _UBUNTUSANSMONO_ITALIC55PT7B_H_
