#ifndef _UBUNTUSANSMONO_ITALIC11PT7B_H_
#define _UBUNTUSANSMONO_ITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0x04, 0x7A, 0xA0, 0x12, 0x29, 0xF1, 0x44, 0x9F, 0x94,
  0x50, 0x08, 0x23, 0x48, 0x20, 0x60, 0x82, 0xF0, 0x80, 0x22, 0xA9, 0x63,
  0x81, 0x86, 0x95, 0x4C, 0x19, 0x4A, 0x66, 0xCE, 0x2F, 0x68, 0x08, 0x88,
  0x84, 0x22, 0x10, 0x42, 0x08, 0x10, 0x82, 0x10, 0x84, 0x22, 0x23, 0x20,
  0x21, 0x3E, 0xA5, 0x00, 0x21, 0x3E, 0x44, 0x00, 0x56, 0xE0, 0xC0, 0x02,
  0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x20, 0x83, 0x00, 0x32, 0x63, 0x5A,
  0xCA, 0x5C, 0x13, 0x52, 0x22, 0x2F, 0x18, 0x90, 0x43, 0x10, 0x84, 0x3E,
  0x38, 0x10, 0x46, 0x28, 0x20, 0xBC, 0x04, 0x21, 0x8A, 0x4B, 0xE1, 0x04,
  0x1C, 0x82, 0x0C, 0x08, 0x20, 0xBC, 0x09, 0x91, 0xE8, 0xC6, 0x5E, 0x7C,
  0x21, 0x04, 0x21, 0x04, 0x20, 0x32, 0x52, 0xA7, 0x4A, 0x5E, 0x32, 0x63,
  0x17, 0x88, 0xD8, 0x50, 0xA0, 0x24, 0x04, 0x94, 0x04, 0x66, 0x38, 0x18,
  0x7C, 0x0F, 0x80, 0x40, 0xC0, 0xC6, 0xE0, 0x61, 0x12, 0x48, 0x08, 0x1C,
  0x94, 0x57, 0x66, 0x9B, 0x52, 0x40, 0xC0, 0x04, 0x31, 0x45, 0x24, 0xF4,
  0x71, 0x38, 0x94, 0x52, 0x79, 0x18, 0xBC, 0x3D, 0x08, 0x20, 0x82, 0x08,
  0x3C, 0x31, 0x34, 0x51, 0x46, 0x18, 0xBC, 0x3E, 0x40, 0x82, 0x07, 0x88,
  0x10, 0x7C, 0x3E, 0x40, 0x82, 0x07, 0x88, 0x10, 0x60, 0x3A, 0x21, 0x08,
  0xCA, 0x5E, 0x22, 0x89, 0x12, 0x27, 0xC9, 0x22, 0x44, 0x79, 0x08, 0x42,
  0x21, 0x1C, 0x1C, 0x10, 0x41, 0x08, 0x20, 0xBC, 0x26, 0x59, 0x63, 0x06,
  0x0A, 0x22, 0x44, 0x21, 0x10, 0x84, 0x21, 0x1F, 0x24, 0x96, 0xDB, 0x56,
  0x18, 0xA2, 0x22, 0x49, 0x52, 0xA5, 0x4A, 0xA2, 0x44, 0x32, 0x63, 0x18,
  0xC6, 0x5C, 0x38, 0x94, 0x51, 0x79, 0x04, 0x20, 0x32, 0x63, 0x18, 0xC6,
  0x5C, 0x41, 0x80, 0x38, 0x94, 0x51, 0x79, 0x48, 0xA2, 0x1C, 0x82, 0x08,
  0x18, 0x20, 0xBE, 0x7E, 0x82, 0x08, 0x21, 0x04, 0x10, 0x45, 0x28, 0xA2,
  0x8A, 0x49, 0x38, 0x86, 0x18, 0xA4, 0x92, 0x8A, 0x10, 0x42, 0x85, 0x12,
  0xA7, 0x57, 0x12, 0x44, 0x22, 0x48, 0x60, 0xC1, 0x05, 0x12, 0x44, 0x86,
  0x24, 0x94, 0x60, 0x84, 0x10, 0x3E, 0x08, 0x20, 0x82, 0x04, 0x10, 0x7C,
  0x39, 0x08, 0x84, 0x21, 0x08, 0x84, 0x38, 0xAA, 0x55, 0x54, 0x38, 0x42,
  0x11, 0x08, 0x42, 0x21, 0x38, 0x11, 0x95, 0x10, 0xFC, 0xA4, 0x1D, 0x94,
  0xA2, 0x89, 0xE0, 0x10, 0x82, 0x0E, 0x45, 0x14, 0x52, 0xF0, 0x3D, 0x04,
  0x20, 0x81, 0xE0, 0x04, 0x20, 0x8E, 0x4A, 0x29, 0x24, 0xF0, 0x39, 0x14,
  0xBC, 0x81, 0xE0, 0x06, 0x10, 0x41, 0xE1, 0x02, 0x08, 0x10, 0x20, 0x43,
  0x00, 0x1C, 0x94, 0x52, 0x49, 0xE0, 0xBC, 0x21, 0x08, 0xF4, 0xA5, 0x31,
  0x88, 0x20, 0xE2, 0x24, 0x43, 0x0C, 0x03, 0x82, 0x08, 0x21, 0x04, 0x13,
  0x80, 0x10, 0x82, 0x09, 0x49, 0xC7, 0x14, 0x88, 0xE9, 0x29, 0x27, 0x7D,
  0x55, 0x65, 0x8A, 0x20, 0x39, 0x14, 0x52, 0x4A, 0x20, 0x74, 0x63, 0x19,
  0x70, 0x39, 0x14, 0x51, 0x4B, 0xC8, 0x20, 0x3A, 0x63, 0x29, 0x78, 0x44,
  0x7A, 0x21, 0x08, 0x40, 0x3A, 0x10, 0x61, 0x70, 0x27, 0xD0, 0x84, 0x21,
  0xC0, 0x8C, 0x65, 0x29, 0x78, 0x8C, 0x65, 0x26, 0x20, 0x86, 0x2A, 0xBA,
  0xB2, 0x40, 0x44, 0xA3, 0x0C, 0x52, 0x20, 0x22, 0x44, 0x90, 0xA1, 0x83,
  0x04, 0x70, 0x3C, 0x21, 0x08, 0x43, 0xE0, 0x1C, 0x82, 0x08, 0x43, 0x04,
  0x10, 0x82, 0x0E, 0x00, 0x25, 0x24, 0x94, 0x92, 0x00, 0x30, 0x42, 0x21,
  0x04, 0x42, 0x21, 0x30, 0xEC, 0x80,
};

const GFXglyph UbuntuSansMono_Italic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 8, 6, 2, -8 },
  { 4, 4, 3, 6, 2, -8 },
  { 6, 7, 8, 6, 0, -8 },
  { 13, 6, 10, 6, 0, -9 },
  { 21, 7, 8, 6, 0, -8 },
  { 28, 5, 8, 6, 0, -8 },
  { 33, 2, 3, 6, 3, -8 },
  { 34, 5, 11, 6, 1, -9 },
  { 41, 5, 11, 6, 0, -9 },
  { 48, 5, 5, 6, 1, -8 },
  { 52, 5, 5, 6, 1, -6 },
  { 56, 2, 4, 6, 1, -2 },
  { 57, 3, 1, 6, 2, -4 },
  { 58, 1, 2, 6, 2, -2 },
  { 59, 7, 11, 6, -1, -9 },
  { 69, 5, 8, 6, 1, -8 },
  { 74, 4, 8, 6, 1, -8 },
  { 78, 6, 8, 6, 0, -8 },
  { 84, 6, 8, 6, 0, -8 },
  { 90, 6, 8, 6, 0, -8 },
  { 96, 6, 8, 6, 0, -8 },
  { 102, 5, 8, 6, 1, -8 },
  { 107, 6, 8, 6, 1, -8 },
  { 113, 5, 8, 6, 1, -8 },
  { 118, 5, 8, 6, 1, -8 },
  { 123, 2, 6, 6, 2, -6 },
  { 125, 3, 8, 6, 1, -6 },
  { 128, 6, 5, 6, 0, -6 },
  { 132, 6, 3, 6, 0, -5 },
  { 135, 6, 5, 6, 0, -6 },
  { 139, 4, 8, 6, 2, -8 },
  { 143, 6, 10, 6, 0, -8 },
  { 151, 6, 8, 6, -1, -8 },
  { 157, 6, 8, 6, 0, -8 },
  { 163, 6, 8, 6, 1, -8 },
  { 169, 6, 8, 6, 0, -8 },
  { 175, 7, 8, 6, 0, -8 },
  { 182, 7, 8, 6, 0, -8 },
  { 189, 5, 8, 6, 1, -8 },
  { 194, 7, 8, 6, 0, -8 },
  { 201, 5, 8, 6, 1, -8 },
  { 206, 6, 8, 6, 0, -8 },
  { 212, 7, 8, 6, 0, -8 },
  { 219, 5, 8, 6, 0, -8 },
  { 224, 6, 8, 6, 0, -8 },
  { 230, 7, 8, 6, 0, -8 },
  { 237, 5, 8, 6, 1, -8 },
  { 242, 6, 8, 6, 0, -8 },
  { 248, 5, 10, 6, 1, -8 },
  { 255, 6, 8, 6, 0, -8 },
  { 261, 6, 8, 6, 0, -8 },
  { 267, 6, 8, 6, 1, -8 },
  { 273, 6, 8, 6, 1, -8 },
  { 279, 6, 8, 6, 1, -8 },
  { 285, 7, 8, 6, 0, -8 },
  { 292, 7, 8, 6, 0, -8 },
  { 299, 6, 8, 6, 1, -8 },
  { 305, 7, 8, 6, 0, -8 },
  { 312, 5, 11, 6, 1, -9 },
  { 319, 2, 11, 6, 2, -9 },
  { 322, 5, 11, 6, 0, -9 },
  { 329, 5, 4, 6, 1, -8 },
  { 332, 6, 1, 6, -1, 1 },
  { 333, 2, 3, 6, 3, -9 },
  { 334, 6, 6, 6, 0, -6 },
  { 339, 6, 9, 6, 0, -9 },
  { 346, 6, 6, 6, 0, -6 },
  { 351, 6, 9, 6, 1, -9 },
  { 358, 6, 6, 6, 0, -6 },
  { 363, 7, 11, 6, 0, -9 },
  { 373, 6, 8, 6, 0, -6 },
  { 379, 5, 9, 6, 0, -9 },
  { 385, 4, 8, 6, 1, -8 },
  { 389, 6, 10, 6, 0, -8 },
  { 397, 6, 9, 6, 0, -9 },
  { 404, 3, 8, 6, 2, -8 },
  { 407, 6, 6, 6, 0, -6 },
  { 412, 6, 6, 6, 0, -6 },
  { 417, 5, 6, 6, 1, -6 },
  { 421, 6, 8, 6, 0, -6 },
  { 427, 5, 8, 6, 1, -6 },
  { 432, 5, 6, 6, 1, -6 },
  { 436, 5, 6, 6, 1, -6 },
  { 440, 5, 7, 6, 1, -7 },
  { 445, 5, 6, 6, 1, -6 },
  { 449, 5, 6, 6, 1, -6 },
  { 453, 6, 6, 6, 1, -6 },
  { 458, 6, 6, 6, 0, -6 },
  { 463, 7, 8, 6, -1, -6 },
  { 470, 6, 6, 6, 0, -6 },
  { 475, 6, 11, 6, 1, -9 },
  { 484, 3, 11, 6, 2, -9 },
  { 489, 5, 11, 6, 0, -9 },
  { 496, 5, 2, 6, 1, -4 },
};

const GFXfont UbuntuSansMono_Italic11pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic11pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _UBUNTUSANSMONO_ITALIC11PT7B_H_
