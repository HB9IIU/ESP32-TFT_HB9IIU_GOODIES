#ifndef _UBUNTUSANSMONO_ITALIC31PT7B_H_
#define _UBUNTUSANSMONO_ITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18,
  0x18, 0x30, 0x30, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xF0, 0x61, 0xB1,
  0x98, 0xCC, 0x6C, 0x36, 0x13, 0x19, 0x0C, 0x84, 0x00, 0x00, 0x70, 0xC0,
  0x18, 0x70, 0x0E, 0x18, 0x03, 0x0E, 0x01, 0xC3, 0x07, 0xFF, 0xF3, 0xFF,
  0xFC, 0x0C, 0x18, 0x03, 0x0C, 0x01, 0xC3, 0x00, 0x61, 0xC0, 0x38, 0x60,
  0x0C, 0x38, 0x1F, 0xFF, 0xC7, 0xFF, 0xF2, 0x61, 0x80, 0x30, 0x60, 0x0C,
  0x38, 0x07, 0x0C, 0x01, 0x87, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x38, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0x01, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x60, 0x38, 0xFF, 0xF0, 0x3F, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x08, 0x3F, 0x03, 0x83, 0x18, 0x18, 0x18,
  0xC1, 0x80, 0x86, 0x18, 0x0C, 0x31, 0x80, 0x61, 0x98, 0x03, 0x19, 0xC0,
  0x18, 0xDC, 0x00, 0x7C, 0xC0, 0x01, 0xCC, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0xF0, 0x00, 0xCC, 0xC0, 0x0E, 0xC6, 0x00, 0xE6, 0x30, 0x06, 0x31, 0x80,
  0x61, 0x8C, 0x06, 0x18, 0x60, 0x60, 0x66, 0x06, 0x03, 0x30, 0x70, 0x1F,
  0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x71, 0xC3, 0x87, 0x0C, 0x1C, 0x30, 0x60,
  0xC3, 0x83, 0x1C, 0x0E, 0xE0, 0x1F, 0x00, 0xF0, 0x87, 0xC3, 0x3B, 0x8D,
  0xC7, 0x66, 0x1D, 0xB8, 0x3E, 0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x38, 0x7E,
  0x7F, 0xB8, 0xF8, 0x60, 0x33, 0x77, 0x66, 0x66, 0xC0, 0x00, 0x10, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x04, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x0E, 0x00, 0x40, 0x00, 0x07,
  0x00, 0x30, 0x01, 0x81, 0x8C, 0x6F, 0x6F, 0xFF, 0xF8, 0x18, 0x01, 0xE0,
  0x1D, 0x81, 0xCE, 0x1E, 0x38, 0x21, 0x80, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFC, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x04, 0x1E,
  0x1F, 0x1F, 0x1F, 0x06, 0x0E, 0xBC, 0x78, 0x60, 0x7F, 0xFF, 0x27, 0xBF,
  0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xF8, 0x1C, 0x70, 0x70,
  0x61, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xC7, 0x1F,
  0x9E, 0x37, 0x3C, 0x6E, 0x39, 0xD8, 0x03, 0xB0, 0x06, 0x60, 0x1C, 0xC0,
  0x31, 0x80, 0xE3, 0x83, 0x87, 0x0E, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x00,
  0x30, 0x0F, 0x01, 0xF0, 0x7F, 0x1E, 0x60, 0x86, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x07, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x07, 0xFE, 0x0F,
  0x0E, 0x04, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x7F,
  0xF8, 0xFF, 0xF8, 0x01, 0xF8, 0x0F, 0xF8, 0x1C, 0x78, 0x20, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x07, 0xF0, 0x0F, 0x80,
  0x1F, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE2, 0x03, 0xCF, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x76, 0x00, 0xEE, 0x01, 0xCE, 0x03, 0x8C, 0x07,
  0x0C, 0x06, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x18, 0x30, 0x18, 0x7F,
  0xFE, 0x7F, 0xFE, 0x80, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x07, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x10, 0x3C, 0x1F, 0xFC, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x37, 0xE0, 0x7F, 0xF8, 0x78, 0x38,
  0x60, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38,
  0xE0, 0x38, 0x60, 0x70, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F, 0xFE, 0x7F, 0xFC,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xF8, 0x0F, 0xF8, 0x3C, 0x38, 0x60, 0x71, 0xC0, 0x63, 0x00, 0xC6,
  0x01, 0x8C, 0x07, 0x1C, 0x1C, 0x3C, 0x70, 0x3F, 0xC0, 0xFF, 0x03, 0x8F,
  0x0E, 0x07, 0x38, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x73, 0x00, 0xE7,
  0x03, 0x8F, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0x8F,
  0x0E, 0x07, 0x0C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03,
  0x18, 0x07, 0x1C, 0x07, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0, 0x7F, 0x00,
  0xF8, 0x00, 0x04, 0x3C, 0x78, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x0F, 0x1F, 0x3E, 0x78, 0x00, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x1E, 0x07, 0xC1, 0xF0, 0x7C,
  0x06, 0x03, 0x8B, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0x01, 0x00, 0x06, 0x00,
  0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x70, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x10, 0x3F,
  0xFF, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0xFF, 0xFC, 0x10, 0x00, 0x30, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x03,
  0xE0, 0x0F, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0x84, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0xF0, 0x0F, 0x80, 0x38, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0xF1,
  0xC0, 0xE0, 0x70, 0xE0, 0x18, 0xE0, 0x0C, 0x70, 0x06, 0x70, 0x3F, 0x38,
  0x7F, 0x98, 0xF1, 0x9C, 0x70, 0xCE, 0x70, 0xE6, 0x30, 0x77, 0x18, 0x33,
  0x9C, 0x19, 0xCE, 0x1C, 0xE7, 0x0E, 0x71, 0x86, 0x38, 0xFF, 0x1C, 0x3F,
  0x86, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x06,
  0xE0, 0x06, 0x30, 0x03, 0x18, 0x03, 0x0C, 0x03, 0x86, 0x01, 0x83, 0x01,
  0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x38, 0x7F, 0xFC, 0x3F, 0xFE,
  0x30, 0x07, 0x18, 0x03, 0x98, 0x01, 0xDC, 0x00, 0xEC, 0x00, 0x7E, 0x00,
  0x38, 0x01, 0xF8, 0x03, 0xFF, 0x01, 0x87, 0xC0, 0xC0, 0x70, 0xE0, 0x38,
  0x70, 0x1C, 0x30, 0x0C, 0x18, 0x06, 0x1C, 0x06, 0x0E, 0x1E, 0x07, 0xFE,
  0x03, 0xFF, 0x83, 0x80, 0xE1, 0xC0, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30,
  0x06, 0x38, 0x07, 0x18, 0x07, 0x0C, 0x07, 0x87, 0xFF, 0x07, 0xFE, 0x00,
  0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xE1, 0xC1, 0xC0, 0x21, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x02, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xE0, 0x03, 0xFE, 0x01, 0x8F, 0x81, 0xC1, 0xE0, 0xC0, 0x70, 0x60, 0x1C,
  0x30, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8C, 0x01, 0xC6, 0x00, 0xE7, 0x00,
  0x63, 0x80, 0x31, 0x80, 0x38, 0xC0, 0x1C, 0xE0, 0x0C, 0x70, 0x0E, 0x30,
  0x0E, 0x18, 0x0E, 0x1C, 0x1E, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0x86, 0x0E, 0x02,
  0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38,
  0xC0, 0x38, 0xC0, 0x30, 0xE0, 0x30, 0x70, 0x30, 0x7F, 0xF0, 0x3F, 0xF0,
  0x07, 0x00, 0xE0, 0xC0, 0x18, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xC0, 0x18,
  0x18, 0x03, 0x07, 0x00, 0x60, 0xE0, 0x1C, 0x18, 0x03, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1C, 0x03, 0x83, 0x00, 0x70, 0x60, 0x0C, 0x0C, 0x01, 0x83,
  0x80, 0x70, 0x70, 0x0E, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x70, 0x0E, 0x0E,
  0x01, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x18, 0x1C, 0x1F, 0xFC,
  0x03, 0xFC, 0x00, 0x07, 0x01, 0xE0, 0xE0, 0x70, 0x18, 0x1C, 0x03, 0x07,
  0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x03, 0x3C, 0x00, 0x6F, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0D, 0xC0, 0x03, 0x9C, 0x00, 0x71, 0xC0,
  0x0C, 0x18, 0x01, 0x83, 0x80, 0x70, 0x38, 0x0E, 0x03, 0x01, 0x80, 0x70,
  0x30, 0x0E, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xC0, 0xE0, 0x38, 0x3C, 0x0F, 0x07, 0x81, 0xE1, 0xA0, 0x2C,
  0x3C, 0x0D, 0x8D, 0x81, 0xB1, 0xB0, 0x76, 0x66, 0x0C, 0xC8, 0xC1, 0x9B,
  0x38, 0x71, 0xC6, 0x0C, 0x38, 0xC1, 0x86, 0x18, 0x30, 0x07, 0x0E, 0x00,
  0xE1, 0x80, 0x18, 0x30, 0x03, 0x0E, 0x00, 0x61, 0xC0, 0x1C, 0x30, 0x03,
  0x8E, 0x00, 0x60, 0x07, 0x00, 0xE0, 0xF0, 0x18, 0x1E, 0x03, 0x07, 0xC0,
  0x60, 0xD8, 0x1C, 0x19, 0x83, 0x03, 0x30, 0x60, 0xE6, 0x0C, 0x18, 0xE3,
  0x83, 0x0C, 0x60, 0x61, 0x8C, 0x0C, 0x31, 0x83, 0x86, 0x70, 0x60, 0x6C,
  0x0C, 0x0D, 0x81, 0x81, 0xB0, 0x70, 0x3E, 0x0C, 0x07, 0x81, 0x80, 0x70,
  0x30, 0x0E, 0x0E, 0x01, 0xC0, 0x01, 0xF0, 0x07, 0xF8, 0x3C, 0x78, 0x60,
  0x71, 0x80, 0x67, 0x00, 0xCC, 0x01, 0xB8, 0x03, 0x60, 0x06, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xB0, 0x03, 0x60, 0x0E, 0xC0,
  0x19, 0x80, 0x73, 0x81, 0xC7, 0x07, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x01,
  0xF0, 0x07, 0xFC, 0x0E, 0x1E, 0x0E, 0x07, 0x0C, 0x03, 0x0C, 0x03, 0x1C,
  0x03, 0x1C, 0x03, 0x18, 0x07, 0x18, 0x06, 0x38, 0x0E, 0x38, 0x7C, 0x3F,
  0xF0, 0x3F, 0x80, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xFC, 0x0F,
  0x1E, 0x0C, 0x0E, 0x18, 0x06, 0x38, 0x06, 0x30, 0x07, 0x70, 0x07, 0x60,
  0x06, 0x60, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x38, 0xE0, 0x70, 0xE0, 0xE0, 0x7F,
  0xC0, 0x3F, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03,
  0xC0, 0x00, 0x40, 0x01, 0xF0, 0x03, 0xFF, 0x01, 0xC7, 0xC0, 0xC0, 0x70,
  0x60, 0x38, 0x70, 0x0C, 0x38, 0x06, 0x18, 0x07, 0x0C, 0x03, 0x0E, 0x03,
  0x87, 0x03, 0x83, 0xFF, 0x81, 0xFF, 0x01, 0xC3, 0x00, 0xE1, 0xC0, 0x60,
  0x60, 0x30, 0x38, 0x38, 0x1C, 0x1C, 0x06, 0x0C, 0x03, 0x86, 0x01, 0xC7,
  0x00, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xE0, 0xC1, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x08, 0x0F, 0x0F, 0xFF, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x8C, 0x01, 0x8E, 0x00, 0xC7,
  0x00, 0xE3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0xE0, 0x1C, 0x70, 0x0E,
  0x30, 0x06, 0x18, 0x03, 0x1C, 0x03, 0x8E, 0x01, 0xC6, 0x00, 0xC3, 0x00,
  0x61, 0x80, 0x70, 0xC0, 0x30, 0x60, 0x38, 0x38, 0x38, 0x0F, 0xFC, 0x03,
  0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x03, 0x98, 0x01, 0x8C, 0x01, 0xC6, 0x00,
  0xC3, 0x00, 0xE1, 0x80, 0x60, 0xC0, 0x70, 0x60, 0x30, 0x30, 0x38, 0x18,
  0x18, 0x0C, 0x1C, 0x06, 0x0C, 0x03, 0x8C, 0x01, 0xCE, 0x00, 0xE6, 0x00,
  0x77, 0x00, 0x1B, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0xC6, 0x00, 0x71, 0x80, 0x1C, 0x60, 0x06, 0x38, 0x01, 0x8E, 0x00,
  0xE3, 0x00, 0x30, 0xC0, 0x0C, 0x31, 0xC3, 0x0C, 0x71, 0x87, 0x3C, 0x61,
  0x8D, 0x18, 0x66, 0x4C, 0x1B, 0x13, 0x06, 0xC6, 0xC1, 0x61, 0xA0, 0xD8,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x00, 0x03,
  0x80, 0x78, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83, 0x80, 0x0E, 0x38,
  0x00, 0x73, 0x80, 0x01, 0x98, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1D, 0xC0, 0x01, 0xCE, 0x00,
  0x0E, 0x30, 0x00, 0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0x30, 0x0E, 0x01,
  0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x07, 0xE0, 0x0E, 0xE0,
  0x0C, 0x60, 0x1C, 0x60, 0x38, 0x60, 0x30, 0x70, 0x60, 0x30, 0xE0, 0x31,
  0xC0, 0x39, 0x80, 0x1B, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00,
  0xE3, 0x18, 0xC6, 0x31, 0x8E, 0x73, 0x9C, 0xE7, 0x38, 0xC6, 0x31, 0x8C,
  0x63, 0x9C, 0xE7, 0x39, 0xCE, 0x31, 0x8C, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xC0, 0x1F, 0x00, 0xD8, 0x0C, 0xC0, 0xE7,
  0x0E, 0x18, 0xE0, 0xC6, 0x07, 0x70, 0x1F, 0x00, 0xD0, 0x04, 0xFF, 0xFF,
  0xFF, 0xFE, 0x43, 0x87, 0x0C, 0x18, 0x70, 0x01, 0xFE, 0x0F, 0xFC, 0x3C,
  0x18, 0xE0, 0x73, 0x80, 0xCE, 0x01, 0x9C, 0x07, 0x30, 0x0E, 0xE0, 0x19,
  0xC0, 0x33, 0x80, 0x67, 0x01, 0xCE, 0x03, 0x8E, 0x0F, 0x1F, 0xFE, 0x1F,
  0xCC, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0F, 0xF8, 0x3F, 0xF8, 0x70, 0x38, 0xC0, 0x71,
  0x80, 0x67, 0x00, 0xCE, 0x01, 0x98, 0x03, 0x30, 0x0E, 0x60, 0x19, 0xC0,
  0x73, 0x01, 0xC6, 0x07, 0x8C, 0x1E, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE,
  0x1F, 0xFC, 0x78, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x01,
  0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x03, 0xFE, 0x07,
  0xFF, 0x07, 0x83, 0x07, 0x01, 0x87, 0x01, 0xC3, 0x80, 0xE3, 0x80, 0x61,
  0xC0, 0x30, 0xC0, 0x38, 0x60, 0x1C, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03,
  0x07, 0x07, 0x81, 0xFF, 0xC0, 0x7E, 0x60, 0x03, 0xF8, 0x1F, 0xF8, 0x78,
  0x39, 0xC0, 0x73, 0x80, 0xEE, 0x01, 0xD8, 0x07, 0x73, 0xFC, 0xFF, 0xE1,
  0xF0, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x02, 0x0F, 0xFE, 0x0F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0x84, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x9C, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF,
  0xC1, 0xE0, 0xE1, 0xE0, 0x60, 0xE0, 0x30, 0xE0, 0x38, 0x60, 0x1C, 0x70,
  0x0C, 0x30, 0x06, 0x18, 0x07, 0x0C, 0x03, 0x86, 0x01, 0x83, 0x81, 0xC1,
  0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C,
  0x1C, 0x3C, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xF8,
  0x1F, 0xF8, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0x63, 0x00, 0xC6, 0x03, 0x9C,
  0x07, 0x38, 0x0C, 0x60, 0x18, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0x8C, 0x03,
  0x18, 0x06, 0x70, 0x1C, 0x03, 0x03, 0x83, 0xE1, 0xE0, 0x60, 0x00, 0x00,
  0x00, 0xFE, 0x7F, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0x7E, 0x1F, 0x00, 0x06, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0xE3, 0xC0, 0xFF, 0x80, 0x3C, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x07, 0x1C, 0x0E, 0x1C, 0x3C, 0x18, 0x70, 0x19, 0xE0, 0x3B, 0xC0, 0x3F,
  0x00, 0x3E, 0x00, 0x37, 0x00, 0x33, 0x80, 0x71, 0xC0, 0x60, 0xE0, 0x60,
  0x70, 0x60, 0x70, 0xE0, 0x38, 0xE0, 0x38, 0x7F, 0x7F, 0x81, 0x80, 0xC0,
  0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x85, 0xFE, 0x7F, 0x0F, 0xDF,
  0x0F, 0xFF, 0xC6, 0x38, 0xE3, 0x0C, 0x71, 0x8E, 0x31, 0xC6, 0x18, 0xC3,
  0x0C, 0x61, 0x8E, 0x31, 0xC7, 0x38, 0xE3, 0x1C, 0x01, 0x8C, 0x01, 0xC6,
  0x00, 0xE7, 0x00, 0x63, 0x80, 0x31, 0x80, 0x38, 0x0F, 0xF8, 0x1F, 0xF8,
  0x70, 0x70, 0xE0, 0x71, 0x80, 0xE3, 0x01, 0xCE, 0x03, 0x9C, 0x06, 0x30,
  0x0C, 0x60, 0x19, 0xC0, 0x73, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x38, 0x0E,
  0x70, 0x1C, 0x07, 0xF0, 0x7F, 0xE3, 0xC1, 0xCE, 0x03, 0x70, 0x0D, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xB0, 0x0E, 0xC0,
  0x73, 0x83, 0x87, 0xFC, 0x0F, 0xE0, 0x07, 0xFC, 0x0F, 0xFE, 0x0E, 0x07,
  0x0C, 0x07, 0x0C, 0x03, 0x1C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x07,
  0x38, 0x07, 0x38, 0x0E, 0x30, 0x0E, 0x30, 0x1C, 0x70, 0x78, 0x7F, 0xF0,
  0x7F, 0xC0, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x03, 0xFE, 0x1F, 0xFC, 0x78, 0x31, 0xC0, 0x67, 0x01, 0xCC,
  0x03, 0xB8, 0x06, 0x70, 0x0C, 0xC0, 0x39, 0x80, 0x73, 0x00, 0xC6, 0x01,
  0x8C, 0x07, 0x1C, 0x1E, 0x1F, 0xF8, 0x1F, 0xB0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0F, 0xFE, 0x3F, 0xF8,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x07, 0xFC, 0x3F, 0xF1, 0xC0, 0x46, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x71, 0x01, 0x8F, 0xFE, 0x3F, 0xE0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0C, 0x0F, 0xFF, 0xFF, 0xF1, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x70, 0x47, 0xFC,
  0x3F, 0xC0, 0x38, 0x0C, 0xC0, 0x37, 0x01, 0xDC, 0x07, 0x60, 0x19, 0x80,
  0x66, 0x03, 0xB8, 0x0E, 0xE0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x1C, 0xC0,
  0x73, 0x83, 0xCF, 0xFF, 0x1F, 0xCC, 0xC0, 0x3E, 0x01, 0xB0, 0x0D, 0x80,
  0xEC, 0x06, 0x60, 0x73, 0x83, 0x1C, 0x38, 0xE1, 0x87, 0x18, 0x19, 0xC0,
  0xCC, 0x06, 0xE0, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0x60, 0x03, 0xB0, 0x01,
  0x98, 0x00, 0xDC, 0x00, 0xCE, 0x18, 0x67, 0x1C, 0x73, 0x0E, 0x31, 0x8F,
  0x18, 0xCD, 0x9C, 0x66, 0xCC, 0x36, 0x6E, 0x1B, 0x1E, 0x0F, 0x0F, 0x07,
  0x07, 0x03, 0x83, 0x81, 0x81, 0xC0, 0x07, 0x01, 0xC1, 0xC0, 0xE0, 0x38,
  0x30, 0x06, 0x18, 0x01, 0xCC, 0x00, 0x37, 0x00, 0x0F, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3B, 0x80, 0x1C, 0x60, 0x0E, 0x1C, 0x07,
  0x03, 0x03, 0x80, 0xE3, 0xC0, 0x38, 0x03, 0x00, 0xE0, 0x60, 0x1C, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x38, 0x1C, 0x07, 0x03, 0x00, 0xE0, 0xE0, 0x0C,
  0x18, 0x01, 0x83, 0x00, 0x38, 0xE0, 0x07, 0x18, 0x00, 0x67, 0x00, 0x0C,
  0xC0, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x23, 0xC0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x00, 0x01,
  0xF8, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x07, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3E,
  0x0E, 0xFE, 0x1B, 0x0F, 0xE6, 0x07, 0x80,
};

const GFXglyph UbuntuSansMono_Italic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 21, 17, 5, -21 },
  { 22, 9, 9, 17, 7, -24 },
  { 33, 18, 21, 17, 0, -21 },
  { 81, 16, 27, 17, 1, -24 },
  { 135, 21, 22, 17, -1, -22 },
  { 193, 14, 22, 17, 1, -22 },
  { 232, 4, 9, 17, 9, -24 },
  { 237, 13, 30, 17, 4, -24 },
  { 286, 13, 30, 17, 1, -24 },
  { 335, 13, 12, 17, 4, -21 },
  { 355, 14, 15, 17, 2, -17 },
  { 382, 8, 10, 17, 2, -5 },
  { 392, 8, 2, 17, 5, -10 },
  { 394, 5, 5, 17, 5, -5 },
  { 398, 20, 30, 17, -2, -24 },
  { 473, 15, 22, 17, 2, -22 },
  { 515, 12, 21, 17, 2, -21 },
  { 547, 16, 22, 17, 1, -22 },
  { 591, 15, 22, 17, 1, -22 },
  { 633, 16, 21, 17, 0, -21 },
  { 675, 17, 21, 17, 1, -21 },
  { 720, 16, 22, 17, 2, -22 },
  { 764, 15, 21, 17, 4, -21 },
  { 804, 15, 22, 17, 2, -22 },
  { 846, 16, 22, 17, 1, -22 },
  { 890, 7, 16, 17, 5, -16 },
  { 904, 10, 21, 17, 2, -16 },
  { 931, 16, 14, 17, 1, -16 },
  { 959, 16, 8, 17, 1, -13 },
  { 975, 15, 14, 17, 1, -16 },
  { 1002, 13, 22, 17, 4, -22 },
  { 1038, 17, 27, 17, 1, -22 },
  { 1096, 17, 21, 17, -2, -21 },
  { 1141, 17, 22, 17, 0, -22 },
  { 1188, 17, 22, 17, 2, -22 },
  { 1235, 17, 22, 17, 0, -22 },
  { 1282, 17, 21, 17, 1, -21 },
  { 1327, 17, 21, 17, 1, -21 },
  { 1372, 16, 22, 17, 2, -22 },
  { 1416, 19, 21, 17, 0, -21 },
  { 1466, 15, 21, 17, 2, -21 },
  { 1506, 17, 21, 17, 1, -21 },
  { 1551, 19, 21, 17, 0, -21 },
  { 1601, 12, 21, 17, 1, -21 },
  { 1633, 19, 21, 17, -1, -21 },
  { 1683, 19, 21, 17, 0, -21 },
  { 1733, 15, 22, 17, 2, -22 },
  { 1775, 16, 22, 17, 1, -22 },
  { 1819, 16, 28, 17, 2, -22 },
  { 1875, 17, 22, 17, 0, -22 },
  { 1922, 17, 22, 17, 1, -22 },
  { 1969, 15, 21, 17, 4, -21 },
  { 2009, 17, 21, 17, 2, -21 },
  { 2054, 17, 21, 17, 3, -21 },
  { 2099, 18, 21, 17, 1, -21 },
  { 2147, 21, 21, 17, -1, -21 },
  { 2203, 16, 21, 17, 4, -21 },
  { 2245, 19, 21, 17, 0, -21 },
  { 2295, 15, 30, 17, 2, -24 },
  { 2352, 5, 30, 17, 6, -24 },
  { 2371, 15, 30, 17, 0, -24 },
  { 2428, 13, 11, 17, 3, -21 },
  { 2446, 16, 2, 17, -2, 4 },
  { 2450, 6, 6, 17, 8, -24 },
  { 2455, 15, 16, 17, 1, -16 },
  { 2485, 15, 24, 17, 1, -24 },
  { 2530, 15, 16, 17, 1, -16 },
  { 2560, 17, 24, 17, 2, -24 },
  { 2611, 15, 16, 17, 1, -16 },
  { 2641, 21, 30, 17, -1, -24 },
  { 2720, 17, 22, 17, 0, -16 },
  { 2767, 15, 24, 17, 0, -24 },
  { 2812, 9, 24, 17, 4, -24 },
  { 2839, 16, 30, 17, 0, -24 },
  { 2899, 16, 24, 17, 1, -24 },
  { 2947, 9, 24, 17, 5, -24 },
  { 2974, 17, 16, 17, 0, -16 },
  { 3008, 15, 16, 17, 1, -16 },
  { 3038, 14, 16, 17, 2, -16 },
  { 3066, 16, 22, 17, 0, -16 },
  { 3110, 15, 22, 17, 2, -16 },
  { 3152, 15, 16, 17, 2, -16 },
  { 3182, 14, 16, 17, 2, -16 },
  { 3210, 12, 21, 17, 4, -21 },
  { 3242, 14, 16, 17, 2, -16 },
  { 3270, 13, 16, 17, 4, -16 },
  { 3296, 17, 16, 17, 2, -16 },
  { 3330, 18, 16, 17, -1, -16 },
  { 3366, 19, 22, 17, -2, -16 },
  { 3419, 15, 16, 17, 1, -16 },
  { 3449, 17, 30, 17, 2, -24 },
  { 3513, 10, 30, 17, 4, -24 },
  { 3551, 16, 30, 17, -1, -24 },
  { 3611, 15, 4, 17, 2, -11 },
};

const GFXfont UbuntuSansMono_Italic31pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic31pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic31pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _UBUNTUSANSMONO_ITALIC31PT7B_H_
