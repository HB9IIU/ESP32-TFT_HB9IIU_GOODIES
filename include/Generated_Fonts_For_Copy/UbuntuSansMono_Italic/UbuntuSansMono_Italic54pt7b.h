#ifndef _UBUNTUSANSMONO_ITALIC54PT7B_H_
#define _UBUNTUSANSMONO_ITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x7F, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0xE0, 0x00, 0x3C, 0x0E, 0x78, 0x3C,
  0xE0, 0x7B, 0xC0, 0xE7, 0x81, 0xCF, 0x07, 0x9C, 0x0F, 0x38, 0x1C, 0xF0,
  0x39, 0xC0, 0x73, 0x80, 0xC7, 0x03, 0x8C, 0x07, 0x18, 0x0C, 0x00, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x07, 0x80, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0x01, 0xE0, 0x0F, 0x80, 0x04, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x03, 0x00, 0x07, 0xE0, 0x3C, 0x01, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x10, 0x03, 0xFC, 0x00, 0x1E,
  0x00, 0x7F, 0xE0, 0x03, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0xE0,
  0x07, 0x80, 0x1E, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0xE0, 0x1E, 0x00, 0x3C,
  0x0E, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x78, 0x00, 0x38, 0x0E, 0x0F, 0x00,
  0x03, 0x81, 0xE0, 0xF0, 0x00, 0x38, 0x1E, 0x1E, 0x00, 0x03, 0x81, 0xC3,
  0xC0, 0x00, 0x38, 0x3C, 0x78, 0x00, 0x03, 0xC3, 0x8F, 0x00, 0x00, 0x3E,
  0x79, 0xE0, 0x00, 0x01, 0xFF, 0x3C, 0x00, 0x00, 0x0F, 0xE3, 0xC0, 0x00,
  0x00, 0x10, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x00, 0x3C, 0x7F, 0x80, 0x00, 0x07, 0x8F, 0xFC, 0x00, 0x00,
  0xF1, 0xE3, 0xC0, 0x00, 0x0F, 0x1C, 0x1C, 0x00, 0x01, 0xE3, 0xC1, 0xC0,
  0x00, 0x3C, 0x38, 0x1C, 0x00, 0x07, 0x87, 0x81, 0xC0, 0x00, 0xF0, 0x78,
  0x1C, 0x00, 0x1E, 0x07, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x3C, 0x00, 0x3C,
  0x07, 0x03, 0xC0, 0x07, 0x80, 0x70, 0x38, 0x00, 0xF0, 0x07, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x78, 0x03, 0xC0, 0x07, 0x8F, 0x00, 0x78, 0x00, 0x3F,
  0xE0, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0,
  0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x1F, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x3C, 0x0F, 0xF8, 0x0E, 0x07, 0xFF, 0x07, 0x83, 0xE3, 0xC1, 0xE1, 0xF0,
  0xF8, 0x70, 0x78, 0x1E, 0x3C, 0x3C, 0x03, 0xCF, 0x1F, 0x00, 0xFF, 0x87,
  0xC0, 0x1F, 0xE1, 0xE0, 0x07, 0xF0, 0x78, 0x00, 0xFC, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x01, 0xFC, 0x1F, 0x01,
  0xFF, 0x07, 0xF1, 0xFB, 0xE0, 0xFF, 0xFC, 0x78, 0x1F, 0xFE, 0x1E, 0x03,
  0xFE, 0x07, 0xC0, 0x1E, 0x3C, 0x79, 0xF3, 0xC7, 0x8F, 0x3E, 0x78, 0xF1,
  0xE3, 0x87, 0x1E, 0x38, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x04, 0x07, 0x80, 0x9E, 0x0E, 0x07, 0x3F, 0x1C, 0x7E, 0x7F, 0xBB, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x7B, 0xE0, 0x01, 0xF3, 0xE0, 0x07, 0xC7, 0xE0, 0x1F,
  0x87, 0xC0, 0x7E, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x1F,
  0x81, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0xF0,
  0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x0F, 0x00, 0x80,
  0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x3F, 0x9F, 0xEF,
  0xFF, 0xFB, 0xFD, 0xFC, 0xFC, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xE0, 0x00,
  0x7C, 0xF8, 0x7C, 0x1F, 0x3C, 0x3F, 0x87, 0xDF, 0x0F, 0xE1, 0xF7, 0xC3,
  0xF8, 0x79, 0xE0, 0xFE, 0x1E, 0x78, 0x3F, 0x0F, 0x9E, 0x0F, 0xC3, 0xEF,
  0x80, 0x00, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x1E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0x78, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x07, 0xE1, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0xFF, 0xBC, 0x03, 0xF1, 0xE0, 0x1E, 0x0F, 0x00, 0x80, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xE0, 0x0F,
  0x00, 0x7E, 0x01, 0xC0, 0x07, 0xC0, 0x10, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0x00, 0x7C, 0x00,
  0x80, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x0C, 0x00, 0x3F,
  0x81, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xC7,
  0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x07,
  0xC0, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x13, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x40, 0x01, 0xF8, 0x03, 0xC0,
  0x7F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0xFE, 0x00, 0x3E,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F,
  0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78,
  0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00,
  0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x3F, 0x01,
  0xF0, 0x0F, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x0F, 0x80, 0x7E, 0x03,
  0xE0, 0x07, 0xC0, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01,
  0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x03, 0xF0, 0x3E, 0x00, 0x3F, 0xDF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x7E, 0x7F, 0x80, 0x1F, 0x03, 0xF8, 0x07, 0xC0, 0x1F, 0x81,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x7C, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x81, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0x80, 0x7C, 0x07,
  0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x1E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1F,
  0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3F, 0x00, 0x3F, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xF3, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0xFF, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFE,
  0x07, 0xF0, 0x1F, 0x80, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0,
  0x01, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x06, 0x00,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0E, 0x07, 0xE0, 0x80, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x1E, 0x0F, 0x80, 0x0F, 0xF8, 0x7C, 0x01, 0xFF, 0xE1, 0xF0, 0x1F, 0xFF,
  0x87, 0x81, 0xFF, 0xFC, 0x3E, 0x0F, 0xC0, 0xF0, 0xF8, 0x3E, 0x03, 0xC3,
  0xC1, 0xF0, 0x1F, 0x1F, 0x07, 0x80, 0x78, 0x7C, 0x3E, 0x01, 0xE1, 0xE0,
  0xF0, 0x07, 0x87, 0x83, 0xC0, 0x1E, 0x1E, 0x1F, 0x00, 0xF8, 0xF8, 0x7C,
  0x03, 0xC3, 0xE1, 0xE0, 0x0F, 0x0F, 0x87, 0x80, 0x3C, 0x3E, 0x1F, 0x01,
  0xF0, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0xF0, 0x1E, 0x0F, 0x83, 0xE0, 0x78,
  0x3E, 0x0F, 0xC3, 0xE0, 0xF8, 0x1F, 0xFF, 0x01, 0xE0, 0x3F, 0xFC, 0x07,
  0x80, 0x3F, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x1E, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7C, 0x78, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x01, 0xF0, 0x07, 0xF0, 0x1E, 0x00, 0x3F, 0x01, 0xE0, 0x01,
  0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x3E, 0x07, 0x80, 0x07, 0xC0, 0x78, 0x01, 0xF8, 0x07, 0x80, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x00,
  0x7F, 0x01, 0xF0, 0x01, 0xF8, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C,
  0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x7C, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F,
  0x87, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xE0, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xE0, 0x00, 0x40,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x01, 0xF8, 0x07, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0x01, 0xFC, 0x00, 0x78,
  0x03, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0xF8, 0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x78,
  0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0,
  0x78, 0x00, 0xFC, 0x03, 0xC0, 0x1F, 0xC0, 0x1F, 0x9F, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFE, 0xFF, 0x00, 0xFC, 0x00, 0xE0, 0x1F, 0x80, 0x04, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0x80, 0x3F,
  0x80, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x04, 0x00, 0x1F, 0x00, 0x30, 0x01,
  0xF0, 0x03, 0xE0, 0x3F, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x80,
  0x01, 0xE0, 0x3F, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x03, 0xC1, 0xF8, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0x7E, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x77, 0x80, 0xFE, 0x00, 0x77,
  0x80, 0xEE, 0x00, 0x77, 0x81, 0xCE, 0x00, 0xF7, 0x81, 0xCE, 0x00, 0xE7,
  0x83, 0x9E, 0x00, 0xE3, 0x87, 0x9E, 0x01, 0xE3, 0x87, 0x1C, 0x01, 0xE3,
  0x8F, 0x1C, 0x01, 0xC3, 0x8E, 0x1C, 0x03, 0xC3, 0x9C, 0x3C, 0x03, 0xC3,
  0x9C, 0x3C, 0x03, 0xC3, 0xB8, 0x3C, 0x07, 0x83, 0xB8, 0x38, 0x07, 0x83,
  0xF0, 0x78, 0x07, 0x83, 0xF0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x03, 0xC0, 0x1F,
  0xC0, 0x01, 0xE0, 0x0F, 0xE0, 0x00, 0xE0, 0x07, 0xF8, 0x00, 0xF0, 0x03,
  0xFC, 0x00, 0x78, 0x01, 0xDE, 0x00, 0x3C, 0x01, 0xE7, 0x80, 0x1C, 0x00,
  0xF3, 0xC0, 0x1E, 0x00, 0x79, 0xE0, 0x0F, 0x00, 0x38, 0x70, 0x07, 0x80,
  0x3C, 0x3C, 0x03, 0xC0, 0x1E, 0x1E, 0x03, 0xC0, 0x0F, 0x0F, 0x01, 0xE0,
  0x07, 0x03, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x78,
  0x01, 0xE0, 0x78, 0x3C, 0x00, 0xE0, 0x1C, 0x1E, 0x00, 0xF0, 0x0F, 0x0F,
  0x00, 0x78, 0x07, 0x87, 0x00, 0x3C, 0x03, 0xC7, 0x80, 0x1E, 0x00, 0xE3,
  0xC0, 0x1E, 0x00, 0x71, 0xE0, 0x0F, 0x00, 0x3C, 0xE0, 0x07, 0x80, 0x1E,
  0xF0, 0x03, 0xC0, 0x0F, 0x78, 0x03, 0xC0, 0x03, 0xBC, 0x01, 0xE0, 0x01,
  0xDC, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x38, 0x00,
  0x3F, 0x80, 0x3C, 0x00, 0x1F, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x0F, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF1,
  0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0x7C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x78, 0x00, 0xFC, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1F,
  0x01, 0xE0, 0x03, 0xF0, 0x0F, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFB, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x3C, 0x0F, 0x80, 0x07, 0xC0, 0x78, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x07,
  0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x0F,
  0x80, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C,
  0x03, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7E,
  0x00, 0x30, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0xC0,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x3C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3C,
  0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80,
  0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0x78, 0xF8, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x07, 0x80,
  0xE0, 0x1E, 0x0F, 0x81, 0xE0, 0x1C, 0x0F, 0x81, 0xE0, 0x3C, 0x1F, 0x81,
  0xE0, 0x3C, 0x1F, 0x81, 0xC0, 0x3C, 0x3B, 0xC3, 0xC0, 0x38, 0x79, 0xC3,
  0xC0, 0x38, 0x71, 0xC3, 0x80, 0x38, 0xF1, 0xC7, 0x80, 0x78, 0xE1, 0xC7,
  0x80, 0x79, 0xE1, 0xC7, 0x00, 0x71, 0xC1, 0xC7, 0x00, 0x73, 0xC1, 0xCF,
  0x00, 0x77, 0x81, 0xCE, 0x00, 0x77, 0x01, 0xCE, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0xEE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x03,
  0xC0, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x01,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x02, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3E, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0xF0, 0x70, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x1C, 0x7C,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x30, 0x00, 0x0C, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x10, 0x0C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xE0, 0x3C, 0x07, 0xF0, 0x07, 0x81,
  0xF8, 0x01, 0xE0, 0x7E, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x00,
  0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF8,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E,
  0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0x9E, 0x00, 0xFF, 0xE3, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x3E, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x1E,
  0x00, 0x1F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE3, 0xE0,
  0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0xC3,
  0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0x78, 0x01, 0xF8, 0x1E, 0x01, 0xFC,
  0x07, 0x83, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFC, 0x01, 0x81, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x08, 0x0F, 0xE0, 0x1F, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xF8, 0x0F, 0x00, 0x3F, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x0F, 0xC0,
  0x07, 0x80, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x03,
  0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xE0,
  0x1E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF8, 0x0F,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x78, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x3C, 0x00, 0x3F, 0xF0, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x7C,
  0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x79, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x1E, 0x00, 0x7F, 0xC7, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x08, 0x0F, 0xE0,
  0x1F, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xF8,
  0x04, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x77, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFE, 0x03, 0xC0, 0x07,
  0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x3C, 0x01, 0xF8,
  0x00, 0x78, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1E, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xC0,
  0x07, 0xFB, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xDC, 0x00,
  0x03, 0xFC, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x40,
  0x00, 0xF8, 0x00, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x3C, 0x00,
  0xF8, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x80,
  0x03, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3C,
  0x3E, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x01, 0x80, 0x3F, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x7E, 0x03, 0xC0, 0x0F,
  0xC0, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x0F, 0xC0, 0x07,
  0x81, 0xF8, 0x00, 0x78, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF1, 0xF8,
  0x00, 0x0F, 0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1E, 0xFC, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x3E, 0x3F,
  0x00, 0x03, 0xC1, 0xF8, 0x00, 0x3C, 0x0F, 0xC0, 0x03, 0xC0, 0x7C, 0x00,
  0x3C, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x01, 0xF0, 0x07, 0x80,
  0x0F, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0xE0, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE7, 0xFF, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x4F, 0x81, 0x9F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x07,
  0x00, 0x00, 0x1E, 0x01, 0x80, 0x0F, 0xFC, 0x7F, 0x00, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x3C, 0x3F, 0x8F, 0x83, 0xC0, 0xF0, 0x3C, 0x1E,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x7C, 0x1F,
  0x07, 0xC3, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F,
  0x07, 0x83, 0xE0, 0x78, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1E,
  0x07, 0x81, 0xE0, 0xF0, 0x7C, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xE0, 0x7F, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x1E, 0x00,
  0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0x87, 0xF0, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x1F,
  0x00, 0x07, 0x9F, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xEF, 0x80, 0x00, 0xF7,
  0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03,
  0xCF, 0x00, 0x03, 0xE7, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01,
  0xF0, 0x7C, 0x03, 0xF0, 0x3F, 0x8F, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xC0, 0x7F, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xF0, 0x0F,
  0x00, 0x7F, 0x00, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xC0, 0xFC,
  0x01, 0xE0, 0x7E, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87,
  0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x1F,
  0x1E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x3E, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xE0,
  0x78, 0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFD, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0x00, 0x30, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0xF0,
  0x1F, 0x00, 0x08, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x60,
  0x00, 0xF8, 0x3C, 0x01, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x1C, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C,
  0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC3, 0xE0,
  0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x0F, 0xE0, 0x7C, 0x0F, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xE7, 0x80, 0x7F, 0xF0, 0xF0, 0x01, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C,
  0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0,
  0x78, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x3E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C,
  0x7C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x1E,
  0x01, 0xC0, 0x78, 0x78, 0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x0F, 0x07, 0x81,
  0xF0, 0x3C, 0x1E, 0x0F, 0xC0, 0xE0, 0x78, 0x3F, 0x07, 0x81, 0xE1, 0xFC,
  0x1E, 0x0F, 0x87, 0x70, 0xF0, 0x3C, 0x39, 0xE3, 0xC0, 0xF1, 0xE7, 0x8E,
  0x03, 0xC7, 0x1E, 0x78, 0x0F, 0x3C, 0x79, 0xE0, 0x3C, 0xE0, 0xEF, 0x00,
  0xF7, 0x03, 0xBC, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F,
  0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xC0,
  0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7E, 0xF0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xE1, 0xE0, 0x00,
  0x1F, 0x83, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0x80, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x7E, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x1E, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x20,
  0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x01, 0x03, 0xFC, 0x00, 0xF3, 0xFF,
  0xC0, 0x38, 0xFF, 0xF8, 0x1E, 0x78, 0x3F, 0x9F, 0x3C, 0x03, 0xFF, 0x8F,
  0x00, 0x7F, 0xC1, 0x80, 0x0F, 0xE0,
};

const GFXglyph UbuntuSansMono_Italic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 14, 38, 30, 8, -37 },
  { 68, 15, 14, 30, 12, -41 },
  { 95, 32, 37, 30, 0, -37 },
  { 243, 28, 48, 30, 2, -42 },
  { 411, 36, 39, 30, -2, -38 },
  { 587, 26, 38, 30, 1, -38 },
  { 711, 7, 16, 30, 16, -41 },
  { 725, 22, 52, 30, 7, -42 },
  { 868, 23, 52, 30, 1, -42 },
  { 1018, 23, 21, 30, 6, -37 },
  { 1079, 25, 26, 30, 3, -29 },
  { 1161, 13, 17, 30, 4, -8 },
  { 1189, 13, 4, 30, 9, -17 },
  { 1196, 9, 9, 30, 8, -8 },
  { 1207, 34, 52, 30, -3, -42 },
  { 1428, 26, 39, 30, 3, -38 },
  { 1555, 21, 37, 30, 4, -37 },
  { 1653, 27, 38, 30, 2, -38 },
  { 1782, 27, 39, 30, 2, -38 },
  { 1914, 27, 37, 30, 1, -37 },
  { 2039, 29, 38, 30, 2, -37 },
  { 2177, 27, 39, 30, 4, -38 },
  { 2309, 26, 37, 30, 7, -37 },
  { 2430, 27, 39, 30, 3, -38 },
  { 2562, 27, 38, 30, 3, -38 },
  { 2691, 14, 29, 30, 8, -28 },
  { 2742, 18, 37, 30, 4, -28 },
  { 2826, 27, 23, 30, 2, -27 },
  { 2904, 27, 15, 30, 2, -23 },
  { 2955, 27, 23, 30, 1, -27 },
  { 3033, 21, 39, 30, 8, -38 },
  { 3136, 30, 46, 30, 2, -38 },
  { 3309, 29, 37, 30, -3, -37 },
  { 3444, 28, 38, 30, 1, -38 },
  { 3577, 30, 39, 30, 3, -38 },
  { 3724, 29, 38, 30, 0, -38 },
  { 3862, 30, 37, 30, 2, -37 },
  { 4001, 30, 37, 30, 2, -37 },
  { 4140, 28, 39, 30, 3, -38 },
  { 4277, 32, 37, 30, 0, -37 },
  { 4425, 27, 37, 30, 3, -37 },
  { 4550, 29, 38, 30, 2, -37 },
  { 4688, 32, 37, 30, 1, -37 },
  { 4836, 22, 37, 30, 1, -37 },
  { 4938, 32, 37, 30, -1, -37 },
  { 5086, 33, 37, 30, 0, -37 },
  { 5239, 27, 39, 30, 3, -38 },
  { 5371, 29, 38, 30, 1, -38 },
  { 5509, 28, 48, 30, 3, -38 },
  { 5677, 29, 38, 30, 1, -38 },
  { 5815, 30, 39, 30, 1, -38 },
  { 5962, 26, 37, 30, 7, -37 },
  { 6083, 30, 38, 30, 3, -37 },
  { 6226, 29, 37, 30, 6, -37 },
  { 6361, 32, 37, 30, 2, -37 },
  { 6509, 36, 37, 30, -2, -37 },
  { 6676, 28, 37, 30, 7, -37 },
  { 6806, 32, 37, 30, 0, -37 },
  { 6954, 26, 52, 30, 4, -42 },
  { 7123, 9, 52, 30, 11, -42 },
  { 7182, 27, 52, 30, -1, -42 },
  { 7358, 24, 19, 30, 5, -37 },
  { 7415, 28, 4, 30, -4, 6 },
  { 7429, 10, 11, 30, 14, -42 },
  { 7443, 27, 30, 30, 2, -29 },
  { 7545, 26, 43, 30, 2, -42 },
  { 7685, 26, 30, 30, 2, -29 },
  { 7783, 30, 43, 30, 3, -42 },
  { 7945, 26, 30, 30, 2, -29 },
  { 8043, 35, 52, 30, -1, -42 },
  { 8271, 31, 39, 30, -1, -29 },
  { 8423, 26, 42, 30, 0, -42 },
  { 8560, 17, 41, 30, 6, -41 },
  { 8648, 29, 51, 30, 0, -41 },
  { 8833, 28, 42, 30, 2, -42 },
  { 8980, 15, 43, 30, 9, -42 },
  { 9061, 29, 29, 30, 0, -29 },
  { 9167, 26, 29, 30, 2, -29 },
  { 9262, 25, 30, 30, 3, -29 },
  { 9356, 29, 39, 30, -1, -29 },
  { 9498, 26, 39, 30, 3, -29 },
  { 9625, 25, 29, 30, 4, -29 },
  { 9716, 25, 30, 30, 3, -29 },
  { 9810, 21, 38, 30, 7, -37 },
  { 9910, 26, 29, 30, 3, -28 },
  { 10005, 24, 28, 30, 6, -28 },
  { 10089, 30, 28, 30, 3, -28 },
  { 10194, 31, 28, 30, -1, -28 },
  { 10303, 33, 38, 30, -3, -28 },
  { 10460, 27, 28, 30, 1, -28 },
  { 10555, 29, 52, 30, 3, -42 },
  { 10744, 17, 52, 30, 7, -42 },
  { 10855, 29, 52, 30, -2, -42 },
  { 11044, 26, 8, 30, 3, -20 },
};

const GFXfont UbuntuSansMono_Italic54pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic54pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic54pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _UBUNTUSANSMONO_ITALIC54PT7B_H_
