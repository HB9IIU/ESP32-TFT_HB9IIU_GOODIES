#ifndef _UBUNTUSANSMONO_ITALIC44PT7B_H_
#define _UBUNTUSANSMONO_ITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1F,
  0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x08, 0x00, 0x3C, 0x39, 0xC1, 0xCE,
  0x0E, 0x70, 0xE3, 0x07, 0x38, 0x39, 0xC1, 0x8E, 0x0C, 0x60, 0x63, 0x06,
  0x30, 0x30, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x38,
  0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0xF0, 0x78, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0x07,
  0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x1C, 0x00,
  0x1C, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x78, 0x3C, 0x01, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x0E,
  0x07, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x38, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xF0, 0x18, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x04, 0x00, 0x3C, 0x0F, 0x01, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x04, 0x03, 0xF8, 0x00, 0xE0, 0x1C, 0x70, 0x07, 0x00, 0x71, 0xC0, 0x38,
  0x03, 0x87, 0x01, 0xC0, 0x0E, 0x1C, 0x0F, 0x00, 0x30, 0x70, 0x78, 0x01,
  0xC1, 0xC1, 0xC0, 0x07, 0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x70, 0x00, 0x70,
  0xE3, 0x80, 0x01, 0xC3, 0x9C, 0x00, 0x07, 0x9C, 0xF0, 0x00, 0x0F, 0xE7,
  0x80, 0x00, 0x1F, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x39, 0xFC, 0x00, 0x01, 0xCF, 0xF8, 0x00, 0x0F, 0x38, 0xE0,
  0x00, 0x79, 0xC3, 0x80, 0x01, 0xC7, 0x0E, 0x00, 0x0E, 0x18, 0x38, 0x00,
  0x70, 0xE0, 0xE0, 0x03, 0x83, 0x83, 0x80, 0x1C, 0x0E, 0x0E, 0x00, 0xF0,
  0x38, 0x70, 0x07, 0x80, 0xE1, 0xC0, 0x1C, 0x03, 0x8E, 0x00, 0xE0, 0x07,
  0xF8, 0x0F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xC1, 0xE0, 0x1C, 0x0F, 0x01, 0xE0,
  0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x81, 0xE0, 0x1C, 0x0E, 0x00,
  0xE0, 0xF0, 0x07, 0x8F, 0x00, 0x1D, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0x0F, 0xF0, 0x70, 0xF3, 0xC3, 0x8F, 0x0F, 0x3C, 0x70,
  0x39, 0xC7, 0x81, 0xEE, 0x38, 0x07, 0xE3, 0xC0, 0x3F, 0x1E, 0x00, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xF0, 0xF0, 0x7F, 0x87, 0xFF,
  0xDE, 0x1F, 0xF8, 0xF0, 0x7F, 0x07, 0x80, 0x3C, 0xF3, 0x8E, 0x79, 0xE7,
  0x1C, 0x71, 0x8E, 0x38, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x04,
  0x0E, 0x04, 0xF1, 0xC7, 0x9F, 0xBB, 0xF7, 0xFF, 0xFF, 0x1F, 0xFF, 0x00,
  0x1C, 0x00, 0x07, 0xC0, 0x01, 0xDC, 0x00, 0x7B, 0xC0, 0x1E, 0x3C, 0x07,
  0x87, 0xC0, 0xF0, 0x78, 0x0C, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC0, 0xF0,
  0x1E, 0x07, 0x83, 0xE3, 0xF8, 0x3E, 0x06, 0x00, 0x7F, 0xEF, 0xFF, 0xFF,
  0x80, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x10, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7C, 0x3E, 0x03, 0xE0,
  0x78, 0x0F, 0x00, 0xE0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x0F, 0x3C, 0x38, 0x3C, 0xF1,
  0xF0, 0xE3, 0x8F, 0xC3, 0x9E, 0x3F, 0x1E, 0x78, 0xFC, 0x79, 0xE1, 0xE1,
  0xE7, 0x00, 0x07, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xF3, 0xC0, 0x07, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0xF0, 0x70, 0x03, 0xC1, 0xC0, 0x1E, 0x07, 0x80,
  0xF0, 0x1E, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0xFD, 0xC0, 0x7C, 0xF0, 0x1C, 0x3C, 0x04, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0x00,
  0x3C, 0x08, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0x81, 0xF0,
  0x10, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x80, 0x1F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3D, 0xC0, 0x01, 0xE7, 0x00, 0x0F, 0x3C, 0x00,
  0x78, 0xF0, 0x03, 0xC3, 0x80, 0x1E, 0x0E, 0x00, 0xF0, 0x38, 0x07, 0x81,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x70, 0x3C, 0x03, 0xC0,
  0xE0, 0x0E, 0x07, 0x80, 0x38, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x60, 0x0F, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0xF7, 0xFC, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x00,
  0x0E, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x0E,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xC3, 0xC0, 0x0F, 0x07, 0x00, 0x7C, 0x1E,
  0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0x81, 0xE0,
  0x3C, 0x03, 0xC0, 0x70, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0x7C, 0x3C, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x1E, 0x0F, 0x80, 0x78, 0x0F, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x0F,
  0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x83, 0xC0, 0x3E, 0x07, 0xC1, 0xF8, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0xF0,
  0x03, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00,
  0x38, 0x78, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x07,
  0x83, 0xC0, 0x0F, 0x07, 0xC0, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x03, 0xF3, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0x00, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x1F, 0x83, 0xE0,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x0F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0x01, 0x00, 0x00,
  0x10, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3E,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x07, 0xF0, 0x07, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x20, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xF8, 0x3E,
  0x01, 0xE0, 0x0E, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F,
  0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x01, 0xFE, 0x3C, 0x0F, 0xFE,
  0x3C, 0x1F, 0xFE, 0x38, 0x3C, 0x1E, 0x78, 0x78, 0x1C, 0x78, 0xF0, 0x1C,
  0x70, 0xF0, 0x3C, 0xF0, 0xE0, 0x3C, 0xF1, 0xE0, 0x38, 0xF1, 0xE0, 0x38,
  0xF1, 0xE0, 0x78, 0xE1, 0xE0, 0x78, 0xE1, 0xE0, 0x70, 0xE1, 0xE0, 0x70,
  0xE0, 0xE0, 0xF0, 0xE0, 0xF0, 0xF0, 0xF0, 0x7F, 0xE0, 0xF0, 0x3F, 0xE0,
  0xF0, 0x0F, 0x80, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0x9E,
  0x00, 0x07, 0x1E, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x0E,
  0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0E,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x01, 0xC0, 0x0F,
  0x03, 0xC0, 0x0F, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xC0, 0x7E,
  0x01, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x0F,
  0x03, 0x80, 0x0F, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x3C,
  0x07, 0x00, 0x78, 0x07, 0x07, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x0E, 0x0F, 0xF0, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x38, 0x00, 0x78, 0x38, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x03, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xF8, 0x1E, 0x03, 0xC0, 0x04,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x01, 0x80, 0x3F, 0x9F, 0x80,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xC1, 0xF8, 0x03, 0xC0, 0x7C,
  0x03, 0x80, 0x3E, 0x03, 0x80, 0x1E, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x0F,
  0x07, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x0E,
  0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x38, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0x78, 0x01, 0xE0, 0x70, 0x07, 0xC0, 0x70, 0x1F, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF8, 0x0F, 0xC0, 0x70, 0x3E, 0x00, 0x40, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x79, 0xE0, 0x00, 0xE3, 0xC0, 0x01,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38,
  0x78, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xF0, 0x03, 0x81, 0xE0, 0x07, 0x01,
  0xF0, 0x1E, 0x03, 0xF8, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x3C,
  0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1E, 0x00, 0x1C, 0x07, 0x00, 0x07,
  0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x0F, 0x00,
  0x0E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x1E,
  0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xE0,
  0x3C, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x80, 0x0F, 0x01, 0x80, 0x3C, 0x07, 0xF3, 0xF0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x0F,
  0xC0, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x01, 0xF0, 0x03, 0x80,
  0xF8, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x1C, 0x1F, 0x00, 0x07,
  0x0F, 0x80, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x39, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x77, 0xC0,
  0x00, 0x1C, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0x70, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x80, 0x70, 0x01,
  0xE0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x0F, 0x00, 0x1C,
  0x03, 0xC0, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x37, 0x03, 0x70, 0x1D,
  0xC1, 0xDC, 0x07, 0x70, 0x66, 0x01, 0x9C, 0x3B, 0x80, 0xE7, 0x1C, 0xE0,
  0x39, 0xC7, 0x38, 0x0E, 0x73, 0x8E, 0x07, 0x0C, 0xC3, 0x81, 0xC3, 0x71,
  0xC0, 0x70, 0xD8, 0x70, 0x3C, 0x3E, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x83,
  0xC1, 0xC0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07,
  0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C,
  0x1E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00,
  0x3C, 0x3C, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x38,
  0x07, 0xC0, 0x07, 0x00, 0xFC, 0x01, 0xE0, 0x3F, 0x80, 0x38, 0x07, 0x70,
  0x07, 0x00, 0xEE, 0x00, 0xE0, 0x1C, 0xE0, 0x3C, 0x03, 0x9C, 0x07, 0x00,
  0xE3, 0x80, 0xE0, 0x1C, 0x78, 0x1C, 0x03, 0x87, 0x03, 0x80, 0x70, 0xE0,
  0xE0, 0x1C, 0x1C, 0x1C, 0x03, 0x83, 0xC3, 0x80, 0x70, 0x38, 0x70, 0x0E,
  0x07, 0x1E, 0x03, 0x80, 0xE3, 0x80, 0x70, 0x1C, 0x70, 0x0E, 0x01, 0xCE,
  0x01, 0xC0, 0x3B, 0xC0, 0x78, 0x07, 0x70, 0x0E, 0x00, 0xEE, 0x01, 0xC0,
  0x1D, 0xC0, 0x38, 0x01, 0xF8, 0x0F, 0x00, 0x3E, 0x01, 0xC0, 0x07, 0xC0,
  0x38, 0x00, 0xF8, 0x07, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0x83, 0xE0, 0x3C,
  0x03, 0xC0, 0xF0, 0x03, 0x81, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0x80, 0x01,
  0xE7, 0x00, 0x03, 0x9E, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x79, 0xC0, 0x00, 0xE7, 0x80, 0x01, 0xCF, 0x00, 0x07, 0x9E,
  0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x70, 0xF0, 0x01, 0xE0, 0xE0,
  0x07, 0x81, 0xE0, 0x0F, 0x03, 0xE0, 0x7C, 0x03, 0xF3, 0xF0, 0x03, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xC0, 0x7E, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x0E, 0x03, 0x80, 0x0F, 0x03, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x0F, 0x00,
  0x3C, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x0F, 0x83, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x03, 0x81, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0x79,
  0xE0, 0x00, 0xF3, 0x80, 0x01, 0xE7, 0x00, 0x03, 0xDE, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xE7, 0x80,
  0x01, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x70, 0xF0, 0x01, 0xE0, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xE0, 0x7C,
  0x03, 0xF3, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1E, 0x07, 0xE0, 0x38, 0x03, 0xE0,
  0x70, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x07, 0x07, 0x80, 0x3E, 0x0F, 0x03, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF8, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0xF0, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x03, 0x80, 0xE0, 0x07, 0x81,
  0xC0, 0x0F, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x38,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xF8, 0x0E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x60, 0x03, 0xE0, 0x7F, 0x7F, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1C, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x00,
  0x38, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x78, 0x38, 0x00, 0x78, 0x78, 0x00,
  0x70, 0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0xF0, 0x00,
  0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x70, 0x03,
  0xC0, 0x78, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x3E, 0x3F, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0E,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0x83,
  0xC0, 0x0E, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0x38, 0x0F, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x78, 0x01, 0xC0,
  0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x78,
  0x00, 0x3C, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0,
  0xF0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x0E,
  0x0F, 0x07, 0x01, 0xC1, 0xE0, 0xE0, 0x38, 0x7C, 0x38, 0x07, 0x1F, 0x87,
  0x01, 0xC3, 0xF0, 0xE0, 0x38, 0xE6, 0x18, 0x07, 0x1C, 0xC7, 0x00, 0xE7,
  0x18, 0xE0, 0x18, 0xE3, 0x18, 0x03, 0x38, 0x67, 0x00, 0xEE, 0x0C, 0xE0,
  0x1D, 0xC1, 0xD8, 0x03, 0xF0, 0x3B, 0x00, 0x6E, 0x07, 0xE0, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0x70, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0xF8,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x70, 0x00, 0x1E, 0x70,
  0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x38,
  0x01, 0xE0, 0x38, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x07, 0x80, 0x1C,
  0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x0F,
  0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xF1, 0xE3, 0xC7,
  0x8F, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7B, 0x80, 0x0E,
  0x70, 0x03, 0xCE, 0x00, 0xF0, 0xE0, 0x3C, 0x1C, 0x0F, 0x03, 0x81, 0xC0,
  0x38, 0x78, 0x07, 0x1E, 0x00, 0xE7, 0x80, 0x0F, 0xE0, 0x01, 0xD8, 0x00,
  0x39, 0x00, 0x04, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0,
  0x30, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x02, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xC0, 0xF0, 0xF8, 0x07, 0x0F, 0x80,
  0x38, 0xF8, 0x01, 0xC7, 0x80, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x07, 0x1C,
  0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0F,
  0x1C, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xF0,
  0x1F, 0x07, 0xC3, 0xF8, 0x1F, 0xFD, 0xE0, 0x7F, 0xC7, 0x00, 0x20, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xF8, 0x3E, 0x03, 0xC1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xE0, 0x01,
  0xE7, 0x00, 0x0E, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x78, 0xE0,
  0x07, 0xC7, 0x00, 0x7C, 0x78, 0x07, 0xC3, 0xC0, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x1F, 0x80, 0x21, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0x07, 0xF9,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0x80, 0xE0, 0x1F, 0x80, 0x70, 0x0F,
  0x00, 0x78, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x0E, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0,
  0xF0, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0x38,
  0x0F, 0x00, 0x1C, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x7F,
  0x80, 0x3F, 0xFD, 0xC0, 0x07, 0xF8, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0x01, 0xE1, 0xF0, 0x07,
  0x9F, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0x78, 0x00, 0xF7, 0x80,
  0x0F, 0x3C, 0x07, 0xF9, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xE0, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x01, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xE0, 0x20, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFC, 0x0F, 0x01,
  0xF0, 0x0E, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x1C,
  0x00, 0x70, 0x1C, 0x00, 0xF0, 0x1E, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFC, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x0F, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x7F, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x1E, 0x03, 0xE0,
  0xE0, 0x0F, 0x07, 0x00, 0x38, 0x78, 0x01, 0xC3, 0xC0, 0x0E, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0E, 0x1C,
  0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x70, 0x01, 0xC3, 0x80, 0x0E,
  0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x80,
  0x1E, 0x00, 0x00, 0x60, 0x03, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0xFF,
  0xE3, 0xFF, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xFF, 0x07, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x10, 0x0F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x1F, 0x03, 0x80, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x01, 0xF0,
  0x07, 0x03, 0xE0, 0x07, 0x07, 0x80, 0x0F, 0x1F, 0x00, 0x0F, 0x3E, 0x00,
  0x0E, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1C, 0xF8, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x38, 0x0F, 0x00, 0x38, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x70, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x7F, 0xE3, 0xFF,
  0x3F, 0xF8, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x27,
  0xCF, 0x3F, 0xF8, 0xFF, 0x80, 0x60, 0x03, 0xFC, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0F,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x0E, 0x1C, 0x1E, 0x1E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x3C, 0x3C,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x38, 0x70, 0x00, 0x78,
  0x70, 0x00, 0x78, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0,
  0xE0, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xF0,
  0x1F, 0x0E, 0x00, 0xF0, 0xE0, 0x07, 0x1E, 0x00, 0x71, 0xE0, 0x07, 0x1C,
  0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x73, 0xC0, 0x0F, 0x3C, 0x00, 0xF3,
  0x80, 0x0E, 0x38, 0x00, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x00, 0x1C,
  0x70, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCE, 0x00, 0x38, 0xE0, 0x03,
  0x80, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x81, 0xE0,
  0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x00, 0xE7, 0x80, 0x07, 0x38, 0x00,
  0x3B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0x78,
  0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x1E,
  0x1E, 0x01, 0xF0, 0xF0, 0x1F, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01,
  0xC0, 0x3E, 0x01, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03,
  0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x1E,
  0x03, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3D,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xF8, 0x0E, 0x0F, 0x80,
  0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1C, 0x38, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xE3, 0xC0,
  0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x07, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x7E, 0x3F, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0x78, 0x00, 0x41, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0x80,
  0x20, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x40, 0x0F, 0x07, 0xE7, 0xF0, 0x7F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0x20, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x20, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x80, 0x1E, 0x3C,
  0x00, 0xF1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00,
  0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x1C, 0x1C, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0xEF, 0xF8, 0x1F, 0xFD,
  0xE0, 0x7F, 0xC7, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x78,
  0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0x3C, 0x01, 0xE3, 0x80, 0x38, 0x70,
  0x0F, 0x0E, 0x01, 0xC1, 0xC0, 0x78, 0x38, 0x0E, 0x07, 0x83, 0x80, 0xF0,
  0xF0, 0x1E, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x07, 0x38, 0x00, 0xEF,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x9C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x60, 0x70, 0xF0, 0x70, 0x38,
  0x70, 0x78, 0x3C, 0x38, 0x3E, 0x1C, 0x1C, 0x3F, 0x0E, 0x0E, 0x1F, 0x8E,
  0x07, 0x1D, 0xC7, 0x03, 0x8C, 0xE7, 0x81, 0xCE, 0x73, 0x80, 0xEE, 0x39,
  0xC0, 0x77, 0x0D, 0xC0, 0x7F, 0x06, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x78,
  0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xB8, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x0E,
  0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x1C, 0x0F, 0x80,
  0x07, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C,
  0x07, 0x80, 0x0E, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0x80, 0x0F,
  0x01, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x0E, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x38,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x02, 0x03, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x8F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xC0, 0x1C, 0x7F, 0x80, 0xE3, 0xFF, 0x87, 0x9C, 0x1F, 0xFC,
  0x70, 0x3F, 0xE3, 0x80, 0x3F, 0x00,
};

const GFXglyph UbuntuSansMono_Italic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 11, 31, 25, 7, -30 },
  { 44, 13, 11, 25, 9, -33 },
  { 62, 26, 30, 25, 0, -30 },
  { 160, 23, 39, 25, 2, -34 },
  { 273, 30, 32, 25, -2, -31 },
  { 393, 21, 31, 25, 1, -31 },
  { 475, 6, 12, 25, 13, -33 },
  { 484, 18, 42, 25, 6, -34 },
  { 579, 18, 42, 25, 1, -34 },
  { 674, 19, 17, 25, 5, -30 },
  { 715, 20, 22, 25, 3, -24 },
  { 770, 11, 13, 25, 3, -6 },
  { 788, 11, 3, 25, 7, -14 },
  { 793, 7, 8, 25, 7, -7 },
  { 800, 28, 42, 25, -3, -34 },
  { 947, 22, 32, 25, 2, -31 },
  { 1035, 18, 30, 25, 3, -30 },
  { 1103, 22, 31, 25, 2, -31 },
  { 1189, 21, 32, 25, 2, -31 },
  { 1273, 22, 30, 25, 1, -30 },
  { 1356, 24, 31, 25, 1, -30 },
  { 1449, 22, 32, 25, 3, -31 },
  { 1537, 22, 30, 25, 5, -30 },
  { 1620, 23, 32, 25, 2, -31 },
  { 1712, 23, 31, 25, 2, -31 },
  { 1802, 11, 24, 25, 7, -23 },
  { 1835, 15, 30, 25, 3, -23 },
  { 1892, 21, 19, 25, 2, -22 },
  { 1942, 22, 12, 25, 2, -19 },
  { 1975, 22, 19, 25, 1, -22 },
  { 2028, 18, 32, 25, 6, -31 },
  { 2100, 24, 38, 25, 2, -31 },
  { 2214, 24, 30, 25, -3, -30 },
  { 2304, 24, 31, 25, 0, -31 },
  { 2397, 24, 32, 25, 3, -31 },
  { 2493, 24, 31, 25, 0, -31 },
  { 2586, 24, 30, 25, 2, -30 },
  { 2676, 24, 30, 25, 2, -30 },
  { 2766, 23, 32, 25, 2, -31 },
  { 2858, 26, 30, 25, 0, -30 },
  { 2956, 22, 30, 25, 2, -30 },
  { 3039, 23, 31, 25, 2, -30 },
  { 3129, 26, 30, 25, 1, -30 },
  { 3227, 17, 30, 25, 1, -30 },
  { 3291, 26, 30, 25, -1, -30 },
  { 3389, 27, 30, 25, 0, -30 },
  { 3491, 23, 32, 25, 2, -31 },
  { 3583, 24, 31, 25, 1, -31 },
  { 3676, 23, 39, 25, 2, -31 },
  { 3789, 23, 31, 25, 1, -31 },
  { 3879, 24, 32, 25, 1, -31 },
  { 3975, 21, 30, 25, 6, -30 },
  { 4054, 24, 31, 25, 2, -30 },
  { 4147, 23, 30, 25, 5, -30 },
  { 4234, 27, 30, 25, 1, -30 },
  { 4336, 29, 30, 25, -1, -30 },
  { 4445, 24, 30, 25, 5, -30 },
  { 4535, 26, 30, 25, 0, -30 },
  { 4633, 22, 42, 25, 3, -34 },
  { 4749, 7, 42, 25, 9, -34 },
  { 4786, 21, 42, 25, 0, -34 },
  { 4897, 19, 16, 25, 4, -30 },
  { 4935, 23, 3, 25, -3, 5 },
  { 4944, 8, 9, 25, 11, -34 },
  { 4953, 21, 24, 25, 2, -23 },
  { 5016, 21, 34, 25, 2, -34 },
  { 5106, 21, 24, 25, 2, -23 },
  { 5169, 25, 35, 25, 2, -34 },
  { 5279, 21, 24, 25, 2, -23 },
  { 5342, 29, 42, 25, -1, -34 },
  { 5495, 24, 31, 25, 0, -23 },
  { 5588, 21, 34, 25, 0, -34 },
  { 5678, 14, 34, 25, 5, -34 },
  { 5738, 23, 42, 25, 0, -34 },
  { 5859, 24, 34, 25, 1, -34 },
  { 5961, 13, 35, 25, 7, -34 },
  { 6018, 24, 23, 25, 0, -23 },
  { 6087, 20, 23, 25, 2, -23 },
  { 6145, 21, 23, 25, 2, -23 },
  { 6206, 24, 31, 25, -1, -23 },
  { 6299, 22, 31, 25, 2, -23 },
  { 6385, 21, 23, 25, 3, -23 },
  { 6446, 21, 24, 25, 2, -23 },
  { 6509, 18, 31, 25, 5, -30 },
  { 6579, 21, 23, 25, 2, -23 },
  { 6640, 19, 23, 25, 5, -23 },
  { 6695, 25, 23, 25, 2, -23 },
  { 6767, 26, 23, 25, -1, -23 },
  { 6842, 26, 31, 25, -2, -23 },
  { 6943, 22, 23, 25, 1, -23 },
  { 7007, 24, 42, 25, 2, -34 },
  { 7133, 14, 42, 25, 6, -34 },
  { 7207, 24, 42, 25, -2, -34 },
  { 7333, 22, 6, 25, 2, -16 },
};

const GFXfont UbuntuSansMono_Italic44pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic44pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic44pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _UBUNTUSANSMONO_ITALIC44PT7B_H_
