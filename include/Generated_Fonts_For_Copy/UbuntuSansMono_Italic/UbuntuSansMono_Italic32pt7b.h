#ifndef _UBUNTUSANSMONO_ITALIC32PT7B_H_
#define _UBUNTUSANSMONO_ITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x18,
  0x18, 0x18, 0x10, 0x10, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x71,
  0xB0, 0xD8, 0xCC, 0x6C, 0x36, 0x1B, 0x09, 0x0C, 0x00, 0x30, 0xE0, 0x0E,
  0x18, 0x01, 0x87, 0x00, 0x70, 0xC0, 0x0C, 0x18, 0x01, 0x87, 0x07, 0xFF,
  0xF9, 0xFF, 0xFE, 0x03, 0x86, 0x00, 0x61, 0xC0, 0x1C, 0x30, 0x03, 0x0E,
  0x00, 0xE1, 0x80, 0x18, 0x30, 0x1F, 0xFF, 0xE7, 0xFF, 0xF8, 0x18, 0x70,
  0x07, 0x0C, 0x00, 0xC3, 0x80, 0x38, 0x60, 0x06, 0x1C, 0x01, 0xC3, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x0F, 0xF0,
  0x1F, 0xFC, 0x1E, 0x0C, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC3, 0x01, 0xC3,
  0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x3F, 0x01, 0xC1, 0x98, 0x1C, 0x18, 0xC0, 0xC0,
  0xC6, 0x0C, 0x0C, 0x30, 0xC0, 0x61, 0x8C, 0x03, 0x0C, 0xE0, 0x18, 0xCE,
  0x00, 0x66, 0xE0, 0x03, 0xE6, 0x00, 0x00, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x67, 0xC0, 0x07, 0x67, 0x00, 0x73, 0x18, 0x07, 0x30, 0xC0, 0x31, 0x86,
  0x03, 0x0C, 0x70, 0x30, 0x63, 0x03, 0x03, 0x18, 0x38, 0x19, 0x83, 0x80,
  0x78, 0x00, 0x00, 0x60, 0x03, 0xF0, 0x1E, 0xF0, 0x30, 0x60, 0xE0, 0xC1,
  0xC3, 0x83, 0x06, 0x06, 0x1C, 0x0E, 0x70, 0x1D, 0xC0, 0x1F, 0x00, 0x78,
  0x71, 0xF8, 0xE7, 0x31, 0x9C, 0x77, 0x70, 0x7C, 0xE0, 0xF9, 0xC0, 0xE3,
  0x81, 0xC7, 0x07, 0xCE, 0x1F, 0x8F, 0xF3, 0x0F, 0xC7, 0x00, 0x76, 0x6E,
  0xEC, 0xCC, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x20, 0x00, 0x00, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x01, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x01, 0xC1, 0x0E, 0x1F, 0x27, 0xFF, 0xFC, 0xFF, 0x00, 0xE0, 0x0D, 0x80,
  0xEE, 0x0E, 0x38, 0xF1, 0xE1, 0x04, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x00,
  0x0C, 0x7C, 0xF9, 0xF1, 0xE1, 0xC7, 0x3C, 0xF1, 0x80, 0x7F, 0xFF, 0x77,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x07,
  0xF8, 0x1F, 0xF0, 0x78, 0x71, 0xE0, 0xE3, 0x80, 0xCE, 0x01, 0x9C, 0x03,
  0x70, 0x06, 0xE7, 0x1D, 0x8F, 0x3F, 0x3E, 0x7E, 0x3C, 0xFC, 0x71, 0xB8,
  0x07, 0x70, 0x0E, 0xC0, 0x39, 0xC0, 0x73, 0x81, 0xC7, 0x07, 0x8E, 0x1E,
  0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x07, 0xE0,
  0xFF, 0x07, 0x38, 0x41, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x78, 0x03, 0xFE, 0x07, 0xFF, 0x06,
  0x07, 0x04, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x04, 0x7F,
  0xF8, 0xFF, 0xF8, 0x00, 0x70, 0x03, 0xFC, 0x07, 0xFE, 0x02, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x3C, 0x40, 0x78, 0xFF, 0xF0, 0x7F,
  0xC0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x70,
  0x07, 0x30, 0x07, 0x38, 0x07, 0x1C, 0x07, 0x0E, 0x07, 0x06, 0x03, 0x03,
  0x03, 0x03, 0x83, 0x81, 0xC3, 0x80, 0xC1, 0xFF, 0xFC, 0xFF, 0xFE, 0x80,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x08, 0x0F, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x7F, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x80, 0x3F, 0xF0, 0x7F, 0xF8, 0x70, 0x1C, 0x60,
  0x0C, 0x60, 0x0C, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0x60,
  0x38, 0x70, 0x70, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F, 0xFF, 0x3F, 0xFE, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0xFC, 0x07, 0xDE, 0x0E, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x18, 0x07, 0x18, 0x07, 0x1C, 0x0E, 0x1C, 0x1C, 0x0F,
  0x38, 0x07, 0xF0, 0x1F, 0xF0, 0x38, 0x78, 0x70, 0x3C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x38, 0xE0, 0x70, 0x7F, 0xF0, 0x3F,
  0xC0, 0x00, 0x38, 0x00, 0xFF, 0x01, 0xF7, 0xC0, 0xE0, 0x60, 0xE0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x18, 0x03, 0x8C, 0x01, 0xC7, 0x00,
  0xC3, 0xC1, 0xE0, 0xFF, 0xF0, 0x3F, 0xB8, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7C, 0x03, 0xF8, 0x03,
  0xF0, 0x00, 0x0E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0xF0, 0x03, 0x81, 0xF0, 0x7C, 0x1F,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0F,
  0x83, 0xE0, 0xF8, 0x1E, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x0F, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x38, 0x00, 0x08, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFC, 0x18, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x1F,
  0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0x00, 0x10, 0x00, 0x00,
  0x07, 0x83, 0xFE, 0x18, 0xF0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x1E, 0x0E, 0x07, 0x01, 0xC3, 0x80,
  0x71, 0xC0, 0x1C, 0x70, 0x07, 0x38, 0x3F, 0x8E, 0x3F, 0xE7, 0x1E, 0x39,
  0xC7, 0x0E, 0x73, 0x83, 0x18, 0xE0, 0xCE, 0x30, 0x73, 0x8C, 0x1C, 0xE3,
  0x06, 0x38, 0xC1, 0x8E, 0x38, 0xE3, 0x87, 0xF8, 0x60, 0xFC, 0x18, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xD8, 0x00, 0xFE, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x07, 0x60, 0x03,
  0x30, 0x03, 0x18, 0x03, 0x8E, 0x01, 0x87, 0x01, 0xC3, 0x80, 0xC1, 0xC0,
  0xE0, 0xE0, 0x60, 0x70, 0x60, 0x18, 0x30, 0x0C, 0x3F, 0xFE, 0x1F, 0xFF,
  0x18, 0x01, 0x9C, 0x00, 0xCC, 0x00, 0x6E, 0x00, 0x36, 0x00, 0x1F, 0x00,
  0x0C, 0x07, 0xFE, 0x03, 0xFF, 0xC1, 0x80, 0xE0, 0xC0, 0x70, 0xE0, 0x18,
  0x70, 0x0C, 0x30, 0x0E, 0x18, 0x06, 0x1C, 0x0F, 0x0F, 0xFE, 0x07, 0xFE,
  0x03, 0x0F, 0xC3, 0x80, 0x61, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x30,
  0x07, 0x38, 0x03, 0x1C, 0x03, 0x8C, 0x07, 0x87, 0xFF, 0x87, 0xFE, 0x00,
  0x00, 0x3C, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xE0, 0x20, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x81, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0x83, 0xC1, 0xC0, 0xF0, 0xE0, 0x38,
  0x60, 0x0C, 0x30, 0x06, 0x38, 0x03, 0x1C, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0x67, 0x00, 0x73, 0x80, 0x39, 0x80, 0x18, 0xC0, 0x1C, 0xE0, 0x0E, 0x70,
  0x0E, 0x30, 0x0E, 0x18, 0x0F, 0x1C, 0x1E, 0x0F, 0xFE, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x81, 0xFF,
  0xC0, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFC, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xC1, 0xFF, 0xC1, 0xE0,
  0x21, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x71,
  0x80, 0x38, 0xC0, 0x18, 0x60, 0x0C, 0x38, 0x0E, 0x1C, 0x07, 0x07, 0x03,
  0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0x00, 0x60, 0xC0, 0x1C, 0x18, 0x03,
  0x87, 0x00, 0x60, 0xE0, 0x0C, 0x1C, 0x03, 0x83, 0x00, 0x70, 0xE0, 0x0C,
  0x1C, 0x01, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0x80, 0x30,
  0x70, 0x0E, 0x0C, 0x01, 0xC1, 0x80, 0x30, 0x70, 0x06, 0x0E, 0x01, 0xC1,
  0x80, 0x38, 0x30, 0x07, 0x0E, 0x00, 0xC1, 0xC0, 0x38, 0x00, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x10, 0x0E, 0x0C, 0x0E,
  0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0x00, 0xF0, 0x70, 0x1C, 0x07, 0x03,
  0x80, 0x60, 0x70, 0x06, 0x0E, 0x00, 0xE3, 0xC0, 0x0E, 0x78, 0x00, 0xCE,
  0x00, 0x0D, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xB8, 0x00, 0x19,
  0xC0, 0x03, 0x8E, 0x00, 0x38, 0x60, 0x03, 0x07, 0x00, 0x30, 0x38, 0x07,
  0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x0E, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x60,
  0x38, 0x1C, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x3C, 0x36, 0x0D, 0x86, 0xC1,
  0xB1, 0x98, 0x36, 0x36, 0x0E, 0x6C, 0xC1, 0x8D, 0x98, 0x31, 0xE3, 0x0E,
  0x38, 0x61, 0x87, 0x1C, 0x30, 0x03, 0x06, 0x00, 0x61, 0xC0, 0x0C, 0x30,
  0x03, 0x86, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0x86, 0x00, 0x31, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x60, 0xF0, 0x0C, 0x1E, 0x03, 0x83, 0xC0, 0x60,
  0xFC, 0x0C, 0x19, 0x81, 0x83, 0x30, 0x70, 0x66, 0x0E, 0x1C, 0xE1, 0x83,
  0x8C, 0x30, 0x61, 0x8E, 0x0C, 0x31, 0xC1, 0x87, 0x30, 0x70, 0x66, 0x0C,
  0x0C, 0xC1, 0x81, 0xB8, 0x30, 0x36, 0x0E, 0x03, 0xC1, 0x80, 0x78, 0x30,
  0x0F, 0x06, 0x01, 0xC1, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x03, 0xFC, 0x07,
  0xFE, 0x0E, 0x0E, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x30, 0x03, 0x70,
  0x07, 0x60, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xC0, 0x06, 0xC0,
  0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x38, 0xE0, 0x30, 0xF0,
  0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x83, 0x81, 0xC1,
  0xC0, 0x70, 0xC0, 0x38, 0x60, 0x1C, 0x70, 0x0E, 0x38, 0x06, 0x18, 0x03,
  0x0C, 0x03, 0x8E, 0x03, 0x87, 0xFF, 0x83, 0xFF, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x03, 0xFC, 0x07, 0xFE, 0x0E, 0x0E,
  0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x30, 0x03, 0x70, 0x07, 0x60, 0x07,
  0x60, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x38, 0xE0, 0x30, 0xF0, 0xF0, 0x7F, 0xE0,
  0x3F, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xE0,
  0x00, 0x40, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x70, 0x38, 0x18, 0x06, 0x06,
  0x01, 0xC3, 0x80, 0x60, 0xE0, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x87, 0x01,
  0xC1, 0xC1, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x0E, 0x1C, 0x03, 0x83, 0x00,
  0xC0, 0xE0, 0x30, 0x38, 0x1C, 0x06, 0x07, 0x01, 0xC1, 0x80, 0x70, 0x60,
  0x0C, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xE0,
  0x20, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x84, 0x03,
  0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x1C, 0x01, 0x8E, 0x01, 0xC6, 0x00, 0xE7, 0x00, 0x63, 0x80, 0x31,
  0xC0, 0x38, 0xC0, 0x1C, 0x60, 0x0C, 0x70, 0x06, 0x38, 0x07, 0x18, 0x03,
  0x8C, 0x01, 0x8E, 0x00, 0xC7, 0x00, 0x63, 0x00, 0x71, 0x80, 0x38, 0xC0,
  0x18, 0x60, 0x1C, 0x38, 0x0C, 0x1C, 0x0E, 0x07, 0xFE, 0x01, 0xFE, 0x00,
  0xC0, 0x07, 0xE0, 0x03, 0xB0, 0x01, 0x98, 0x01, 0xCC, 0x00, 0xC6, 0x00,
  0xE3, 0x00, 0x61, 0x80, 0x70, 0xC0, 0x70, 0x60, 0x30, 0x38, 0x38, 0x1C,
  0x18, 0x0E, 0x1C, 0x07, 0x0C, 0x03, 0x8E, 0x01, 0xC6, 0x00, 0x67, 0x00,
  0x33, 0x00, 0x1B, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x1C, 0x30,
  0x03, 0x0E, 0x00, 0x61, 0x80, 0x1C, 0x30, 0xC3, 0x06, 0x38, 0x60, 0xC7,
  0x0C, 0x39, 0xB3, 0x86, 0x36, 0x60, 0xCC, 0xCC, 0x1B, 0x99, 0x83, 0x63,
  0x60, 0x78, 0x6C, 0x1B, 0x0D, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x18,
  0x01, 0x81, 0xC0, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x01, 0x9C, 0x00, 0x0E,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0xEE, 0x00, 0x0E, 0x30, 0x00, 0x71, 0xC0, 0x07, 0x06,
  0x00, 0x70, 0x30, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x07, 0x00, 0x30, 0x78,
  0x01, 0xC0, 0xE0, 0x03, 0xF0, 0x03, 0xB8, 0x03, 0x8C, 0x01, 0xC6, 0x01,
  0xC3, 0x81, 0xC1, 0xC0, 0xC0, 0x60, 0xE0, 0x30, 0xE0, 0x1C, 0xE0, 0x06,
  0x60, 0x03, 0x60, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xC6, 0x31, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xC6, 0x31, 0x8C, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x71,
  0x8C, 0x63, 0x1C, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x3E, 0x01, 0xDC, 0x06, 0x30,
  0x38, 0xC1, 0xC3, 0x8E, 0x06, 0x70, 0x19, 0x80, 0x7E, 0x00, 0xD0, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0x23, 0x87, 0x0E, 0x18, 0x70, 0x80, 0x00, 0x7E,
  0x03, 0xFF, 0x0F, 0x87, 0x1E, 0x06, 0x1C, 0x06, 0x38, 0x0E, 0x70, 0x0E,
  0x70, 0x0C, 0x60, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x18,
  0xE0, 0x38, 0x70, 0x78, 0x7F, 0xF8, 0x3F, 0x98, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0xF8, 0x0F, 0xFC, 0x1F, 0x1E, 0x1C, 0x06, 0x18, 0x07, 0x18, 0x07,
  0x18, 0x07, 0x38, 0x07, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x70, 0x1C,
  0x70, 0x1C, 0x60, 0x38, 0x60, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0xFE,
  0x07, 0xFF, 0x0F, 0x02, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x08, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0xFE, 0x03, 0xFF, 0x03, 0xE1, 0x83, 0x81, 0xC3, 0x80, 0xC3,
  0x80, 0x61, 0xC0, 0x31, 0xC0, 0x38, 0xE0, 0x18, 0x60, 0x0C, 0x30, 0x0E,
  0x18, 0x07, 0x0C, 0x03, 0x87, 0x01, 0x83, 0x81, 0xC0, 0xFF, 0xF0, 0x3F,
  0xB8, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x3C, 0x38, 0xE0, 0x33, 0x80, 0x66,
  0x00, 0xDC, 0x03, 0xB0, 0x1E, 0xFF, 0xF9, 0xFF, 0xC3, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1E, 0x02, 0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xC4, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x04,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x7F,
  0xF0, 0x3E, 0x18, 0x1E, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0xC1, 0xC0, 0x30,
  0x60, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x30,
  0x0E, 0x0E, 0x07, 0x01, 0xFF, 0xC0, 0x3F, 0xB0, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0xC0, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x38, 0x78, 0xE0, 0x71, 0xC0,
  0x63, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x38, 0x0E, 0x70, 0x1C, 0xC0, 0x39,
  0x80, 0x67, 0x00, 0xCE, 0x03, 0x98, 0x07, 0x30, 0x0C, 0xE0, 0x38, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xFC, 0xFE, 0x3F, 0x80,
  0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x38, 0x07, 0x01, 0xFC, 0x1E, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x18, 0x38, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x03, 0x86, 0x03, 0x87, 0x07, 0x83, 0x87, 0x01, 0x87,
  0x00, 0xCF, 0x00, 0x6F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x19, 0xC0, 0x0C,
  0x70, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x03, 0x81, 0x80, 0xE1, 0xC0, 0x70,
  0xE0, 0x1C, 0x00, 0x7F, 0x3F, 0xBF, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C,
  0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC2, 0xFF, 0x3F, 0x80, 0x07, 0xCF, 0x07, 0xFF,
  0xC7, 0x3C, 0xE3, 0x8C, 0x31, 0x86, 0x18, 0xC3, 0x1C, 0xE3, 0x8E, 0x71,
  0xC6, 0x30, 0xC3, 0x18, 0x61, 0x9C, 0x71, 0xCE, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x33, 0x80, 0x39, 0xC0, 0x1C, 0xC0, 0x0C, 0x00, 0x03, 0xF8, 0x1F,
  0xF8, 0x38, 0x78, 0xE0, 0x71, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x9C, 0x03,
  0x38, 0x0E, 0x60, 0x1C, 0xC0, 0x33, 0x80, 0x67, 0x01, 0xCC, 0x03, 0x98,
  0x06, 0x30, 0x0C, 0xE0, 0x38, 0x03, 0xF0, 0x1F, 0xF0, 0x78, 0xF1, 0xE0,
  0x63, 0x80, 0xEE, 0x01, 0xD8, 0x03, 0xF0, 0x07, 0xE0, 0x0D, 0x80, 0x1B,
  0x00, 0x76, 0x00, 0xEC, 0x03, 0x9C, 0x0F, 0x38, 0x3C, 0x3F, 0xF0, 0x3F,
  0x80, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xC3, 0xC1, 0xC0, 0xE0, 0xC0, 0x38,
  0x60, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x0C, 0x01, 0x8E, 0x01,
  0xC7, 0x00, 0xC3, 0x80, 0xE1, 0x80, 0xE0, 0xC1, 0xE0, 0xFF, 0xE0, 0x7F,
  0xC0, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xFE, 0x0F, 0xFC, 0x3C, 0x38, 0xE0, 0x73, 0x80, 0xEE,
  0x01, 0x98, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0x80, 0x33, 0x00, 0xE6, 0x01,
  0xCC, 0x03, 0x9C, 0x06, 0x38, 0x1C, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0x01, 0xFE,
  0x1F, 0xFC, 0x38, 0x08, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xFA, 0x0F, 0xF8, 0x3C, 0x30,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x10, 0x1C, 0x7F, 0xF0,
  0xFF, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x43, 0xFC,
  0x0F, 0xE0, 0x38, 0x06, 0x70, 0x1C, 0xC0, 0x3B, 0x80, 0x67, 0x00, 0xCE,
  0x03, 0x98, 0x07, 0x30, 0x0C, 0xE0, 0x19, 0xC0, 0x73, 0x00, 0xE6, 0x01,
  0x8C, 0x03, 0x18, 0x0E, 0x38, 0x3C, 0x3F, 0xF8, 0x3F, 0x38, 0xC0, 0x1F,
  0x00, 0x6C, 0x03, 0xB0, 0x0C, 0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x38, 0x30,
  0xE1, 0xC3, 0x86, 0x06, 0x38, 0x18, 0xC0, 0x66, 0x01, 0xF8, 0x07, 0xC0,
  0x1E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xEC, 0x00,
  0x6E, 0x00, 0x37, 0x0C, 0x3B, 0x8E, 0x19, 0xC7, 0x1C, 0xC7, 0x8C, 0x63,
  0x66, 0x33, 0x37, 0x1B, 0x1B, 0x0D, 0x8F, 0x87, 0x87, 0x83, 0xC3, 0xC1,
  0xC1, 0xC0, 0xC0, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0xE0, 0x38, 0x0E, 0x0E,
  0x01, 0xC1, 0x80, 0x1C, 0x60, 0x03, 0x9C, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x01, 0xCC, 0x00, 0x71, 0xC0,
  0x1C, 0x18, 0x07, 0x03, 0x81, 0xC0, 0x70, 0xF0, 0x07, 0x00, 0x03, 0x00,
  0x70, 0x30, 0x06, 0x03, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x38,
  0x1C, 0x03, 0x81, 0xC0, 0x18, 0x18, 0x01, 0x83, 0x80, 0x1C, 0x30, 0x01,
  0xC7, 0x00, 0x1C, 0x60, 0x00, 0xCE, 0x00, 0x0C, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x43, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x38,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0,
  0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x1C, 0x04, 0xFE,
  0x0D, 0x9E, 0x36, 0x0F, 0xEC, 0x0F, 0x00,
};

const GFXglyph UbuntuSansMono_Italic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 8, 22, 18, 5, -22 },
  { 23, 9, 8, 18, 7, -24 },
  { 32, 19, 22, 18, 0, -22 },
  { 85, 17, 28, 18, 1, -25 },
  { 145, 21, 23, 18, -1, -23 },
  { 206, 15, 23, 18, 1, -23 },
  { 250, 4, 9, 18, 10, -24 },
  { 255, 13, 31, 18, 4, -25 },
  { 306, 13, 31, 18, 1, -25 },
  { 357, 13, 13, 18, 4, -22 },
  { 379, 15, 15, 18, 2, -17 },
  { 408, 7, 10, 18, 3, -5 },
  { 417, 8, 2, 18, 5, -10 },
  { 419, 5, 5, 18, 5, -5 },
  { 423, 20, 31, 18, -2, -25 },
  { 501, 15, 23, 18, 2, -23 },
  { 545, 13, 22, 18, 2, -22 },
  { 581, 16, 23, 18, 1, -23 },
  { 627, 16, 23, 18, 1, -23 },
  { 673, 17, 22, 18, 0, -22 },
  { 720, 17, 22, 18, 1, -22 },
  { 767, 16, 22, 18, 2, -22 },
  { 811, 16, 22, 18, 4, -22 },
  { 855, 16, 23, 18, 2, -23 },
  { 901, 17, 23, 18, 1, -23 },
  { 950, 8, 17, 18, 5, -17 },
  { 967, 10, 22, 18, 3, -17 },
  { 995, 16, 14, 18, 1, -16 },
  { 1023, 16, 9, 18, 1, -14 },
  { 1041, 15, 14, 18, 1, -16 },
  { 1068, 12, 23, 18, 5, -23 },
  { 1103, 18, 28, 18, 1, -23 },
  { 1166, 17, 22, 18, -2, -22 },
  { 1213, 17, 22, 18, 0, -22 },
  { 1260, 17, 23, 18, 2, -23 },
  { 1309, 17, 22, 18, 0, -22 },
  { 1356, 18, 22, 18, 1, -22 },
  { 1406, 18, 22, 18, 1, -22 },
  { 1456, 17, 23, 18, 2, -23 },
  { 1505, 19, 22, 18, 0, -22 },
  { 1558, 16, 22, 18, 2, -22 },
  { 1602, 17, 22, 18, 1, -22 },
  { 1649, 20, 22, 18, 0, -22 },
  { 1704, 12, 22, 18, 1, -22 },
  { 1737, 19, 22, 18, -1, -22 },
  { 1790, 19, 22, 18, 0, -22 },
  { 1843, 16, 23, 18, 2, -23 },
  { 1889, 17, 22, 18, 1, -22 },
  { 1936, 16, 29, 18, 2, -23 },
  { 1994, 18, 22, 18, 0, -22 },
  { 2044, 17, 23, 18, 1, -23 },
  { 2093, 16, 22, 18, 4, -22 },
  { 2137, 17, 22, 18, 2, -22 },
  { 2184, 17, 22, 18, 4, -22 },
  { 2231, 19, 22, 18, 1, -22 },
  { 2284, 21, 22, 18, -1, -22 },
  { 2342, 17, 22, 18, 4, -22 },
  { 2389, 19, 22, 18, 0, -22 },
  { 2442, 16, 31, 18, 2, -25 },
  { 2504, 5, 31, 18, 7, -25 },
  { 2524, 15, 31, 18, 0, -25 },
  { 2583, 14, 12, 18, 3, -22 },
  { 2604, 16, 2, 18, -2, 4 },
  { 2608, 6, 7, 18, 8, -25 },
  { 2614, 16, 17, 18, 1, -17 },
  { 2648, 16, 25, 18, 1, -25 },
  { 2698, 16, 17, 18, 1, -17 },
  { 2732, 17, 25, 18, 2, -25 },
  { 2786, 15, 17, 18, 1, -17 },
  { 2818, 21, 31, 18, -1, -25 },
  { 2900, 18, 23, 18, 0, -17 },
  { 2952, 15, 25, 18, 0, -25 },
  { 2999, 10, 24, 18, 4, -24 },
  { 3029, 17, 30, 18, 0, -24 },
  { 3093, 17, 25, 18, 1, -25 },
  { 3147, 9, 25, 18, 5, -25 },
  { 3176, 17, 17, 18, 0, -17 },
  { 3213, 15, 17, 18, 1, -17 },
  { 3245, 15, 17, 18, 2, -17 },
  { 3277, 17, 23, 18, 0, -17 },
  { 3326, 15, 23, 18, 2, -17 },
  { 3370, 15, 17, 18, 2, -17 },
  { 3402, 15, 17, 18, 2, -17 },
  { 3434, 13, 22, 18, 4, -22 },
  { 3470, 15, 17, 18, 2, -17 },
  { 3502, 14, 17, 18, 4, -17 },
  { 3532, 17, 17, 18, 2, -17 },
  { 3569, 19, 17, 18, -1, -17 },
  { 3610, 20, 23, 18, -2, -17 },
  { 3668, 16, 17, 18, 1, -17 },
  { 3702, 17, 31, 18, 2, -25 },
  { 3768, 10, 31, 18, 4, -25 },
  { 3807, 17, 31, 18, -1, -25 },
  { 3873, 15, 5, 18, 2, -12 },
};

const GFXfont UbuntuSansMono_Italic32pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic32pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _UBUNTUSANSMONO_ITALIC32PT7B_H_
