#ifndef _UBUNTUSANSMONO_ITALIC30PT7B_H_
#define _UBUNTUSANSMONO_ITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x61, 0x83,
  0x06, 0x00, 0x00, 0x00, 0xC3, 0xC7, 0x8E, 0x00, 0x31, 0x98, 0xD8, 0x6C,
  0x66, 0x33, 0x19, 0x09, 0x84, 0x00, 0x71, 0xC0, 0x18, 0x60, 0x0E, 0x18,
  0x03, 0x0C, 0x01, 0xC3, 0x00, 0x61, 0xC1, 0xFF, 0xFC, 0xFF, 0xFE, 0x03,
  0x0C, 0x01, 0x87, 0x00, 0x61, 0x80, 0x38, 0x60, 0x0C, 0x30, 0x1F, 0xFF,
  0xC7, 0xFF, 0xE2, 0x61, 0x80, 0x30, 0xE0, 0x0C, 0x30, 0x07, 0x1C, 0x01,
  0x86, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0xFC, 0x03, 0xFF, 0x07, 0x86, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x60, 0x78, 0xFF, 0xF0, 0x7F,
  0xC0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x70,
  0x6C, 0x06, 0x0C, 0x60, 0xC0, 0xC6, 0x18, 0x18, 0x63, 0x01, 0x84, 0x60,
  0x18, 0xCE, 0x01, 0x8D, 0xC0, 0x1D, 0x98, 0x00, 0xF3, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0xF0, 0x01, 0x9F, 0x00, 0x3B, 0x18, 0x07, 0x31, 0x80, 0x66,
  0x18, 0x0C, 0x61, 0x81, 0x86, 0x30, 0x30, 0x63, 0x06, 0x07, 0x60, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0xE0, 0xC7, 0x03, 0x38, 0x0F, 0xC0, 0x1E, 0x01, 0xF0, 0xCE, 0xC6, 0x73,
  0x99, 0x87, 0x6E, 0x0F, 0x30, 0x3C, 0xC0, 0x63, 0x03, 0xCE, 0x1F, 0x1F,
  0xEC, 0x3E, 0x38, 0x37, 0x66, 0x6E, 0xCC, 0xC0, 0x00, 0x30, 0x0F, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0x80, 0x08, 0x00, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x30, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x0C, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x60, 0x06, 0x08, 0x61, 0xE6, 0x7F, 0xFF, 0x3F, 0x80, 0xF0,
  0x1F, 0x83, 0x9C, 0x71, 0xE3, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x1E, 0x3C, 0x78,
  0xF0, 0xE1, 0x9F, 0x78, 0x40, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xE1,
  0xC7, 0x07, 0x18, 0x0C, 0xE0, 0x33, 0x00, 0xDC, 0x03, 0x63, 0x0F, 0x9E,
  0x7E, 0x79, 0xF9, 0xE6, 0xC0, 0x1B, 0x00, 0xEC, 0x03, 0x30, 0x1C, 0xC0,
  0x63, 0x03, 0x8E, 0x1C, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x30, 0x07, 0x01,
  0xE0, 0x3E, 0x1F, 0x61, 0xCE, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07,
  0x0F, 0xFE, 0xFF, 0xE0, 0x03, 0xF8, 0x0F, 0xF8, 0x38, 0x38, 0x20, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF8,
  0x18, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x71, 0x01, 0xC7, 0xFF, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xEE, 0x01, 0xCC,
  0x03, 0x8C, 0x03, 0x1C, 0x06, 0x1C, 0x0C, 0x18, 0x1C, 0x18, 0x38, 0x38,
  0x30, 0x38, 0x70, 0x30, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0F, 0x00,
  0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x80, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0,
  0x00, 0x1E, 0x00, 0xFC, 0x07, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x33, 0xC0, 0xFF, 0xE1, 0xFB, 0xE3, 0x01, 0xCE, 0x01,
  0x9C, 0x03, 0x38, 0x06, 0x70, 0x0C, 0xE0, 0x39, 0xC0, 0x61, 0x81, 0xC3,
  0xDF, 0x03, 0xF8, 0x00, 0x3F, 0xFE, 0x7F, 0xF9, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF8,
  0x38, 0x30, 0xE0, 0x71, 0x80, 0xE3, 0x01, 0xC6, 0x03, 0x0C, 0x0E, 0x1C,
  0x38, 0x1E, 0xE0, 0x3F, 0x81, 0xCF, 0x87, 0x07, 0x1C, 0x07, 0x30, 0x0E,
  0x60, 0x1C, 0xC0, 0x39, 0x80, 0x63, 0x81, 0xC7, 0xFF, 0x07, 0xF8, 0x00,
  0x01, 0xF8, 0x07, 0xFE, 0x0F, 0x0E, 0x0E, 0x06, 0x1C, 0x07, 0x18, 0x07,
  0x18, 0x07, 0x18, 0x07, 0x18, 0x06, 0x18, 0x06, 0x1E, 0x3E, 0x0F, 0xFE,
  0x03, 0xCC, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0xC0, 0x7F, 0x00, 0xF8, 0x00, 0x1E, 0x7C, 0xF8, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x00, 0x03, 0xC1, 0xF0, 0x7C,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x38, 0x0C, 0x1F, 0x0F, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x3C, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x1C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0x00, 0x3F, 0xFE,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x7F,
  0xFE, 0x10, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xC0, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x3C, 0x00, 0x80, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x70, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x01, 0xFF,
  0x81, 0xE1, 0xC1, 0xE0, 0x60, 0xE0, 0x38, 0xE0, 0x18, 0xE0, 0x0C, 0x70,
  0xFE, 0x30, 0xFF, 0x38, 0xE3, 0x9C, 0xE1, 0x8C, 0x60, 0xCE, 0x70, 0x67,
  0x38, 0x73, 0x9C, 0x31, 0xCE, 0x18, 0xE7, 0x0C, 0x71, 0xEE, 0x38, 0x7F,
  0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x36, 0x00, 0x66,
  0x00, 0x67, 0x00, 0xC7, 0x01, 0xC7, 0x01, 0x87, 0x03, 0x83, 0x03, 0x03,
  0x06, 0x03, 0x06, 0x03, 0x0F, 0xFF, 0x0F, 0xFF, 0x18, 0x03, 0x18, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x60, 0x03, 0xE0, 0x03, 0x07, 0xFC, 0x07, 0xFE,
  0x06, 0x0F, 0x0E, 0x07, 0x0E, 0x03, 0x0C, 0x03, 0x0C, 0x07, 0x1C, 0x06,
  0x1C, 0x1C, 0x1F, 0xF8, 0x1F, 0xF8, 0x38, 0x3C, 0x38, 0x0E, 0x30, 0x0E,
  0x30, 0x0E, 0x30, 0x0E, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0x38, 0x7F, 0xF0,
  0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFF, 0x0F, 0x02, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x20, 0x7F, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xFC,
  0x0E, 0x1E, 0x0C, 0x0E, 0x0C, 0x07, 0x0C, 0x03, 0x1C, 0x03, 0x18, 0x03,
  0x18, 0x03, 0x18, 0x03, 0x38, 0x03, 0x38, 0x07, 0x30, 0x07, 0x30, 0x06,
  0x70, 0x0E, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0x38, 0x60, 0xF0, 0xFF, 0xC0,
  0xFF, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0F, 0xFE, 0x07,
  0xFE, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFF,
  0x07, 0x03, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x1C,
  0xE0, 0x1C, 0x60, 0x18, 0x60, 0x18, 0x70, 0x38, 0x78, 0x38, 0x3F, 0xF0,
  0x1F, 0xF0, 0x06, 0x00, 0xC1, 0x80, 0x70, 0xE0, 0x18, 0x38, 0x06, 0x0C,
  0x01, 0x83, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0C, 0x18, 0x03, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0xE0, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x83, 0x00, 0xE1,
  0xC0, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x01, 0xC3, 0x80, 0x60, 0xC0,
  0x18, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x60, 0xE0, 0xFF, 0xE0,
  0x7F, 0xC0, 0x07, 0x01, 0xC1, 0x80, 0xE0, 0x60, 0x70, 0x18, 0x38, 0x0E,
  0x1C, 0x03, 0x0E, 0x00, 0xC7, 0x00, 0x33, 0x80, 0x1D, 0xC0, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x6E, 0x00, 0x39, 0xC0, 0x0E, 0x30, 0x03, 0x0E, 0x00,
  0xC1, 0xC0, 0x70, 0x30, 0x1C, 0x0E, 0x06, 0x01, 0x81, 0x80, 0x70, 0xE0,
  0x1C, 0x00, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0x80,
  0xC0, 0x60, 0x70, 0x3C, 0x1C, 0x0F, 0x0F, 0x02, 0xC3, 0xC1, 0xB1, 0xB0,
  0x6C, 0x4C, 0x33, 0x36, 0x0C, 0xD9, 0x83, 0x36, 0x60, 0xCF, 0x18, 0x63,
  0xC6, 0x18, 0xE3, 0x86, 0x00, 0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x30, 0x07,
  0x1C, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x18, 0xE0, 0x06, 0x00, 0x07, 0x00,
  0xC1, 0xC0, 0x30, 0x70, 0x1C, 0x3E, 0x06, 0x0D, 0x81, 0x83, 0x60, 0x60,
  0xDC, 0x38, 0x73, 0x0C, 0x18, 0xC3, 0x06, 0x30, 0xC1, 0x8E, 0x30, 0x61,
  0x98, 0x30, 0x66, 0x0C, 0x19, 0x83, 0x06, 0x60, 0xC0, 0xF0, 0x60, 0x3C,
  0x18, 0x0F, 0x06, 0x03, 0xC1, 0x80, 0xF0, 0xE0, 0x18, 0x00, 0x03, 0xF8,
  0x0F, 0xF8, 0x38, 0x70, 0xE0, 0x73, 0x80, 0xE6, 0x01, 0xDC, 0x01, 0xB0,
  0x07, 0x60, 0x0F, 0xC0, 0x1F, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x03,
  0xB0, 0x06, 0x60, 0x1C, 0xC0, 0x31, 0x80, 0xE3, 0x83, 0x83, 0xFE, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xFC, 0x0C, 0x0E, 0x0C, 0x07, 0x0C, 0x07,
  0x1C, 0x07, 0x1C, 0x07, 0x18, 0x06, 0x18, 0x06, 0x38, 0x0C, 0x38, 0x3C,
  0x3F, 0xF0, 0x3F, 0xC0, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xF8,
  0x38, 0x70, 0xE0, 0x73, 0x80, 0xE6, 0x01, 0xDC, 0x01, 0xB0, 0x07, 0x60,
  0x0F, 0xC0, 0x1F, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x03, 0xB0, 0x06,
  0x60, 0x1C, 0xC0, 0x31, 0x80, 0xE3, 0x83, 0x83, 0xFE, 0x03, 0xF8, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x07, 0xF8, 0x07,
  0xFE, 0x06, 0x0F, 0x06, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C,
  0x03, 0x1C, 0x07, 0x18, 0x0E, 0x18, 0x7C, 0x1F, 0xF8, 0x3F, 0xE0, 0x38,
  0x60, 0x30, 0x70, 0x30, 0x30, 0x70, 0x38, 0x70, 0x38, 0x60, 0x18, 0x60,
  0x18, 0xE0, 0x1C, 0x01, 0xFE, 0x07, 0xFF, 0x07, 0x02, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x40, 0x70, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x18, 0x03,
  0x18, 0x07, 0x38, 0x07, 0x38, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x30, 0x0E,
  0x70, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0xE0, 0x18, 0xC0, 0x18,
  0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x70, 0xE0, 0xE0,
  0x7F, 0xC0, 0x3F, 0x80, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E,
  0xE0, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x30, 0x60, 0x30, 0x60, 0x60,
  0x60, 0xE0, 0x60, 0xC0, 0x61, 0xC0, 0x61, 0x80, 0x63, 0x80, 0x63, 0x00,
  0x76, 0x00, 0x76, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1C, 0x01,
  0xC6, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x38, 0x03, 0x8E, 0x00, 0xC3,
  0x00, 0x30, 0xC0, 0x1C, 0x31, 0xC6, 0x0C, 0x71, 0x86, 0x3C, 0x61, 0x8B,
  0x30, 0x66, 0xCC, 0x1B, 0x33, 0x06, 0xCC, 0x81, 0x63, 0x60, 0xD8, 0x58,
  0x3C, 0x14, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x00, 0x03, 0x80,
  0x70, 0x38, 0x0E, 0x01, 0x80, 0xC0, 0x1C, 0x1C, 0x01, 0xC3, 0x80, 0x0C,
  0x70, 0x00, 0xE6, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x80, 0x01, 0xD8, 0x00, 0x39, 0x80, 0x03, 0x1C, 0x00,
  0x70, 0xC0, 0x0E, 0x0C, 0x01, 0xC0, 0xE0, 0x38, 0x06, 0x07, 0x00, 0x60,
  0xE0, 0x07, 0x00, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x0C, 0xE0, 0x18, 0x60,
  0x38, 0x60, 0x30, 0x60, 0x60, 0x70, 0xC0, 0x31, 0xC0, 0x31, 0x80, 0x3B,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0xE7, 0x38, 0xC6, 0x31, 0x8C, 0x63, 0x1C, 0xE7,
  0x39, 0xCE, 0x71, 0x8C, 0x63, 0x18, 0xC7, 0x39, 0xCE, 0x73, 0x80, 0x03,
  0xFC, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xC0,
  0xFE, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x0E, 0xC0, 0xE6, 0x0E, 0x30,
  0x60, 0xC6, 0x06, 0x70, 0x37, 0x01, 0xF0, 0x06, 0xFF, 0xFF, 0xFF, 0xFC,
  0x47, 0x1C, 0x61, 0x88, 0x00, 0xFC, 0x07, 0xFC, 0x3C, 0x30, 0xE0, 0x63,
  0x80, 0xC6, 0x03, 0x9C, 0x06, 0x30, 0x0C, 0xE0, 0x19, 0xC0, 0x73, 0x80,
  0xE7, 0x01, 0x8E, 0x03, 0x0C, 0x0E, 0x1F, 0xFC, 0x1F, 0xDC, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0xF8, 0x1F, 0xF8, 0x3C, 0x38, 0x60, 0x30, 0xC0, 0x73, 0x80, 0xE6, 0x01,
  0xCC, 0x03, 0x98, 0x06, 0x30, 0x1C, 0xE0, 0x39, 0x80, 0xE3, 0x03, 0x86,
  0x0E, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x38, 0x10,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x02, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0x0C, 0x3C, 0x1C, 0x30, 0x18,
  0x70, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30,
  0xC0, 0x70, 0xC0, 0x60, 0xE0, 0xE0, 0x7F, 0xF0, 0x3F, 0x30, 0x01, 0xF0,
  0x1F, 0xF1, 0xE1, 0xCF, 0x03, 0x38, 0x0D, 0xC0, 0x36, 0x01, 0xF8, 0x3E,
  0xFF, 0xF3, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x43, 0xFF,
  0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x5E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x81, 0xF0, 0xC1, 0xE0, 0xE0,
  0xE0, 0x70, 0xE0, 0x30, 0x60, 0x18, 0x70, 0x0C, 0x30, 0x0E, 0x18, 0x06,
  0x0C, 0x03, 0x06, 0x01, 0x83, 0x81, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x20, 0x1C, 0x1E, 0x7C, 0x0F, 0xFC, 0x01,
  0xD0, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0xF8, 0x0F, 0xF8, 0x3C, 0x38, 0x70, 0x30, 0xC0,
  0x61, 0x80, 0xE3, 0x01, 0x8E, 0x03, 0x18, 0x06, 0x30, 0x1C, 0x60, 0x39,
  0xC0, 0x63, 0x00, 0xC6, 0x03, 0x8C, 0x07, 0x38, 0x0C, 0x00, 0x03, 0x81,
  0xE0, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x21, 0x80, 0x60,
  0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0xF0, 0x7C, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0xF7, 0x80, 0xFF, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x07, 0x1C, 0x0E, 0x1C, 0x3C, 0x18, 0x70, 0x18,
  0xE0, 0x3B, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x37, 0x00, 0x73, 0x80, 0x71,
  0xC0, 0x60, 0xC0, 0x60, 0xE0, 0x60, 0x70, 0xE0, 0x30, 0xC0, 0x38, 0xFE,
  0x7F, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x0B, 0xF8,
  0xFE, 0x0F, 0x9E, 0x1F, 0xFF, 0x18, 0xE7, 0x18, 0xE3, 0x18, 0xC3, 0x38,
  0xC3, 0x30, 0xC7, 0x31, 0xC6, 0x31, 0xC6, 0x71, 0x86, 0x60, 0x0E, 0x60,
  0x0C, 0x60, 0x0C, 0xE0, 0x0C, 0xE0, 0x1C, 0xC0, 0x18, 0x03, 0xF0, 0x7F,
  0xE1, 0xC3, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x80, 0xCC, 0x03, 0x30,
  0x1C, 0xC0, 0x77, 0x01, 0x98, 0x06, 0x60, 0x39, 0x80, 0xEE, 0x03, 0x38,
  0x0C, 0x03, 0xE0, 0x3F, 0xC1, 0xE3, 0x8E, 0x06, 0x70, 0x1D, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0xB0, 0x0C, 0xC0, 0x73,
  0x83, 0x87, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x0E, 0x1E, 0x0C,
  0x06, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x07, 0x18, 0x06, 0x38,
  0x06, 0x38, 0x0E, 0x30, 0x1C, 0x30, 0x3C, 0x70, 0x78, 0x7F, 0xE0, 0x7F,
  0xC0, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x01, 0xF8, 0x1F, 0xF1, 0xF1, 0xCF, 0x07, 0x70, 0x19, 0x80, 0x6E,
  0x03, 0xB0, 0x0E, 0xC0, 0x33, 0x00, 0xCC, 0x07, 0x30, 0x1C, 0xC0, 0x63,
  0x83, 0x8F, 0xFE, 0x1F, 0xF8, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x03, 0xFC, 0x7F, 0xF1, 0xC0, 0x46, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x7F, 0xC7,
  0x86, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x18, 0x00, 0xE0, 0x06, 0x40, 0x73, 0xFF, 0x1F, 0xF0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x7F, 0x83, 0xF8, 0x30, 0x0C, 0xC0, 0x77, 0x01, 0x9C, 0x06, 0x60,
  0x19, 0x80, 0xE6, 0x03, 0xB8, 0x0C, 0xC0, 0x33, 0x01, 0xCC, 0x07, 0x30,
  0x18, 0xC0, 0x63, 0x83, 0x8F, 0xFE, 0x1F, 0xDC, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0xCC, 0x18, 0xC3, 0x8E, 0x30, 0xE7,
  0x06, 0x60, 0x6C, 0x07, 0xC0, 0x78, 0x07, 0x00, 0x60, 0x03, 0x60, 0x03,
  0x60, 0x06, 0xE0, 0x06, 0xE1, 0x0E, 0xC3, 0x8C, 0xC3, 0x8C, 0xC7, 0x9C,
  0xCD, 0x98, 0xCD, 0x98, 0xD9, 0xB0, 0xD9, 0xB0, 0xF1, 0xE0, 0xE1, 0xE0,
  0xE0, 0xE0, 0xC0, 0xC0, 0x06, 0x01, 0xC1, 0xC0, 0xE0, 0x30, 0x70, 0x0E,
  0x18, 0x01, 0x8C, 0x00, 0x76, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x7C, 0x00, 0x3B, 0x00, 0x1C, 0xE0, 0x0E, 0x18, 0x07, 0x07, 0x03,
  0x80, 0xC3, 0xC0, 0x38, 0x03, 0x00, 0xE0, 0x60, 0x18, 0x0C, 0x03, 0x01,
  0x80, 0xE0, 0x30, 0x18, 0x07, 0x03, 0x00, 0xE0, 0xE0, 0x1C, 0x18, 0x01,
  0x87, 0x00, 0x30, 0xC0, 0x06, 0x38, 0x00, 0xE6, 0x00, 0x0D, 0xC0, 0x01,
  0xB0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x27, 0x80, 0x0F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFE, 0x1F,
  0xF8, 0x40, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F,
  0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x07,
  0x80, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x00, 0x03, 0xF8,
  0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x0F, 0x00, 0xFE, 0x00, 0xE0, 0x00, 0x1E, 0x06, 0x7F, 0x1D,
  0x87, 0xF7, 0x07, 0xC0,
};

const GFXglyph UbuntuSansMono_Italic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 7, 21, 17, 5, -21 },
  { 20, 9, 8, 17, 6, -23 },
  { 29, 18, 21, 17, 0, -21 },
  { 77, 16, 26, 17, 1, -23 },
  { 129, 20, 21, 17, -1, -21 },
  { 182, 14, 21, 17, 1, -21 },
  { 219, 4, 9, 17, 9, -23 },
  { 224, 12, 29, 17, 4, -23 },
  { 268, 12, 29, 17, 1, -23 },
  { 312, 12, 12, 17, 4, -21 },
  { 330, 14, 15, 17, 2, -16 },
  { 357, 7, 9, 17, 2, -4 },
  { 365, 7, 3, 17, 5, -10 },
  { 368, 4, 4, 17, 5, -4 },
  { 370, 19, 29, 17, -2, -23 },
  { 439, 14, 21, 17, 2, -21 },
  { 476, 12, 21, 17, 2, -21 },
  { 508, 15, 21, 17, 1, -21 },
  { 548, 15, 21, 17, 1, -21 },
  { 588, 16, 21, 17, 0, -21 },
  { 630, 16, 21, 17, 1, -21 },
  { 672, 15, 21, 17, 2, -21 },
  { 712, 15, 21, 17, 4, -21 },
  { 752, 15, 21, 17, 2, -21 },
  { 792, 16, 21, 17, 1, -21 },
  { 834, 7, 15, 17, 5, -15 },
  { 848, 10, 20, 17, 2, -15 },
  { 873, 15, 13, 17, 1, -15 },
  { 898, 15, 8, 17, 1, -13 },
  { 913, 14, 13, 17, 1, -15 },
  { 936, 12, 21, 17, 4, -21 },
  { 968, 17, 25, 17, 1, -21 },
  { 1022, 16, 21, 17, -2, -21 },
  { 1064, 16, 21, 17, 0, -21 },
  { 1106, 16, 21, 17, 2, -21 },
  { 1148, 16, 21, 17, 0, -21 },
  { 1190, 17, 21, 17, 1, -21 },
  { 1235, 17, 21, 17, 1, -21 },
  { 1280, 16, 21, 17, 1, -21 },
  { 1322, 18, 21, 17, 0, -21 },
  { 1370, 16, 21, 17, 1, -21 },
  { 1412, 16, 21, 17, 1, -21 },
  { 1454, 18, 21, 17, 0, -21 },
  { 1502, 12, 21, 17, 1, -21 },
  { 1534, 18, 21, 17, -1, -21 },
  { 1582, 18, 21, 17, 0, -21 },
  { 1630, 15, 21, 17, 2, -21 },
  { 1670, 16, 21, 17, 1, -21 },
  { 1712, 15, 26, 17, 2, -21 },
  { 1761, 16, 21, 17, 0, -21 },
  { 1803, 16, 21, 17, 1, -21 },
  { 1845, 14, 21, 17, 4, -21 },
  { 1882, 16, 21, 17, 2, -21 },
  { 1924, 16, 21, 17, 3, -21 },
  { 1966, 18, 21, 17, 1, -21 },
  { 2014, 20, 21, 17, -1, -21 },
  { 2067, 16, 21, 17, 4, -21 },
  { 2109, 18, 21, 17, 0, -21 },
  { 2157, 15, 29, 17, 2, -23 },
  { 2212, 5, 29, 17, 6, -23 },
  { 2231, 14, 29, 17, 0, -23 },
  { 2282, 13, 11, 17, 3, -21 },
  { 2300, 15, 2, 17, -2, 4 },
  { 2304, 5, 6, 17, 8, -23 },
  { 2308, 15, 16, 17, 1, -16 },
  { 2338, 15, 23, 17, 1, -23 },
  { 2382, 15, 16, 17, 1, -16 },
  { 2412, 16, 23, 17, 2, -23 },
  { 2458, 14, 16, 17, 1, -16 },
  { 2486, 20, 29, 17, -1, -23 },
  { 2559, 17, 22, 17, 0, -16 },
  { 2606, 15, 23, 17, 0, -23 },
  { 2650, 10, 23, 17, 3, -23 },
  { 2679, 16, 29, 17, 0, -23 },
  { 2737, 16, 23, 17, 1, -23 },
  { 2783, 9, 23, 17, 5, -23 },
  { 2809, 16, 16, 17, 0, -16 },
  { 2841, 14, 16, 17, 1, -16 },
  { 2869, 14, 16, 17, 2, -16 },
  { 2897, 16, 22, 17, 0, -16 },
  { 2941, 14, 22, 17, 2, -16 },
  { 2980, 14, 16, 17, 2, -16 },
  { 3008, 13, 16, 17, 2, -16 },
  { 3034, 12, 20, 17, 4, -20 },
  { 3064, 14, 16, 17, 2, -16 },
  { 3092, 12, 16, 17, 4, -16 },
  { 3116, 16, 16, 17, 2, -16 },
  { 3148, 18, 16, 17, -1, -16 },
  { 3184, 19, 22, 17, -2, -16 },
  { 3237, 15, 16, 17, 1, -16 },
  { 3267, 16, 29, 17, 2, -23 },
  { 3325, 9, 29, 17, 4, -23 },
  { 3358, 16, 29, 17, -1, -23 },
  { 3416, 15, 4, 17, 1, -11 },
};

const GFXfont UbuntuSansMono_Italic30pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic30pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic30pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _UBUNTUSANSMONO_ITALIC30PT7B_H_
