#ifndef _UBUNTUSANSMONO_ITALIC72PT7B_H_
#define _UBUNTUSANSMONO_ITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x7C,
  0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x80,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xE0, 0xE0, 0x0F, 0x07,
  0x00, 0x78, 0x38, 0x03, 0x81, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0x80, 0x07,
  0xF0, 0x00, 0x04, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x40, 0x00,
  0x03, 0xF0, 0x07, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x7C,
  0x03, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0xC3, 0xE0, 0x00, 0x00,
  0x3E, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0x1F, 0x03, 0xE3, 0xF0, 0x00, 0x00,
  0x07, 0xC3, 0xE1, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE1, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE1, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x3E, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xC0,
  0x1F, 0x00, 0x00, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x7F,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0x00, 0x1F, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xF8, 0x0F,
  0xFF, 0xC0, 0x3E, 0x07, 0xF1, 0xF8, 0x1F, 0x03, 0xF8, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0xC1, 0xF0, 0x7E, 0x03, 0xF8, 0xF8, 0x3F, 0x00, 0x7E, 0x3E,
  0x0F, 0xC0, 0x0F, 0xDF, 0x87, 0xE0, 0x03, 0xF7, 0xC1, 0xF8, 0x00, 0x7F,
  0xF0, 0x7E, 0x00, 0x1F, 0xF8, 0x3F, 0x00, 0x03, 0xFE, 0x0F, 0xC0, 0x00,
  0xFF, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xE0, 0xFE,
  0x00, 0x3F, 0xF8, 0x1F, 0xC0, 0x3F, 0xFE, 0x07, 0xFE, 0x7F, 0xCF, 0xC0,
  0xFF, 0xFF, 0xE3, 0xF0, 0x1F, 0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0xF0, 0x1F,
  0x80, 0x7F, 0xF0, 0x07, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x8F, 0x87, 0xC3,
  0xE1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x07, 0xC0, 0x18, 0x7C, 0x07,
  0x80, 0xF9, 0xFE, 0x0F, 0x0F, 0xF3, 0xFF, 0x1E, 0x7F, 0xE7, 0xFF, 0xBB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xE0, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x80, 0x07, 0x07, 0xF8, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0xFF,
  0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x03, 0xF1, 0xF8, 0x1F, 0x00, 0x7E, 0x3F, 0x07, 0xF8, 0x1F, 0x8F, 0xC1,
  0xFF, 0x03, 0xF1, 0xF8, 0x3F, 0xE0, 0x7E, 0x3F, 0x07, 0xFE, 0x0F, 0xCF,
  0xC0, 0xFF, 0xC1, 0xF9, 0xF8, 0x1F, 0xF0, 0x7E, 0x3F, 0x03, 0xFE, 0x0F,
  0xC7, 0xE0, 0x3F, 0x81, 0xF8, 0xFC, 0x03, 0xE0, 0x3F, 0x1F, 0x00, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xBE, 0x00, 0x3F,
  0xFB, 0xF0, 0x01, 0xFF, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xC0, 0x00, 0x7F,
  0x00, 0x18, 0x00, 0x07, 0xF0, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0x80, 0x07, 0xF0, 0x00, 0x40, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x04, 0x00, 0x00, 0x7F, 0x80, 0xE0, 0x00, 0x3F, 0xF0, 0x1F,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7F, 0x0F,
  0x80, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x00, 0xFE, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0x80, 0x01,
  0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC7, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xFC,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x1F,
  0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE7, 0xFF,
  0x00, 0x03, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xE0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x03,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF7, 0xE0, 0x00, 0x1F, 0xFC, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x3F, 0x80, 0x0F, 0xFF, 0xF0, 0x7E,
  0x00, 0x7F, 0xFF, 0xE1, 0xFC, 0x03, 0xFF, 0xFF, 0xC3, 0xF0, 0x0F, 0xFC,
  0x3F, 0x87, 0xE0, 0x3F, 0xC0, 0x3E, 0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x3F,
  0x01, 0xF8, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0x03, 0xF1, 0xFC, 0x0F, 0xC0,
  0x07, 0xC3, 0xF0, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0xF8, 0x00, 0x7E, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x07, 0xE0,
  0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0xFC,
  0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x0F,
  0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xF0, 0xFC, 0x07, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0x80,
  0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0x80, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xC0,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00,
  0x7F, 0x80, 0x7C, 0x00, 0x07, 0xFC, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x00, 0x0C, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0x00, 0x03, 0xFC,
  0x00, 0x0E, 0x00, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xE0,
  0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xFC,
  0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x03, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0xF8, 0x00,
  0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0,
  0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x00, 0x08, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x40, 0x00, 0x1F, 0xC0, 0x01,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x0F,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x03, 0xEF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xBF, 0xC0, 0x00, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x00, 0x3D, 0xF0,
  0x07, 0xDE, 0x00, 0x07, 0xBE, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0xC0, 0x3E,
  0x78, 0x00, 0x3C, 0xF8, 0x07, 0x9F, 0x00, 0x07, 0x8F, 0x01, 0xF3, 0xE0,
  0x01, 0xF1, 0xE0, 0x3C, 0x7C, 0x00, 0x3C, 0x3C, 0x0F, 0x0F, 0x00, 0x0F,
  0x87, 0x83, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x78, 0x7C, 0x00, 0x3E, 0x1E,
  0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE3, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0xF8,
  0x3E, 0x00, 0x3E, 0x0F, 0x9E, 0x07, 0x80, 0x07, 0xC1, 0xF7, 0x81, 0xF0,
  0x01, 0xF0, 0x3F, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xFC, 0x07, 0xC0, 0x07,
  0xC0, 0x7F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x3E, 0x01,
  0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xC0, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x0F,
  0xF8, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xC0, 0x07, 0xDF, 0x80, 0x01, 0xF0, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x03, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x00, 0xFC,
  0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x03, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0x00, 0x3C, 0x7C, 0x00,
  0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x07, 0xC0,
  0x00, 0xFB, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0xF8, 0x00, 0x07,
  0xBE, 0x00, 0x3E, 0x00, 0x01, 0xEF, 0x80, 0x0F, 0x80, 0x00, 0x7F, 0xE0,
  0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF8,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x7C, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x0F,
  0xE0, 0x00, 0x04, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x03, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x1F,
  0x00, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x3F, 0xC0, 0x7C, 0x00, 0x7C, 0x07,
  0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xFF, 0x01, 0xF0, 0x01, 0xF0, 0x3D, 0xE0,
  0x3E, 0x00, 0x7C, 0x0F, 0xBC, 0x0F, 0x80, 0x0F, 0x81, 0xE7, 0x81, 0xF0,
  0x01, 0xF0, 0x7C, 0xF0, 0x3E, 0x00, 0x3E, 0x1F, 0x1E, 0x07, 0x80, 0x07,
  0x83, 0xC3, 0xC1, 0xF0, 0x00, 0xF0, 0xF8, 0x7C, 0x3E, 0x00, 0x3E, 0x1E,
  0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x00, 0xF8, 0xF0, 0x1E,
  0x3E, 0x00, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x03, 0xCF, 0x80, 0x78, 0xF0,
  0x00, 0x79, 0xF0, 0x0F, 0x3E, 0x00, 0x0F, 0x7C, 0x01, 0xE7, 0x80, 0x03,
  0xEF, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xE0, 0x07, 0xBE, 0x00, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80,
  0x03, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x0F,
  0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0x60, 0x00, 0x00, 0x70, 0x40, 0x00,
  0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x08, 0x00, 0xC0, 0x1F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x70, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x3F, 0xE0, 0x03, 0xF0, 0x0F, 0xF0,
  0x00, 0x7E, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0xFF, 0x00, 0x01, 0xF0, 0x3F,
  0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x03, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x7C, 0x00, 0xFF, 0xFF, 0x8F, 0x80, 0x07, 0xFF, 0xC1,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF1, 0xFF, 0x80, 0x00, 0x7E, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xF0, 0x7C, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x0F, 0xE0, 0x7C,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x0F, 0xF0, 0x0F, 0x80, 0x03, 0xFC, 0x01, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xE7, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x40,
  0x3F, 0xC0, 0x00, 0x30, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xF0,
  0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x01, 0xFF, 0x1F, 0x00, 0x07, 0xFF, 0x8F, 0xDF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x40, 0x3F, 0xC0, 0x00, 0x70,
  0x0F, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x61, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE3,
  0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x04, 0x00,
  0x03, 0xF0, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC3, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x07,
  0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x07, 0xF8,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x01, 0xF0,
  0x1F, 0xE0, 0x00, 0x07, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xF0, 0x00,
  0x00, 0xFC, 0x7F, 0x80, 0x00, 0x03, 0xE7, 0xF8, 0x00, 0x00, 0x0F, 0xBF,
  0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0xFF,
  0x00, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x00,
  0x3E, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x13, 0xF8, 0x07, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0x03, 0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x3E, 0x01, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x03, 0xF8, 0x07, 0xC0,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01,
  0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x1F, 0xE0, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xE0, 0x03, 0xF0,
  0x0F, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xDF, 0x80, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x78, 0x03, 0xF8, 0x00, 0x08,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x40, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x04, 0x01, 0xFE, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x7C, 0x03, 0xFF, 0xFF, 0x9F, 0x00, 0x7F, 0xFF, 0xC7, 0xC0, 0x07,
  0xFF, 0xC1, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x7C, 0x03,
  0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xFC, 0x0F,
  0x80, 0x7C, 0x0F, 0xFC, 0x0F, 0x80, 0x7C, 0x0F, 0x7C, 0x1F, 0x80, 0x7C,
  0x1F, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x7C, 0x1F, 0x00, 0xFC, 0x3E, 0x3C,
  0x3E, 0x00, 0xFC, 0x7C, 0x3C, 0x3E, 0x00, 0xFC, 0x78, 0x3C, 0x7E, 0x00,
  0xFC, 0xF8, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x3E, 0xFC, 0x00, 0xF9, 0xF0,
  0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x3E, 0xF8, 0x00, 0xFB, 0xC0, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xEF, 0x80, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x0F, 0xE1, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x20, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xCF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xE0, 0x7F, 0xF8, 0x00, 0x3C, 0x7F, 0xFF, 0x00, 0x1F,
  0x1F, 0xFF, 0xF0, 0x0F, 0x8F, 0xC3, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0xFF,
  0xF1, 0xF0, 0x07, 0xFF, 0xF8, 0xF8, 0x00, 0x7F, 0xFC, 0x3C, 0x00, 0x0F,
  0xFE, 0x03, 0x00, 0x00, 0xFE, 0x00,
};

const GFXglyph UbuntuSansMono_Italic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 19, 51, 40, 11, -50 },
  { 123, 21, 20, 40, 16, -55 },
  { 176, 43, 50, 40, 0, -50 },
  { 445, 37, 64, 40, 3, -56 },
  { 741, 49, 52, 40, -3, -51 },
  { 1060, 34, 52, 40, 2, -51 },
  { 1281, 9, 21, 40, 22, -55 },
  { 1305, 30, 69, 40, 9, -56 },
  { 1564, 30, 69, 40, 2, -56 },
  { 1823, 31, 29, 40, 8, -50 },
  { 1936, 33, 35, 40, 4, -39 },
  { 2081, 17, 22, 40, 6, -11 },
  { 2128, 18, 5, 40, 12, -23 },
  { 2140, 11, 12, 40, 11, -11 },
  { 2157, 46, 69, 40, -5, -56 },
  { 2554, 35, 52, 40, 4, -51 },
  { 2782, 29, 50, 40, 5, -50 },
  { 2964, 36, 51, 40, 3, -51 },
  { 3194, 35, 52, 40, 3, -51 },
  { 3422, 36, 50, 40, 1, -50 },
  { 3647, 39, 51, 40, 2, -50 },
  { 3896, 36, 51, 40, 5, -50 },
  { 4126, 36, 50, 40, 9, -50 },
  { 4351, 36, 52, 40, 4, -51 },
  { 4585, 37, 51, 40, 3, -51 },
  { 4821, 18, 39, 40, 11, -38 },
  { 4909, 23, 49, 40, 6, -38 },
  { 5050, 35, 31, 40, 3, -36 },
  { 5186, 36, 20, 40, 3, -31 },
  { 5276, 35, 31, 40, 2, -36 },
  { 5412, 28, 52, 40, 10, -51 },
  { 5594, 39, 62, 40, 3, -51 },
  { 5897, 39, 50, 40, -4, -50 },
  { 6141, 38, 50, 40, 1, -50 },
  { 6379, 39, 52, 40, 4, -51 },
  { 6633, 39, 50, 40, 0, -50 },
  { 6877, 40, 50, 40, 3, -50 },
  { 7127, 40, 50, 40, 3, -50 },
  { 7377, 38, 52, 40, 4, -51 },
  { 7624, 43, 50, 40, 0, -50 },
  { 7893, 36, 50, 40, 4, -50 },
  { 8118, 39, 51, 40, 3, -50 },
  { 8367, 43, 50, 40, 1, -50 },
  { 8636, 28, 50, 40, 2, -50 },
  { 8811, 43, 50, 40, -1, -50 },
  { 9080, 42, 50, 40, 1, -50 },
  { 9343, 37, 52, 40, 4, -51 },
  { 9584, 38, 50, 40, 2, -50 },
  { 9822, 37, 64, 40, 4, -51 },
  { 10118, 38, 50, 40, 1, -50 },
  { 10356, 39, 52, 40, 2, -51 },
  { 10610, 34, 50, 40, 10, -50 },
  { 10823, 39, 51, 40, 4, -50 },
  { 11072, 38, 50, 40, 8, -50 },
  { 11310, 43, 50, 40, 2, -50 },
  { 11579, 48, 50, 40, -2, -50 },
  { 11879, 38, 50, 40, 9, -50 },
  { 12117, 43, 50, 40, 0, -50 },
  { 12386, 35, 69, 40, 5, -56 },
  { 12688, 11, 69, 40, 15, -56 },
  { 12783, 35, 69, 40, -1, -56 },
  { 13085, 31, 27, 40, 7, -50 },
  { 13190, 37, 5, 40, -5, 8 },
  { 13214, 13, 15, 40, 19, -56 },
  { 13239, 35, 39, 40, 3, -38 },
  { 13410, 35, 57, 40, 3, -56 },
  { 13660, 35, 39, 40, 3, -38 },
  { 13831, 40, 57, 40, 4, -56 },
  { 14116, 34, 39, 40, 3, -38 },
  { 14282, 46, 70, 40, -1, -56 },
  { 14685, 41, 52, 40, -1, -38 },
  { 14952, 34, 56, 40, 1, -56 },
  { 15190, 23, 55, 40, 8, -55 },
  { 15349, 39, 68, 40, -1, -55 },
  { 15681, 38, 56, 40, 2, -56 },
  { 15947, 20, 57, 40, 12, -56 },
  { 16090, 39, 38, 40, 0, -38 },
  { 16276, 34, 38, 40, 3, -38 },
  { 16438, 34, 39, 40, 4, -38 },
  { 16604, 39, 51, 40, -1, -38 },
  { 16853, 35, 51, 40, 4, -38 },
  { 17077, 34, 38, 40, 5, -38 },
  { 17239, 33, 39, 40, 4, -38 },
  { 17400, 29, 50, 40, 9, -49 },
  { 17582, 34, 38, 40, 4, -37 },
  { 17744, 32, 37, 40, 8, -37 },
  { 17892, 40, 37, 40, 4, -37 },
  { 18077, 41, 37, 40, -1, -37 },
  { 18267, 44, 51, 40, -4, -37 },
  { 18548, 36, 37, 40, 2, -37 },
  { 18715, 39, 69, 40, 4, -56 },
  { 19052, 22, 69, 40, 10, -56 },
  { 19242, 39, 69, 40, -3, -56 },
  { 19579, 34, 11, 40, 4, -27 },
};

const GFXfont UbuntuSansMono_Italic72pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic72pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic72pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _UBUNTUSANSMONO_ITALIC72PT7B_H_
