#ifndef _UBUNTUSANSMONO_ITALIC71PT7B_H_
#define _UBUNTUSANSMONO_ITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC7,
  0xC0, 0x3C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x07,
  0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0xF8,
  0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0E, 0x00, 0xF0,
  0x70, 0x07, 0x07, 0x80, 0x38, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xE0,
  0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x01,
  0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x3E, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0xF8,
  0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x7C, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0x83,
  0xE1, 0xF0, 0x00, 0x00, 0x0F, 0x8F, 0x87, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xE1,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xE1, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x87,
  0xFF, 0x80, 0x00, 0x00, 0x3E, 0x1F, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x7C,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0xF0, 0x3E, 0x00, 0x00, 0x07, 0xC3, 0xE0,
  0x3C, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x78, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xE0, 0x1F,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x78,
  0x00, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xF0, 0x00, 0x78, 0x1F, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0x83, 0xF8,
  0x00, 0x07, 0xE7, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0x80, 0x7F, 0xF0, 0x07, 0xC0, 0x7F, 0xFC, 0x07, 0xC0, 0xFE, 0x7E,
  0x03, 0xE0, 0xFE, 0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x03,
  0xF0, 0xF8, 0x7E, 0x00, 0xFC, 0x7C, 0x3E, 0x00, 0x7E, 0x7C, 0x3F, 0x00,
  0x1F, 0xBE, 0x1F, 0x80, 0x0F, 0xFE, 0x0F, 0x80, 0x03, 0xFF, 0x0F, 0xC0,
  0x00, 0xFF, 0x07, 0xE0, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF8, 0x3F,
  0x80, 0x07, 0xFC, 0x1F, 0xC0, 0x07, 0xFF, 0x07, 0xF0, 0x0F, 0xFF, 0x83,
  0xFF, 0x3F, 0xEF, 0xC0, 0xFF, 0xFF, 0xE3, 0xF0, 0x3F, 0xFF, 0xE1, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x08, 0x01, 0xF0, 0x02, 0x38, 0x07, 0xC0, 0x79, 0xFC, 0x1F,
  0x07, 0xE7, 0xFC, 0x78, 0x7F, 0xDF, 0xFC, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0x80,
  0x7F, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x30, 0x01, 0x80, 0x00, 0x40, 0x04,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x01, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00,
  0xFE, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x04, 0x07, 0xF1, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xF9, 0xFE, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0xFC, 0x7E, 0x03, 0x80, 0x3F, 0x1F, 0x83, 0xF8, 0x0F, 0xCF, 0xC1, 0xFF,
  0x03, 0xF3, 0xF0, 0x7F, 0xC0, 0xFC, 0xFC, 0x1F, 0xF0, 0x3E, 0x7E, 0x07,
  0xFC, 0x1F, 0x9F, 0x81, 0xFF, 0x07, 0xE7, 0xE0, 0x7F, 0xC1, 0xF9, 0xF8,
  0x1F, 0xE0, 0x7E, 0x7E, 0x03, 0xF0, 0x3F, 0x3F, 0x00, 0x20, 0x0F, 0xCF,
  0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x03, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x17, 0xFE, 0xFC, 0x00, 0xFF, 0xCF, 0xC0, 0x0F, 0xF0, 0xF8, 0x00,
  0xFC, 0x1F, 0x80, 0x0E, 0x01, 0xF8, 0x00, 0x80, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0x80, 0x00, 0x7E, 0x00, 0x10, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0x06, 0x00,
  0x0F, 0xE0, 0x00, 0x40, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x02, 0x00, 0x00, 0x3F, 0xC0,
  0x38, 0x00, 0x0F, 0xF8, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0x80, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0x00, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xF0,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0x80, 0x00, 0xFF, 0xC0, 0x07,
  0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0xF0, 0x00, 0x1F,
  0xDF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xC7, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x8F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01,
  0xF8, 0x3F, 0xE0, 0x10, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xE0,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x3F, 0x80, 0x0F, 0xFF, 0xF0, 0xFC, 0x00,
  0xFF, 0xFF, 0xC3, 0xF0, 0x07, 0xFF, 0xFE, 0x1F, 0x80, 0x7F, 0xFF, 0xF8,
  0x7E, 0x03, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x00, 0x7C, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x7E, 0x00, 0x3F, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x7E, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0xFC, 0x00, 0x7E, 0x3F,
  0x03, 0xF0, 0x01, 0xF0, 0xFC, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x3E, 0x00,
  0x3F, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0xFC,
  0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x3F, 0x03, 0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x03, 0xF0,
  0x1F, 0xE0, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0x00, 0x7F, 0xFF,
  0x80, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE7, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xE0,
  0x07, 0xC0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x01, 0xFE,
  0x00, 0x7C, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3F,
  0x81, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x03, 0xFC, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x3F,
  0x00, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x00, 0x08, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0x00, 0x01, 0xFF,
  0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x03,
  0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0x00, 0x0F, 0xE0,
  0x00, 0x04, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0x80,
  0x07, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xE0,
  0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x40, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x00,
  0xFE, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xF0,
  0x07, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x00,
  0x00, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x9F, 0xE0, 0x00, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x00, 0x01, 0xF7, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFB, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x1D, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0x78, 0x00, 0xF7, 0x80, 0x03, 0xDF, 0x00, 0x7D, 0xE0, 0x00, 0xF7, 0xC0,
  0x1E, 0xF8, 0x00, 0x79, 0xF0, 0x0F, 0xBE, 0x00, 0x1E, 0x7C, 0x03, 0xCF,
  0x00, 0x07, 0x9F, 0x01, 0xE3, 0xC0, 0x03, 0xE7, 0xC0, 0xF8, 0xF0, 0x00,
  0xF1, 0xF0, 0x3C, 0x7C, 0x00, 0x3C, 0x3C, 0x1F, 0x1F, 0x00, 0x1F, 0x0F,
  0x07, 0x87, 0xC0, 0x07, 0xC3, 0xC3, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0xF0,
  0x78, 0x00, 0xF8, 0x3C, 0x78, 0x3E, 0x00, 0x3E, 0x0F, 0x3E, 0x0F, 0x80,
  0x0F, 0x03, 0xCF, 0x03, 0xE0, 0x07, 0xC0, 0xFF, 0xC0, 0xF8, 0x01, 0xF0,
  0x3F, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xFC,
  0x07, 0xC0, 0x0F, 0x80, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0x80, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0xC0, 0x07, 0xDF, 0x00, 0x03, 0xE0, 0x01, 0xF3, 0xE0, 0x00,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0x87, 0xC0, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x03, 0xE0,
  0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0xF8,
  0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x07,
  0xC0, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC7, 0xC0, 0x07, 0xC0, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0xEF, 0x80,
  0x0F, 0x80, 0x00, 0xFB, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x7C, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0x80, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x03, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xE0, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x08, 0x00,
  0x00, 0x7F, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x01, 0xFC, 0x03,
  0xE0, 0x03, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0x7C, 0x0F, 0xF8, 0x0F, 0x00,
  0x0F, 0x01, 0xEF, 0x03, 0xE0, 0x03, 0xE0, 0x7D, 0xE0, 0x7C, 0x00, 0x7C,
  0x1F, 0x3C, 0x0F, 0x00, 0x0F, 0x83, 0xE7, 0x83, 0xE0, 0x01, 0xF0, 0xF8,
  0xF0, 0x7C, 0x00, 0x3C, 0x1E, 0x1E, 0x0F, 0x80, 0x07, 0x87, 0xC3, 0xC1,
  0xE0, 0x01, 0xF0, 0xF0, 0x78, 0x7C, 0x00, 0x3E, 0x3E, 0x0F, 0x0F, 0x80,
  0x07, 0xCF, 0x81, 0xE1, 0xE0, 0x00, 0xF1, 0xF0, 0x3E, 0x7C, 0x00, 0x1E,
  0x7C, 0x07, 0xCF, 0x80, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x00, 0x7B, 0xE0,
  0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x03, 0xDF, 0x00, 0x3D,
  0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x1F, 0xC3, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3C, 0x3F,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0x3C,
  0x00, 0x00, 0x1C, 0x08, 0x00, 0x00, 0x10, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0xE0, 0x1F, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0x80, 0x3F, 0xF0, 0x03,
  0xE0, 0x0F, 0xF8, 0x00, 0x7C, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0xFF, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x0F, 0x81, 0xFC,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0xF8, 0x00, 0xFF, 0xFF, 0x1F, 0x80,
  0x07, 0xFF, 0x81, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x0F, 0xCF, 0xFF, 0x00, 0x03, 0xEF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x03, 0xF8, 0x3E, 0x00, 0x01, 0xFC, 0x0F, 0x80, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x3F,
  0xE0, 0x1F, 0x00, 0x3F, 0xF0, 0x0F, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xE0, 0x1F, 0xF0, 0x00,
  0x10, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x40, 0x3F,
  0x80, 0x00, 0x70, 0x0F, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0xE0,
  0x07, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x00,
  0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0x01, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xDF, 0x00, 0x01,
  0xFF, 0xFE, 0x3F, 0x00, 0x00, 0xFF, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7E,
  0x07, 0xF8, 0x00, 0x0F, 0x83, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00,
  0xF8, 0x7F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00,
  0x01, 0xFE, 0x1F, 0x00, 0x03, 0xFF, 0x8F, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x40, 0x3F, 0x80, 0x00, 0x70, 0x0F, 0xFC,
  0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x7E, 0x00, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x30,
  0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x02, 0x00,
  0x00, 0x3F, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x1F, 0xFC, 0x03, 0xF0, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x20,
  0x00, 0x3F, 0x80, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0xFF, 0x00, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x01, 0xF0,
  0x3F, 0x80, 0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xE0, 0x00,
  0x00, 0xF9, 0xFF, 0x00, 0x00, 0x03, 0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x01,
  0x3F, 0x80, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF,
  0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0xFF,
  0x80, 0x0F, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0xFF, 0xC7, 0xF0, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x3F,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x7E, 0x03,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x3E, 0x01, 0xF8,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F,
  0x80, 0xFC, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0x81,
  0xF8, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xE0, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x2E, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xF9, 0xFC,
  0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF9, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x07,
  0xF0, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xF3,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xE0, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0xFC,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xDF, 0x80, 0x00,
  0x3F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x70, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x03, 0xF0, 0x03,
  0xF8, 0x00, 0x18, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x40, 0x00, 0x0F, 0xC0, 0x38, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x02, 0x01, 0xFC, 0x03,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xBF, 0x00,
  0x7F, 0xFF, 0x87, 0xC0, 0x07, 0xFF, 0x81, 0xF0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3F,
  0x1F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xE0,
  0x3F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00,
  0x07, 0xE1, 0xF8, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xFE,
  0x01, 0xF0, 0x3E, 0x03, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0xF0, 0x3F, 0x01, 0xF0, 0x3D, 0xE0, 0x7C, 0x03, 0xE0, 0xFB,
  0xE0, 0xF8, 0x0F, 0xC3, 0xE7, 0xC3, 0xE0, 0x1F, 0x87, 0x8F, 0x87, 0xC0,
  0x3F, 0x1F, 0x1F, 0x1F, 0x80, 0x7C, 0x3C, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x3C, 0x7C, 0x01, 0xF3, 0xE0, 0x79, 0xF0, 0x03, 0xE7, 0x80, 0xF3, 0xE0,
  0x07, 0xDF, 0x01, 0xEF, 0x80, 0x0F, 0xBC, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x1F,
  0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x02, 0x01, 0xFF, 0xC0,
  0x01, 0xF0, 0xFF, 0xF8, 0x00, 0x78, 0x7F, 0xFF, 0x80, 0x3E, 0x3F, 0xBF,
  0xF0, 0x1F, 0x1F, 0x81, 0xFF, 0x0F, 0xC7, 0xC0, 0x1F, 0xFF, 0xE3, 0xE0,
  0x03, 0xFF, 0xF0, 0xF0, 0x00, 0x7F, 0xF8, 0x1C, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x30, 0x00,
};

const GFXglyph UbuntuSansMono_Italic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 18, 50, 40, 11, -49 },
  { 114, 21, 19, 40, 15, -54 },
  { 164, 42, 49, 40, 0, -49 },
  { 422, 37, 63, 40, 3, -55 },
  { 714, 47, 51, 40, -2, -50 },
  { 1014, 33, 51, 40, 2, -50 },
  { 1225, 10, 20, 40, 21, -54 },
  { 1250, 29, 69, 40, 9, -56 },
  { 1501, 29, 69, 40, 2, -56 },
  { 1752, 30, 29, 40, 8, -49 },
  { 1861, 33, 34, 40, 4, -38 },
  { 2002, 16, 21, 40, 6, -10 },
  { 2044, 17, 5, 40, 12, -23 },
  { 2055, 11, 12, 40, 11, -11 },
  { 2072, 44, 69, 40, -4, -56 },
  { 2452, 34, 51, 40, 4, -50 },
  { 2669, 28, 49, 40, 5, -49 },
  { 2841, 36, 50, 40, 3, -50 },
  { 3066, 36, 51, 40, 2, -50 },
  { 3296, 36, 49, 40, 1, -49 },
  { 3517, 39, 50, 40, 2, -49 },
  { 3761, 36, 50, 40, 5, -49 },
  { 3986, 35, 49, 40, 9, -49 },
  { 4201, 36, 51, 40, 4, -50 },
  { 4431, 37, 50, 40, 3, -50 },
  { 4663, 17, 38, 40, 11, -37 },
  { 4744, 22, 48, 40, 6, -37 },
  { 4876, 35, 31, 40, 3, -36 },
  { 5012, 37, 20, 40, 2, -31 },
  { 5105, 35, 31, 40, 2, -36 },
  { 5241, 28, 51, 40, 10, -50 },
  { 5420, 38, 61, 40, 3, -50 },
  { 5710, 38, 49, 40, -4, -49 },
  { 5943, 37, 50, 40, 1, -50 },
  { 6175, 39, 51, 40, 4, -50 },
  { 6424, 38, 50, 40, 0, -50 },
  { 6662, 39, 49, 40, 3, -49 },
  { 6901, 39, 49, 40, 3, -49 },
  { 7140, 38, 51, 40, 3, -50 },
  { 7383, 43, 49, 40, 0, -49 },
  { 7647, 35, 49, 40, 4, -49 },
  { 7862, 38, 50, 40, 3, -49 },
  { 8100, 42, 49, 40, 1, -49 },
  { 8358, 29, 49, 40, 1, -49 },
  { 8536, 42, 49, 40, -1, -49 },
  { 8794, 42, 49, 40, 1, -49 },
  { 9052, 36, 51, 40, 4, -50 },
  { 9282, 38, 50, 40, 2, -50 },
  { 9520, 36, 63, 40, 4, -50 },
  { 9804, 38, 50, 40, 1, -50 },
  { 10042, 38, 51, 40, 2, -50 },
  { 10285, 34, 49, 40, 10, -49 },
  { 10494, 39, 50, 40, 4, -49 },
  { 10738, 38, 49, 40, 8, -49 },
  { 10971, 43, 49, 40, 2, -49 },
  { 11235, 47, 49, 40, -2, -49 },
  { 11523, 38, 49, 40, 9, -49 },
  { 11756, 43, 49, 40, 0, -49 },
  { 12020, 35, 69, 40, 5, -56 },
  { 12322, 11, 69, 40, 15, -56 },
  { 12417, 35, 69, 40, -1, -56 },
  { 12719, 32, 26, 40, 6, -49 },
  { 12823, 37, 5, 40, -5, 8 },
  { 12847, 13, 14, 40, 18, -55 },
  { 12870, 35, 39, 40, 3, -38 },
  { 13041, 34, 56, 40, 3, -55 },
  { 13279, 34, 39, 40, 3, -38 },
  { 13445, 39, 56, 40, 4, -55 },
  { 13718, 34, 39, 40, 3, -38 },
  { 13884, 46, 68, 40, -1, -55 },
  { 14275, 40, 51, 40, -1, -38 },
  { 14530, 33, 55, 40, 1, -55 },
  { 14757, 22, 54, 40, 8, -54 },
  { 14906, 38, 67, 40, -1, -54 },
  { 15225, 38, 55, 40, 2, -55 },
  { 15487, 20, 56, 40, 12, -55 },
  { 15627, 38, 38, 40, 0, -38 },
  { 15808, 33, 38, 40, 3, -38 },
  { 15965, 33, 39, 40, 4, -38 },
  { 16126, 38, 51, 40, -1, -38 },
  { 16369, 35, 51, 40, 4, -38 },
  { 16593, 33, 38, 40, 5, -38 },
  { 16750, 33, 39, 40, 4, -38 },
  { 16911, 28, 49, 40, 9, -48 },
  { 17083, 34, 38, 40, 4, -37 },
  { 17245, 31, 37, 40, 8, -37 },
  { 17389, 39, 37, 40, 4, -37 },
  { 17570, 41, 37, 40, -1, -37 },
  { 17760, 43, 50, 40, -4, -37 },
  { 18029, 35, 37, 40, 2, -37 },
  { 18191, 38, 69, 40, 4, -56 },
  { 18519, 22, 69, 40, 10, -56 },
  { 18709, 38, 69, 40, -3, -56 },
  { 19037, 34, 11, 40, 4, -26 },
};

const GFXfont UbuntuSansMono_Italic71pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic71pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic71pt7bGlyphs,
  0x20, 0x7E, 85
};

#endif // _UBUNTUSANSMONO_ITALIC71PT7B_H_
