#ifndef _UBUNTUSANSMONO_ITALIC23PT7B_H_
#define _UBUNTUSANSMONO_ITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x21, 0x18, 0x00, 0x63, 0x98, 0x66,
  0x8B, 0x36, 0x68, 0x91, 0x00, 0x01, 0x8C, 0x04, 0x60, 0x31, 0x80, 0x8C,
  0x3F, 0xFC, 0xFF, 0xE0, 0xC6, 0x03, 0x10, 0x18, 0xC0, 0x63, 0x07, 0xFF,
  0x3F, 0xFC, 0x23, 0x01, 0x8C, 0x04, 0x20, 0x31, 0x80, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x7F, 0x0E, 0x21, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC4, 0x18, 0xFF, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x00, 0x0F, 0x07, 0x19, 0x04, 0x11, 0x08, 0x11,
  0x18, 0x11, 0x30, 0x13, 0x60, 0x1E, 0xC0, 0x0D, 0x80, 0x01, 0x30, 0x02,
  0x78, 0x06, 0x88, 0x0C, 0x88, 0x19, 0x98, 0x31, 0x98, 0x61, 0x90, 0xC0,
  0xF0, 0x07, 0x87, 0x31, 0x8C, 0x43, 0x11, 0x86, 0xE1, 0xF0, 0x71, 0x3C,
  0xD9, 0xBC, 0x6B, 0x0E, 0xC3, 0x30, 0xEE, 0xF9, 0xE3, 0x6F, 0x6D, 0x00,
  0x00, 0x80, 0xC1, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x04, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x0E, 0x0E,
  0x06, 0x00, 0x0C, 0x06, 0x22, 0x3D, 0x7F, 0xF8, 0xE0, 0xD8, 0xEE, 0x63,
  0x00, 0x03, 0x00, 0x60, 0x08, 0x03, 0x07, 0xFF, 0xFF, 0xC1, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x00, 0x39, 0xCE, 0x33, 0x72, 0x00, 0xFC, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x00, 0x07, 0xC1, 0xDC, 0x61, 0x98, 0x33, 0x02, 0xC0,
  0xD9, 0x9B, 0x7B, 0x6E, 0x78, 0x0F, 0x03, 0x60, 0x6C, 0x19, 0x87, 0x19,
  0xC3, 0xF0, 0x01, 0x81, 0x83, 0xC7, 0x62, 0x30, 0x10, 0x18, 0x0C, 0x06,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x63, 0xFD, 0xFE, 0x0F, 0xC3, 0x9C, 0x41,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C,
  0x03, 0x00, 0xC0, 0x3F, 0xE7, 0xFC, 0x1F, 0xC1, 0x9C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0xC0, 0x70, 0x78, 0x03, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0xB1, 0xE7, 0xF8, 0x00, 0x30, 0x0F, 0x01, 0xE0, 0x36, 0x06, 0x60,
  0xC6, 0x08, 0x41, 0x8C, 0x30, 0xC6, 0x0C, 0x7F, 0xEF, 0xFE, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x30, 0x07, 0xF0, 0x7F, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x1C, 0x01, 0xF8, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0xC7, 0x8F, 0xE0, 0x00, 0xE0, 0xFC, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x1B, 0x87, 0xFC, 0xC1, 0x98, 0x1B, 0x03, 0x60, 0x6C, 0x19, 0x83, 0x30,
  0xC3, 0xF0, 0x7F, 0xEF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0x07, 0xE0, 0xC6, 0x18, 0x31, 0x83, 0x30, 0x31, 0x06, 0x18, 0xE0, 0xF8,
  0x3B, 0x87, 0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0x63, 0x87, 0xF0,
  0x07, 0xC1, 0xC6, 0x18, 0x33, 0x03, 0x30, 0x33, 0x03, 0x30, 0x33, 0x06,
  0x1F, 0xE0, 0xE6, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0xFC, 0x0F, 0x00,
  0x39, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x38, 0x0E, 0x1C, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x70, 0xE0, 0xC3, 0x1C, 0x20, 0x00, 0x00, 0x20, 0x0C,
  0x0F, 0x0F, 0x87, 0x81, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x7F,
  0xF7, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x20, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x01, 0xC0, 0xF0, 0xF0, 0x78, 0x18, 0x00, 0x3F, 0x10,
  0xC0, 0x20, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x00, 0x00,
  0x03, 0x03, 0x81, 0xC0, 0x07, 0xE0, 0xE7, 0x1C, 0x33, 0x81, 0x30, 0x16,
  0x1F, 0x63, 0xF6, 0x63, 0xCC, 0x2C, 0xC6, 0xCC, 0x6C, 0xC6, 0xCC, 0x4C,
  0xFC, 0xC3, 0xCC, 0x00, 0x60, 0x07, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x32, 0x03, 0x20, 0x62, 0x04, 0x30, 0xC3, 0x08, 0x31, 0x83,
  0x1F, 0xF3, 0xFF, 0x20, 0x36, 0x03, 0xC0, 0x3C, 0x03, 0x0F, 0xE0, 0xCF,
  0x18, 0x31, 0x81, 0x18, 0x31, 0x03, 0x30, 0x63, 0xF8, 0x31, 0xE3, 0x06,
  0x60, 0x26, 0x02, 0x60, 0x66, 0x0E, 0x43, 0xCF, 0xF0, 0x03, 0xF0, 0x71,
  0xC7, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0xC6, 0x07, 0xF0, 0x0F,
  0xC1, 0xDE, 0x18, 0x31, 0x83, 0x10, 0x13, 0x01, 0x30, 0x13, 0x01, 0x20,
  0x36, 0x03, 0x60, 0x36, 0x06, 0x60, 0xC4, 0x1C, 0xEF, 0x8F, 0xE0, 0x0F,
  0xF8, 0x7F, 0x86, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x07, 0xF8,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0xFF, 0x1F,
  0xF0, 0x0F, 0xF8, 0x7F, 0x86, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x07, 0xF8, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0x07, 0xF0, 0xE3, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0xC0, 0xC6, 0x0C,
  0x71, 0x83, 0xF8, 0x0C, 0x0C, 0x60, 0x21, 0x81, 0x86, 0x06, 0x18, 0x18,
  0x40, 0x63, 0x03, 0x0F, 0xFC, 0x30, 0x30, 0x80, 0xC6, 0x02, 0x18, 0x18,
  0x60, 0x61, 0x01, 0x8C, 0x04, 0x30, 0x30, 0x0F, 0xF0, 0xFE, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0x88, 0x18, 0xE3, 0x07, 0xE0, 0x0C, 0x1C, 0x30, 0xE0, 0x87,
  0x06, 0x38, 0x19, 0x80, 0x6C, 0x01, 0x60, 0x0F, 0x00, 0x3E, 0x00, 0xD8,
  0x02, 0x30, 0x18, 0x60, 0x61, 0x81, 0x83, 0x04, 0x0C, 0x30, 0x18, 0x0C,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x60, 0x18, 0x07, 0xFF, 0xFE, 0x04, 0x18, 0x70, 0xC3, 0x8E,
  0x3C, 0x71, 0x65, 0x8B, 0x2C, 0xDA, 0x46, 0x72, 0x23, 0x33, 0x19, 0x98,
  0x0C, 0xC0, 0x64, 0x02, 0x60, 0x33, 0x01, 0x90, 0x0C, 0x0C, 0x0C, 0x30,
  0x31, 0xE0, 0x87, 0x86, 0x1A, 0x18, 0x4C, 0x63, 0x31, 0x0C, 0xCC, 0x31,
  0x30, 0x84, 0xC2, 0x1A, 0x18, 0x68, 0x60, 0xE1, 0x03, 0x84, 0x0C, 0x30,
  0x30, 0x07, 0xC0, 0xC6, 0x18, 0x33, 0x03, 0x30, 0x36, 0x03, 0x60, 0x34,
  0x03, 0x40, 0x2C, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0xCC, 0x18, 0x63, 0x03,
  0xE0, 0x1F, 0xC1, 0x8E, 0x18, 0x31, 0x03, 0x30, 0x33, 0x03, 0x30, 0x62,
  0x0E, 0x7F, 0x87, 0xF0, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x07, 0xC0, 0xC6, 0x18, 0x33, 0x03, 0x30, 0x36, 0x03, 0x60, 0x34,
  0x03, 0xC0, 0x3C, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0xCC, 0x18, 0x63, 0x03,
  0xE0, 0x18, 0x01, 0xC0, 0x0F, 0x80, 0x70, 0x0F, 0xE0, 0x63, 0x82, 0x0C,
  0x30, 0x31, 0x81, 0x8C, 0x08, 0x40, 0xC6, 0x0C, 0x3F, 0xC1, 0xF8, 0x08,
  0x60, 0xC3, 0x06, 0x0C, 0x30, 0x61, 0x03, 0x18, 0x18, 0x07, 0xF0, 0xE3,
  0x18, 0x01, 0x00, 0x10, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xC3, 0x8F, 0xF0, 0xFF, 0xFF, 0xFC,
  0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x18, 0x18, 0x80, 0xCC, 0x0C,
  0x60, 0x63, 0x03, 0x10, 0x19, 0x80, 0x8C, 0x0C, 0x60, 0x62, 0x03, 0x30,
  0x11, 0x81, 0x8C, 0x0C, 0x60, 0xC1, 0x8E, 0x07, 0xE0, 0x80, 0x38, 0x06,
  0x80, 0x6C, 0x0C, 0xC0, 0x8C, 0x18, 0xC1, 0x0C, 0x30, 0xC2, 0x0C, 0x60,
  0xCC, 0x0C, 0xC0, 0xD8, 0x0D, 0x00, 0xF0, 0x06, 0x00, 0x30, 0x09, 0x80,
  0xCC, 0x06, 0x40, 0x26, 0x03, 0x30, 0x19, 0x98, 0xC8, 0xC4, 0x4E, 0x62,
  0x53, 0x34, 0xD1, 0xE7, 0x8A, 0x3C, 0x71, 0xC3, 0x0E, 0x18, 0x20, 0x06,
  0x07, 0x06, 0x06, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x30, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x0C, 0x60, 0x18,
  0x60, 0x38, 0x30, 0x30, 0x30, 0xE0, 0x30, 0xC0, 0x3C, 0x06, 0xC0, 0x44,
  0x0C, 0x61, 0x86, 0x30, 0x62, 0x02, 0x60, 0x3C, 0x03, 0x80, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFE, 0x3F, 0xF0, 0x07,
  0xE0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0xF8, 0x00, 0xDB, 0x6D, 0xB6, 0xD9, 0x36, 0xDB,
  0x6D, 0xB6, 0xC0, 0x07, 0xE0, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC1, 0xF8, 0x00, 0x03, 0x01,
  0xC0, 0xD0, 0x66, 0x19, 0x8C, 0x26, 0x0F, 0x03, 0x40, 0x80, 0xFF, 0xF0,
  0x4C, 0x63, 0x10, 0x07, 0xE3, 0xCC, 0xC1, 0xB0, 0x26, 0x0D, 0x81, 0xB0,
  0x36, 0x04, 0xC1, 0x98, 0x33, 0x8E, 0x3F, 0x40, 0x0C, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x0F, 0xF1, 0xE6, 0x30, 0x64, 0x0C, 0x81, 0xB0,
  0x36, 0x06, 0xC1, 0x90, 0x36, 0x0C, 0xCF, 0x1F, 0x80, 0x0F, 0xE3, 0x8C,
  0xC0, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0xC6,
  0x1F, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x1F, 0x83, 0xCC, 0x38, 0x61, 0x83, 0x18, 0x10, 0xC1, 0x8C, 0x0C, 0x60,
  0x63, 0x02, 0x18, 0x10, 0x63, 0x81, 0xF6, 0x00, 0x0F, 0xC3, 0x9C, 0xC1,
  0xB0, 0x3C, 0x0D, 0x87, 0xBF, 0xC6, 0x00, 0xC0, 0x18, 0x01, 0xC6, 0x1F,
  0xC0, 0x00, 0x3C, 0x03, 0xF0, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0xFF, 0x87, 0xFE, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0xB8, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x78, 0x87, 0x0C, 0x30, 0x63, 0x03,
  0x18, 0x11, 0x81, 0x8C, 0x0C, 0x60, 0x63, 0x86, 0x0F, 0xF0, 0x19, 0x80,
  0x0C, 0x00, 0xC3, 0x0C, 0x1F, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x30, 0x07, 0xF0, 0xE7, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x32, 0x06,
  0xC0, 0x98, 0x33, 0x06, 0x40, 0xD8, 0x10, 0x08, 0x38, 0x70, 0x40, 0x00,
  0x3E, 0x7C, 0x18, 0x20, 0xC1, 0x83, 0x06, 0x08, 0x18, 0x3E, 0x3C, 0x00,
  0x20, 0x07, 0x00, 0x70, 0x02, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x30, 0xC6, 0x0F, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x73, 0x0C, 0x31, 0x83, 0x70, 0x2C,
  0x07, 0x80, 0x6C, 0x06, 0x60, 0x43, 0x0C, 0x30, 0xC1, 0x8C, 0x1C, 0xFF,
  0xE1, 0x86, 0x18, 0x43, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xE5,
  0xF0, 0x1F, 0xF3, 0xBB, 0x33, 0x13, 0x33, 0x23, 0x36, 0x23, 0x66, 0x26,
  0x02, 0x40, 0x64, 0x06, 0xC0, 0x6C, 0x0C, 0x1F, 0x87, 0x38, 0xC1, 0x98,
  0x32, 0x06, 0xC0, 0x98, 0x33, 0x06, 0x40, 0xD8, 0x1B, 0x06, 0x60, 0xC0,
  0x0F, 0xC3, 0x98, 0xC1, 0xB0, 0x36, 0x06, 0x80, 0xF0, 0x1E, 0x06, 0xC0,
  0xD8, 0x31, 0xDE, 0x1F, 0x00, 0x0F, 0xC1, 0xCE, 0x18, 0x31, 0x83, 0x30,
  0x33, 0x03, 0x30, 0x33, 0x06, 0x20, 0x66, 0x0C, 0x63, 0x87, 0xF0, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0xF1, 0xE6, 0x38, 0x67, 0x06, 0x60,
  0x44, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0x8C, 0x18, 0x63, 0x83, 0xF8, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x0F, 0xE3, 0x84, 0x60, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x00, 0x0F, 0xE3,
  0x88, 0x60, 0x08, 0x01, 0x80, 0x1C, 0x01, 0xE0, 0x0C, 0x00, 0x80, 0x31,
  0x8E, 0x7F, 0x80, 0x08, 0x0C, 0x06, 0x03, 0x0F, 0xFF, 0xFC, 0xC0, 0x60,
  0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x88, 0x7C, 0x30, 0x66, 0x0D,
  0x81, 0xB0, 0x26, 0x0C, 0xC1, 0x90, 0x36, 0x04, 0xC1, 0x98, 0x31, 0x9E,
  0x3F, 0x40, 0xC0, 0xF0, 0x6C, 0x1B, 0x0C, 0xC3, 0x31, 0x8C, 0x63, 0x30,
  0xC8, 0x16, 0x07, 0x01, 0x80, 0x60, 0x1B, 0x00, 0x98, 0x0C, 0x84, 0x64,
  0x62, 0x27, 0x33, 0x29, 0x9B, 0x58, 0xD3, 0xC7, 0x1C, 0x38, 0xE1, 0x86,
  0x00, 0x18, 0x18, 0xE1, 0x83, 0x18, 0x19, 0x80, 0x78, 0x01, 0x80, 0x1C,
  0x01, 0xB0, 0x19, 0x81, 0x84, 0x18, 0x31, 0x81, 0x80, 0x0C, 0x0C, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x30, 0xC0, 0x42, 0x01, 0x98, 0x06,
  0x40, 0x1B, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x08, 0xC0, 0x3E,
  0x00, 0x1F, 0xE7, 0xF8, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0,
  0x30, 0x0C, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0xF8, 0x1C, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x1E, 0x01,
  0xE0, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x03, 0x00, 0x1F, 0x80, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x83,
  0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x04,
  0x18, 0x00, 0x07, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x0F, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0E, 0x0F, 0xC0, 0x10,
  0x0F, 0x85, 0x1F, 0x61, 0xC0,
};

const GFXglyph UbuntuSansMono_Italic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 16, 13, 4, -16 },
  { 11, 7, 6, 13, 5, -17 },
  { 17, 14, 16, 13, 0, -16 },
  { 45, 12, 21, 13, 1, -18 },
  { 77, 16, 16, 13, -1, -16 },
  { 109, 10, 16, 13, 1, -16 },
  { 129, 3, 6, 13, 7, -17 },
  { 132, 9, 22, 13, 3, -18 },
  { 157, 9, 22, 13, 1, -18 },
  { 182, 9, 9, 13, 3, -16 },
  { 193, 11, 11, 13, 1, -12 },
  { 209, 5, 7, 13, 2, -3 },
  { 214, 6, 1, 13, 4, -7 },
  { 215, 3, 3, 13, 4, -3 },
  { 217, 14, 22, 13, -1, -18 },
  { 256, 11, 16, 13, 1, -16 },
  { 278, 9, 16, 13, 2, -16 },
  { 296, 11, 16, 13, 1, -16 },
  { 318, 11, 16, 13, 1, -16 },
  { 340, 12, 16, 13, 0, -16 },
  { 364, 12, 16, 13, 1, -16 },
  { 388, 11, 16, 13, 2, -16 },
  { 410, 11, 16, 13, 3, -16 },
  { 432, 12, 16, 13, 1, -16 },
  { 456, 12, 16, 13, 1, -16 },
  { 480, 5, 11, 13, 4, -11 },
  { 487, 7, 15, 13, 2, -11 },
  { 501, 11, 10, 13, 1, -12 },
  { 515, 12, 6, 13, 1, -10 },
  { 524, 11, 10, 13, 1, -12 },
  { 538, 9, 16, 13, 3, -16 },
  { 556, 12, 19, 13, 1, -16 },
  { 585, 12, 16, 13, -1, -16 },
  { 609, 12, 16, 13, 0, -16 },
  { 633, 13, 16, 13, 1, -16 },
  { 659, 12, 16, 13, 0, -16 },
  { 683, 13, 16, 13, 1, -16 },
  { 709, 13, 16, 13, 1, -16 },
  { 735, 12, 16, 13, 1, -16 },
  { 759, 14, 16, 13, 0, -16 },
  { 787, 12, 16, 13, 1, -16 },
  { 811, 12, 16, 13, 1, -16 },
  { 835, 14, 16, 13, 0, -16 },
  { 863, 10, 16, 13, 0, -16 },
  { 883, 13, 16, 13, 0, -16 },
  { 909, 14, 16, 13, 0, -16 },
  { 937, 12, 16, 13, 1, -16 },
  { 961, 12, 16, 13, 1, -16 },
  { 985, 12, 20, 13, 1, -16 },
  { 1015, 13, 16, 13, 0, -16 },
  { 1041, 12, 16, 13, 1, -16 },
  { 1065, 11, 16, 13, 3, -16 },
  { 1087, 13, 16, 13, 1, -16 },
  { 1113, 12, 16, 13, 3, -16 },
  { 1137, 13, 16, 13, 1, -16 },
  { 1163, 16, 16, 13, -1, -16 },
  { 1195, 12, 16, 13, 3, -16 },
  { 1219, 14, 16, 13, 0, -16 },
  { 1247, 11, 22, 13, 2, -18 },
  { 1278, 3, 22, 13, 5, -18 },
  { 1287, 11, 22, 13, 0, -18 },
  { 1318, 10, 9, 13, 2, -16 },
  { 1330, 12, 1, 13, -2, 3 },
  { 1332, 4, 5, 13, 6, -18 },
  { 1335, 11, 12, 13, 1, -12 },
  { 1352, 11, 18, 13, 1, -18 },
  { 1377, 11, 12, 13, 1, -12 },
  { 1394, 13, 18, 13, 1, -18 },
  { 1424, 11, 12, 13, 1, -12 },
  { 1441, 14, 22, 13, 0, -18 },
  { 1480, 13, 16, 13, 0, -12 },
  { 1506, 11, 18, 13, 0, -18 },
  { 1531, 7, 18, 13, 3, -18 },
  { 1547, 12, 22, 13, 0, -18 },
  { 1580, 12, 18, 13, 1, -18 },
  { 1607, 6, 18, 13, 4, -18 },
  { 1621, 12, 12, 13, 0, -12 },
  { 1639, 11, 12, 13, 1, -12 },
  { 1656, 11, 12, 13, 1, -12 },
  { 1673, 12, 16, 13, 0, -12 },
  { 1697, 12, 16, 13, 1, -12 },
  { 1721, 11, 12, 13, 1, -12 },
  { 1738, 11, 12, 13, 1, -12 },
  { 1755, 9, 16, 13, 3, -16 },
  { 1773, 11, 12, 13, 1, -12 },
  { 1790, 10, 12, 13, 3, -12 },
  { 1805, 13, 12, 13, 1, -12 },
  { 1825, 13, 12, 13, 0, -12 },
  { 1845, 14, 16, 13, -1, -12 },
  { 1873, 11, 12, 13, 1, -12 },
  { 1890, 13, 22, 13, 1, -18 },
  { 1926, 7, 22, 13, 3, -18 },
  { 1946, 12, 22, 13, -1, -18 },
  { 1979, 11, 4, 13, 1, -9 },
};

const GFXfont UbuntuSansMono_Italic23pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic23pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic23pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _UBUNTUSANSMONO_ITALIC23PT7B_H_
