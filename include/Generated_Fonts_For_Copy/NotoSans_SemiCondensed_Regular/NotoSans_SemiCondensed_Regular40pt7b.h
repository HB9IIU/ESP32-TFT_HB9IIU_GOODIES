#ifndef _NOTOSANS_SEMICONDENSED_REGULAR40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x77, 0x76, 0x66, 0x60,
  0x00, 0x6F, 0xFF, 0xF0, 0xF0, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1,
  0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1D, 0xC3, 0x80, 0x00, 0xC1, 0xC0, 0x0E,
  0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x18, 0x00, 0xE0, 0xC0,
  0x06, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x83, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x07, 0x06, 0x00, 0x30, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00,
  0xE0, 0xE0, 0x07, 0x06, 0x00, 0x38, 0x30, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x07, 0x07, 0x00, 0x38, 0x30, 0x01, 0xC1, 0x80, 0x0C,
  0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xFF, 0x01, 0xFF, 0xF1,
  0xFF, 0xF9, 0xE7, 0x39, 0xE3, 0x80, 0xF1, 0xC0, 0x70, 0xE0, 0x3C, 0x70,
  0x1E, 0x38, 0x07, 0x9C, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x73, 0xC0, 0x38, 0xF0, 0x1C, 0x78, 0x0E, 0x1C,
  0x07, 0x1F, 0x03, 0x8E, 0xE1, 0xDF, 0x7F, 0xFF, 0x3F, 0xFF, 0x03, 0xFC,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x1C,
  0x07, 0xF0, 0x07, 0x01, 0xFE, 0x00, 0xE0, 0x38, 0xE0, 0x38, 0x0E, 0x1C,
  0x07, 0x01, 0xC1, 0x81, 0xC0, 0x38, 0x38, 0x38, 0x07, 0x07, 0x0E, 0x00,
  0xE0, 0xE1, 0xC0, 0x1C, 0x1C, 0x70, 0x03, 0x83, 0x8E, 0x00, 0x70, 0x73,
  0x82, 0x0E, 0x0C, 0x73, 0xF1, 0xC3, 0x9C, 0x7F, 0x1C, 0x73, 0x9C, 0x73,
  0xFC, 0x63, 0x8E, 0x3F, 0x9C, 0xE0, 0xE3, 0xC3, 0x9C, 0x1C, 0x00, 0xE3,
  0x83, 0x80, 0x1C, 0x70, 0x70, 0x07, 0x0E, 0x0E, 0x00, 0xE1, 0xC1, 0xC0,
  0x38, 0x38, 0x38, 0x07, 0x07, 0x07, 0x01, 0xC0, 0xE0, 0xE0, 0x38, 0x0E,
  0x38, 0x0E, 0x01, 0xC7, 0x01, 0xC0, 0x1F, 0xC0, 0x70, 0x01, 0xF0, 0x03,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1E, 0x1C, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x1C,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x3C, 0x7C,
  0xF0, 0x3C, 0x78, 0x78, 0x38, 0xF0, 0x3C, 0x38, 0xF0, 0x1E, 0x78, 0xE0,
  0x0F, 0x70, 0xE0, 0x0F, 0xF0, 0xE0, 0x07, 0xE0, 0xF0, 0x03, 0xE0, 0xF0,
  0x07, 0xE0, 0x78, 0x0F, 0xF0, 0x7F, 0xFE, 0x78, 0x3F, 0xFC, 0x3C, 0x1F,
  0xF0, 0x1F, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x70, 0x07, 0x83, 0x83, 0x83,
  0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF0,
  0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xE0,
  0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x03, 0x81,
  0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x78,
  0x38, 0x3C, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x81, 0x81, 0xF1, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x07, 0xE0,
  0x0E, 0xE0, 0x0E, 0x70, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x38, 0x08, 0x10,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x7B, 0xDE, 0xF7, 0x3B, 0xDC, 0xE6, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x6F, 0xFF, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0x87, 0xC7, 0x81, 0xE3, 0xC0, 0x79, 0xC0, 0x3D, 0xE0, 0x0E,
  0xF0, 0x07, 0x78, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x1E, 0x78, 0x0E,
  0x1E, 0x0F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0xF0,
  0x7C, 0x3F, 0x1F, 0xDF, 0x7F, 0x9D, 0x87, 0x21, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x07, 0xE0,
  0x1F, 0xFC, 0x1F, 0xFF, 0x1F, 0x07, 0xC6, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0x1F, 0x07, 0xC6, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x60, 0x0F, 0x3F, 0xFF, 0x9F, 0xFF, 0x87,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xDC, 0x00, 0x3B, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00,
  0x71, 0xC0, 0x1E, 0x38, 0x03, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x07,
  0x03, 0x81, 0xE0, 0x70, 0x38, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x70,
  0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x3F,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x30,
  0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xF3, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x60, 0x0F, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF,
  0x00, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x83, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x3E, 0x0F, 0x7F, 0xC7, 0x7F, 0xF3, 0xF0, 0x7D, 0xF0, 0x1E, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3D,
  0xC0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0x83, 0xC7, 0x80, 0xF3, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07,
  0x3C, 0x07, 0x8E, 0x07, 0x87, 0xC7, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xF8, 0x3C, 0x3E, 0x3C, 0x0F, 0xBC, 0x03, 0xDE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xBC, 0x07,
  0x9F, 0xDF, 0x87, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x0F, 0x87, 0xC7, 0x81, 0xE7, 0x80, 0x7B, 0xC0, 0x1D, 0xC0, 0x0E,
  0xE0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7D, 0xE0, 0x7E, 0xFF, 0xFF, 0x3F, 0xF7, 0x87, 0xF3, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x6F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0x18, 0xF3, 0xCF, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCF, 0x38,
  0xE7, 0x9C, 0x71, 0xCE, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00,
  0x20, 0x00, 0x00, 0x0F, 0xE1, 0xFF, 0xE1, 0xFF, 0xE3, 0xC3, 0xE4, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0E, 0x38, 0x07, 0xE0, 0xE3, 0x81, 0xFF, 0x06, 0x70, 0x3F, 0xF0,
  0x77, 0x07, 0x07, 0x07, 0x70, 0xE0, 0x70, 0x7E, 0x0E, 0x07, 0x07, 0xE0,
  0xE0, 0x70, 0x7E, 0x0E, 0x07, 0x07, 0xE1, 0xC0, 0x70, 0x7E, 0x1C, 0x07,
  0x07, 0xE0, 0xC0, 0x70, 0x7E, 0x0E, 0x0F, 0x07, 0xE0, 0xE0, 0xF0, 0xEE,
  0x0F, 0x1F, 0x8E, 0x70, 0x7F, 0x9F, 0xC7, 0x03, 0xF1, 0xF8, 0x70, 0x0C,
  0x06, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x08, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xE7,
  0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0xF0, 0x78, 0x01, 0xC0, 0xF0, 0x03, 0x80, 0xE0,
  0x0F, 0x01, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81,
  0xC0, 0x0F, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78,
  0x00, 0x38, 0xF0, 0x00, 0x79, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xEF, 0x00,
  0x01, 0xE0, 0xFF, 0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0x83, 0xFC, 0xE0,
  0x0F, 0x38, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x07, 0xB8, 0x01,
  0xCE, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0x7E, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xF8, 0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x0E, 0xE0,
  0x03, 0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07, 0xB8, 0x07,
  0xCF, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0xFC, 0x1F, 0xFF, 0x87, 0xE0, 0xF1, 0xF0, 0x02, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x08, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFE,
  0x0E, 0x1F, 0xF0, 0xE0, 0x0F, 0x8E, 0x00, 0x7C, 0xE0, 0x03, 0xCE, 0x00,
  0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x1E,
  0xE0, 0x03, 0xCE, 0x00, 0x7C, 0xE0, 0x0F, 0x8E, 0x03, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xBF,
  0xFE, 0xFF, 0xFB, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF8, 0x3E, 0x1F,
  0x00, 0x10, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0xF7, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00,
  0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xE3, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x1F, 0x9F,
  0xFF, 0xF8, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xBF, 0xEF, 0xF3, 0xF8, 0x30,
  0x00, 0xE0, 0x03, 0xF8, 0x01, 0xEE, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x1E,
  0x38, 0x0F, 0x0E, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x38, 0x78, 0x0E,
  0x3C, 0x03, 0x9E, 0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0xFB, 0xC0, 0x3C, 0x78, 0x0E, 0x0F, 0x03, 0x83, 0xC0, 0xE0, 0x78,
  0x38, 0x1F, 0x0E, 0x03, 0xC3, 0x80, 0x78, 0xE0, 0x1E, 0x38, 0x03, 0xCE,
  0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0x7F, 0xE0, 0x01, 0xDF, 0xB8, 0x00, 0xF7,
  0xEE, 0x00, 0x39, 0xFB, 0xC0, 0x0E, 0x7E, 0x70, 0x07, 0x9F, 0x9C, 0x01,
  0xC7, 0xE7, 0x80, 0x71, 0xF8, 0xE0, 0x3C, 0x7E, 0x38, 0x0E, 0x1F, 0x87,
  0x03, 0x87, 0xE1, 0xC1, 0xC1, 0xF8, 0x70, 0x70, 0x7E, 0x0E, 0x1C, 0x1F,
  0x83, 0x8E, 0x07, 0xE0, 0xF3, 0x81, 0xF8, 0x1C, 0xE0, 0x7E, 0x07, 0x70,
  0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x03,
  0xE0, 0x1F, 0x80, 0x78, 0x07, 0xE0, 0x1C, 0x01, 0xC0, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7E, 0xF0, 0x07, 0xEF, 0x00, 0x7E, 0x78, 0x07, 0xE3, 0x80,
  0x7E, 0x3C, 0x07, 0xE1, 0xC0, 0x7E, 0x1E, 0x07, 0xE0, 0xF0, 0x7E, 0x0F,
  0x07, 0xE0, 0x78, 0x7E, 0x07, 0x87, 0xE0, 0x3C, 0x7E, 0x01, 0xC7, 0xE0,
  0x1E, 0x7E, 0x00, 0xF7, 0xE0, 0x0F, 0x7E, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0x81, 0xF0, 0x1E, 0x00,
  0xF8, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x78, 0x00,
  0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x78, 0x1F, 0x01, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xE3, 0xFE, 0xE0, 0x3E, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0x80, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0x81, 0xF0, 0x1E,
  0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x1F, 0x01, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0xFE,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xE0, 0x1E, 0x38, 0x03,
  0xCE, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x0F, 0x38, 0x03, 0xCE, 0x00, 0xF3,
  0x80, 0x3C, 0xE0, 0x1E, 0x38, 0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF,
  0xE0, 0x38, 0x3C, 0x0E, 0x0F, 0x03, 0x81, 0xE0, 0xE0, 0x78, 0x38, 0x0F,
  0x0E, 0x03, 0xC3, 0x80, 0x78, 0xE0, 0x0E, 0x38, 0x03, 0xCE, 0x00, 0x7B,
  0x80, 0x1E, 0xE0, 0x03, 0xC0, 0x07, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE, 0x7E,
  0x1E, 0x78, 0x02, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x3E, 0xFF, 0xFC, 0xFF,
  0xF8, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80, 0x0E,
  0x78, 0x01, 0xE3, 0xE0, 0x3C, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x9E, 0x00, 0x1E,
  0x78, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x38, 0x1C,
  0x01, 0xE0, 0x70, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x38, 0x01, 0xC1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x1C, 0x00, 0x38, 0xF0, 0x00, 0xE3, 0xC0, 0x03, 0xCE, 0x00, 0x07,
  0x38, 0x00, 0x1D, 0xE0, 0x00, 0x77, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xDC, 0x00, 0x78, 0x00, 0xE7, 0x00, 0x1E, 0x00, 0x39, 0xE0, 0x0F,
  0xC0, 0x1E, 0x78, 0x03, 0xF0, 0x07, 0x8E, 0x00, 0xFC, 0x01, 0xE3, 0x80,
  0x3F, 0x00, 0x70, 0xF0, 0x1F, 0xE0, 0x3C, 0x3C, 0x07, 0x38, 0x0F, 0x07,
  0x01, 0xCE, 0x03, 0xC1, 0xC0, 0x73, 0x80, 0xE0, 0x78, 0x3C, 0xF0, 0x38,
  0x1E, 0x0E, 0x1C, 0x1E, 0x03, 0x83, 0x87, 0x07, 0x80, 0xE0, 0xE1, 0xC1,
  0xC0, 0x3C, 0x78, 0x78, 0x70, 0x0F, 0x1C, 0x0E, 0x3C, 0x01, 0xC7, 0x03,
  0x8F, 0x00, 0x71, 0xC0, 0xE3, 0x80, 0x1C, 0xF0, 0x1C, 0xE0, 0x07, 0xB8,
  0x07, 0x78, 0x01, 0xEE, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x77, 0x00, 0x0F,
  0xC0, 0x0D, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x0F, 0x00, 0x78, 0x38, 0x03, 0x81,
  0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x3C, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x8F,
  0x00, 0x1C, 0xF0, 0x00, 0xF7, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x0E, 0xE0,
  0x00, 0xF7, 0x80, 0x0F, 0x1C, 0x00, 0x70, 0xF0, 0x07, 0x83, 0x80, 0x38,
  0x1E, 0x03, 0xC0, 0x78, 0x1C, 0x03, 0xC1, 0xE0, 0x0F, 0x0E, 0x00, 0x78,
  0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78,
  0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x03, 0x81,
  0xE0, 0x78, 0x0E, 0x07, 0x00, 0xF0, 0xF0, 0x07, 0x0E, 0x00, 0x79, 0xE0,
  0x03, 0x9C, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x7F, 0xFF, 0xE0, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0x70, 0x01,
  0xCE, 0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x01, 0xC1, 0xC0, 0x70, 0x38, 0x0E,
  0x03, 0x83, 0xC0, 0x70, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0x0E, 0xF0,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xE1, 0xE1,
  0xC1, 0xC1, 0xC1, 0x80, 0x03, 0xE0, 0x7F, 0xF0, 0xFF, 0xF1, 0xC1, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x07, 0xFC, 0x7F,
  0xFB, 0xFF, 0xF7, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0xFF, 0xEF, 0xF7, 0xFE, 0xE7, 0xF8, 0xC0, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF1, 0xF0, 0x73, 0xFE, 0x3B, 0xFF, 0x9F, 0xC3, 0xEF,
  0x80, 0xF7, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xBF, 0x03, 0xDD, 0xFF, 0xCE, 0xFF, 0xC7,
  0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0x86, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x4F,
  0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x03, 0xC3,
  0x87, 0xF9, 0xC7, 0xFE, 0xE7, 0xC3, 0xF7, 0x80, 0xFB, 0xC0, 0x3D, 0xC0,
  0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x70, 0x07, 0xBC, 0x03,
  0xDF, 0x03, 0xE7, 0xEF, 0xF1, 0xFF, 0xB8, 0x7F, 0x9C, 0x03, 0xE0, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x80, 0xF3, 0x80, 0x79, 0xC0, 0x1D,
  0xE0, 0x0E, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x47, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xC0, 0x3F, 0xC3,
  0xFC, 0x1E, 0x21, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x3F, 0xF9, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x07, 0xF9, 0xC7, 0xFE, 0xE7, 0xC3, 0xF7, 0x80, 0xFB, 0xC0, 0x3D,
  0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x70, 0x07, 0xBC,
  0x03, 0xDF, 0x03, 0xE7, 0xEF, 0xF1, 0xFF, 0xB8, 0x7F, 0x9C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE8, 0x01, 0xE7, 0xE7,
  0xF3, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1,
  0xF0, 0xE7, 0xFC, 0xEF, 0xFE, 0xFE, 0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x4F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x02, 0x03,
  0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xC0, 0xE8, 0xF7, 0xFB, 0xF8, 0x60, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0x78, 0xE0, 0xF0, 0xE0, 0xE0, 0xE1,
  0xE0, 0xE3, 0xC0, 0xE7, 0x80, 0xEF, 0x00, 0xEF, 0x80, 0xFF, 0x80, 0xFB,
  0xC0, 0xF1, 0xE0, 0xE1, 0xE0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x78, 0xE0,
  0x3C, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0x1E, 0x0E, 0x7F, 0x87, 0xFC, 0xEF, 0xFC, 0xFF, 0xCF, 0xC3, 0xFC, 0x3E,
  0xF8, 0x1F, 0x81, 0xEF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00,
  0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00,
  0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0,
  0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0xE7, 0xFC, 0xEF, 0xFE, 0xFE, 0x1F, 0xF8,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x78, 0x07, 0x1E, 0x01,
  0xE7, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0E, 0x70,
  0x07, 0x9E, 0x01, 0xE3, 0xC0, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xFE,
  0x00, 0x01, 0xF0, 0x73, 0xFE, 0x3B, 0xFF, 0x9F, 0x83, 0xEF, 0x80, 0xF7,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFC, 0x07, 0xBF, 0x03, 0xDD, 0xFF, 0xCE, 0x7F, 0xC7, 0x1F, 0xC3,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07,
  0xF9, 0xC7, 0xFE, 0xE7, 0xC3, 0xF7, 0x80, 0xFB, 0xC0, 0x3D, 0xC0, 0x1F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0x70, 0x07, 0xBC, 0x03, 0xDF,
  0x03, 0xE7, 0xEF, 0xF1, 0xFF, 0xB8, 0x7F, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFC, 0x7F, 0x9F, 0xF7, 0x9F, 0xC1,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00,
  0x0F, 0xC1, 0xFF, 0xDF, 0xFF, 0xE0, 0x6E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC1, 0xFF, 0xFF, 0xF9, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xFB, 0x1F, 0xE1, 0xFC,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F,
  0x7F, 0xFF, 0x3F, 0xF7, 0x1F, 0xC7, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x80,
  0x39, 0xE0, 0x1E, 0x38, 0x07, 0x8E, 0x01, 0xC3, 0xC0, 0xF0, 0x70, 0x3C,
  0x1C, 0x0E, 0x07, 0x83, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x0F, 0x1C, 0x01,
  0xCF, 0x00, 0x73, 0x80, 0x1E, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x77, 0x00, 0xF8,
  0x0F, 0x78, 0x0F, 0x80, 0xF7, 0x81, 0xF8, 0x0E, 0x38, 0x1D, 0xC0, 0xE3,
  0x81, 0xDC, 0x1E, 0x3C, 0x1D, 0xC1, 0xE3, 0xC3, 0x9C, 0x1C, 0x1C, 0x38,
  0xE1, 0xC1, 0xC3, 0x8E, 0x1C, 0x1E, 0x78, 0xE3, 0xC1, 0xE7, 0x0F, 0x38,
  0x0E, 0x70, 0x73, 0x80, 0xE7, 0x07, 0x38, 0x0E, 0x70, 0x77, 0x80, 0xFE,
  0x07, 0x70, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xBC, 0x07,
  0x8F, 0x07, 0x87, 0x83, 0x81, 0xE3, 0xC0, 0x71, 0xC0, 0x3D, 0xE0, 0x0F,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x7B, 0xC0, 0x38, 0xE0, 0x3C, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x1E, 0x03,
  0xCE, 0x00, 0xEF, 0x00, 0x78, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x80, 0x39,
  0xE0, 0x1E, 0x38, 0x07, 0x8F, 0x01, 0xC1, 0xC0, 0xF0, 0x70, 0x3C, 0x1E,
  0x0E, 0x03, 0x83, 0x80, 0xE1, 0xE0, 0x3C, 0x70, 0x07, 0x1C, 0x01, 0xCF,
  0x00, 0x7B, 0x80, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x02, 0x7E, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x03, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x07, 0xC0, 0xFE, 0x07, 0xC0, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0xFE, 0x07, 0xC0, 0x3F, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x3F, 0x80, 0x7C, 0x00, 0xF0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xF8, 0x07, 0xC0, 0x7E, 0x07,
  0xC0, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x7E, 0x07, 0xE0, 0x3E,
  0x00, 0x1C, 0x00, 0xBF, 0xC0, 0x7F, 0xFC, 0xF8, 0x7F, 0xF8, 0x0F, 0xF4,
  0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 29, 10, 3, -29 },
  { 16, 11, 11, 16, 2, -29 },
  { 32, 21, 29, 23, 1, -29 },
  { 109, 17, 32, 21, 2, -30 },
  { 177, 27, 29, 31, 2, -29 },
  { 275, 24, 29, 26, 2, -29 },
  { 362, 4, 11, 9, 2, -29 },
  { 368, 9, 35, 12, 2, -29 },
  { 408, 9, 35, 12, 1, -29 },
  { 448, 16, 16, 20, 2, -30 },
  { 480, 17, 19, 21, 2, -24 },
  { 521, 5, 10, 10, 2, -5 },
  { 528, 10, 3, 12, 1, -12 },
  { 532, 4, 5, 10, 3, -5 },
  { 535, 13, 29, 15, 1, -29 },
  { 583, 17, 29, 21, 2, -29 },
  { 645, 10, 29, 21, 3, -29 },
  { 682, 17, 29, 21, 2, -29 },
  { 744, 17, 29, 21, 2, -29 },
  { 806, 19, 29, 21, 1, -29 },
  { 875, 17, 29, 21, 2, -29 },
  { 937, 17, 29, 21, 2, -29 },
  { 999, 17, 29, 21, 2, -29 },
  { 1061, 17, 29, 21, 2, -29 },
  { 1123, 17, 29, 21, 2, -29 },
  { 1185, 4, 22, 10, 3, -22 },
  { 1196, 6, 27, 10, 1, -22 },
  { 1217, 17, 19, 21, 2, -24 },
  { 1258, 17, 11, 21, 2, -20 },
  { 1282, 17, 19, 21, 2, -24 },
  { 1323, 15, 29, 16, 0, -29 },
  { 1378, 28, 32, 32, 2, -29 },
  { 1490, 23, 29, 23, 0, -29 },
  { 1574, 18, 29, 23, 4, -29 },
  { 1640, 19, 29, 23, 2, -29 },
  { 1709, 20, 29, 26, 4, -29 },
  { 1782, 14, 29, 20, 4, -29 },
  { 1833, 14, 29, 19, 4, -29 },
  { 1884, 22, 29, 26, 2, -29 },
  { 1964, 19, 29, 27, 4, -29 },
  { 2033, 9, 29, 13, 2, -29 },
  { 2066, 10, 37, 10, -3, -29 },
  { 2113, 18, 29, 22, 4, -29 },
  { 2179, 14, 29, 19, 4, -29 },
  { 2230, 26, 29, 34, 4, -29 },
  { 2325, 20, 29, 28, 4, -29 },
  { 2398, 24, 29, 28, 2, -29 },
  { 2485, 16, 29, 22, 4, -29 },
  { 2543, 24, 36, 28, 2, -29 },
  { 2651, 18, 29, 23, 4, -29 },
  { 2717, 16, 29, 20, 2, -29 },
  { 2775, 19, 29, 20, 0, -29 },
  { 2844, 20, 29, 26, 3, -29 },
  { 2917, 22, 29, 22, 0, -29 },
  { 2997, 34, 29, 34, 0, -29 },
  { 3121, 21, 29, 21, 0, -29 },
  { 3198, 20, 29, 20, 0, -29 },
  { 3271, 18, 29, 20, 1, -29 },
  { 3337, 9, 35, 13, 3, -29 },
  { 3377, 13, 29, 15, 1, -29 },
  { 3425, 9, 35, 13, 1, -29 },
  { 3465, 19, 17, 21, 1, -29 },
  { 3506, 18, 3, 18, 0, 3 },
  { 3513, 7, 7, 11, 2, -31 },
  { 3520, 15, 22, 20, 2, -22 },
  { 3562, 17, 30, 22, 3, -30 },
  { 3626, 14, 22, 17, 2, -22 },
  { 3665, 17, 30, 22, 2, -30 },
  { 3729, 17, 22, 20, 2, -22 },
  { 3776, 13, 31, 12, 1, -31 },
  { 3827, 17, 32, 22, 2, -22 },
  { 3895, 16, 30, 22, 3, -30 },
  { 3955, 4, 30, 10, 3, -30 },
  { 3970, 9, 40, 10, -2, -30 },
  { 4015, 16, 30, 19, 3, -30 },
  { 4075, 4, 30, 10, 3, -30 },
  { 4090, 28, 22, 34, 3, -22 },
  { 4167, 16, 22, 22, 3, -22 },
  { 4211, 18, 22, 22, 2, -22 },
  { 4261, 17, 32, 22, 3, -22 },
  { 4329, 17, 32, 22, 2, -22 },
  { 4397, 11, 22, 15, 3, -22 },
  { 4428, 13, 22, 17, 2, -22 },
  { 4464, 11, 26, 13, 1, -26 },
  { 4500, 16, 21, 22, 3, -21 },
  { 4542, 18, 21, 18, 0, -21 },
  { 4590, 28, 21, 29, 0, -21 },
  { 4664, 17, 21, 19, 1, -21 },
  { 4709, 18, 31, 18, 0, -21 },
  { 4779, 14, 21, 16, 1, -21 },
  { 4816, 13, 35, 15, 1, -29 },
  { 4873, 3, 40, 20, 8, -30 },
  { 4888, 13, 35, 15, 1, -29 },
  { 4945, 17, 6, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_Regular40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR40PT7B_H_
