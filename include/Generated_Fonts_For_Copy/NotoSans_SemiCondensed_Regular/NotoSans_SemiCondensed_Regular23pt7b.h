#ifndef _NOTOSANS_SEMICONDENSED_REGULAR23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xE6, 0x8D, 0x1A, 0x24, 0x48, 0x80, 0x0C,
  0xC0, 0x8C, 0x18, 0xC1, 0x88, 0xFF, 0xFF, 0xFF, 0x11, 0x81, 0x18, 0x11,
  0x83, 0x10, 0xFF, 0xE3, 0x30, 0x23, 0x02, 0x30, 0x23, 0x06, 0x20, 0x0C,
  0x03, 0x03, 0xF9, 0xB6, 0xCC, 0x33, 0x0E, 0xC1, 0xF0, 0x3E, 0x03, 0xE0,
  0xDC, 0x33, 0x0C, 0xE3, 0x6F, 0xF9, 0xF8, 0x0C, 0x03, 0x00, 0x30, 0x08,
  0x78, 0x30, 0xCC, 0x30, 0xC4, 0x20, 0xC4, 0x60, 0xC4, 0x40, 0xC4, 0xC0,
  0xC4, 0x9C, 0xCD, 0xB6, 0x79, 0x22, 0x33, 0x63, 0x02, 0x63, 0x06, 0x63,
  0x04, 0x63, 0x0C, 0x22, 0x08, 0x36, 0x18, 0x1C, 0x0C, 0x00, 0xFC, 0x03,
  0x38, 0x18, 0x60, 0x61, 0x80, 0xCC, 0x03, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xD8, 0x66, 0x73, 0x30, 0xEC, 0xC1, 0xF3, 0x03, 0x8E, 0x0E, 0x1F, 0xEC,
  0x3F, 0x1C, 0xE9, 0x24, 0x80, 0x19, 0x98, 0xC6, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x61, 0x8C, 0x61, 0x8C, 0x30, 0xC3, 0x18, 0x63, 0x18, 0x63, 0x18,
  0xC6, 0x31, 0x98, 0xC6, 0x63, 0x31, 0x80, 0x0C, 0x06, 0x22, 0x3F, 0xF3,
  0xE0, 0xE0, 0xD8, 0xE6, 0x22, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x6D, 0xED, 0x80, 0xFF,
  0xC0, 0xFC, 0x03, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x18,
  0x30, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x0C, 0x0F, 0xC7, 0x39, 0x86, 0xC1,
  0xB0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8, 0x66,
  0x18, 0xFC, 0x3E, 0x00, 0x1C, 0xF6, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x1C, 0x1F, 0xCE, 0x38, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0xFF,
  0xFF, 0xC0, 0x1C, 0x1F, 0xCC, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x1C,
  0x3E, 0x01, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x70, 0x1B, 0x9E, 0xFE, 0x00,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x68, 0x06, 0x80, 0xD8, 0x09, 0x81, 0x98,
  0x31, 0x83, 0x18, 0x61, 0x84, 0x18, 0xFF, 0xF0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x7F, 0x98, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0xE1, 0xFE,
  0x01, 0x80, 0x30, 0x0C, 0x03, 0x01, 0xE0, 0x6E, 0x7B, 0xF8, 0x07, 0x87,
  0xE3, 0x81, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x7C, 0xF3, 0xB8, 0x7C, 0x0F,
  0x03, 0xC0, 0xD8, 0x36, 0x18, 0xEE, 0x1F, 0x00, 0xFF, 0xC0, 0x30, 0x18,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x18,
  0x06, 0x03, 0x80, 0xC0, 0x0C, 0x0F, 0xC6, 0x19, 0x86, 0xC0, 0x98, 0x66,
  0x18, 0xFC, 0x1E, 0x0D, 0xC6, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x1D, 0xCE,
  0x3F, 0x00, 0x0C, 0x0F, 0xC6, 0x3B, 0x06, 0xC0, 0xB0, 0x3C, 0x0F, 0x03,
  0x61, 0xDF, 0xB3, 0xCC, 0x02, 0x01, 0x80, 0x60, 0x31, 0x3C, 0x7C, 0x00,
  0xBE, 0x00, 0x0F, 0xC0, 0x4D, 0xA0, 0x00, 0x01, 0xB7, 0xB4, 0x00, 0x40,
  0x30, 0x38, 0x38, 0x38, 0x38, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x04,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80, 0x30, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x3C, 0x3C, 0x3C, 0x3C, 0x08, 0x00, 0x1C, 0xFE,
  0x43, 0x03, 0x01, 0x03, 0x03, 0x06, 0x0C, 0x18, 0x18, 0x10, 0x00, 0x00,
  0x18, 0x38, 0x38, 0x07, 0xF8, 0x1C, 0x1C, 0x38, 0x06, 0x30, 0x02, 0x61,
  0xF3, 0x63, 0x31, 0x46, 0x31, 0xC4, 0x31, 0xCC, 0x31, 0xCC, 0x31, 0xC4,
  0x33, 0xC6, 0x53, 0x47, 0xDE, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1E,
  0x70, 0x07, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x60, 0x1B, 0x00, 0xD8, 0x04,
  0x60, 0x63, 0x03, 0x18, 0x10, 0x61, 0xFF, 0x0F, 0xF8, 0x60, 0xE6, 0x03,
  0x30, 0x19, 0x80, 0xF8, 0x03, 0xFF, 0x30, 0xEC, 0x0F, 0x03, 0xC0, 0xF0,
  0x7C, 0x3B, 0xFC, 0xC3, 0xB0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7F, 0xFB,
  0xFC, 0x03, 0x83, 0xFC, 0xE1, 0x98, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xFF, 0x0F,
  0xE0, 0xFF, 0x0C, 0x3C, 0xC0, 0xCC, 0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x6C, 0x06, 0xC0, 0xEC, 0x1C, 0xFF, 0x8F,
  0xE0, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x03, 0xC0, 0x7F,
  0x8F, 0x0C, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0xFE,
  0x07, 0xF8, 0x06, 0xC0, 0x36, 0x01, 0xB8, 0x0C, 0xE0, 0x63, 0xFF, 0x0F,
  0xF0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xF9,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0xDF, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x39, 0xBE,
  0xC0, 0xF8, 0x33, 0x0C, 0x63, 0x8C, 0x61, 0x98, 0x36, 0x07, 0xC0, 0xEC,
  0x19, 0xC3, 0x18, 0x61, 0x8C, 0x39, 0x83, 0x30, 0x36, 0x07, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFD, 0x81, 0x7B,
  0x06, 0xF6, 0x0D, 0xE6, 0x13, 0xCC, 0x67, 0x98, 0xCF, 0x19, 0x1E, 0x36,
  0x3C, 0x2C, 0x78, 0x70, 0xF0, 0xE1, 0xE0, 0xC3, 0xE0, 0x3E, 0x03, 0xF0,
  0x3F, 0x83, 0xD8, 0x3C, 0xC3, 0xCC, 0x3C, 0x63, 0xC6, 0x3C, 0x33, 0xC3,
  0xBC, 0x1B, 0xC1, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0x07, 0x80, 0x7F, 0x83,
  0x87, 0x1C, 0x0E, 0x60, 0x19, 0x80, 0x6E, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3E, 0x01, 0xD8, 0x06, 0x60, 0x19, 0x80, 0x63, 0x03, 0x0F, 0xFC,
  0x0F, 0xC0, 0xFF, 0x31, 0xEC, 0x1B, 0x06, 0xC1, 0xF0, 0x6C, 0x1B, 0x0E,
  0xFF, 0x3E, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x07, 0x80,
  0x7F, 0x83, 0x87, 0x1C, 0x0E, 0x60, 0x19, 0x80, 0x6E, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xD8, 0x06, 0x60, 0x19, 0x80, 0x63, 0x03,
  0x0F, 0xFC, 0x0F, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0xFF,
  0x18, 0xF3, 0x06, 0x60, 0xEC, 0x1D, 0x83, 0x30, 0x67, 0xF8, 0xFE, 0x18,
  0xC3, 0x1C, 0x61, 0x8C, 0x39, 0x83, 0x30, 0x36, 0x07, 0x0E, 0x1F, 0xD8,
  0x78, 0x0C, 0x06, 0x01, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xE0, 0x30, 0x18,
  0x0E, 0x07, 0xFE, 0xFE, 0x00, 0xFF, 0xE0, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06, 0xC1, 0xDF, 0xF1,
  0xFC, 0xC0, 0x36, 0x03, 0x60, 0x76, 0x06, 0x30, 0x63, 0x06, 0x30, 0xC3,
  0x8C, 0x18, 0xC1, 0x98, 0x19, 0x80, 0xD8, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x60, 0xE0, 0x60, 0x6C, 0x1C, 0x0D, 0x83, 0xC1, 0xB0, 0x78, 0x66, 0x1B,
  0x0C, 0x63, 0x61, 0x8C, 0x66, 0x31, 0x8C, 0xCC, 0x33, 0x19, 0x83, 0x61,
  0x30, 0x6C, 0x36, 0x0D, 0x86, 0x81, 0xA0, 0xF0, 0x1C, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0xE0, 0x73, 0x0C, 0x30, 0xC1, 0x98, 0x19, 0x80, 0xF0,
  0x0F, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x19, 0x81, 0x98, 0x30, 0xC7, 0x0C,
  0x60, 0x6E, 0x07, 0xE0, 0x76, 0x06, 0x60, 0xC3, 0x0C, 0x31, 0x81, 0x98,
  0x1B, 0x00, 0xF0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xFF, 0x80, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x0F, 0xFF, 0xFF, 0xFE,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xF0,
  0xE0, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06,
  0x06, 0x06, 0x03, 0x03, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xFF, 0xF0, 0x0C, 0x07, 0x01, 0xE0, 0xC8, 0x33, 0x18,
  0x46, 0x19, 0x02, 0xC0, 0xC0, 0xFF, 0xC0, 0xC6, 0x63, 0x0C, 0x3F, 0x88,
  0xE0, 0x30, 0x18, 0x0C, 0xFE, 0xC3, 0xC1, 0xE0, 0xF0, 0xFC, 0xF7, 0xD8,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC4, 0x3F, 0xCE, 0x3B, 0x06, 0xC1, 0xB0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x6C, 0x1B, 0xCE, 0x9F, 0x00, 0x0C, 0x3F,
  0x71, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x7B, 0x3F, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x08, 0xCF, 0xB7, 0x1D, 0x83, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF8, 0x36, 0x1D, 0xCF, 0x3E, 0xC0, 0x0C, 0x0F, 0xC7,
  0x19, 0x86, 0xC0, 0xF0, 0x3F, 0xFF, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xE6,
  0x1F, 0x80, 0x06, 0x1F, 0x18, 0x30, 0x30, 0x30, 0xFE, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x08, 0x0F, 0xB7, 0x1D,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x36, 0x1D, 0xCF, 0x3E,
  0xC0, 0x30, 0x0C, 0x03, 0x41, 0x9F, 0xC0, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0xC7, 0xFB, 0x8F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0x80, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x18, 0xC4, 0x00,
  0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0xF9, 0x00,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x1B, 0x19, 0x98, 0xD8, 0x6C, 0x3E,
  0x1F, 0x8C, 0xC6, 0x33, 0x19, 0x86, 0xC3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x18, 0xBF, 0x7E, 0xE3, 0xC6, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0x0C, 0x5F, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0x0C, 0x0F, 0xC7, 0x19, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8, 0x36, 0x0C, 0xEE, 0x1F, 0x00, 0x0C,
  0x3F, 0xCE, 0x3B, 0x06, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x6E,
  0x1B, 0xDE, 0xDF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x0C,
  0x0F, 0xB7, 0x1D, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x36,
  0x1D, 0xCF, 0x3E, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x0E,
  0x7F, 0x38, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x18, 0x7F, 0xC2,
  0xC0, 0xC0, 0x70, 0x3C, 0x0E, 0x07, 0x03, 0x03, 0xEE, 0xFC, 0x30, 0x60,
  0xC7, 0xF3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x47, 0x80,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF9,
  0xEF, 0xB0, 0xC0, 0xD8, 0x36, 0x0D, 0x86, 0x31, 0x8C, 0x63, 0x30, 0x6C,
  0x1B, 0x07, 0x80, 0xE0, 0x38, 0xC1, 0xC3, 0x61, 0xC3, 0x63, 0xC3, 0x63,
  0x46, 0x63, 0x66, 0x32, 0x66, 0x36, 0x66, 0x36, 0x2C, 0x36, 0x3C, 0x14,
  0x3C, 0x1C, 0x3C, 0x1C, 0x18, 0x60, 0xCC, 0x63, 0x38, 0x6C, 0x0E, 0x03,
  0x80, 0xE0, 0x6C, 0x1B, 0x0C, 0x66, 0x1F, 0x83, 0xC0, 0xEC, 0x19, 0x83,
  0x30, 0xC3, 0x18, 0x63, 0x0C, 0xC0, 0xD8, 0x1B, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0xF0, 0x08, 0x00, 0xFE, 0x06, 0x06,
  0x0C, 0x1C, 0x18, 0x30, 0x30, 0x60, 0xE0, 0xFF, 0xFF, 0x0E, 0x30, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x71, 0x81, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x30, 0x78, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x18, 0x1C, 0x71, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x63, 0x84, 0x00, 0x30, 0x7F, 0x18, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_Regular23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 16, 6, 2, -16 },
  { 5, 7, 6, 9, 1, -16 },
  { 11, 12, 16, 13, 1, -16 },
  { 35, 10, 18, 12, 1, -17 },
  { 58, 16, 17, 18, 1, -17 },
  { 92, 14, 17, 15, 1, -17 },
  { 122, 3, 6, 5, 1, -16 },
  { 125, 5, 20, 7, 1, -16 },
  { 138, 5, 20, 7, 1, -16 },
  { 151, 9, 9, 11, 1, -17 },
  { 162, 10, 11, 12, 1, -14 },
  { 176, 3, 6, 6, 1, -3 },
  { 179, 5, 2, 7, 1, -7 },
  { 181, 2, 3, 6, 2, -3 },
  { 182, 8, 16, 9, 0, -16 },
  { 198, 10, 17, 12, 1, -17 },
  { 220, 6, 16, 12, 2, -16 },
  { 232, 10, 17, 12, 1, -17 },
  { 254, 10, 17, 12, 1, -17 },
  { 276, 12, 17, 12, 0, -17 },
  { 302, 10, 16, 12, 1, -16 },
  { 322, 10, 17, 12, 1, -17 },
  { 344, 10, 16, 12, 1, -16 },
  { 364, 10, 17, 12, 1, -17 },
  { 386, 10, 17, 12, 1, -17 },
  { 408, 2, 13, 6, 2, -13 },
  { 412, 3, 16, 6, 1, -13 },
  { 418, 10, 11, 12, 1, -14 },
  { 432, 10, 6, 12, 1, -11 },
  { 440, 10, 11, 12, 1, -14 },
  { 454, 8, 17, 9, 0, -17 },
  { 471, 16, 18, 19, 1, -16 },
  { 507, 13, 16, 13, 0, -16 },
  { 533, 10, 16, 14, 2, -16 },
  { 553, 11, 17, 13, 1, -17 },
  { 577, 12, 16, 15, 2, -16 },
  { 601, 8, 16, 12, 2, -16 },
  { 617, 8, 16, 11, 2, -16 },
  { 633, 13, 17, 15, 1, -17 },
  { 661, 11, 16, 15, 2, -16 },
  { 683, 5, 16, 7, 1, -16 },
  { 693, 6, 20, 6, -2, -16 },
  { 708, 11, 16, 13, 2, -16 },
  { 730, 8, 16, 11, 2, -16 },
  { 746, 15, 16, 19, 2, -16 },
  { 776, 12, 16, 16, 2, -16 },
  { 800, 14, 17, 16, 1, -17 },
  { 830, 10, 16, 13, 2, -16 },
  { 850, 14, 21, 16, 1, -17 },
  { 887, 11, 16, 13, 2, -16 },
  { 909, 9, 17, 11, 1, -17 },
  { 929, 11, 16, 11, 0, -16 },
  { 951, 11, 16, 15, 2, -16 },
  { 973, 12, 16, 12, 0, -16 },
  { 997, 19, 16, 20, 0, -16 },
  { 1035, 12, 16, 12, 0, -16 },
  { 1059, 12, 16, 12, 0, -16 },
  { 1083, 10, 16, 11, 1, -16 },
  { 1103, 5, 20, 7, 2, -16 },
  { 1116, 8, 16, 9, 0, -16 },
  { 1132, 5, 20, 7, 1, -16 },
  { 1145, 10, 9, 12, 1, -16 },
  { 1157, 10, 1, 10, 0, 2 },
  { 1159, 4, 4, 6, 1, -18 },
  { 1161, 9, 13, 12, 1, -13 },
  { 1176, 10, 17, 13, 2, -17 },
  { 1198, 8, 13, 10, 1, -13 },
  { 1211, 10, 17, 13, 1, -17 },
  { 1233, 10, 13, 12, 1, -13 },
  { 1250, 8, 18, 7, 0, -18 },
  { 1268, 10, 19, 13, 1, -13 },
  { 1292, 9, 17, 13, 2, -17 },
  { 1312, 2, 17, 6, 2, -17 },
  { 1317, 5, 23, 6, -1, -17 },
  { 1332, 9, 17, 11, 2, -17 },
  { 1352, 2, 17, 6, 2, -17 },
  { 1357, 16, 13, 19, 2, -13 },
  { 1383, 9, 13, 13, 2, -13 },
  { 1398, 10, 13, 13, 1, -13 },
  { 1415, 10, 19, 13, 2, -13 },
  { 1439, 10, 19, 13, 1, -13 },
  { 1463, 6, 13, 9, 2, -13 },
  { 1473, 8, 13, 10, 1, -13 },
  { 1486, 7, 15, 7, 0, -15 },
  { 1500, 9, 12, 13, 2, -12 },
  { 1514, 10, 12, 11, 0, -12 },
  { 1529, 16, 12, 17, 0, -12 },
  { 1553, 10, 12, 11, 0, -12 },
  { 1568, 11, 18, 11, 0, -12 },
  { 1593, 8, 12, 9, 1, -12 },
  { 1605, 7, 20, 9, 1, -16 },
  { 1623, 2, 24, 11, 5, -18 },
  { 1629, 7, 20, 9, 1, -16 },
  { 1647, 10, 3, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Regular23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR23PT7B_H_
