#ifndef _NOTOSANS_SEMICONDENSED_REGULAR62PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular62pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x7E, 0xFE, 0xFF, 0xFF, 0x7E, 0x7E, 0x38, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0,
  0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7,
  0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0,
  0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x01, 0xE0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xF9, 0xE1, 0xF1, 0xF8, 0x78,
  0x08, 0x7C, 0x1E, 0x00, 0x3F, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x03, 0xE0,
  0x78, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01,
  0xF8, 0x78, 0x00, 0x3F, 0x9E, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1E, 0x7F, 0x80, 0x07, 0x87, 0xE0,
  0x01, 0xE0, 0xFC, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x81,
  0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x0F, 0xF0, 0x07,
  0x87, 0xEF, 0x81, 0xE7, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x40, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00,
  0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x1F, 0x00,
  0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x00, 0xF0,
  0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x00, 0xF8,
  0x1E, 0x00, 0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x83, 0xC0,
  0x00, 0x3C, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x78, 0x3F, 0x83,
  0xE0, 0x3C, 0x3E, 0x1F, 0xF0, 0x78, 0x0F, 0x0F, 0x0F, 0xFE, 0x1E, 0x07,
  0xC7, 0xC7, 0xFF, 0xC7, 0xC1, 0xE1, 0xE1, 0xE1, 0xF0, 0xF8, 0xF8, 0xF8,
  0xF8, 0x3E, 0x3F, 0xFC, 0x3C, 0x3C, 0x07, 0x87, 0xFF, 0x1F, 0x0F, 0x01,
  0xE0, 0xFF, 0x87, 0x87, 0xC0, 0x78, 0x0F, 0x83, 0xE1, 0xF0, 0x1F, 0x00,
  0x00, 0xF0, 0x78, 0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x01, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x78,
  0x07, 0xC0, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x7C,
  0x00, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0xCF,
  0xC0, 0x07, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0xF8, 0x1F, 0xEF, 0xC0, 0x07, 0xC1, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC1,
  0xFC, 0x03, 0xE0, 0xFC, 0x07, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0xC0, 0xF8,
  0x7E, 0x00, 0x7F, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x7C, 0x1F, 0x00, 0x07,
  0xE7, 0xE0, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xC0, 0x00, 0x7F, 0xF0, 0x3E,
  0x00, 0x03, 0xFF, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xE0,
  0x07, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xBF, 0x81, 0xFF, 0xFF, 0xF8, 0xFC,
  0x07, 0xFF, 0xFF, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF,
  0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0xFC, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x01, 0x00, 0x78, 0x01, 0x78, 0x1E, 0x03, 0x9F, 0xE7,
  0x8F, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x07, 0xE0,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x01, 0xE0, 0x00,
  0x80, 0x20, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8,
  0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0x83, 0xC3, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7D, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0x9C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0xE0, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xDF, 0x3F, 0x9F, 0x7F, 0x3F, 0xFC,
  0x3F, 0x78, 0x3F, 0x30, 0x3F, 0x20, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xC0, 0x07, 0xF0, 0xC0, 0x00, 0xFC, 0x20,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0x80, 0x07, 0xF0, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE8, 0x00, 0x03, 0xFB, 0x00, 0x01, 0xFC, 0xFC, 0x01,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x00, 0x7D, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x1F,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x0F,
  0x80, 0x07, 0xC0, 0x3C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC1, 0xF8, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF4, 0x00, 0x03, 0xF3, 0x00, 0x03, 0xF9, 0xF0, 0x0F, 0xF8,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x03, 0xF0, 0x07, 0xC7, 0xFF, 0x83, 0xF3, 0xFF, 0xF0, 0xFD, 0xFF, 0xFE,
  0x3E, 0xFF, 0xFF, 0xCF, 0xFC, 0x03, 0xF3, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0x0F, 0xBF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x0F, 0xE0, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0xFE, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xFC,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3E,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xF7, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x3F, 0x00,
  0x1F, 0xC7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0x7F, 0x80, 0x7F, 0x87, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xDF,
  0x80, 0x07, 0xF7, 0xF0, 0x03, 0xFC, 0xFE, 0x03, 0xDF, 0x1F, 0xFF, 0xF7,
  0xC7, 0xFF, 0xF9, 0xF0, 0x7F, 0xFC, 0xFC, 0x0F, 0xFC, 0x3F, 0x00, 0x10,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x20, 0x0F, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x3C, 0x7E, 0xFE,
  0xFE, 0xFF, 0xFE, 0x7E, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x7E, 0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0x38, 0x0F, 0x0F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x87,
  0xC7, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xF0, 0x0F,
  0xE6, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0xFC, 0x03, 0xC1, 0xE0, 0x07, 0xFF, 0xF0, 0x3E, 0x3E, 0x00, 0xFF, 0xFF,
  0x03, 0xE3, 0xE0, 0x1F, 0xC7, 0xF0, 0x1E, 0x3C, 0x03, 0xF0, 0x1E, 0x01,
  0xE7, 0xC0, 0x7E, 0x01, 0xE0, 0x1F, 0x7C, 0x07, 0xC0, 0x1E, 0x01, 0xF7,
  0x80, 0x78, 0x01, 0xE0, 0x1F, 0x78, 0x0F, 0x80, 0x1E, 0x01, 0xF7, 0x80,
  0xF8, 0x01, 0xE0, 0x0F, 0x78, 0x0F, 0x80, 0x1E, 0x00, 0xFF, 0x80, 0xF0,
  0x01, 0xE0, 0x1F, 0xF8, 0x0F, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0xF0, 0x03,
  0xE0, 0x1F, 0xF8, 0x0F, 0x00, 0x3E, 0x01, 0xEF, 0x80, 0xF0, 0x03, 0xE0,
  0x1E, 0xF8, 0x0F, 0x00, 0x3E, 0x01, 0xEF, 0x80, 0xF8, 0x03, 0xE0, 0x3E,
  0x78, 0x0F, 0x80, 0x7E, 0x03, 0xC7, 0x80, 0x7C, 0x07, 0xE0, 0x7C, 0x78,
  0x07, 0xE0, 0xEF, 0x07, 0x87, 0xC0, 0x3F, 0xFE, 0x7F, 0xF8, 0x7C, 0x03,
  0xFF, 0xC7, 0xFF, 0x07, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3E, 0x00, 0x7F,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0xFC, 0x07, 0xFF, 0xCF, 0xC0, 0x03, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xF8, 0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x0F, 0xF8, 0xFC, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC,
  0x00, 0x1F, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0x00, 0xF8, 0x3F, 0xC0, 0x00, 0x81, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x06, 0x07, 0xFF, 0x07,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x0F, 0xF0, 0xFC,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0x38, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xF0,
  0x00, 0x3F, 0x07, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xC0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xFA, 0x0F, 0xE7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0,
  0x3F, 0x00, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x9F, 0x80, 0x03,
  0xF8, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC,
  0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xBE, 0x00, 0x00, 0x1F, 0xFF, 0xEF, 0x80, 0x00, 0x07, 0xFF,
  0xFB, 0xE0, 0x00, 0x01, 0xEF, 0xFE, 0x7C, 0x00, 0x00, 0xFB, 0xFF, 0x9F,
  0x00, 0x00, 0x3E, 0xFF, 0xE7, 0xC0, 0x00, 0x0F, 0x3F, 0xF8, 0xF8, 0x00,
  0x07, 0xCF, 0xFE, 0x3E, 0x00, 0x01, 0xF3, 0xFF, 0xCF, 0x80, 0x00, 0xF8,
  0xFF, 0xF1, 0xF0, 0x00, 0x3E, 0x3F, 0xFC, 0x7C, 0x00, 0x0F, 0x8F, 0xFF,
  0x1F, 0x00, 0x07, 0xC3, 0xFF, 0xC3, 0xE0, 0x01, 0xF0, 0xFF, 0xF0, 0xF8,
  0x00, 0x7C, 0x3F, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xFF, 0x07, 0xC0, 0x0F,
  0x83, 0xFF, 0xC1, 0xF0, 0x03, 0xE0, 0xFF, 0xF0, 0x7E, 0x01, 0xF0, 0x3F,
  0xFC, 0x0F, 0x80, 0x7C, 0x0F, 0xFF, 0x03, 0xE0, 0x1F, 0x03, 0xFF, 0xC0,
  0xFC, 0x0F, 0x80, 0xFF, 0xF0, 0x1F, 0x03, 0xE0, 0x3F, 0xFC, 0x07, 0xC0,
  0xF0, 0x0F, 0xFF, 0x00, 0xF8, 0x7C, 0x03, 0xFF, 0xC0, 0x3E, 0x1F, 0x00,
  0xFF, 0xF0, 0x0F, 0x87, 0x80, 0x3F, 0xFC, 0x01, 0xF3, 0xE0, 0x0F, 0xFF,
  0x00, 0x7C, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x3C, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFB, 0xF0, 0x00, 0x1F, 0xFB, 0xF0, 0x00,
  0x1F, 0xF9, 0xF8, 0x00, 0x1F, 0xF8, 0xFC, 0x00, 0x1F, 0xF8, 0xFC, 0x00,
  0x1F, 0xF8, 0x7E, 0x00, 0x1F, 0xF8, 0x7E, 0x00, 0x1F, 0xFC, 0x3F, 0x00,
  0x1F, 0xFC, 0x3F, 0x00, 0x1F, 0xFC, 0x1F, 0x80, 0x1F, 0xFC, 0x0F, 0x80,
  0x1F, 0xFC, 0x0F, 0xC0, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x07, 0xE0,
  0x1F, 0xFC, 0x03, 0xF0, 0x1F, 0xFC, 0x03, 0xF0, 0x1F, 0xFC, 0x01, 0xF8,
  0x1F, 0xFC, 0x01, 0xF8, 0x1F, 0xFC, 0x00, 0xFC, 0x1F, 0xFC, 0x00, 0x7E,
  0x1F, 0xFC, 0x00, 0x7E, 0x1F, 0xFC, 0x00, 0x3F, 0x1F, 0xFC, 0x00, 0x3F,
  0x1F, 0xFC, 0x00, 0x1F, 0x9F, 0xFC, 0x00, 0x1F, 0x9F, 0xFC, 0x00, 0x0F,
  0xDF, 0xFC, 0x00, 0x07, 0xEF, 0xFC, 0x00, 0x07, 0xEF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFC, 0x0F, 0xFF,
  0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0xFE, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7E, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF1, 0xFE, 0x03, 0xF1, 0xFC, 0x00, 0x18, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFD, 0xC0, 0x01, 0xFE, 0xFE, 0x03, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF7,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0x9F, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF3, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0xC0, 0xFC,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x01,
  0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0xF8, 0x07,
  0xC0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x1F, 0x01, 0xF0,
  0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x0F, 0x87, 0xE0, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x8F, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xEF, 0x80, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x07, 0xBC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F,
  0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xE0, 0x1E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0E, 0x00, 0xFE, 0x08, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC0,
  0x1F, 0x7F, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0x7F, 0xFF,
  0xDF, 0x3F, 0xFF, 0x9F, 0x1F, 0xFF, 0x0F, 0x0F, 0xFC, 0x0F, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x3E, 0x1F, 0xFC, 0x07, 0xCF, 0xFF, 0xC0, 0xFB, 0xFF, 0xFC, 0x1F, 0x7F,
  0xFF, 0xC3, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0x8F, 0xE0, 0x01, 0xF9,
  0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0xE0, 0x07, 0xE3, 0xFF,
  0x03, 0xFC, 0x7D, 0xFF, 0xFF, 0x0F, 0x3F, 0xFF, 0xC1, 0xE1, 0xFF, 0xF0,
  0x3C, 0x1F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x80, 0xE1,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x04, 0x7F, 0x80, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0x60, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x7F, 0xF0, 0xF8, 0x3F,
  0xFF, 0x1F, 0x0F, 0xFF, 0xF3, 0xE3, 0xFF, 0xFF, 0x7C, 0x7F, 0x01, 0xFF,
  0x9F, 0xC0, 0x0F, 0xF3, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xDF, 0x80,
  0x03, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x7E, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x3F,
  0x00, 0x0F, 0xE7, 0xF0, 0x03, 0xFC, 0x7F, 0x01, 0xFF, 0x87, 0xFF, 0xFD,
  0xF0, 0xFF, 0xFF, 0x3E, 0x07, 0xFF, 0xC7, 0xC0, 0x7F, 0xE0, 0x78, 0x00,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0x81, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xE7, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0x07, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xF8, 0x20, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF8,
  0x7C, 0x1F, 0xFF, 0x8F, 0x87, 0xFF, 0xF9, 0xF1, 0xFF, 0xFF, 0xBE, 0x3F,
  0x80, 0xFF, 0xCF, 0xE0, 0x07, 0xF9, 0xF8, 0x00, 0xFF, 0x7E, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0x9F, 0x80, 0x07, 0xF3, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0xFF, 0xC3,
  0xFF, 0xFE, 0xF8, 0x7F, 0xFF, 0x9F, 0x03, 0xFF, 0xE3, 0xE0, 0x3F, 0xF0,
  0x7C, 0x00, 0x60, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0xC0, 0x00, 0x7E, 0x1E, 0x00, 0x3F, 0xC3, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xFE, 0x03,
  0xE1, 0xFF, 0xC1, 0xF3, 0xFF, 0xF8, 0xFB, 0xFF, 0xFE, 0x7D, 0xFF, 0xFF,
  0x3F, 0xE0, 0x1F, 0xDF, 0xE0, 0x07, 0xEF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x38, 0xF9, 0xF7, 0xFF, 0xEF,
  0x9F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x80,
  0x00, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0xFF, 0xE7, 0xFF, 0x3F, 0xF1,
  0xFF, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0B,
  0xE0, 0x01, 0xF9, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0xFC,
  0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0xFC,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x7E,
  0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBF, 0x80, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFE, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7E,
  0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0,
  0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x07,
  0xE7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x1E, 0x0F, 0xFE, 0x03, 0xFF, 0x83,
  0xC7, 0xFF, 0xE0, 0xFF, 0xFC, 0x7D, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xBF,
  0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xBF, 0xC0, 0x1F,
  0xF0, 0x03, 0xF7, 0xF0, 0x01, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xDF, 0x80, 0x07, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x80, 0x03,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x78, 0x3F, 0xF8, 0x3C, 0x7F,
  0xFF, 0x1F, 0x7F, 0xFF, 0xCF, 0xBF, 0xFF, 0xE7, 0xFC, 0x03, 0xFB, 0xFC,
  0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x7E, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xFE, 0x07, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1E, 0x0F, 0xFE,
  0x03, 0xC7, 0xFF, 0xE0, 0x7D, 0xFF, 0xFE, 0x0F, 0xBF, 0xFF, 0xE1, 0xFF,
  0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F,
  0x9F, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF8, 0x00,
  0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xF0, 0x03, 0xF1, 0xFF, 0x81, 0xFE, 0x3E,
  0xFF, 0xFF, 0x87, 0xCF, 0xFF, 0xE0, 0xF8, 0xFF, 0xF8, 0x1F, 0x0F, 0xFC,
  0x03, 0xE0, 0x1C, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF8, 0x7C, 0x1F,
  0xFF, 0x8F, 0x87, 0xFF, 0xF9, 0xF0, 0xFF, 0xFF, 0xBE, 0x3F, 0x80, 0xFF,
  0xCF, 0xE0, 0x07, 0xF9, 0xF8, 0x00, 0xFF, 0x7E, 0x00, 0x0F, 0xEF, 0xC0,
  0x01, 0xFD, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x3F, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x9F,
  0x80, 0x0F, 0xF3, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0xFF, 0xC3, 0xFF, 0xFE,
  0xF8, 0x7F, 0xFF, 0x9F, 0x03, 0xFF, 0xE3, 0xE0, 0x3F, 0xF0, 0x7C, 0x00,
  0x60, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F,
  0xFF, 0xDF, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0x00, 0x73, 0xF0, 0x00, 0x9F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0x78, 0x03, 0xFB, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x41, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0x00, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x1F, 0xF7, 0xF0, 0x1F, 0xFB, 0xFF, 0xFF, 0x7C, 0xFF, 0xFF, 0x3E, 0x3F,
  0xFF, 0x1F, 0x07, 0xFE, 0x0F, 0x80, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x80,
  0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x3E, 0x00, 0x3F,
  0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xFC, 0x00, 0xFC, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0x1F, 0x80, 0x1E, 0xF0, 0x03, 0xE1, 0xF0, 0x07, 0xDE, 0x00, 0x7C,
  0x3E, 0x00, 0xFB, 0xE0, 0x1F, 0x87, 0xC0, 0x1E, 0x7C, 0x03, 0xE0, 0xFC,
  0x07, 0xCF, 0x80, 0x7C, 0x0F, 0x80, 0xF8, 0xF0, 0x0F, 0x81, 0xF0, 0x1F,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x07, 0xE0, 0xF8, 0x7C,
  0x0F, 0x80, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x01, 0xF0, 0x78, 0x1F, 0x0F, 0x80, 0x3F, 0x1F, 0x03, 0xE1, 0xF0, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0x3E, 0x00, 0x1F, 0x7C, 0x01,
  0xF7, 0xC0, 0x03, 0xEF, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xE0, 0x07, 0xDE,
  0x00, 0x0F, 0xBC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE7, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x3F,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xBF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x27, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xB0, 0x01, 0xFF, 0xE4, 0x00, 0x0F, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Regular62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 8, 45, 16, 4, -44 },
  { 46, 17, 16, 25, 4, -44 },
  { 80, 33, 44, 36, 1, -44 },
  { 262, 26, 51, 32, 3, -47 },
  { 428, 42, 46, 48, 3, -45 },
  { 670, 37, 46, 40, 3, -45 },
  { 883, 6, 16, 14, 4, -44 },
  { 895, 14, 54, 18, 3, -44 },
  { 990, 14, 54, 18, 2, -44 },
  { 1085, 26, 25, 31, 2, -47 },
  { 1167, 26, 30, 32, 3, -37 },
  { 1265, 9, 15, 16, 2, -7 },
  { 1282, 15, 5, 19, 2, -19 },
  { 1292, 7, 8, 16, 4, -7 },
  { 1299, 21, 44, 23, 1, -44 },
  { 1415, 26, 46, 32, 3, -45 },
  { 1565, 16, 44, 32, 5, -44 },
  { 1653, 26, 45, 32, 3, -45 },
  { 1800, 26, 46, 32, 3, -45 },
  { 1950, 30, 45, 32, 1, -45 },
  { 2119, 25, 45, 32, 4, -44 },
  { 2260, 26, 46, 32, 3, -45 },
  { 2410, 27, 44, 32, 2, -44 },
  { 2559, 27, 46, 32, 3, -45 },
  { 2715, 26, 46, 32, 3, -45 },
  { 2865, 8, 35, 16, 4, -34 },
  { 2900, 9, 42, 16, 2, -34 },
  { 2948, 27, 29, 32, 3, -37 },
  { 3046, 26, 17, 32, 3, -30 },
  { 3102, 27, 29, 32, 3, -37 },
  { 3200, 22, 46, 24, 1, -45 },
  { 3327, 44, 49, 50, 3, -44 },
  { 3597, 35, 44, 35, 0, -44 },
  { 3790, 28, 44, 36, 5, -44 },
  { 3944, 29, 46, 35, 4, -45 },
  { 4111, 32, 44, 40, 5, -44 },
  { 4287, 23, 44, 31, 5, -44 },
  { 4414, 23, 44, 29, 5, -44 },
  { 4541, 33, 46, 41, 4, -45 },
  { 4731, 31, 44, 41, 5, -44 },
  { 4902, 15, 44, 20, 2, -44 },
  { 4985, 15, 56, 16, -4, -44 },
  { 5090, 30, 44, 34, 5, -44 },
  { 5255, 23, 44, 29, 5, -44 },
  { 5382, 42, 44, 52, 5, -44 },
  { 5613, 32, 44, 43, 5, -44 },
  { 5789, 36, 46, 43, 4, -45 },
  { 5996, 26, 44, 34, 5, -44 },
  { 6139, 36, 56, 43, 4, -45 },
  { 6391, 29, 44, 35, 5, -44 },
  { 6551, 25, 46, 31, 3, -45 },
  { 6695, 29, 44, 31, 1, -44 },
  { 6855, 30, 45, 41, 5, -44 },
  { 7024, 34, 44, 34, 0, -44 },
  { 7211, 51, 44, 53, 1, -44 },
  { 7492, 32, 44, 32, 0, -44 },
  { 7668, 31, 44, 31, 0, -44 },
  { 7839, 27, 44, 31, 2, -44 },
  { 7988, 13, 54, 20, 5, -44 },
  { 8076, 21, 44, 23, 1, -44 },
  { 8192, 13, 54, 20, 2, -44 },
  { 8280, 29, 26, 32, 2, -44 },
  { 8375, 27, 4, 27, 0, 5 },
  { 8389, 13, 9, 17, 2, -47 },
  { 8404, 24, 35, 32, 3, -34 },
  { 8509, 27, 48, 35, 5, -47 },
  { 8671, 22, 35, 27, 3, -34 },
  { 8768, 27, 48, 35, 3, -47 },
  { 8930, 26, 35, 32, 3, -34 },
  { 9044, 20, 47, 19, 1, -47 },
  { 9162, 27, 49, 35, 3, -34 },
  { 9328, 25, 47, 35, 5, -47 },
  { 9475, 7, 46, 15, 4, -46 },
  { 9516, 13, 61, 15, -2, -46 },
  { 9616, 25, 47, 30, 5, -47 },
  { 9763, 5, 47, 15, 5, -47 },
  { 9793, 43, 34, 52, 5, -34 },
  { 9976, 25, 34, 35, 5, -34 },
  { 10083, 28, 35, 34, 3, -34 },
  { 10206, 27, 49, 35, 5, -34 },
  { 10372, 27, 49, 35, 3, -34 },
  { 10538, 17, 34, 23, 5, -34 },
  { 10611, 21, 35, 27, 3, -34 },
  { 10703, 18, 42, 20, 1, -41 },
  { 10798, 25, 34, 35, 5, -33 },
  { 10905, 28, 33, 28, 0, -33 },
  { 11021, 43, 33, 45, 1, -33 },
  { 11199, 27, 33, 29, 1, -33 },
  { 11311, 28, 48, 28, 0, -33 },
  { 11479, 21, 33, 25, 2, -33 },
  { 11566, 19, 54, 23, 2, -44 },
  { 11695, 5, 62, 31, 13, -47 },
  { 11734, 19, 54, 23, 2, -44 },
  { 11863, 27, 8, 32, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_Regular62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR62PT7B_H_
