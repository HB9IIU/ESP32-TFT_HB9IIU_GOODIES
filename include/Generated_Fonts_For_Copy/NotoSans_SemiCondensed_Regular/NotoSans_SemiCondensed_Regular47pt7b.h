#ifndef _NOTOSANS_SEMICONDENSED_REGULAR47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular47pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x78, 0xE3, 0x8C, 0x30, 0x00, 0x00, 0x31, 0xEF,
  0xFF, 0xFD, 0xE1, 0x00, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x07,
  0x78, 0x3B, 0xC1, 0xDE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7,
  0x07, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00,
  0x0E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03, 0x81, 0xE0,
  0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x0F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x0E, 0x07, 0x00, 0x07, 0x03,
  0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xE0,
  0x78, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x07, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01,
  0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x78, 0x3C, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1F,
  0x80, 0x1F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0xE3, 0x9E, 0x1C,
  0x03, 0xC3, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x38,
  0x07, 0xC7, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x39, 0xF0, 0x07, 0x1F, 0x00, 0xE1,
  0xE0, 0x1C, 0x3C, 0x03, 0x87, 0x80, 0x70, 0xF8, 0x0E, 0x3F, 0xC1, 0xCF,
  0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x1F, 0xC0, 0x03, 0x80, 0x3F, 0xE0, 0x07, 0x80, 0x78, 0xF0,
  0x07, 0x00, 0x70, 0x70, 0x0F, 0x00, 0x70, 0x70, 0x0E, 0x00, 0xF0, 0x78,
  0x1E, 0x00, 0xF0, 0x78, 0x1C, 0x00, 0xF0, 0x38, 0x1C, 0x00, 0xF0, 0x38,
  0x3C, 0x00, 0xF0, 0x38, 0x38, 0x00, 0xF0, 0x38, 0x78, 0x00, 0xF0, 0x38,
  0x70, 0x00, 0xF0, 0x78, 0xF0, 0x40, 0xF0, 0x78, 0xE3, 0xF8, 0x70, 0x71,
  0xE7, 0xFC, 0x70, 0x71, 0xC7, 0xBE, 0x78, 0xF3, 0xCF, 0x0E, 0x3F, 0xE3,
  0x8E, 0x0E, 0x1F, 0xC7, 0x8E, 0x0F, 0x0F, 0x87, 0x1E, 0x0F, 0x00, 0x0F,
  0x1E, 0x07, 0x00, 0x0E, 0x1E, 0x07, 0x00, 0x1E, 0x1E, 0x07, 0x00, 0x1C,
  0x1E, 0x07, 0x00, 0x3C, 0x1E, 0x07, 0x00, 0x38, 0x1E, 0x07, 0x00, 0x78,
  0x1E, 0x0F, 0x00, 0x70, 0x0E, 0x0F, 0x00, 0xF0, 0x0E, 0x0E, 0x00, 0xE0,
  0x0F, 0x1E, 0x01, 0xE0, 0x07, 0xFE, 0x01, 0xC0, 0x07, 0xFC, 0x03, 0xC0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x7C,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x3C, 0x1F, 0x7C, 0x03, 0xC3, 0xE3, 0xE0, 0x3C,
  0x7C, 0x1F, 0x07, 0x87, 0x80, 0xF8, 0x78, 0xF8, 0x07, 0xC7, 0x8F, 0x00,
  0x3E, 0xF0, 0xF0, 0x03, 0xFF, 0x0F, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0xFE,
  0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFE, 0x07, 0xC0, 0x1F, 0xF0, 0x7F,
  0x0F, 0xEF, 0x83, 0xFF, 0xFC, 0x7C, 0x1F, 0xFF, 0x87, 0xE0, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x70, 0x01, 0xE0, 0x78, 0x1E,
  0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x30, 0x38, 0x1F, 0xE7, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x3B, 0x80, 0x0F, 0x78, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x0F, 0x07, 0xC1, 0xF0, 0x18, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x3E, 0x78,
  0xF3, 0xE7, 0x8F, 0x1E, 0x38, 0xF1, 0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x31, 0xEF, 0xFF, 0xFD, 0xE2, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78,
  0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0xC0,
  0x1E, 0x3C, 0x03, 0xE3, 0xE0, 0x3C, 0x1F, 0x0F, 0xC0, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0x1F, 0xF3,
  0xEF, 0x7C, 0xFF, 0x8F, 0xF0, 0xF6, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xF8, 0x01, 0xFF, 0xE0,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF8, 0x78, 0x07, 0xC3, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x01, 0xFF,
  0xF0, 0x7F, 0xFF, 0x8F, 0xFB, 0xFC, 0x78, 0x07, 0xC2, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x7F, 0xE0,
  0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE8, 0x00, 0x3E, 0xF0,
  0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x01,
  0xE7, 0x80, 0x03, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x01, 0xE0, 0xF0, 0x03, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0x80, 0x3C, 0x0F, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE3, 0xC0, 0x3F, 0xFF, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0x84, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7D, 0x00, 0x1F, 0x3C, 0x0F,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0x8C, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x8F, 0xE0, 0x79, 0xFF, 0x87, 0x3F, 0xFC,
  0xF7, 0x8F, 0xEF, 0xE0, 0x3E, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80,
  0x0F, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x01, 0xE3, 0xE0, 0x3E, 0x1F,
  0x07, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF9, 0xFC, 0x3E, 0x03, 0xE7, 0xC0,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78,
  0x01, 0xE3, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xF0, 0xF8, 0x0F, 0xDF, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xBF, 0x83, 0xE0, 0xFC,
  0x3C, 0x03, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xF7, 0x80,
  0x1E, 0x7E, 0x03, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x01,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3E, 0x07, 0xC7,
  0xC0, 0x3C, 0x78, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01,
  0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xF3, 0xE0, 0x7F, 0x3F, 0xFE, 0xF1, 0xFF,
  0xCF, 0x07, 0xF8, 0xF0, 0x08, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x01, 0xF8, 0x20, 0x3F, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0x31, 0xEF, 0xFF, 0xFD, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x31, 0xEF, 0xFF, 0xFD, 0xE2, 0x00, 0x18, 0xF9, 0xFB,
  0xF7, 0xE7, 0x84, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x8F, 0x3E, 0x78, 0xF1, 0xE3, 0x8F, 0x1E, 0x38,
  0x70, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0xE0, 0x7F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x60, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x02, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFE,
  0x1F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0xC0, 0x0E, 0x78, 0x07, 0xFE, 0x0E, 0x78, 0x1F, 0xFE, 0x0F, 0x70, 0x3F,
  0x1E, 0x07, 0xF0, 0x3C, 0x0E, 0x07, 0xF0, 0x78, 0x0E, 0x07, 0xE0, 0x70,
  0x0E, 0x07, 0xE0, 0xF0, 0x1E, 0x07, 0xE0, 0xF0, 0x1E, 0x07, 0xE0, 0xF0,
  0x1E, 0x07, 0xE0, 0xF0, 0x1E, 0x07, 0xE0, 0xF0, 0x1E, 0x07, 0xE0, 0xF0,
  0x1E, 0x07, 0xE0, 0xF0, 0x1E, 0x07, 0xE0, 0x70, 0x3E, 0x0E, 0xE0, 0x78,
  0x3E, 0x0E, 0xE0, 0x7C, 0x77, 0x1E, 0xF0, 0x3F, 0xE7, 0xFC, 0xF0, 0x1F,
  0xC3, 0xF8, 0x70, 0x0F, 0x81, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x1E, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x03, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x01, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x7C, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF,
  0x00, 0x7E, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00,
  0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1F, 0x78,
  0x01, 0xF3, 0xC0, 0x3F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x3C, 0x03, 0xF9, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xC0, 0x18, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x20, 0xFF, 0x07, 0x81, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0xF0, 0xF0, 0x01, 0xF8, 0xF0,
  0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0xFC, 0xF0, 0x01, 0xF8, 0xF0, 0x07, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFE, 0x00, 0xE0, 0xFC, 0x00, 0x10, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDF, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xF0, 0x00, 0x78, 0xFC, 0x00, 0x3C, 0x3F,
  0xC0, 0x7E, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC7, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC1, 0xF7, 0xFE, 0xFF, 0x9F, 0xE3, 0xF0,
  0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x00, 0x1F, 0x3C, 0x00, 0x78,
  0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x0F, 0x07, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0xF0,
  0x03, 0xC7, 0xC0, 0x0F, 0x3E, 0x00, 0x3C, 0xF0, 0x00, 0xF7, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xEF, 0x00, 0x3F, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xC1,
  0xF0, 0x0F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0x3E,
  0x0F, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0x8F,
  0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xF0, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFB, 0xC0, 0x00, 0xEF, 0xF7, 0x80, 0x03, 0xDF, 0xEF,
  0x00, 0x07, 0xBF, 0xCF, 0x00, 0x0E, 0x7F, 0x9E, 0x00, 0x3C, 0xFF, 0x3C,
  0x00, 0x79, 0xFE, 0x3C, 0x00, 0xE3, 0xFC, 0x78, 0x03, 0xC7, 0xF8, 0xF0,
  0x07, 0x8F, 0xF0, 0xF0, 0x0E, 0x1F, 0xE1, 0xE0, 0x3C, 0x3F, 0xC3, 0xC0,
  0x78, 0x7F, 0x83, 0xC0, 0xE0, 0xFF, 0x07, 0x83, 0xC1, 0xFE, 0x07, 0x07,
  0x83, 0xFC, 0x0F, 0x0E, 0x07, 0xF8, 0x1E, 0x3C, 0x0F, 0xF0, 0x1C, 0x78,
  0x1F, 0xE0, 0x3C, 0xE0, 0x3F, 0xC0, 0x7B, 0xC0, 0x7F, 0x80, 0x77, 0x80,
  0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x07,
  0xF8, 0x03, 0xE0, 0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x07, 0x00, 0x3C,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xF7, 0x80, 0x0F,
  0xF7, 0xC0, 0x0F, 0xF3, 0xC0, 0x0F, 0xF3, 0xE0, 0x0F, 0xF1, 0xE0, 0x0F,
  0xF1, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0x7C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1F, 0x0F,
  0xF0, 0x0F, 0x0F, 0xF0, 0x0F, 0x8F, 0xF0, 0x07, 0x8F, 0xF0, 0x07, 0xC7,
  0xF0, 0x03, 0xE7, 0xF0, 0x01, 0xE7, 0xF0, 0x01, 0xF7, 0xF0, 0x00, 0xF7,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xF8, 0x03, 0xE0, 0x7E,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF0,
  0x1F, 0xCF, 0x00, 0x7E, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xF0,
  0x1F, 0xC3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0xF0, 0x01,
  0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xE3,
  0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x01, 0xF0, 0xF0, 0x7F, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0x1E, 0x0F,
  0x00, 0x7C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0x8F, 0x00,
  0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xF0, 0x01, 0xFE,
  0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xE0, 0x1C, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xBF, 0x07, 0xF7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0xC0, 0x1F, 0x0F,
  0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x07,
  0x80, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03,
  0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3D, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x7E, 0x00,
  0x1E, 0x78, 0x00, 0x7E, 0x00, 0x1E, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x3C,
  0x00, 0x7E, 0x00, 0x3C, 0x3C, 0x00, 0xFF, 0x00, 0x3C, 0x3C, 0x00, 0xFF,
  0x00, 0x3C, 0x3E, 0x00, 0xEF, 0x00, 0x7C, 0x1E, 0x00, 0xE7, 0x00, 0x78,
  0x1E, 0x01, 0xE7, 0x80, 0x78, 0x1E, 0x01, 0xE7, 0x80, 0x78, 0x1F, 0x01,
  0xE7, 0x80, 0x78, 0x0F, 0x03, 0xC3, 0x80, 0xF0, 0x0F, 0x03, 0xC3, 0xC0,
  0xF0, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x0F, 0x03, 0x83, 0xC0, 0xF0, 0x07,
  0x87, 0x81, 0xC1, 0xE0, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0x07, 0x87, 0x01, 0xE1, 0xE0, 0x03, 0xCF, 0x00, 0xF3, 0xE0,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x03, 0xCE,
  0x00, 0x73, 0xC0, 0x01, 0xCE, 0x00, 0x73, 0xC0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x7C,
  0x1F, 0x00, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x81, 0xF0,
  0x07, 0xC1, 0xE0, 0x03, 0xC3, 0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xE7, 0x80,
  0x00, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xF7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x03, 0xC3, 0xC0,
  0x07, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF8,
  0x1F, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3E,
  0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E,
  0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x78,
  0x1E, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xE0,
  0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0x80,
  0x01, 0xE7, 0x80, 0x01, 0xEF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x30,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0x87, 0x00, 0x0E,
  0x1E, 0x00, 0x78, 0x38, 0x01, 0xC0, 0xF0, 0x0F, 0x01, 0xC0, 0x38, 0x07,
  0x81, 0xE0, 0x0E, 0x07, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0xE0, 0x01, 0xE7,
  0x80, 0x03, 0xBC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x00, 0xF0,
  0x03, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1C, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x0F,
  0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xF7, 0xE0, 0x3D, 0xE0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xF7,
  0xC1, 0xFD, 0xFF, 0xF7, 0x3F, 0xF9, 0xC7, 0xF8, 0x70, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x30,
  0x0F, 0x3F, 0xE0, 0xF7, 0xFF, 0x0F, 0xFF, 0xF8, 0xFE, 0x07, 0xCF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E,
  0xF8, 0x03, 0xEF, 0xC0, 0x3C, 0xFE, 0x0F, 0xCE, 0xFF, 0xF8, 0xE7, 0xFF,
  0x0E, 0x3F, 0xE0, 0x00, 0x30, 0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1,
  0xF0, 0x31, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x0E, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x38, 0x1E, 0x0F, 0xF8, 0xF0, 0xFF, 0xE7, 0x8F, 0xFF, 0xBC,
  0xFC, 0x0F, 0xE7, 0xC0, 0x3F, 0x7C, 0x01, 0xFB, 0xC0, 0x07, 0xDE, 0x00,
  0x3E, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1E, 0xF0, 0x01,
  0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x7D, 0xF0, 0x07, 0xE7, 0xC0, 0x3F, 0x3F,
  0x07, 0xF8, 0xFF, 0xFB, 0xC3, 0xFF, 0x9E, 0x0F, 0xF8, 0xF0, 0x00, 0x70,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1E, 0x07, 0xC3, 0xC0,
  0x3E, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x02, 0x1F, 0x80, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0x60, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x03,
  0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x3F, 0xE3, 0xC3, 0xFF, 0x9E, 0x3F, 0xFE, 0xF3, 0xF0, 0x7F,
  0x9F, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x00, 0x1F, 0x78, 0x00, 0xFB, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00,
  0x3E, 0xF0, 0x01, 0xF7, 0xC0, 0x1F, 0x9F, 0x00, 0xFC, 0xFC, 0x1F, 0xE3,
  0xFF, 0xEF, 0x0F, 0xFE, 0x78, 0x3F, 0xE3, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x20,
  0x03, 0xE1, 0xF0, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0xC0, 0x79, 0xFF, 0x0F, 0x7F, 0xF9, 0xFF, 0xFF, 0x3F, 0x81,
  0xF7, 0xE0, 0x1E, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xF0, 0x33, 0xFF, 0xF7, 0x98, 0x00, 0x00, 0x1E, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE8, 0xFB, 0xFE, 0xFF, 0x3F, 0x80, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x1F, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x03, 0xE3, 0xC1, 0xF0, 0xF0,
  0x78, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xCF, 0x80, 0xF7, 0xC0, 0x3D, 0xE0,
  0x0E, 0xFC, 0x03, 0xFF, 0x80, 0xFD, 0xE0, 0x3E, 0x7C, 0x0F, 0x0F, 0x03,
  0xC1, 0xE0, 0xF0, 0x7C, 0x3C, 0x0F, 0x0F, 0x03, 0xE3, 0xC0, 0x7C, 0xF0,
  0x0F, 0x3C, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x01, 0xC0, 0xE3, 0xFE, 0x0F, 0xF8, 0xE7, 0xFF,
  0x1F, 0xFC, 0xEF, 0xFF, 0xBF, 0xFE, 0xFC, 0x0F, 0xF8, 0x3E, 0xF8, 0x07,
  0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03,
  0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03,
  0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03,
  0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03,
  0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03,
  0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03,
  0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x1C, 0x7F, 0xC3, 0x9F, 0xFE, 0x77, 0xFF, 0xCF, 0xE0, 0x7D, 0xF0, 0x07,
  0xBE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3C,
  0x00, 0x30, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xF0,
  0x3E, 0x1F, 0x00, 0xF9, 0xF0, 0x03, 0xCF, 0x00, 0x1F, 0x78, 0x00, 0x7B,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x1E, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x1F, 0x00, 0xF8, 0x7C, 0x0F,
  0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x30, 0x0E,
  0x3F, 0xE0, 0xE7, 0xFF, 0x0E, 0xFF, 0xF8, 0xFE, 0x07, 0xCF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x80, 0x1E, 0xF8,
  0x03, 0xEF, 0xC0, 0x3C, 0xFE, 0x0F, 0xCE, 0xFF, 0xF8, 0xF7, 0xFF, 0x0F,
  0x1F, 0xE0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xE3, 0xC3,
  0xFF, 0x9E, 0x3F, 0xFE, 0xF3, 0xF0, 0x3F, 0x9F, 0x00, 0xFD, 0xF0, 0x07,
  0xEF, 0x00, 0x1F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0xC0,
  0x1F, 0x9F, 0x00, 0xFC, 0xFC, 0x1F, 0xE3, 0xFF, 0xEF, 0x0F, 0xFE, 0x78,
  0x3F, 0xE3, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x77, 0x0F, 0xF9,
  0xFF, 0xCF, 0xFE, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x1F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFE, 0xF8,
  0x06, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xE0,
  0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x3F,
  0x7C, 0x03, 0xF7, 0xE0, 0xFF, 0x3F, 0xFE, 0xF1, 0xFF, 0xCF, 0x0F, 0xF8,
  0xF0, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03,
  0xE0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x78, 0x03,
  0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF1, 0xE0, 0x03, 0x8F, 0x00, 0x1E, 0x78,
  0x00, 0xF7, 0x80, 0x03, 0xBC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xBC,
  0x01, 0xF8, 0x03, 0xDE, 0x00, 0xFC, 0x01, 0xEF, 0x00, 0x7E, 0x01, 0xE3,
  0xC0, 0x7F, 0x00, 0xF1, 0xE0, 0x3F, 0xC0, 0x78, 0xF0, 0x1D, 0xE0, 0x3C,
  0x78, 0x0E, 0x70, 0x3C, 0x1E, 0x0F, 0x3C, 0x1E, 0x0F, 0x07, 0x9E, 0x0F,
  0x07, 0x83, 0x8F, 0x07, 0x83, 0xC3, 0xC3, 0x87, 0x80, 0xF1, 0xE1, 0xE3,
  0xC0, 0x78, 0xF0, 0xF1, 0xE0, 0x3C, 0x70, 0x78, 0xF0, 0x1E, 0x78, 0x1C,
  0x70, 0x07, 0xBC, 0x0F, 0x78, 0x03, 0xDC, 0x07, 0xBC, 0x01, 0xEE, 0x03,
  0xDE, 0x00, 0xF7, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x77, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF7, 0xC0, 0x1E, 0x3C, 0x03, 0xC3, 0xE0,
  0x7C, 0x1E, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x8F, 0x00, 0x79, 0xE0, 0x03,
  0xDE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0x9E, 0x00, 0xF8, 0xF0,
  0x0F, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0xC3, 0xC0, 0x3C, 0x7C, 0x03,
  0xE7, 0x80, 0x1F, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x3E, 0xF8, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF8, 0x07,
  0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0x71, 0xE0,
  0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0x77, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x01, 0xF0, 0x1F,
  0xC0, 0xFF, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x01, 0xF0, 0x3F, 0x80, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xFF,
  0x00, 0xFC, 0x03, 0xF0, 0x3F, 0xC1, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x0F, 0xE0, 0x3F, 0x00, 0xF8,
  0x00, 0x0C, 0x00, 0x13, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF8, 0x01, 0xFE, 0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 35, 12, 3, -34 },
  { 28, 13, 13, 19, 3, -34 },
  { 50, 25, 34, 27, 1, -34 },
  { 157, 19, 39, 24, 3, -36 },
  { 250, 32, 34, 36, 2, -34 },
  { 386, 28, 34, 30, 2, -34 },
  { 505, 4, 13, 10, 3, -34 },
  { 512, 11, 41, 14, 2, -34 },
  { 569, 11, 41, 14, 1, -34 },
  { 626, 19, 19, 23, 2, -36 },
  { 672, 20, 23, 24, 2, -28 },
  { 730, 7, 11, 12, 2, -5 },
  { 740, 11, 3, 14, 2, -14 },
  { 745, 6, 7, 12, 3, -6 },
  { 751, 16, 34, 17, 1, -34 },
  { 819, 20, 34, 24, 2, -34 },
  { 904, 12, 34, 24, 4, -34 },
  { 955, 20, 34, 24, 2, -34 },
  { 1040, 20, 34, 24, 2, -34 },
  { 1125, 23, 34, 24, 1, -34 },
  { 1223, 19, 34, 24, 3, -34 },
  { 1304, 20, 34, 24, 2, -34 },
  { 1389, 20, 34, 24, 2, -34 },
  { 1474, 20, 34, 24, 2, -34 },
  { 1559, 20, 34, 24, 2, -34 },
  { 1644, 6, 27, 12, 3, -26 },
  { 1665, 7, 32, 12, 2, -26 },
  { 1693, 20, 22, 24, 2, -28 },
  { 1748, 20, 13, 24, 2, -23 },
  { 1781, 20, 22, 24, 2, -28 },
  { 1836, 16, 35, 18, 1, -34 },
  { 1906, 32, 38, 38, 3, -34 },
  { 2058, 27, 34, 27, 0, -34 },
  { 2173, 21, 34, 28, 4, -34 },
  { 2263, 22, 34, 27, 3, -34 },
  { 2357, 24, 34, 31, 4, -34 },
  { 2459, 17, 34, 24, 4, -34 },
  { 2532, 17, 34, 22, 4, -34 },
  { 2605, 25, 34, 31, 3, -34 },
  { 2712, 23, 34, 31, 4, -34 },
  { 2810, 11, 34, 15, 2, -34 },
  { 2857, 11, 43, 12, -3, -34 },
  { 2917, 22, 34, 26, 4, -34 },
  { 3011, 17, 34, 22, 4, -34 },
  { 3084, 31, 34, 39, 4, -34 },
  { 3216, 24, 34, 32, 4, -34 },
  { 3318, 27, 34, 33, 3, -34 },
  { 3433, 20, 34, 26, 4, -34 },
  { 3518, 27, 42, 33, 3, -34 },
  { 3660, 22, 34, 26, 4, -34 },
  { 3754, 19, 34, 23, 2, -34 },
  { 3835, 23, 34, 23, 0, -34 },
  { 3933, 23, 34, 31, 4, -34 },
  { 4031, 25, 34, 25, 0, -34 },
  { 4138, 40, 34, 40, 0, -34 },
  { 4308, 24, 34, 24, 0, -34 },
  { 4410, 24, 34, 24, 0, -34 },
  { 4512, 20, 34, 23, 2, -34 },
  { 4597, 10, 41, 15, 4, -34 },
  { 4649, 16, 34, 17, 1, -34 },
  { 4717, 11, 41, 15, 1, -34 },
  { 4774, 22, 20, 25, 1, -34 },
  { 4829, 21, 3, 21, 0, 4 },
  { 4837, 9, 8, 13, 2, -36 },
  { 4846, 18, 26, 24, 2, -26 },
  { 4905, 20, 36, 26, 4, -36 },
  { 4995, 17, 26, 20, 2, -26 },
  { 5051, 21, 36, 26, 2, -36 },
  { 5146, 20, 26, 24, 2, -26 },
  { 5211, 15, 36, 15, 1, -36 },
  { 5279, 21, 37, 26, 2, -26 },
  { 5377, 19, 36, 26, 4, -36 },
  { 5463, 5, 35, 11, 3, -35 },
  { 5485, 10, 46, 11, -2, -35 },
  { 5543, 18, 36, 23, 4, -36 },
  { 5624, 4, 36, 11, 4, -36 },
  { 5642, 32, 26, 40, 4, -26 },
  { 5746, 19, 26, 26, 4, -26 },
  { 5808, 21, 26, 26, 2, -26 },
  { 5877, 20, 37, 26, 4, -26 },
  { 5970, 21, 37, 26, 2, -26 },
  { 6068, 13, 26, 18, 4, -26 },
  { 6111, 16, 26, 20, 2, -26 },
  { 6163, 13, 31, 15, 1, -31 },
  { 6214, 20, 25, 26, 3, -25 },
  { 6277, 21, 25, 21, 0, -25 },
  { 6343, 33, 25, 34, 0, -25 },
  { 6447, 20, 25, 22, 1, -25 },
  { 6510, 21, 36, 22, 0, -25 },
  { 6605, 16, 25, 19, 2, -25 },
  { 6655, 14, 41, 18, 2, -34 },
  { 6727, 3, 47, 23, 10, -36 },
  { 6745, 14, 41, 18, 2, -34 },
  { 6817, 20, 7, 24, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_Regular47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR47PT7B_H_
