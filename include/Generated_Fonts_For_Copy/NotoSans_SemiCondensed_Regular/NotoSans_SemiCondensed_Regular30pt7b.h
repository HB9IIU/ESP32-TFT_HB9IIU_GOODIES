#ifndef _NOTOSANS_SEMICONDENSED_REGULAR30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular30pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x04, 0xEF, 0xE0,
  0xE7, 0xE7, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0x07, 0x18, 0x06, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x18, 0x0E, 0x30, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x18, 0x60, 0xFF, 0xFE, 0xFF,
  0xFE, 0x18, 0x60, 0x18, 0xE0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30,
  0xC0, 0x06, 0x00, 0x60, 0x06, 0x03, 0xFF, 0x7F, 0xEE, 0x66, 0xC6, 0x0C,
  0x60, 0xC6, 0x0E, 0x60, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x06, 0x70,
  0x67, 0x06, 0x30, 0x67, 0x86, 0x7F, 0xFE, 0xFF, 0xC0, 0xE0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x08, 0x00, 0x81, 0xF0, 0x18, 0x19, 0xC0, 0xC0, 0xC6,
  0x0C, 0x06, 0x30, 0x60, 0x71, 0x86, 0x03, 0x8E, 0x30, 0x1C, 0x73, 0x00,
  0xE3, 0x18, 0x03, 0x19, 0xDF, 0x18, 0xCC, 0xFC, 0xEE, 0xEC, 0x63, 0xE6,
  0x63, 0x04, 0x73, 0x1C, 0x03, 0x18, 0x60, 0x38, 0xC3, 0x01, 0x86, 0x18,
  0x1C, 0x31, 0xC0, 0xC1, 0x8C, 0x0E, 0x0C, 0x60, 0x60, 0x3F, 0x07, 0x01,
  0xF0, 0x07, 0x80, 0x07, 0xF0, 0x01, 0xCE, 0x00, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x1C, 0x03, 0x86, 0x00, 0x63, 0x80, 0x1D, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7E, 0x0E, 0x3B, 0xC3, 0x9C, 0x78, 0xC6, 0x0E, 0x33, 0x81,
  0xDC, 0xE0, 0x3E, 0x38, 0x07, 0x87, 0x03, 0xE1, 0xE1, 0xFC, 0x3F, 0xF7,
  0x87, 0xF0, 0xF0, 0xFF, 0xED, 0xB0, 0x0E, 0x38, 0x61, 0xC3, 0x0E, 0x1C,
  0x30, 0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xC1, 0xC3, 0x83,
  0x07, 0x0E, 0x0E, 0x0C, 0x1C, 0xE0, 0xE0, 0xC1, 0xC1, 0x83, 0x07, 0x0E,
  0x0C, 0x18, 0x30, 0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0x87,
  0x0C, 0x38, 0x61, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x06, 0x63,
  0x7F, 0xFB, 0xFF, 0xE1, 0xE0, 0x0D, 0x80, 0xEE, 0x0E, 0x38, 0x31, 0x80,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x83, 0xFF, 0xFF,
  0xFF, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x7B, 0x9C, 0xC6, 0x33, 0x00, 0xFF, 0xFC, 0x4E, 0xFE, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x30, 0x0E, 0x00, 0x07, 0x80, 0xFE, 0x0F, 0xF8, 0x70, 0xE7, 0x03, 0x38,
  0x1D, 0x80, 0xEC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x1D, 0x80, 0xEC, 0x07, 0x60, 0x3B, 0x81, 0x9C, 0x1C, 0x70, 0xE1,
  0xFE, 0x07, 0xE0, 0x07, 0x0F, 0x3F, 0x77, 0xE7, 0x47, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0F, 0x01, 0xFE, 0x3F, 0xF8, 0xC0, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0x01, 0xFF, 0x3F, 0xFC, 0xC0, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x0F, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x81, 0xEF, 0xFE, 0x3F, 0xE0,
  0x00, 0x60, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0x60, 0x1D, 0x80, 0x66,
  0x03, 0x98, 0x0C, 0x60, 0x61, 0x83, 0x86, 0x0C, 0x18, 0x70, 0x61, 0x81,
  0x8C, 0x06, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x7F, 0xE7, 0xFE, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xFF, 0x8F, 0xFC, 0x41, 0xE0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x81, 0xEF, 0xFC, 0xFF, 0x80, 0x03,
  0xE0, 0xFE, 0x3F, 0x63, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0xFC, 0xDF, 0xEF, 0x0F, 0xE0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x3E, 0x07, 0x60, 0x77, 0x0E, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xFF, 0x0F, 0x7C,
  0xE0, 0xE7, 0x03, 0xB0, 0x1D, 0xC0, 0xEE, 0x06, 0x38, 0x70, 0xFF, 0x03,
  0xE0, 0x3F, 0x83, 0x8E, 0x38, 0x39, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0xD8, 0x0E, 0xE0, 0xF3, 0xFF, 0x0F, 0xE0, 0x07, 0x00, 0xFE, 0x0F, 0xF8,
  0xE0, 0xE6, 0x03, 0x30, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x01, 0xDC,
  0x0E, 0xF1, 0xF3, 0xFF, 0x8F, 0x9C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x38, 0x03, 0xC3, 0xFC, 0x1F, 0x80, 0xEF, 0xE4, 0x00, 0x00, 0x00,
  0x00, 0x4E, 0xFE, 0x73, 0xDC, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39,
  0xCE, 0x63, 0x31, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x00, 0xF8, 0x1F, 0x03, 0xC0,
  0xF8, 0x0F, 0x00, 0x60, 0x00, 0x1E, 0x1F, 0xF1, 0xFF, 0x20, 0x70, 0x0E,
  0x00, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x0E, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xF3, 0xE0, 0x3C, 0x03, 0x83, 0x80,
  0x0E, 0x18, 0x00, 0x31, 0x80, 0xC0, 0xCC, 0x3F, 0xC6, 0xE3, 0x8E, 0x36,
  0x18, 0x71, 0xF1, 0xC3, 0x87, 0x8C, 0x1C, 0x3C, 0x60, 0xE3, 0xE3, 0x06,
  0x1B, 0x18, 0x30, 0xD8, 0xE1, 0x86, 0xC3, 0x9E, 0x66, 0x1F, 0x9F, 0x38,
  0x38, 0x60, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x80, 0x7C, 0x38,
  0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x37, 0x00, 0x3B, 0x80, 0x18, 0xC0, 0x0C, 0x70, 0x0E,
  0x38, 0x06, 0x0C, 0x03, 0x07, 0x03, 0x83, 0x81, 0xFF, 0xC0, 0xFF, 0xF0,
  0xE0, 0x38, 0x70, 0x0C, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x00, 0xDC, 0x00,
  0x7E, 0x00, 0x38, 0xFF, 0xC7, 0xFF, 0x30, 0x1D, 0x80, 0xEC, 0x03, 0xE0,
  0x1F, 0x00, 0xD8, 0x0E, 0xC0, 0xE7, 0xFC, 0x3F, 0xF9, 0x80, 0xEC, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x3D, 0xFF, 0xCF,
  0xFC, 0x00, 0x01, 0xE0, 0x3F, 0xF1, 0xFF, 0xCF, 0x02, 0x78, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x02, 0x1F, 0xF8, 0x1F, 0xE0, 0xFF, 0xC1, 0xFF, 0xE3, 0x03, 0xE6, 0x01,
  0xCC, 0x01, 0xD8, 0x03, 0xB0, 0x03, 0x60, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x60, 0x0E, 0xC0,
  0x39, 0x80, 0xF3, 0x07, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0F, 0xFF, 0xFF, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0x1F, 0xFE, 0x3C, 0x02, 0x78,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60,
  0x07, 0x70, 0x07, 0x78, 0x07, 0x3E, 0x07, 0x1F, 0xFF, 0x07, 0xFE, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0C,
  0xFE, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE7, 0xFF, 0xE0, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x61, 0xC3, 0x87, 0xFD, 0xFB, 0xC0, 0xC0, 0x3B, 0x01, 0xCC, 0x0E,
  0x30, 0x70, 0xC1, 0xC3, 0x0E, 0x0C, 0x70, 0x33, 0x80, 0xCC, 0x03, 0x70,
  0x0F, 0xE0, 0x3D, 0xC0, 0xE7, 0x03, 0x0E, 0x0C, 0x1C, 0x30, 0x70, 0xC0,
  0xE3, 0x03, 0xCC, 0x07, 0x30, 0x0E, 0xC0, 0x3C, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xD8, 0x03, 0x7D,
  0xC0, 0x37, 0xDC, 0x07, 0x7C, 0xC0, 0x67, 0xCE, 0x06, 0x7C, 0xE0, 0xE7,
  0xC6, 0x0C, 0x7C, 0x70, 0xC7, 0xC7, 0x1C, 0x7C, 0x31, 0x87, 0xC3, 0xB8,
  0x7C, 0x3B, 0x87, 0xC1, 0xB0, 0x7C, 0x1F, 0x07, 0xC0, 0xE0, 0x7C, 0x0E,
  0x07, 0xC0, 0xE0, 0x70, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3D,
  0xC0, 0x7B, 0x80, 0xF3, 0x81, 0xE7, 0x03, 0xC7, 0x07, 0x8E, 0x0F, 0x0E,
  0x1E, 0x0C, 0x3C, 0x1C, 0x78, 0x1C, 0xF0, 0x39, 0xE0, 0x3B, 0xC0, 0x77,
  0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0xFC,
  0x0F, 0xFF, 0x07, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x3B, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0x38, 0x03, 0x9E, 0x03,
  0xC7, 0x83, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0x8F, 0xFE, 0xC0, 0xEC,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0E, 0xFF, 0xCF,
  0xF8, 0xFE, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0x07, 0x01, 0xC7,
  0x00, 0x73, 0x80, 0x3B, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0x38, 0x03, 0x9E, 0x03, 0xC7, 0x83, 0xC1, 0xFF, 0xC0,
  0x7F, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0xFF, 0x87, 0xFF, 0x30, 0x39, 0x80, 0xEC, 0x07, 0x60, 0x3B, 0x01,
  0xD8, 0x0E, 0xC0, 0x76, 0x0F, 0x3F, 0xF1, 0xFE, 0x0C, 0x38, 0x61, 0xC3,
  0x07, 0x18, 0x18, 0xC0, 0xE6, 0x03, 0xB0, 0x1D, 0x80, 0x7C, 0x03, 0x80,
  0x07, 0x80, 0xFF, 0x8F, 0xFC, 0xE0, 0x27, 0x00, 0x30, 0x01, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1D, 0xC1, 0xEF, 0xFE, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xB0, 0x07, 0x70, 0x0E, 0xE0, 0x38, 0xF0,
  0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x06, 0x70,
  0x0E, 0x30, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x18, 0x18, 0x1C,
  0x38, 0x1C, 0x38, 0x0C, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x06, 0x70, 0x07,
  0x60, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0xE0,
  0x1C, 0x03, 0xB0, 0x0F, 0x01, 0xDC, 0x07, 0x80, 0xEE, 0x07, 0xC0, 0x67,
  0x03, 0x60, 0x71, 0x81, 0xB8, 0x38, 0xE0, 0xDC, 0x1C, 0x70, 0xE6, 0x0C,
  0x38, 0x73, 0x0E, 0x0C, 0x31, 0xC7, 0x07, 0x18, 0x63, 0x83, 0x9C, 0x31,
  0x81, 0xCC, 0x18, 0xC0, 0x66, 0x0E, 0xE0, 0x33, 0x03, 0x70, 0x1F, 0x81,
  0xB0, 0x0F, 0x80, 0xD8, 0x03, 0xC0, 0x6C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x70, 0x38, 0xE0, 0x60, 0xE1,
  0xC1, 0xC3, 0x01, 0xCE, 0x03, 0x98, 0x03, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x6E, 0x01, 0xCC, 0x03, 0x1C, 0x0E, 0x18, 0x18,
  0x38, 0x70, 0x30, 0xC0, 0x73, 0x80, 0x7E, 0x00, 0xE0, 0xE0, 0x0E, 0xE0,
  0x39, 0xC0, 0x71, 0xC1, 0xC3, 0x83, 0x83, 0x86, 0x07, 0x1C, 0x06, 0x30,
  0x0E, 0xE0, 0x0D, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xFC, 0xE0,
  0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x07, 0x00, 0x60, 0x0E, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xF0,
  0x02, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xE0, 0x0D, 0x80, 0x33, 0x01, 0x8C,
  0x06, 0x18, 0x30, 0x60, 0xC0, 0xC6, 0x03, 0x18, 0x06, 0xE0, 0x1C, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF1, 0xC3, 0x86, 0x0C, 0x1F, 0xC3, 0xFE, 0x20, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x03, 0xF3, 0xFF, 0x78, 0x77, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x77, 0x0F, 0x7F, 0xB3, 0xF3, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1D, 0xF8, 0xFF, 0xE7, 0x83, 0xBC,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0xE0, 0x7F, 0x87, 0x7F, 0xF3, 0x3F, 0x00, 0x1F, 0xCF, 0xF7,
  0x07, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80,
  0xE0, 0x1C, 0x17, 0xFC, 0x7F, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x63, 0xF3, 0x3F, 0xF9, 0xC3, 0xDC, 0x0E, 0xE0,
  0x76, 0x01, 0xB0, 0x0F, 0x80, 0x7C, 0x03, 0x60, 0x1B, 0x00, 0xDC, 0x06,
  0xE0, 0x73, 0x87, 0x9F, 0xEC, 0x7E, 0x60, 0x1F, 0x87, 0xFC, 0x70, 0xEE,
  0x06, 0xE0, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x02, 0x3F, 0xE1, 0xFE, 0x07, 0xC3, 0xF1, 0xE4, 0x70,
  0x1C, 0x06, 0x01, 0x81, 0xFE, 0xFF, 0x86, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x1F, 0x99, 0xFE, 0xCE, 0x1E, 0xE0, 0x77, 0x03, 0xB0, 0x0D, 0x80, 0x7C,
  0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xE0, 0x37, 0x03, 0x9C, 0x3C, 0xFF,
  0x63, 0xF3, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x72, 0x07, 0x1F, 0xF8,
  0xFF, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1D, 0xFC, 0xFF, 0xF7, 0xC3, 0xBC, 0x0D, 0xC0, 0x6E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xE0, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1C, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFE, 0xF0, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0xE0,
  0xEE, 0x1C, 0xE3, 0x8E, 0x70, 0xEE, 0x0E, 0xC0, 0xFE, 0x0F, 0x70, 0xE7,
  0x0E, 0x38, 0xE1, 0x8E, 0x1C, 0xE0, 0xEE, 0x0E, 0xE0, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xCF, 0xC7, 0xE7, 0xFF, 0x7F,
  0xBC, 0x3E, 0x0F, 0xE0, 0xF0, 0x7E, 0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81,
  0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F,
  0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E,
  0x07, 0xCF, 0xE7, 0xFF, 0xBE, 0x1D, 0xE0, 0x6E, 0x03, 0x70, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0x0F, 0xE0, 0xFF, 0xC3, 0x87, 0x9C, 0x0E, 0x70, 0x19,
  0x80, 0x76, 0x01, 0xF8, 0x07, 0x60, 0x1D, 0x80, 0x76, 0x01, 0xDC, 0x06,
  0x70, 0x38, 0xE1, 0xE1, 0xFF, 0x03, 0xF0, 0xEF, 0xC7, 0xFF, 0xBC, 0x1D,
  0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x3B, 0xFF, 0x9D, 0xF8, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1F, 0x99, 0xFE,
  0xCE, 0x1E, 0xE0, 0x77, 0x03, 0xB0, 0x0D, 0x80, 0x7C, 0x03, 0xE0, 0x1B,
  0x00, 0xD8, 0x06, 0xE0, 0x37, 0x03, 0x9C, 0x3C, 0xFF, 0x63, 0xF3, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0xC7,
  0xF7, 0xFE, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0x3F, 0xCF, 0xF9, 0x81, 0x70, 0x0E, 0x00,
  0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x78, 0x03, 0x00, 0x70, 0x0F, 0x83,
  0xBF, 0xF3, 0xF8, 0x18, 0x0C, 0x06, 0x03, 0x07, 0xFF, 0xFC, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x07,
  0xE1, 0xF0, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x77, 0x0F, 0x7F,
  0xB3, 0xF3, 0xE0, 0x1D, 0x80, 0xE7, 0x03, 0x9C, 0x0E, 0x30, 0x30, 0xC1,
  0xC3, 0x87, 0x06, 0x18, 0x18, 0xE0, 0x73, 0x80, 0xCC, 0x03, 0x70, 0x0F,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xE0, 0x70, 0x1B, 0x03, 0xC1, 0xDC,
  0x1E, 0x0E, 0xE1, 0xF0, 0x67, 0x0D, 0x83, 0x18, 0x6E, 0x38, 0xC3, 0x31,
  0xC7, 0x39, 0x8C, 0x39, 0x8E, 0x60, 0xCC, 0x77, 0x06, 0x61, 0xB8, 0x3F,
  0x0D, 0x81, 0xF0, 0x6C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70,
  0xE0, 0x73, 0x83, 0x1C, 0x38, 0x73, 0x81, 0x9C, 0x0F, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xFC, 0x07, 0x60, 0x73, 0x83, 0x0E, 0x38, 0x73, 0x81,
  0xDC, 0x07, 0xE0, 0x1D, 0x80, 0x67, 0x03, 0x9C, 0x0E, 0x30, 0x30, 0xE1,
  0xC3, 0x87, 0x06, 0x18, 0x1C, 0xE0, 0x73, 0x80, 0xCC, 0x03, 0xF0, 0x0F,
  0xC0, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E,
  0x03, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38,
  0x0F, 0xFF, 0xFF, 0x07, 0x87, 0xC3, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x0F, 0x0E, 0x07, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x30, 0x1E, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x7C, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xE0, 0x38,
  0x7C, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0xF0,
  0xF0, 0x60, 0x00, 0x10, 0x0B, 0xF0, 0x7F, 0xFF, 0x07, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Regular30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 8, 7, 12, 2, -21 },
  { 19, 16, 21, 17, 1, -21 },
  { 61, 12, 25, 16, 2, -23 },
  { 99, 21, 22, 23, 1, -22 },
  { 157, 18, 22, 19, 1, -22 },
  { 207, 3, 7, 7, 2, -21 },
  { 210, 7, 26, 9, 1, -21 },
  { 233, 7, 26, 9, 1, -21 },
  { 256, 13, 12, 15, 1, -23 },
  { 276, 13, 15, 16, 1, -18 },
  { 301, 5, 7, 8, 1, -3 },
  { 306, 7, 2, 9, 1, -9 },
  { 308, 4, 4, 8, 2, -4 },
  { 310, 11, 21, 11, 0, -21 },
  { 339, 13, 22, 16, 1, -22 },
  { 375, 8, 21, 16, 2, -21 },
  { 396, 13, 22, 16, 1, -22 },
  { 432, 13, 22, 16, 1, -22 },
  { 468, 14, 22, 16, 1, -22 },
  { 507, 12, 21, 16, 2, -21 },
  { 539, 12, 22, 16, 2, -22 },
  { 572, 13, 21, 16, 1, -21 },
  { 607, 13, 22, 16, 1, -22 },
  { 643, 13, 22, 16, 1, -22 },
  { 679, 4, 16, 8, 2, -16 },
  { 687, 5, 20, 8, 1, -16 },
  { 700, 13, 14, 16, 1, -18 },
  { 723, 13, 9, 16, 1, -15 },
  { 738, 13, 14, 16, 1, -18 },
  { 761, 11, 22, 12, 0, -22 },
  { 792, 21, 25, 24, 2, -22 },
  { 858, 17, 21, 17, 0, -21 },
  { 903, 13, 21, 18, 3, -21 },
  { 938, 14, 22, 17, 2, -22 },
  { 977, 15, 21, 20, 3, -21 },
  { 1017, 10, 21, 15, 3, -21 },
  { 1044, 10, 21, 14, 3, -21 },
  { 1071, 16, 22, 20, 2, -22 },
  { 1115, 14, 21, 20, 3, -21 },
  { 1152, 7, 21, 10, 1, -21 },
  { 1171, 7, 27, 8, -2, -21 },
  { 1195, 14, 21, 17, 3, -21 },
  { 1232, 10, 21, 14, 3, -21 },
  { 1259, 20, 21, 25, 3, -21 },
  { 1312, 15, 21, 21, 3, -21 },
  { 1352, 17, 22, 21, 2, -22 },
  { 1399, 12, 21, 16, 3, -21 },
  { 1431, 17, 27, 21, 2, -22 },
  { 1489, 13, 21, 17, 3, -21 },
  { 1524, 13, 22, 15, 1, -22 },
  { 1560, 14, 21, 15, 0, -21 },
  { 1597, 15, 21, 20, 2, -21 },
  { 1637, 16, 21, 16, 0, -21 },
  { 1679, 25, 21, 26, 0, -21 },
  { 1745, 15, 21, 16, 0, -21 },
  { 1785, 15, 21, 15, 0, -21 },
  { 1825, 13, 21, 15, 1, -21 },
  { 1860, 7, 26, 10, 2, -21 },
  { 1883, 11, 21, 11, 0, -21 },
  { 1912, 6, 26, 10, 1, -21 },
  { 1932, 14, 13, 16, 1, -22 },
  { 1955, 13, 2, 13, 0, 3 },
  { 1959, 6, 5, 8, 1, -23 },
  { 1963, 12, 16, 15, 1, -16 },
  { 1987, 13, 23, 17, 2, -23 },
  { 2025, 10, 16, 13, 2, -16 },
  { 2045, 13, 23, 17, 1, -23 },
  { 2083, 12, 16, 15, 2, -16 },
  { 2107, 10, 23, 9, 0, -23 },
  { 2136, 13, 23, 17, 1, -16 },
  { 2174, 13, 23, 17, 2, -23 },
  { 2212, 3, 22, 7, 2, -22 },
  { 2221, 6, 29, 7, -1, -22 },
  { 2243, 12, 23, 15, 2, -23 },
  { 2278, 3, 23, 7, 2, -23 },
  { 2287, 21, 16, 25, 2, -16 },
  { 2329, 13, 16, 17, 2, -16 },
  { 2355, 14, 16, 16, 1, -16 },
  { 2383, 13, 23, 17, 2, -16 },
  { 2421, 13, 23, 17, 1, -16 },
  { 2459, 9, 16, 11, 2, -16 },
  { 2477, 11, 16, 13, 1, -16 },
  { 2499, 9, 20, 10, 0, -20 },
  { 2522, 12, 16, 17, 2, -16 },
  { 2546, 14, 16, 14, 0, -16 },
  { 2574, 21, 16, 22, 0, -16 },
  { 2616, 13, 16, 14, 1, -16 },
  { 2642, 14, 23, 14, 0, -16 },
  { 2683, 10, 16, 12, 1, -16 },
  { 2703, 9, 26, 11, 1, -21 },
  { 2733, 3, 30, 15, 6, -23 },
  { 2745, 9, 26, 11, 1, -21 },
  { 2775, 13, 4, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_Regular30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR30PT7B_H_
