#ifndef _NOTOSANS_SEMICONDENSED_REGULAR6PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x7F, 0xD0, 0x5F, 0x3C, 0xFF, 0x75, 0xE4, 0xBF, 0x80,
  0xEA, 0x40, 0x95, 0x80, 0x5E, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A,
  0xF6, 0xF0, 0xD5, 0xE5, 0x70, 0xE8, 0xF0, 0x4B, 0x90, 0xF8, 0xF0, 0xFA,
  0xF0, 0xE5, 0x20, 0xEA, 0xF0, 0xF5, 0xA0, 0xA0, 0xB0, 0x39, 0x80, 0xFC,
  0x8F, 0x00, 0xDA, 0x77, 0xF5, 0x46, 0x00, 0x4D, 0xD0, 0xFF, 0xF2, 0x30,
  0xD6, 0xE0, 0xFB, 0xFA, 0x7A, 0x97, 0xFF, 0xEB, 0xF8, 0xEB, 0xAB, 0xBB,
  0xDD, 0xB7, 0xD0, 0xF9, 0x96, 0xFA, 0xF9, 0x96, 0x30, 0xFB, 0xF8, 0xF0,
  0xE9, 0x20, 0xB6, 0xB0, 0xB5, 0x20, 0xAD, 0x74, 0xA0, 0xA9, 0x50, 0xA9,
  0x20, 0xE9, 0x70, 0xEA, 0xC0, 0xA5, 0xF8, 0x54, 0xE0, 0x80, 0x7F, 0x80,
  0x9A, 0xDE, 0xEC, 0x2E, 0xDE, 0xFB, 0x80, 0x7A, 0x80, 0xF6, 0xB0, 0x9A,
  0xDA, 0xF0, 0xF8, 0x97, 0x6A, 0xF8, 0xFD, 0x6A, 0xF6, 0x80, 0xF7, 0x80,
  0xF7, 0xC0, 0xF7, 0x90, 0xE8, 0xDC, 0xEB, 0xB7, 0x80, 0xB9, 0x00, 0xBF,
  0x50, 0xEA, 0x80, 0xB9, 0x60, 0xDC, 0x59, 0x40, 0xFC, 0xD5, 0x80, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Regular6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 2, 1, 2, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 5, 0, -4 },
  { 9, 4, 4, 4, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 2, 5, 2, 0, -4 },
  { 16, 3, 3, 3, 0, -5 },
  { 18, 3, 3, 3, 0, -4 },
  { 20, 1, 2, 2, 0, -1 },
  { 21, 2, 1, 2, 0, -2 },
  { 22, 1, 1, 2, 0, -1 },
  { 23, 2, 4, 2, 0, -4 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 2, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 1, 3, 2, 0, -3 },
  { 44, 1, 4, 2, 0, -3 },
  { 45, 3, 3, 3, 0, -4 },
  { 47, 3, 2, 3, 0, -3 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 2, 4, 2, 0, -4 },
  { 51, 5, 5, 5, 0, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 2, 4, 4, 1, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 4, 1, -4 },
  { 62, 2, 4, 3, 1, -4 },
  { 63, 2, 4, 3, 1, -4 },
  { 64, 4, 4, 4, 0, -4 },
  { 66, 2, 4, 4, 1, -4 },
  { 67, 2, 4, 2, 0, -4 },
  { 68, 1, 5, 2, 0, -4 },
  { 69, 2, 4, 3, 1, -4 },
  { 70, 2, 4, 3, 1, -4 },
  { 71, 4, 4, 5, 1, -4 },
  { 73, 3, 4, 4, 1, -4 },
  { 75, 4, 4, 4, 0, -4 },
  { 77, 2, 4, 3, 1, -4 },
  { 78, 4, 5, 4, 0, -4 },
  { 81, 2, 4, 3, 1, -4 },
  { 82, 3, 4, 3, 0, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 3, 4, 4, 0, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 5, 4, 5, 0, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 2, 5, 2, 0, -4 },
  { 101, 2, 4, 2, 0, -4 },
  { 102, 1, 5, 2, 0, -4 },
  { 103, 3, 2, 3, 0, -4 },
  { 104, 3, 1, 3, 0, 0 },
  { 105, 1, 1, 2, 0, -5 },
  { 106, 3, 3, 3, 0, -3 },
  { 108, 3, 5, 3, 0, -5 },
  { 110, 2, 3, 3, 0, -3 },
  { 111, 3, 5, 3, 0, -5 },
  { 113, 3, 3, 3, 0, -3 },
  { 115, 2, 5, 2, 0, -5 },
  { 117, 3, 4, 3, 0, -3 },
  { 119, 3, 5, 3, 0, -5 },
  { 121, 1, 4, 1, 0, -4 },
  { 122, 1, 5, 1, 0, -4 },
  { 123, 3, 5, 3, 0, -5 },
  { 125, 1, 5, 1, 0, -5 },
  { 126, 5, 3, 5, 0, -3 },
  { 128, 3, 3, 3, 0, -3 },
  { 130, 3, 3, 3, 0, -3 },
  { 132, 3, 4, 3, 0, -3 },
  { 134, 3, 4, 3, 0, -3 },
  { 136, 2, 3, 2, 0, -3 },
  { 137, 2, 3, 3, 0, -3 },
  { 138, 2, 4, 2, 0, -4 },
  { 139, 3, 3, 3, 0, -3 },
  { 141, 3, 3, 3, 0, -3 },
  { 143, 4, 3, 4, 0, -3 },
  { 145, 3, 3, 3, 0, -3 },
  { 147, 3, 4, 3, 0, -3 },
  { 149, 2, 3, 2, 0, -3 },
  { 150, 2, 5, 2, 0, -4 },
  { 152, 1, 6, 3, 1, -5 },
  { 153, 2, 5, 2, 0, -4 },
  { 155, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Regular6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular6pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR6PT7B_H_
