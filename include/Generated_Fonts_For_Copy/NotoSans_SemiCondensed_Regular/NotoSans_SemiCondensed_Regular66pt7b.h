#ifndef _NOTOSANS_SEMICONDENSED_REGULAR66PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x03, 0xF7, 0xC0, 0xFD, 0xF0,
  0x3F, 0x7C, 0x07, 0xDF, 0x01, 0xE7, 0xC0, 0x79, 0xF0, 0x1E, 0x78, 0x07,
  0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFB,
  0xFE, 0x3F, 0x8F, 0x03, 0x8F, 0xC1, 0xE0, 0x11, 0xF8, 0x3C, 0x00, 0x3E,
  0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x03, 0xC0,
  0x03, 0xE0, 0x78, 0x00, 0x7E, 0x0F, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0xFE,
  0x3C, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0x8F, 0xF0, 0x00, 0xF0, 0x7E,
  0x00, 0x1E, 0x07, 0xE0, 0x03, 0xC0, 0xFC, 0x00, 0x78, 0x0F, 0x80, 0x0F,
  0x01, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x0F, 0xC0, 0x07, 0x81, 0xFC,
  0x00, 0xF0, 0x7E, 0xE0, 0x1E, 0x1F, 0xDF, 0xE3, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0x80, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x00,
  0x78, 0x07, 0x80, 0x0F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x3E,
  0x01, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x7C,
  0x00, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0xF8, 0x0F, 0x80, 0x7C, 0x3E, 0x1F,
  0xF0, 0x3C, 0x03, 0xC3, 0xE1, 0xFF, 0xC1, 0xF0, 0x3E, 0x1F, 0x1F, 0xFF,
  0x0F, 0x81, 0xF1, 0xF0, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xE1,
  0xF9, 0xF8, 0xF8, 0x7C, 0x0F, 0x87, 0xFF, 0x87, 0xC3, 0xC0, 0x7C, 0x3F,
  0xFC, 0x7C, 0x3E, 0x03, 0xE0, 0x7F, 0x83, 0xE1, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x00, 0x0F,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x3C,
  0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x1E,
  0x00, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x78, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xF0, 0x7F, 0x9F,
  0xC0, 0x07, 0xC0, 0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x1F, 0xC0, 0x3F,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7C, 0x1F, 0x80, 0x3F, 0xC1, 0xF8, 0x7F, 0x00,
  0x3F, 0x83, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xC1, 0xF8, 0x00, 0x3F, 0x9F,
  0x83, 0xF0, 0x00, 0x3F, 0xFF, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0x9F, 0xFE,
  0x7F, 0x01, 0xFF, 0xFF, 0xF8, 0x7F, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79,
  0xE7, 0x9E, 0x78, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7E, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0xDF, 0x83, 0xC1, 0xFB, 0xFF,
  0x79, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0x80,
  0x7C, 0x00, 0x70, 0x06, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x8F,
  0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0x87,
  0xC7, 0xC3, 0xE1, 0xE0, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E,
  0x1C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xBE,
  0x3F, 0x9F, 0x3F, 0x9F, 0xBF, 0x8F, 0xFF, 0x87, 0xEF, 0x83, 0xF3, 0x81,
  0xF8, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x7E, 0x00,
  0x3F, 0x83, 0xC0, 0x01, 0xFC, 0x10, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7C, 0x00,
  0x3F, 0x83, 0x80, 0x01, 0xFC, 0x20, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE8, 0x00, 0x01, 0xFC, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x0F,
  0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F,
  0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF3, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x80, 0x00, 0x3F, 0x9C, 0x00, 0x1F, 0xE3, 0xF8,
  0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xF0, 0x08, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03,
  0x80, 0x07, 0xC1, 0xFF, 0x80, 0x7C, 0x7F, 0xFE, 0x07, 0xCF, 0xFF, 0xF0,
  0x7D, 0xFF, 0xFF, 0x8F, 0xFF, 0x03, 0xFC, 0xFF, 0xC0, 0x0F, 0xCF, 0xF8,
  0x00, 0x7E, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x1F, 0x7E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFF, 0x87, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F,
  0xC0, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xF1, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0x80,
  0x3F, 0xC3, 0xF0, 0x01, 0xFE, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x7F,
  0x00, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x3F,
  0x83, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7C,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xF7, 0xF0, 0x01, 0xFF,
  0x3F, 0x80, 0x3F, 0xF3, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0xFB, 0xF0, 0xFF,
  0xFF, 0x3F, 0x07, 0xFF, 0xE3, 0xF0, 0x1F, 0xF8, 0x3E, 0x00, 0x08, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x01, 0x80, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xD0, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x7F, 0x7E,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7F, 0x7F, 0x7F,
  0xFF, 0x7F, 0x7F, 0x7E, 0x1C, 0x0F, 0x07, 0xF1, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF1, 0xFC, 0x7E, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE3,
  0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xE0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF,
  0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xE0, 0xFF,
  0x9E, 0x00, 0x7F, 0x10, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x7F, 0xF8, 0x07,
  0xC3, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0x8F, 0x80, 0x3F, 0xFF, 0xE0, 0x3E,
  0x7C, 0x01, 0xFF, 0xFF, 0x80, 0xF9, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xE7,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0x9E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0xF8,
  0x07, 0xC0, 0x0F, 0x80, 0x7F, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xFF, 0x80,
  0xF8, 0x00, 0xF0, 0x07, 0xFC, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0xF0, 0x0F,
  0x80, 0x1F, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0x7B, 0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xEF, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0xBC, 0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0xF0, 0x0F, 0x80, 0x3F,
  0x00, 0xF3, 0xE0, 0x1F, 0x01, 0xFE, 0x07, 0xCF, 0x80, 0x7E, 0x07, 0xF8,
  0x3E, 0x3E, 0x01, 0xFE, 0x7C, 0xFB, 0xF8, 0xF8, 0x03, 0xFF, 0xE3, 0xFF,
  0xC1, 0xF0, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1F, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x04, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00,
  0x7E, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xF0, 0x00, 0xFF, 0x8F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0xFF, 0x8F, 0xC0, 0x00, 0xFF, 0x3F, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x0F, 0xF3, 0xF0, 0x00, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC,
  0x7F, 0x81, 0xFF, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x04, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x70, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x03, 0xFF,
  0x83, 0xF0, 0x00, 0x3F, 0xC1, 0xF8, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x03,
  0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x1F,
  0xF0, 0x7E, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC1, 0xFF,
  0x80, 0xFF, 0x80, 0x01, 0xE0, 0x3F, 0xC0, 0x00, 0x0C, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x01,
  0xF8, 0xFF, 0x00, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0xFF, 0x00,
  0x00, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0x81, 0xFF, 0xF9, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xE0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x3F, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF,
  0x00, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80,
  0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x7E, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x1F, 0xBF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x3F, 0xBF, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFB, 0xE0, 0x00, 0x00, 0xFB, 0xFF,
  0xBF, 0x00, 0x00, 0x0F, 0xBF, 0xFB, 0xF0, 0x00, 0x01, 0xFB, 0xFF, 0x9F,
  0x00, 0x00, 0x1F, 0x3F, 0xF9, 0xF8, 0x00, 0x01, 0xF3, 0xFF, 0x9F, 0x80,
  0x00, 0x3F, 0x3F, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xFF, 0x8F, 0xC0, 0x00,
  0x3E, 0x3F, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xFF, 0x87, 0xC0, 0x00, 0x7C,
  0x3F, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xFF, 0x83, 0xE0, 0x00, 0xF8, 0x3F,
  0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xFF, 0x83, 0xF0, 0x00, 0xF8, 0x3F, 0xF8,
  0x1F, 0x00, 0x1F, 0x03, 0xFF, 0x81, 0xF0, 0x01, 0xF0, 0x3F, 0xF8, 0x1F,
  0x80, 0x1F, 0x03, 0xFF, 0x80, 0xF8, 0x03, 0xE0, 0x3F, 0xF8, 0x0F, 0x80,
  0x3E, 0x03, 0xFF, 0x80, 0xFC, 0x03, 0xE0, 0x3F, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xFF, 0x80, 0x7C, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xFF, 0x80, 0x3E, 0x0F, 0x80, 0x3F, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0x1F, 0x00, 0x3F, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0xFC, 0x00, 0x03, 0xFF,
  0xBF, 0x80, 0x00, 0xFF, 0xE7, 0xE0, 0x00, 0x3F, 0xF9, 0xFC, 0x00, 0x0F,
  0xFE, 0x3F, 0x00, 0x03, 0xFF, 0x87, 0xE0, 0x00, 0xFF, 0xE1, 0xF8, 0x00,
  0x3F, 0xF8, 0x3F, 0x00, 0x0F, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0x81, 0xF8,
  0x00, 0xFF, 0xE0, 0x7F, 0x00, 0x3F, 0xF8, 0x0F, 0xC0, 0x0F, 0xFE, 0x01,
  0xF8, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0xF8,
  0x03, 0xF8, 0x0F, 0xFE, 0x00, 0x7E, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xFF,
  0xE0, 0x03, 0xF0, 0x3F, 0xF8, 0x00, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0x83,
  0xFF, 0x80, 0x03, 0xF0, 0xFF, 0xE0, 0x00, 0xFE, 0x3F, 0xF8, 0x00, 0x1F,
  0x8F, 0xFE, 0x00, 0x07, 0xF3, 0xFF, 0x80, 0x00, 0xFC, 0x7F, 0xE0, 0x00,
  0x3F, 0x9F, 0xF8, 0x00, 0x07, 0xE7, 0xFE, 0x00, 0x00, 0xFD, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x9F,
  0xC0, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF8,
  0x03, 0xFF, 0x3F, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xE7,
  0xE0, 0x7F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x1F,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x03, 0xFE,
  0x0F, 0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFE,
  0x0F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC,
  0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFB, 0xFF, 0x0F, 0xF0, 0x01, 0xE3, 0xF8,
  0x00, 0x04, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xD8, 0x00, 0x03, 0xFB, 0xE0, 0x01, 0xFE,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xF9, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xE0, 0x1F,
  0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x00, 0x7C, 0x01, 0xF0, 0x3E,
  0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3E,
  0x00, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x07,
  0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x1F,
  0x80, 0x1F, 0x87, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xFC, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7E,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xC0,
  0x01, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xE0, 0x1F, 0xC0, 0x40, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFD, 0xFC, 0x07, 0xDF, 0x7F, 0xFF, 0xE7, 0xCF,
  0xFF, 0xF1, 0xF1, 0xFF, 0xF8, 0x7C, 0x1F, 0xF8, 0x1F, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x87, 0xFF, 0x80, 0xFC,
  0xFF, 0xFE, 0x07, 0xEF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xC0,
  0x7F, 0x8F, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x3F, 0xC0, 0x01,
  0xF9, 0xFE, 0x00, 0x1F, 0xCF, 0xFC, 0x01, 0xFC, 0x7F, 0xF8, 0x3F, 0xC3,
  0xEF, 0xFF, 0xFE, 0x1F, 0x3F, 0xFF, 0xE0, 0xF8, 0x7F, 0xFE, 0x07, 0x81,
  0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0x1C,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x02, 0x0F, 0xF8, 0x3E, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0xFE, 0x07, 0xE0, 0x3F, 0xFC, 0x3F, 0x03, 0xFF, 0xF9, 0xF8, 0x3F,
  0xFF, 0xEF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x7F, 0xF1, 0xFC, 0x00,
  0xFF, 0x9F, 0xC0, 0x03, 0xFC, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F,
  0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF, 0xF3, 0xE0,
  0xFF, 0xFF, 0x1F, 0x03, 0xFF, 0xF0, 0xF8, 0x07, 0xFF, 0x07, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x1F,
  0x80, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x02, 0x1F,
  0xE0, 0x00, 0xC0, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFE, 0x38, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF,
  0x07, 0xC0, 0xFF, 0xFE, 0x3E, 0x0F, 0xFF, 0xF9, 0xF0, 0xFF, 0xFF, 0xEF,
  0x8F, 0xF0, 0x1F, 0xFC, 0x7F, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xE3, 0xFE,
  0x07, 0xFF, 0x0F, 0xFF, 0xFD, 0xF8, 0x3F, 0xFF, 0xCF, 0xC0, 0xFF, 0xFC,
  0x7E, 0x01, 0xFF, 0xC3, 0xF0, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE2, 0x00, 0x00,
  0x7E, 0x0C, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x03, 0xFC, 0x07, 0xE1, 0xFF, 0xE0, 0xFC, 0xFF, 0xFF,
  0x1F, 0xBF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xF0, 0x1F, 0xEF, 0xF8,
  0x01, 0xFD, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFC, 0x33, 0xFF, 0xFF, 0xFF, 0xFF, 0xCC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F,
  0xA0, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7F, 0x00,
  0x0F, 0x9F, 0xC0, 0x03, 0xEF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xEF,
  0xC0, 0x0F, 0xF3, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFE, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x03, 0xE1, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0x8F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x3E, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF3, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xEF, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xBF, 0xC0, 0x07, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFB,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x0F, 0xF0, 0x1F, 0x07, 0xFF, 0x83, 0xE3, 0xFF, 0xFC, 0x7C, 0xFF, 0xFF,
  0xCF, 0xBF, 0xFF, 0xF9, 0xFF, 0xC0, 0x7F, 0xBF, 0xE0, 0x07, 0xF7, 0xF8,
  0x00, 0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x01,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x0F,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x07,
  0xC3, 0xFF, 0xE0, 0x3E, 0x3F, 0xFF, 0x81, 0xF3, 0xFF, 0xFE, 0x0F, 0xBF,
  0xFF, 0xF8, 0x7F, 0xE0, 0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFD,
  0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xFC, 0x00,
  0x0F, 0xCF, 0xF0, 0x00, 0x7E, 0x7F, 0x80, 0x07, 0xF3, 0xFF, 0x00, 0x7F,
  0x1F, 0x7E, 0x0F, 0xF0, 0xFD, 0xFF, 0xFF, 0x87, 0xEF, 0xFF, 0xF8, 0x3F,
  0x1F, 0xFF, 0x81, 0xF8, 0x7F, 0xF0, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0x07,
  0xC0, 0xFF, 0xFE, 0x3E, 0x0F, 0xFF, 0xF9, 0xF0, 0xFF, 0xFF, 0xEF, 0x8F,
  0xF0, 0x1F, 0xFC, 0x7F, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xE3, 0xFE, 0x0F,
  0xFF, 0x0F, 0xFF, 0xFD, 0xF8, 0x3F, 0xFF, 0xCF, 0xC0, 0xFF, 0xFC, 0x7E,
  0x01, 0xFF, 0xC3, 0xF0, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0x7C, 0x7F, 0xEF,
  0x9F, 0xFD, 0xF7, 0xF0, 0xBE, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xE0, 0x0F, 0x3F, 0x00, 0x04,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xD0, 0x00, 0x1F, 0xB8, 0x00, 0x7F, 0x7E, 0x03, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0xC1, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0xE0, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xF7, 0xE0, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0xDF, 0xF0, 0x7F, 0xF9, 0xFF,
  0xFF, 0x9F, 0x1F, 0xFF, 0xE3, 0xE1, 0xFF, 0xF8, 0x7C, 0x1F, 0xFE, 0x0F,
  0x80, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0x9F, 0x00, 0x07,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xDF, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x7C,
  0x00, 0xFC, 0x3F, 0x00, 0x7D, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF3, 0xE0,
  0x0F, 0x83, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x07, 0xC0, 0x3E, 0x3E, 0x01,
  0xF8, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xE1, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xF0,
  0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x00,
  0xFC, 0x3F, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xE0, 0x07,
  0xC3, 0xE0, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x7C, 0x7C, 0x00, 0x7E,
  0x7C, 0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0xC0, 0x03, 0xE7,
  0xC0, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x78,
  0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x0F,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E,
  0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x11, 0xFF, 0x80, 0x01, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x80, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 48, 17, 5, -47 },
  { 43, 18, 17, 26, 4, -47 },
  { 82, 35, 47, 38, 2, -47 },
  { 288, 27, 54, 34, 4, -50 },
  { 471, 45, 49, 51, 3, -48 },
  { 747, 39, 49, 42, 3, -48 },
  { 986, 6, 17, 14, 4, -47 },
  { 999, 15, 57, 20, 3, -47 },
  { 1106, 15, 57, 20, 2, -47 },
  { 1213, 27, 27, 33, 3, -50 },
  { 1305, 28, 31, 34, 3, -39 },
  { 1414, 9, 17, 17, 3, -8 },
  { 1434, 16, 5, 20, 2, -20 },
  { 1444, 8, 9, 17, 4, -8 },
  { 1453, 23, 47, 25, 1, -47 },
  { 1589, 28, 49, 34, 3, -48 },
  { 1761, 17, 47, 34, 5, -47 },
  { 1861, 28, 48, 34, 3, -48 },
  { 2029, 28, 49, 34, 3, -48 },
  { 2201, 32, 47, 34, 1, -47 },
  { 2389, 27, 48, 34, 4, -47 },
  { 2551, 28, 49, 34, 3, -48 },
  { 2723, 28, 47, 34, 3, -47 },
  { 2888, 28, 49, 34, 3, -48 },
  { 3060, 28, 49, 34, 3, -48 },
  { 3232, 8, 37, 17, 4, -36 },
  { 3269, 10, 45, 17, 2, -36 },
  { 3326, 28, 31, 34, 3, -39 },
  { 3435, 28, 18, 34, 3, -32 },
  { 3498, 28, 31, 34, 3, -39 },
  { 3607, 23, 49, 26, 1, -48 },
  { 3748, 46, 53, 53, 4, -47 },
  { 4053, 38, 47, 38, 0, -47 },
  { 4277, 30, 47, 39, 6, -47 },
  { 4454, 31, 49, 37, 4, -48 },
  { 4644, 33, 47, 43, 6, -47 },
  { 4838, 23, 47, 33, 6, -47 },
  { 4974, 23, 47, 31, 6, -47 },
  { 5110, 35, 49, 44, 4, -48 },
  { 5325, 32, 47, 44, 6, -47 },
  { 5513, 15, 47, 21, 3, -47 },
  { 5602, 15, 60, 17, -4, -47 },
  { 5715, 31, 47, 37, 6, -47 },
  { 5898, 23, 47, 31, 6, -47 },
  { 6034, 44, 47, 55, 6, -47 },
  { 6293, 34, 47, 46, 6, -47 },
  { 6493, 38, 49, 46, 4, -48 },
  { 6726, 27, 47, 36, 6, -47 },
  { 6885, 38, 59, 46, 4, -48 },
  { 7166, 30, 47, 37, 6, -47 },
  { 7343, 27, 49, 33, 3, -48 },
  { 7509, 31, 47, 32, 1, -47 },
  { 7692, 33, 48, 43, 5, -47 },
  { 7890, 36, 47, 36, 0, -47 },
  { 8102, 55, 47, 56, 1, -47 },
  { 8426, 34, 47, 34, 0, -47 },
  { 8626, 33, 47, 33, 0, -47 },
  { 8820, 29, 47, 33, 2, -47 },
  { 8991, 15, 58, 21, 5, -47 },
  { 9100, 23, 47, 25, 1, -47 },
  { 9236, 14, 58, 21, 2, -47 },
  { 9338, 31, 28, 35, 2, -47 },
  { 9447, 29, 4, 29, 0, 6 },
  { 9462, 13, 11, 18, 3, -51 },
  { 9480, 26, 37, 34, 3, -36 },
  { 9601, 29, 51, 37, 5, -50 },
  { 9786, 24, 37, 28, 3, -36 },
  { 9897, 29, 51, 37, 3, -50 },
  { 10082, 28, 37, 34, 3, -36 },
  { 10212, 22, 50, 21, 1, -50 },
  { 10350, 29, 52, 37, 3, -36 },
  { 10539, 27, 50, 37, 5, -50 },
  { 10708, 6, 49, 16, 5, -49 },
  { 10745, 14, 65, 16, -3, -49 },
  { 10859, 26, 50, 32, 5, -50 },
  { 11022, 6, 50, 16, 5, -50 },
  { 11060, 46, 36, 56, 5, -36 },
  { 11267, 27, 36, 37, 5, -36 },
  { 11389, 30, 37, 36, 3, -36 },
  { 11528, 29, 52, 37, 5, -36 },
  { 11717, 29, 52, 37, 3, -36 },
  { 11906, 19, 36, 25, 5, -36 },
  { 11992, 23, 37, 28, 3, -36 },
  { 12099, 19, 45, 21, 1, -44 },
  { 12206, 27, 36, 37, 5, -35 },
  { 12328, 30, 35, 30, 0, -35 },
  { 12460, 46, 35, 48, 1, -35 },
  { 12662, 29, 35, 31, 1, -35 },
  { 12789, 30, 51, 30, 0, -35 },
  { 12981, 23, 35, 27, 2, -35 },
  { 13082, 20, 58, 25, 2, -47 },
  { 13227, 5, 66, 33, 14, -50 },
  { 13269, 20, 58, 25, 2, -47 },
  { 13414, 28, 9, 34, 3, -28 },
};

const GFXfont NotoSans_SemiCondensed_Regular66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular66pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR66PT7B_H_
