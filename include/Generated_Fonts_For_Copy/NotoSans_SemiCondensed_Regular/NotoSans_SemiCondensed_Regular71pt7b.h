#ifndef _NOTOSANS_SEMICONDENSED_REGULAR71PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07,
  0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xE0,
  0x3E, 0x7E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE3,
  0xC0, 0x3E, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0xFF, 0xC7, 0xF8, 0xF0, 0x1E,
  0x3F, 0x07, 0x80, 0x23, 0xF0, 0x3C, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0xFC,
  0x0F, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x3F, 0x03, 0xC0, 0x01, 0xF8, 0x1E,
  0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x7F, 0x07, 0x80, 0x01, 0xFC, 0x3C, 0x00,
  0x0F, 0xF9, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0x3F,
  0xF0, 0x00, 0x78, 0x7F, 0x80, 0x03, 0xC0, 0xFE, 0x00, 0x1E, 0x03, 0xF0,
  0x00, 0xF0, 0x1F, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x01,
  0xE0, 0x1F, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x78, 0x0F, 0xE0, 0x03, 0xC0,
  0xFF, 0xC0, 0x1E, 0x0F, 0xEF, 0xE0, 0xF3, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x3E,
  0x00, 0x00, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x7C,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0xF8,
  0x1F, 0xC0, 0x7C, 0x03, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x03, 0xE1, 0xF0,
  0xFF, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0xFF, 0xFC, 0x7E, 0x07, 0xC3, 0xE1,
  0xF8, 0xFC, 0x3E, 0x07, 0xC3, 0xE1, 0xF0, 0x7E, 0x3F, 0x0F, 0xC7, 0xC3,
  0xE0, 0x3E, 0x1F, 0xFF, 0x87, 0xC3, 0xE0, 0x3E, 0x0F, 0xFF, 0x0F, 0xC3,
  0xE0, 0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xE0, 0x1F, 0x03, 0xFC, 0x1F, 0x87,
  0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7E, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xFC, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xEF, 0xE0, 0x01, 0xF8, 0x1F,
  0xE1, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0xC0,
  0xFC, 0x1F, 0x80, 0x07, 0xF8, 0x7F, 0x0F, 0xE0, 0x00, 0xFF, 0x1F, 0x83,
  0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x3F, 0x00,
  0x00, 0x7F, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xF0,
  0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x7F,
  0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0x87, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x1E, 0x3C, 0x78, 0xF0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0x80, 0x7C, 0x03, 0x9F, 0x83, 0xE0, 0xFF, 0xFF, 0xDF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x3F,
  0x00, 0x7F, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0x80, 0x38, 0x00,
  0x04, 0x00, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xE3,
  0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x10, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xBF, 0x1F, 0xCF, 0xCF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0x7C, 0x0F, 0xCE, 0x03, 0xF3, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x83, 0xF0, 0x00, 0xFE,
  0x0F, 0x00, 0x01, 0xFC, 0x18, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0x87, 0xE0, 0x00, 0xFF,
  0x0E, 0x00, 0x01, 0xFC, 0x10, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0xA0, 0x00, 0x01, 0xFE, 0xE0, 0x00, 0x0F, 0xF3, 0xF0,
  0x00, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x07, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFD, 0x00, 0x00, 0x1F,
  0xCC, 0x00, 0x01, 0xFE, 0x7C, 0x00, 0x3F, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x80, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x1F, 0xFE,
  0x03, 0xF1, 0xFF, 0xFC, 0x0F, 0xCF, 0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xE3, 0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E,
  0x7E, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x0F,
  0xE0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x0F,
  0xE0, 0x03, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x01,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0xFE, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0x3F, 0x00, 0x07, 0xFC, 0xFE,
  0x00, 0x3F, 0xF1, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF,
  0xFC, 0xFC, 0x1F, 0xFF, 0xE3, 0xF0, 0x1F, 0xFF, 0x0F, 0xC0, 0x1F, 0xF0,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x01, 0xFB, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x07, 0x81, 0xF8, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xC0, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F,
  0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE3, 0xF8, 0x0F, 0xF9, 0xE0, 0x01, 0xFC, 0x40, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0xF0,
  0x03, 0xF0, 0x7C, 0x00, 0x3F, 0xFF, 0xC0, 0x7C, 0x3F, 0x00, 0x3F, 0xFF,
  0xF0, 0x1F, 0x0F, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0xF0,
  0x7F, 0x00, 0xF9, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x3E, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xE7, 0xC0, 0x3F,
  0x00, 0x3E, 0x00, 0x7B, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xF8, 0x07,
  0xE0, 0x03, 0xE0, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0x7C, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xBE, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xEF,
  0x80, 0x7C, 0x00, 0x3E, 0x00, 0xFB, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x3E,
  0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xBE, 0x01, 0xF0, 0x01, 0xF8, 0x03,
  0xEF, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF3, 0xE0, 0x1F, 0x80, 0x3F, 0x80,
  0x7C, 0xF8, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0x3E, 0x00, 0xFC, 0x07, 0xBC,
  0x0F, 0x8F, 0xC0, 0x1F, 0xC7, 0xEF, 0x8F, 0xC1, 0xF0, 0x07, 0xFF, 0xF3,
  0xFF, 0xF0, 0x7C, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0x80, 0x1F, 0xFC,
  0x0F, 0xFC, 0x03, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x70, 0x1F, 0xF0,
  0x00, 0x04, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0x00, 0xFF, 0xE0, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x01,
  0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xE0,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xE0,
  0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xC0,
  0x3F, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x00, 0x08, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x00, 0x3F,
  0x03, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0xA0, 0x3F, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF,
  0xE1, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xF0,
  0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xE0, 0x00, 0x3F, 0xE1, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F,
  0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xDF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFB, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xF7, 0xE0, 0x00, 0x00, 0x7D, 0xFF, 0xEF, 0xC0,
  0x00, 0x01, 0xFB, 0xFF, 0xCF, 0xC0, 0x00, 0x03, 0xF7, 0xFF, 0x9F, 0x80,
  0x00, 0x07, 0xCF, 0xFF, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0xFE, 0x3F, 0x00,
  0x00, 0x3E, 0x3F, 0xFC, 0x7E, 0x00, 0x00, 0x7C, 0x7F, 0xF8, 0xFC, 0x00,
  0x01, 0xF8, 0xFF, 0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xFF, 0xE1, 0xF8, 0x00,
  0x07, 0xC3, 0xFF, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xFF, 0x83, 0xF0, 0x00,
  0x3E, 0x0F, 0xFF, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0xFE, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x7F, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xFF, 0xE0, 0x3F, 0x00, 0x3E,
  0x03, 0xFF, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0x7C, 0x01, 0xF8,
  0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xFE, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x7F, 0xF8, 0x03, 0xF0, 0x3E, 0x00,
  0xFF, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xC1, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0x8F, 0xC0, 0x0F,
  0xFF, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x3E, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x7E, 0x00, 0x00, 0x7F, 0xFB, 0xF8, 0x00, 0x03,
  0xFF, 0xCF, 0xC0, 0x00, 0x1F, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0xF1, 0xFC,
  0x00, 0x07, 0xFF, 0x8F, 0xE0, 0x00, 0x3F, 0xFC, 0x3F, 0x80, 0x01, 0xFF,
  0xE0, 0xFC, 0x00, 0x0F, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x1F, 0x80,
  0x03, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0xF0,
  0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xFC, 0x03, 0xF8, 0x01,
  0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x01,
  0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0xFF,
  0xF0, 0x00, 0xFE, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x3F, 0xFC, 0x00, 0x1F,
  0xC1, 0xFF, 0xE0, 0x00, 0x7E, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0xF8,
  0x00, 0x0F, 0xE3, 0xFF, 0xC0, 0x00, 0x7F, 0x1F, 0xFE, 0x00, 0x01, 0xFC,
  0xFF, 0xF0, 0x00, 0x0F, 0xE7, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0xFC, 0x00,
  0x01, 0xFD, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x8F, 0xE0, 0x03, 0xFE, 0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x7E, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00,
  0x1F, 0xE3, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xC1, 0xFC, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0x87,
  0xF0, 0x00, 0x04, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFD, 0x00, 0x00,
  0x0F, 0xEE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x8F,
  0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x7C, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03,
  0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x03, 0xE0,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x3F,
  0x00, 0x01, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x3F, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0xBF,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01,
  0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xFC, 0x07, 0x80, 0x1F, 0xE0, 0x40, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xF3, 0xFE,
  0x00, 0x3F, 0x7F, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0x7E, 0x00, 0x1F, 0xF7, 0xF0, 0x07, 0xFF, 0x7F, 0xC1, 0xFB, 0xF3,
  0xFF, 0xFF, 0x9F, 0x1F, 0xFF, 0xF1, 0xF0, 0xFF, 0xFC, 0x1F, 0x07, 0xFF,
  0x81, 0xF0, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x3F, 0xFC, 0x03, 0xE1, 0xFF, 0xFC,
  0x0F, 0x8F, 0xFF, 0xF8, 0x3E, 0x7F, 0xFF, 0xF0, 0xFB, 0xFC, 0xFF, 0xE3,
  0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFC, 0xFE,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x7F, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0xC0, 0x1F, 0xE3, 0xEF, 0xF3, 0xFF,
  0x8F, 0x9F, 0xFF, 0xFC, 0x3E, 0x3F, 0xFF, 0xE0, 0xF0, 0x7F, 0xFF, 0x03,
  0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0x80, 0x18, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0x0F, 0xF0, 0x03, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xC0,
  0x3F, 0x00, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0xE3, 0xF0, 0x7F, 0xFF, 0xCF,
  0xC3, 0xFF, 0xFF, 0xBF, 0x1F, 0xF8, 0xFF, 0xFC, 0xFF, 0x00, 0x3F, 0xF3,
  0xF8, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFD, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x7E, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x01,
  0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0xF3, 0xFD, 0xF0, 0xFF, 0xFF, 0xE7,
  0xC1, 0xFF, 0xFF, 0x1F, 0x03, 0xFF, 0xF8, 0x7C, 0x03, 0xFF, 0x81, 0xF0,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF8,
  0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x20, 0xFF, 0x80, 0x0F, 0x03, 0xFF, 0xDF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFD, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x04, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xF0, 0x3F, 0xFF, 0x87, 0xC1, 0xFF,
  0xFF, 0x1F, 0x0F, 0xFF, 0xFE, 0x7C, 0x7F, 0xF7, 0xFD, 0xF1, 0xFE, 0x01,
  0xFF, 0xCF, 0xE0, 0x01, 0xFF, 0x3F, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F,
  0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x3F,
  0x80, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xBF, 0x07, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF, 0xE3, 0xF0, 0x0F, 0xFE,
  0x0F, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x20,
  0x00, 0x07, 0xF8, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x03, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0xFC, 0x3F, 0xFE, 0x0F, 0xC7, 0xFF, 0xF0, 0xF8, 0xFF, 0xFF, 0x8F,
  0x9F, 0xFF, 0xFC, 0xFB, 0xFE, 0xFF, 0xEF, 0xFC, 0x01, 0xFE, 0xFF, 0x80,
  0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF0,
  0x00, 0x7C, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x41, 0xFE,
  0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xFC, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00,
  0xF8, 0x3F, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0xF8, 0xFE, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0xF9, 0xFC, 0x00, 0x0F, 0xBF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7F,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x0F,
  0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00,
  0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFC,
  0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x78, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x3E, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x1F, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xDF, 0xEF, 0xFC, 0xFF, 0x3F,
  0xF3, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xF9, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0xFE, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xBF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xE0, 0x0F, 0x03, 0xFF, 0xE0, 0xF8, 0x7F, 0xFF, 0x0F, 0x8F, 0xFF,
  0xF8, 0xF9, 0xFF, 0xFF, 0xCF, 0xBF, 0xCF, 0xFE, 0xFF, 0xC0, 0x1F, 0xEF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xDF, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0xFF, 0xF0, 0x0F, 0x87,
  0xFF, 0xF0, 0x3E, 0x3F, 0xFF, 0xE0, 0xF9, 0xFF, 0xFF, 0xC3, 0xEF, 0xF3,
  0xFF, 0x8F, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7E,
  0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF,
  0xC0, 0x01, 0xFC, 0xFF, 0x80, 0x0F, 0xF3, 0xFF, 0x00, 0x7F, 0x8F, 0xBF,
  0xCF, 0xFC, 0x3E, 0x7F, 0xFF, 0xF0, 0xF8, 0xFF, 0xFF, 0x83, 0xE1, 0xFF,
  0xFC, 0x0F, 0xC1, 0xFF, 0xC0, 0x3F, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFF, 0x81, 0xF0, 0x3F, 0xFF, 0x87, 0xC1, 0xFF, 0xFF, 0x1F,
  0x0F, 0xFF, 0xFE, 0x7C, 0x7F, 0xE3, 0xFD, 0xF1, 0xFC, 0x01, 0xFF, 0xCF,
  0xE0, 0x01, 0xFF, 0x3F, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xE0,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x07,
  0xFC, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0xFF, 0xBF,
  0x07, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF, 0xE3, 0xF0, 0x0F, 0xFE, 0x0F, 0xC0,
  0x07, 0x80, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x01, 0xFE, 0xF8, 0x7F, 0xEF, 0x8F,
  0xFE, 0xF9, 0xFF, 0xEF, 0x9F, 0xFE, 0xFB, 0xF0, 0x0F, 0xBE, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xE1, 0xFE, 0x7F,
  0x00, 0x1C, 0xFE, 0x00, 0x04, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0xFF,
  0xCF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x9E, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xF0, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xFD,
  0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFF, 0x3F, 0x80, 0x3F, 0xF9, 0xFF,
  0xDF, 0xF7, 0xC7, 0xFF, 0xFF, 0x3E, 0x3F, 0xFF, 0xF1, 0xF0, 0x7F, 0xFF,
  0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x03,
  0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x7C, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xBF, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xDF, 0x80, 0x1F,
  0x83, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0xC0, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x1F, 0x01,
  0xF8, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0xF8,
  0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x3F,
  0x0F, 0xC0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x03, 0xF1, 0xF0, 0x07,
  0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xF8, 0x00,
  0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0xBE, 0x00,
  0x3E, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0,
  0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x41, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x02,
  0x3F, 0xF8, 0x00, 0x04, 0xFF, 0xFC, 0x00, 0x3B, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x60,
  0x00, 0xFF, 0xFC, 0x80, 0x00, 0x7F, 0xE1, 0x00, 0x00, 0x02, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 52, 18, 5, -51 },
  { 53, 20, 19, 28, 4, -51 },
  { 101, 37, 51, 41, 2, -51 },
  { 337, 29, 58, 37, 4, -54 },
  { 548, 48, 52, 55, 3, -51 },
  { 860, 42, 52, 45, 3, -51 },
  { 1133, 7, 19, 16, 4, -51 },
  { 1150, 16, 62, 21, 3, -51 },
  { 1274, 16, 62, 21, 2, -51 },
  { 1398, 29, 29, 35, 3, -54 },
  { 1504, 31, 34, 37, 3, -42 },
  { 1636, 10, 17, 18, 3, -8 },
  { 1658, 17, 6, 22, 2, -22 },
  { 1671, 8, 10, 18, 5, -9 },
  { 1681, 25, 51, 26, 1, -51 },
  { 1841, 31, 52, 37, 3, -51 },
  { 2043, 18, 51, 37, 6, -51 },
  { 2158, 30, 51, 37, 3, -51 },
  { 2350, 30, 52, 37, 3, -51 },
  { 2545, 35, 51, 37, 1, -51 },
  { 2769, 29, 52, 37, 4, -51 },
  { 2958, 30, 52, 37, 4, -51 },
  { 3153, 31, 51, 37, 3, -51 },
  { 3351, 31, 52, 37, 3, -51 },
  { 3553, 30, 52, 37, 3, -51 },
  { 3748, 8, 40, 18, 5, -39 },
  { 3788, 11, 48, 18, 2, -39 },
  { 3854, 31, 33, 37, 3, -42 },
  { 3982, 30, 20, 37, 3, -35 },
  { 4057, 31, 33, 37, 3, -42 },
  { 4185, 25, 52, 28, 1, -51 },
  { 4348, 50, 57, 57, 4, -51 },
  { 4705, 40, 51, 40, 0, -51 },
  { 4960, 32, 51, 42, 6, -51 },
  { 5164, 34, 52, 40, 4, -51 },
  { 5385, 36, 51, 46, 6, -51 },
  { 5615, 26, 51, 36, 6, -51 },
  { 5781, 26, 51, 33, 6, -51 },
  { 5947, 38, 52, 47, 4, -51 },
  { 6194, 35, 51, 47, 6, -51 },
  { 6418, 17, 51, 23, 3, -51 },
  { 6527, 17, 65, 18, -5, -51 },
  { 6666, 34, 51, 39, 6, -51 },
  { 6883, 26, 51, 33, 6, -51 },
  { 7049, 47, 51, 60, 6, -51 },
  { 7349, 37, 51, 49, 6, -51 },
  { 7585, 41, 52, 49, 4, -51 },
  { 7852, 30, 51, 39, 6, -51 },
  { 8044, 41, 63, 49, 4, -51 },
  { 8367, 33, 51, 40, 6, -51 },
  { 8578, 29, 52, 35, 3, -51 },
  { 8767, 33, 51, 35, 1, -51 },
  { 8978, 35, 52, 46, 6, -51 },
  { 9206, 38, 51, 38, 0, -51 },
  { 9449, 59, 51, 61, 1, -51 },
  { 9826, 36, 51, 37, 0, -51 },
  { 10056, 36, 51, 36, 0, -51 },
  { 10286, 31, 51, 35, 2, -51 },
  { 10484, 16, 62, 23, 5, -51 },
  { 10608, 25, 51, 26, 1, -51 },
  { 10768, 15, 62, 23, 2, -51 },
  { 10885, 33, 30, 37, 2, -51 },
  { 11009, 31, 5, 31, 0, 6 },
  { 11029, 14, 11, 20, 3, -54 },
  { 11049, 28, 40, 36, 3, -39 },
  { 11189, 30, 55, 40, 6, -54 },
  { 11396, 25, 40, 31, 4, -39 },
  { 11521, 30, 55, 40, 4, -54 },
  { 11728, 29, 40, 36, 4, -39 },
  { 11873, 24, 54, 22, 1, -54 },
  { 12035, 30, 56, 40, 4, -39 },
  { 12245, 28, 54, 40, 6, -54 },
  { 12434, 7, 52, 17, 5, -52 },
  { 12480, 15, 69, 17, -3, -52 },
  { 12610, 28, 54, 34, 6, -54 },
  { 12799, 6, 54, 17, 6, -54 },
  { 12840, 49, 39, 60, 6, -39 },
  { 13079, 28, 39, 40, 6, -39 },
  { 13216, 31, 40, 39, 4, -39 },
  { 13371, 30, 56, 40, 6, -39 },
  { 13581, 30, 56, 40, 4, -39 },
  { 13791, 20, 39, 26, 6, -39 },
  { 13889, 24, 40, 30, 3, -39 },
  { 14009, 21, 48, 23, 1, -47 },
  { 14135, 29, 39, 40, 5, -38 },
  { 14277, 32, 38, 32, 0, -38 },
  { 14429, 49, 38, 51, 1, -38 },
  { 14662, 31, 38, 34, 1, -38 },
  { 14810, 32, 55, 33, 0, -38 },
  { 15030, 25, 38, 29, 2, -38 },
  { 15149, 22, 62, 26, 2, -51 },
  { 15320, 5, 71, 35, 15, -54 },
  { 15365, 22, 62, 26, 2, -51 },
  { 15536, 31, 10, 37, 3, -30 },
};

const GFXfont NotoSans_SemiCondensed_Regular71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular71pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR71PT7B_H_
