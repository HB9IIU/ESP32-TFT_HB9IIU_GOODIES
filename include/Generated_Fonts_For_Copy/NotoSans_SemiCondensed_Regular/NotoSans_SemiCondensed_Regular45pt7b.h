#ifndef _NOTOSANS_SEMICONDENSED_REGULAR45PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0x20, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xEE,
  0x06, 0x60, 0x60, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x70,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0,
  0x01, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x01, 0xC1, 0xC0, 0x03, 0xC1, 0xC0, 0x03, 0x81, 0xC0,
  0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0x03, 0x80,
  0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x07, 0x00,
  0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xE7, 0x1C, 0x78, 0xE0,
  0x0E, 0x1C, 0x03, 0xC3, 0x80, 0x78, 0x70, 0x07, 0x0E, 0x00, 0xF1, 0xC0,
  0x1F, 0x38, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x0E, 0xFC, 0x01, 0xC7, 0xC0, 0x38, 0x78, 0x07, 0x0F,
  0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0xF0, 0x73, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0x00, 0xFF, 0x00, 0x1C, 0x03, 0xCF, 0x00, 0x70, 0x07, 0x0E,
  0x00, 0xE0, 0x0E, 0x0E, 0x03, 0x80, 0x3C, 0x1C, 0x07, 0x00, 0x70, 0x38,
  0x1C, 0x00, 0xE0, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0xF0, 0x03, 0x81, 0xC1,
  0xC0, 0x07, 0x03, 0x87, 0x80, 0x0E, 0x07, 0x0E, 0x00, 0x1C, 0x0E, 0x3C,
  0x38, 0x3C, 0x1C, 0x71, 0xFC, 0x38, 0x39, 0xE7, 0xFC, 0x70, 0xE3, 0x9E,
  0x38, 0xF3, 0xCF, 0x38, 0x78, 0xFF, 0x1C, 0x70, 0x70, 0xFE, 0x78, 0xE0,
  0xE0, 0x60, 0xE3, 0xC1, 0xC0, 0x03, 0xC7, 0x83, 0x80, 0x07, 0x0E, 0x07,
  0x80, 0x1E, 0x1C, 0x0F, 0x00, 0x38, 0x38, 0x1E, 0x00, 0x70, 0x78, 0x38,
  0x01, 0xC0, 0x70, 0x70, 0x03, 0x80, 0xE0, 0xE0, 0x0E, 0x01, 0xC1, 0xC0,
  0x1C, 0x03, 0xC7, 0x80, 0x70, 0x03, 0xDE, 0x00, 0xE0, 0x07, 0xFC, 0x03,
  0xC0, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0xF0, 0xF9, 0xF0, 0x1E, 0x3E, 0x1F, 0x03, 0x87, 0x81,
  0xF0, 0xF1, 0xF0, 0x1E, 0x1E, 0x3C, 0x03, 0xE7, 0x87, 0x80, 0x3E, 0xF0,
  0xF0, 0x03, 0xFE, 0x1E, 0x00, 0x3F, 0x83, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0xFE, 0x07, 0x80, 0x3F, 0xE0, 0xFC, 0x1F, 0xBE, 0x0F, 0xFF, 0xE7, 0xC0,
  0xFF, 0xF8, 0x7C, 0x0F, 0xFC, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE,
  0x60, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0x3C, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x3C,
  0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x20, 0x38, 0x1F, 0x8C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0x38, 0x03, 0xCF, 0x01, 0xE1,
  0xE0, 0xF8, 0x7C, 0x1E, 0x0E, 0x01, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0xF3, 0xDE, 0x79, 0xE7, 0x1C, 0xF3, 0x8E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0x90, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xE0, 0xF8, 0x78, 0x0F, 0x1E, 0x00, 0xF3,
  0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7B, 0x80, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x78, 0x3C, 0x1F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03,
  0xFC, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x8F, 0xF3, 0xFE, 0xFB, 0xFE, 0x7F,
  0x8F, 0x61, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0,
  0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0x80, 0xF8, 0xE0, 0x0F,
  0x08, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0x80, 0xF8, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x1F, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE8,
  0x00, 0x7D, 0xC0, 0x1F, 0x3F, 0xFF, 0xE7, 0xFF, 0xF0, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0xE3,
  0x80, 0x07, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x07, 0x83, 0x80,
  0x1C, 0x0E, 0x00, 0xF0, 0x38, 0x03, 0x80, 0xE0, 0x1E, 0x03, 0x80, 0xF0,
  0x0E, 0x03, 0x80, 0x38, 0x1E, 0x00, 0xE0, 0x70, 0x03, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF7, 0xC0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7A, 0x00, 0x3E, 0xE0, 0x3F, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE1,
  0xFC, 0x1C, 0xFF, 0xC7, 0xBF, 0xFC, 0xFF, 0x07, 0xDF, 0x80, 0x7B, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7B, 0x80,
  0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0x9E, 0x00, 0xF3, 0xE0,
  0x3C, 0x3E, 0x0F, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC3, 0xC0, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x0E, 0x78, 0x01,
  0xCF, 0x00, 0x39, 0xE0, 0x0F, 0x1E, 0x01, 0xE3, 0xE0, 0x78, 0x3E, 0x3E,
  0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7C, 0xFC,
  0x1F, 0x07, 0xC7, 0x80, 0x7C, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xF7, 0x80, 0x3E,
  0xF8, 0x0F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xE0, 0xF8, 0xF0, 0x0F,
  0x1E, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x1F,
  0x7C, 0x07, 0xE7, 0xC3, 0xFC, 0xFF, 0xF7, 0x8F, 0xFC, 0xF0, 0x7F, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x27, 0xFF, 0xFF, 0xBC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x79, 0x00, 0x08, 0x7C,
  0xF9, 0xF3, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE7, 0xCF, 0x9E, 0x3C, 0x79, 0xE3, 0xC7, 0x0E,
  0x3C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xF0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xE0, 0x3E, 0x40, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x02,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x1E, 0x3C, 0x07, 0xFE, 0x0E, 0x38, 0x0F, 0xFE, 0x0E, 0x38, 0x1E, 0x1E,
  0x0F, 0x78, 0x3C, 0x0E, 0x07, 0x70, 0x38, 0x0E, 0x07, 0x70, 0x78, 0x0E,
  0x07, 0x70, 0x70, 0x0E, 0x07, 0x70, 0x70, 0x1E, 0x07, 0xF0, 0x70, 0x1E,
  0x07, 0xF0, 0x70, 0x1E, 0x07, 0xF0, 0x70, 0x1E, 0x07, 0xF0, 0x70, 0x1E,
  0x0E, 0x70, 0x70, 0x1E, 0x0E, 0x70, 0x78, 0x3E, 0x0E, 0x70, 0x38, 0x36,
  0x1C, 0x70, 0x3F, 0xF7, 0xFC, 0x78, 0x1F, 0xE3, 0xF8, 0x78, 0x0F, 0x81,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x00, 0x07, 0xF0, 0x0F,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x78, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x1C,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x3C,
  0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x1E, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x01, 0xFC, 0xF0, 0x03, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x3E, 0xF0, 0x07, 0xCF, 0x03, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8F, 0x00, 0x7C, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF0, 0x3F, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x80, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0x07, 0x0F, 0x80, 0x08, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x38,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x07, 0x81, 0xFF, 0x0F, 0x00, 0x3F, 0x1E, 0x00,
  0x3E, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7D, 0xE0, 0x00,
  0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC,
  0x00, 0x0F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0,
  0x07, 0xC7, 0x80, 0x3F, 0x0F, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xE0, 0x3C, 0x1F, 0x80, 0x04, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3E, 0x00, 0x0F,
  0x1F, 0x00, 0x0F, 0x0F, 0xE0, 0x1F, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFE, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0xFF,
  0xBF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7D, 0xFF, 0x3F, 0xE7, 0xF0, 0x70, 0x00,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0x3C, 0x00, 0xF9, 0xE0, 0x0F, 0x8F, 0x00,
  0x78, 0x78, 0x07, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07,
  0x83, 0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x3E, 0x00, 0x79, 0xE0,
  0x03, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x3E,
  0x3E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF8,
  0x1E, 0x03, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x7C, 0x3C, 0x01, 0xF1, 0xE0,
  0x07, 0x8F, 0x00, 0x3E, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xDE, 0x00, 0x1F,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xEE, 0x00, 0x03, 0xFF, 0xBC,
  0x00, 0x0F, 0xFE, 0xF0, 0x00, 0x3B, 0xFD, 0xC0, 0x01, 0xEF, 0xF7, 0x80,
  0x07, 0xBF, 0xDE, 0x00, 0x1C, 0xFF, 0x38, 0x00, 0xF3, 0xFC, 0xF0, 0x03,
  0x8F, 0xF3, 0xC0, 0x0E, 0x3F, 0xC7, 0x00, 0x78, 0xFF, 0x1E, 0x01, 0xC3,
  0xFC, 0x78, 0x07, 0x0F, 0xF0, 0xE0, 0x3C, 0x3F, 0xC3, 0xC0, 0xE0, 0xFF,
  0x0F, 0x03, 0x83, 0xFC, 0x1C, 0x1E, 0x0F, 0xF0, 0x78, 0x70, 0x3F, 0xC1,
  0xE1, 0xC0, 0xFF, 0x03, 0x8F, 0x03, 0xFC, 0x0F, 0x38, 0x0F, 0xF0, 0x3D,
  0xE0, 0x3F, 0xC0, 0x77, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF0,
  0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3E, 0x00, 0xFF, 0x00, 0x78, 0x03,
  0xFC, 0x01, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFB, 0xC0, 0x07,
  0xF3, 0xC0, 0x0F, 0xF7, 0x80, 0x1F, 0xE7, 0x80, 0x3F, 0xCF, 0x80, 0x7F,
  0x8F, 0x00, 0xFF, 0x1F, 0x01, 0xFE, 0x1E, 0x03, 0xFC, 0x1E, 0x07, 0xF8,
  0x3C, 0x0F, 0xF0, 0x3C, 0x1F, 0xE0, 0x7C, 0x3F, 0xC0, 0x78, 0x7F, 0x80,
  0xF8, 0xFF, 0x00, 0xF1, 0xFE, 0x01, 0xF3, 0xFC, 0x01, 0xE7, 0xF8, 0x01,
  0xE7, 0xF0, 0x03, 0xEF, 0xE0, 0x03, 0xDF, 0xC0, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x03,
  0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x3F, 0x00, 0x3E, 0x07, 0xF0,
  0x3F, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x78, 0x3F, 0xCF, 0x00, 0xFD,
  0xE0, 0x0F, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xE7,
  0x80, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x0F, 0x83,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x0F, 0x9E, 0x00, 0x03, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x3F,
  0x00, 0x3E, 0x07, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xE0, 0x7F, 0x0F, 0x00, 0x7C, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0x7C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0xF9, 0xE0,
  0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC0, 0x3E, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x87,
  0x80, 0x3C, 0x3C, 0x01, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3E, 0x78, 0x00,
  0xF3, 0xC0, 0x07, 0xDE, 0x00, 0x1F, 0x00, 0x60, 0x01, 0xFF, 0xC1, 0xFF,
  0xFC, 0xFF, 0xFE, 0x7E, 0x03, 0x9F, 0x00, 0x27, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xFC,
  0x07, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x3C, 0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0x81, 0xE0, 0x03,
  0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x01,
  0xE7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xF7, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3D, 0xE0, 0x01,
  0xE0, 0x01, 0xF7, 0x80, 0x0F, 0xC0, 0x07, 0x9E, 0x00, 0x3F, 0x00, 0x1E,
  0x3C, 0x00, 0xFC, 0x00, 0x78, 0xF0, 0x03, 0xF8, 0x01, 0xE3, 0xC0, 0x1F,
  0xE0, 0x0F, 0x0F, 0x00, 0x7B, 0x80, 0x3C, 0x1E, 0x01, 0xCE, 0x00, 0xF0,
  0x78, 0x07, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0xF0, 0x1E, 0x07, 0x80, 0xF1,
  0xC0, 0x78, 0x1E, 0x03, 0x87, 0x01, 0xE0, 0x3C, 0x0E, 0x1E, 0x07, 0x80,
  0xF0, 0x78, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0xE0, 0xF0, 0x0F, 0x07, 0x03,
  0x83, 0xC0, 0x1E, 0x1C, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x3C, 0x38, 0x01,
  0xE3, 0xC0, 0x71, 0xE0, 0x07, 0x8E, 0x01, 0xC7, 0x80, 0x0E, 0x38, 0x07,
  0x9E, 0x00, 0x3D, 0xE0, 0x1E, 0x70, 0x00, 0xF7, 0x80, 0x3B, 0xC0, 0x03,
  0xDC, 0x00, 0xEF, 0x00, 0x07, 0x70, 0x03, 0xFC, 0x00, 0x1D, 0xC0, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0xF8, 0xF8, 0x01, 0xE0, 0xF0, 0x07,
  0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0xC3, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xE0, 0x0F,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x79,
  0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1D, 0xC0,
  0x00, 0xEF, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xE0, 0x07, 0x87, 0x00, 0x38,
  0x3C, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x81, 0xE0, 0x1C, 0x0E, 0x00, 0xF0,
  0xF0, 0x03, 0x87, 0x00, 0x1E, 0x78, 0x00, 0x73, 0xC0, 0x03, 0xFC, 0x00,
  0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x00, 0x60, 0x07, 0xFE, 0x0F, 0xFF, 0xC3,
  0xFF, 0xE1, 0x80, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0xFF, 0xF1, 0xFF, 0xF9, 0xFC, 0x1D, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xFD, 0xFF, 0xEE, 0x7F, 0xE7, 0x1F, 0xE1, 0x80, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x04, 0x03, 0x8F,
  0xF0, 0x73, 0xFF, 0x8E, 0xFF, 0xF1, 0xF8, 0x1F, 0x3E, 0x01, 0xF7, 0x80,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xF0, 0x0F, 0xBF, 0x03,
  0xE7, 0x7F, 0xF8, 0xE7, 0xFE, 0x1C, 0x7F, 0x80, 0x00, 0x20, 0x03, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0x02, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3F, 0x03, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x08, 0x0F, 0x07,
  0xF8, 0xF0, 0xFF, 0xEF, 0x1F, 0xFE, 0xF3, 0xE0, 0x7F, 0x3C, 0x03, 0xF7,
  0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xF3, 0xC0,
  0x3F, 0x3E, 0x07, 0xF1, 0xFF, 0xEF, 0x0F, 0xFC, 0xF0, 0x7F, 0x8F, 0x00,
  0x40, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xE0, 0x78, 0x78,
  0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x0E, 0x78, 0x01, 0xEE, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x04, 0x3E, 0x03, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x01, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x40, 0x00, 0x7F, 0x8F, 0x0F, 0xFE, 0xF1, 0xFF,
  0xEF, 0x3E, 0x07, 0xF3, 0xC0, 0x3F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x78,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x0F,
  0x78, 0x01, 0xF7, 0x80, 0x1F, 0x3C, 0x03, 0xF3, 0xE0, 0x7F, 0x1F, 0xFE,
  0xF0, 0xFF, 0xCF, 0x07, 0xF8, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE3, 0x00, 0x7C, 0x3F,
  0xBF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0x80, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x08, 0x0E, 0x3F, 0xE3, 0x9F, 0xFC,
  0xEF, 0xFF, 0xBF, 0x03, 0xEF, 0x80, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xF0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x03, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x70, 0x03,
  0x81, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78,
  0x1E, 0xDF, 0xBF, 0xCF, 0xE1, 0xF0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x03, 0xFC, 0x03, 0xEE, 0x03, 0xE7, 0x01, 0xE3,
  0x81, 0xE1, 0xC1, 0xE0, 0xE1, 0xE0, 0x71, 0xF0, 0x39, 0xF0, 0x1C, 0xF0,
  0x0E, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF3, 0xC0, 0xF1, 0xE0, 0x70,
  0x78, 0x38, 0x3E, 0x1C, 0x0F, 0x0E, 0x03, 0xC7, 0x01, 0xF3, 0x80, 0x79,
  0xC0, 0x3E, 0xE0, 0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x01, 0x01,
  0xC7, 0xF8, 0x3F, 0xE3, 0x9F, 0xF8, 0xFF, 0xE7, 0x7F, 0xFB, 0xFF, 0xCF,
  0xC1, 0xFE, 0x07, 0xDF, 0x01, 0xF8, 0x07, 0xBC, 0x01, 0xF0, 0x0F, 0x78,
  0x03, 0xC0, 0x0E, 0xF0, 0x07, 0x80, 0x1F, 0xE0, 0x0F, 0x00, 0x3F, 0x80,
  0x1E, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x78, 0x01, 0xFC, 0x00,
  0xF0, 0x03, 0xF8, 0x01, 0xE0, 0x07, 0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x07,
  0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x7F, 0x00, 0x3C,
  0x00, 0xFE, 0x00, 0x78, 0x01, 0xFC, 0x00, 0xF0, 0x03, 0xF8, 0x01, 0xE0,
  0x07, 0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x20, 0x38,
  0xFF, 0x8E, 0x7F, 0xF3, 0xBF, 0xFE, 0xFC, 0x0F, 0xBE, 0x01, 0xEF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF8, 0x3E, 0x07, 0xC3, 0xC0, 0x3E, 0x78, 0x01, 0xE7,
  0x80, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x1E, 0x3C, 0x03, 0xE1, 0xE0,
  0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x20, 0x1C,
  0x7F, 0x83, 0x9F, 0xFC, 0x77, 0xFF, 0x8F, 0xC0, 0xF9, 0xF0, 0x0F, 0xBC,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x80, 0x7D, 0xF8,
  0x1F, 0x3B, 0xFF, 0xC7, 0x3F, 0xF0, 0xE3, 0xFC, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x7F, 0x8F, 0x0F, 0xFE, 0xF1, 0xFF, 0xEF, 0x3E, 0x07, 0xF3,
  0xC0, 0x3F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80,
  0x1F, 0x3C, 0x03, 0xF3, 0xE0, 0x7F, 0x1F, 0xFE, 0xF0, 0xFF, 0xCF, 0x07,
  0xF8, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x6E, 0x3F, 0xE7, 0xFE, 0xFF, 0xEE,
  0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x3F, 0xF8, 0xFF,
  0xFB, 0xFF, 0xEF, 0x80, 0xDE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x01, 0xFC, 0x07,
  0xFF, 0xFF, 0x7F, 0xFC, 0x7F, 0xF0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x01, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x7D, 0xE0, 0x0F, 0xBC, 0x03, 0xF7, 0xC0, 0xFE, 0x7F, 0xFB, 0xCF,
  0xFE, 0x78, 0x7F, 0x8F, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x3C,
  0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x03, 0x80,
  0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x03, 0x81, 0xE0, 0x1E, 0x0F, 0x00,
  0xF0, 0x70, 0x03, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xC0, 0x03, 0x9E,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x78,
  0x03, 0xE0, 0x0E, 0x78, 0x07, 0xE0, 0x1E, 0x78, 0x07, 0xE0, 0x1E, 0x3C,
  0x07, 0xF0, 0x1E, 0x3C, 0x07, 0x70, 0x1C, 0x3C, 0x0F, 0x70, 0x3C, 0x3C,
  0x0E, 0x70, 0x3C, 0x1C, 0x0E, 0x78, 0x3C, 0x1E, 0x1E, 0x78, 0x38, 0x1E,
  0x1E, 0x38, 0x78, 0x1E, 0x1C, 0x38, 0x78, 0x0E, 0x1C, 0x3C, 0x78, 0x0F,
  0x3C, 0x1C, 0x70, 0x0F, 0x3C, 0x1C, 0x70, 0x0F, 0x38, 0x1E, 0xF0, 0x07,
  0x38, 0x1E, 0xF0, 0x07, 0x78, 0x0E, 0xE0, 0x07, 0xF0, 0x0E, 0xE0, 0x07,
  0xF0, 0x0E, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x03,
  0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xE7, 0x80, 0x3C,
  0x3C, 0x07, 0xC3, 0xE0, 0x78, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E,
  0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x0F,
  0x1E, 0x00, 0xF1, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x3C, 0x07, 0x87,
  0x80, 0x3C, 0x78, 0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0xC0, 0x07,
  0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0,
  0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x03, 0xC1, 0xE0,
  0x1E, 0x0F, 0x00, 0x70, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x71,
  0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00,
  0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x0B, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x7C, 0x0F, 0xE0, 0x3E, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF0, 0x1F,
  0x83, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x7C,
  0x0F, 0xE0, 0x7E, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x2F, 0xF8, 0x07, 0xFF,
  0xE3, 0xFB, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 33, 12, 3, -32 },
  { 22, 12, 11, 18, 3, -32 },
  { 39, 24, 32, 26, 1, -32 },
  { 135, 19, 37, 23, 2, -34 },
  { 223, 31, 33, 35, 2, -33 },
  { 351, 27, 33, 29, 2, -33 },
  { 463, 4, 11, 10, 3, -32 },
  { 469, 10, 39, 13, 2, -32 },
  { 518, 10, 39, 13, 1, -32 },
  { 567, 18, 18, 22, 2, -34 },
  { 608, 19, 22, 23, 2, -27 },
  { 661, 6, 11, 11, 2, -5 },
  { 670, 10, 4, 14, 2, -14 },
  { 675, 5, 6, 11, 3, -5 },
  { 679, 15, 32, 17, 1, -32 },
  { 739, 19, 33, 23, 2, -33 },
  { 818, 11, 32, 23, 4, -32 },
  { 862, 19, 33, 23, 2, -33 },
  { 941, 19, 33, 23, 2, -33 },
  { 1020, 22, 32, 23, 1, -32 },
  { 1108, 18, 32, 23, 3, -32 },
  { 1180, 19, 33, 23, 2, -33 },
  { 1259, 19, 32, 23, 2, -32 },
  { 1335, 19, 33, 23, 2, -33 },
  { 1414, 19, 33, 23, 2, -33 },
  { 1493, 5, 26, 11, 3, -25 },
  { 1510, 7, 31, 11, 1, -25 },
  { 1538, 19, 22, 23, 2, -27 },
  { 1591, 19, 12, 23, 2, -22 },
  { 1620, 19, 22, 23, 2, -27 },
  { 1673, 16, 34, 18, 1, -33 },
  { 1741, 32, 36, 36, 2, -32 },
  { 1885, 26, 32, 26, 0, -32 },
  { 1989, 20, 32, 26, 4, -32 },
  { 2069, 21, 33, 25, 3, -33 },
  { 2156, 23, 32, 29, 4, -32 },
  { 2248, 16, 32, 23, 4, -32 },
  { 2312, 16, 32, 21, 4, -32 },
  { 2376, 24, 33, 30, 3, -33 },
  { 2475, 22, 32, 30, 4, -32 },
  { 2563, 11, 32, 14, 2, -32 },
  { 2607, 11, 41, 11, -3, -32 },
  { 2664, 21, 32, 25, 4, -32 },
  { 2748, 16, 32, 21, 4, -32 },
  { 2812, 30, 32, 38, 4, -32 },
  { 2932, 23, 32, 31, 4, -32 },
  { 3024, 26, 33, 31, 3, -33 },
  { 3132, 19, 32, 25, 4, -32 },
  { 3208, 26, 41, 31, 3, -33 },
  { 3342, 21, 32, 25, 4, -32 },
  { 3426, 18, 33, 22, 2, -33 },
  { 3501, 22, 32, 22, 0, -32 },
  { 3589, 22, 32, 29, 4, -32 },
  { 3677, 24, 32, 24, 0, -32 },
  { 3773, 38, 32, 38, 0, -32 },
  { 3925, 23, 32, 23, 0, -32 },
  { 4017, 23, 32, 23, 0, -32 },
  { 4109, 19, 32, 22, 2, -32 },
  { 4185, 10, 39, 15, 3, -32 },
  { 4234, 15, 32, 17, 1, -32 },
  { 4294, 10, 39, 15, 1, -32 },
  { 4343, 21, 19, 24, 1, -32 },
  { 4393, 20, 3, 20, 0, 4 },
  { 4401, 9, 7, 12, 2, -34 },
  { 4409, 17, 25, 23, 2, -25 },
  { 4463, 19, 34, 25, 4, -34 },
  { 4544, 16, 25, 19, 2, -25 },
  { 4594, 20, 34, 25, 2, -34 },
  { 4679, 19, 25, 23, 2, -25 },
  { 4739, 15, 34, 14, 1, -34 },
  { 4803, 20, 36, 25, 2, -25 },
  { 4893, 18, 34, 25, 4, -34 },
  { 4970, 5, 33, 11, 3, -33 },
  { 4991, 10, 44, 11, -2, -33 },
  { 5046, 17, 34, 22, 4, -34 },
  { 5119, 3, 34, 11, 4, -34 },
  { 5132, 31, 25, 38, 4, -25 },
  { 5229, 18, 25, 25, 4, -25 },
  { 5286, 20, 25, 25, 2, -25 },
  { 5349, 19, 36, 25, 4, -25 },
  { 5435, 20, 36, 25, 2, -25 },
  { 5525, 12, 25, 17, 4, -25 },
  { 5563, 15, 25, 19, 2, -25 },
  { 5610, 13, 30, 15, 1, -30 },
  { 5659, 19, 24, 25, 3, -24 },
  { 5716, 21, 24, 21, 0, -24 },
  { 5779, 32, 24, 32, 0, -24 },
  { 5875, 20, 24, 21, 1, -24 },
  { 5935, 21, 35, 21, 0, -24 },
  { 6027, 15, 24, 18, 2, -24 },
  { 6072, 14, 39, 17, 1, -32 },
  { 6141, 3, 45, 22, 10, -34 },
  { 6158, 13, 39, 17, 2, -32 },
  { 6222, 19, 6, 23, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_Regular45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR45PT7B_H_
