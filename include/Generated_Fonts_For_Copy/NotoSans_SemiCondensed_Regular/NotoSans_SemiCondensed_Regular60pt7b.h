#ifndef _NOTOSANS_SEMICONDENSED_REGULAR60PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular60pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xF1, 0xC0, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E,
  0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F,
  0xE7, 0x0F, 0x8F, 0xC3, 0x80, 0xC7, 0xC1, 0xC0, 0x07, 0xC0, 0xE0, 0x03,
  0xE0, 0x70, 0x01, 0xF0, 0x38, 0x00, 0xF8, 0x1C, 0x00, 0x7C, 0x0E, 0x00,
  0x1F, 0x07, 0x00, 0x0F, 0xC3, 0x80, 0x07, 0xF9, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xBF, 0xE0, 0x01, 0xC7, 0xF0, 0x00,
  0xE0, 0xFC, 0x00, 0x70, 0x3E, 0x00, 0x38, 0x1F, 0x00, 0x1C, 0x0F, 0x80,
  0x0E, 0x07, 0xC0, 0x07, 0x03, 0xE0, 0x03, 0x81, 0xF8, 0x01, 0xC1, 0xF7,
  0x80, 0xE3, 0xFB, 0xFF, 0x7F, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0x00,
  0x3F, 0xFC, 0x00, 0x1E, 0x00, 0x7E, 0x7C, 0x00, 0x1E, 0x00, 0x7C, 0x3E,
  0x00, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x01,
  0xE0, 0x00, 0xF0, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x0F,
  0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x0F, 0x07, 0xF0, 0xF0, 0x1F, 0x1F, 0x1F,
  0xF8, 0xF8, 0x1E, 0x1E, 0x1F, 0xFC, 0x78, 0x1E, 0x3E, 0x3F, 0x7C, 0x7C,
  0x3E, 0x3C, 0x7C, 0x3E, 0x3E, 0x7C, 0x7C, 0x78, 0x1E, 0x3F, 0xFC, 0x78,
  0x78, 0x1F, 0x1F, 0xF8, 0xF8, 0x78, 0x0F, 0x0F, 0xF0, 0xF0, 0xF8, 0x0F,
  0x00, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x00,
  0x78, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x78,
  0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x7C, 0x1F, 0xDF, 0xC0, 0x1F, 0x87, 0xE1, 0xFC, 0x03, 0xE1,
  0xF8, 0x1F, 0xC0, 0x7C, 0x3F, 0x01, 0xFC, 0x0F, 0x8F, 0xC0, 0x1F, 0x83,
  0xF1, 0xF0, 0x01, 0xF8, 0x7C, 0x3E, 0x00, 0x1F, 0x9F, 0x87, 0xC0, 0x01,
  0xFB, 0xE0, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0x00, 0x03, 0xFF, 0x03, 0xE0,
  0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0x81,
  0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0x80, 0x0F, 0xFF, 0x03, 0xFC, 0x0F, 0xFB,
  0xF0, 0x3F, 0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x05, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF7, 0xBD, 0xCE, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x70, 0x1E, 0x03, 0xBF, 0x0F, 0x1F, 0xDF, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x07,
  0x00, 0xE0, 0x00, 0x80, 0x40, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8,
  0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x1C,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F,
  0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0xC0, 0x07, 0xE3, 0xE0, 0x03,
  0xE1, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xC7, 0xEF, 0x9F, 0x9F, 0x7E, 0x3F, 0xF8, 0x7D, 0xE0, 0xFB, 0x81,
  0xF2, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC3, 0xE0, 0x07, 0xF0, 0xC0, 0x01, 0xF8, 0x40, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x8F, 0xF0, 0x1F, 0xC3, 0xC0, 0x07, 0xF0, 0x80, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF6, 0x00, 0x03,
  0xF3, 0xE0, 0x07, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x1F, 0x80, 0x01,
  0xF0, 0xFC, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x78, 0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xF0,
  0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0xE0, 0x1F,
  0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00,
  0x7E, 0x07, 0x80, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xE0, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE8, 0x00, 0x07, 0xE6, 0x00, 0x07, 0xF3, 0xE0, 0x0F, 0xF1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFC, 0x02, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x1F, 0xC0, 0x3E, 0x1F, 0xFC,
  0x0F, 0x9F, 0xFF, 0x83, 0xE7, 0xFF, 0xF0, 0xFB, 0xF1, 0xFE, 0x3F, 0xE0,
  0x1F, 0xCF, 0xF0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBF,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x1F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x0F,
  0xC3, 0xE0, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x1F, 0x81, 0xFC,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x1F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7, 0xF0, 0x07, 0xF0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xB0, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC1, 0xF8, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF8, 0x07, 0xFC, 0xFF,
  0x0F, 0xFE, 0x3F, 0xFF, 0xDF, 0x0F, 0xFF, 0xCF, 0x83, 0xFF, 0xC7, 0xC0,
  0x7F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x80, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7C, 0x70, 0x0E, 0x0F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xF1, 0xF1, 0xF8,
  0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7,
  0xC0, 0xFF, 0x38, 0x01, 0xF9, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x1F, 0x00, 0x3F, 0xF8, 0x0F, 0x87, 0x80, 0x3F, 0xFF, 0x01, 0xE3, 0xE0,
  0x1F, 0xFF, 0xC0, 0x78, 0xF0, 0x0F, 0xE1, 0xF0, 0x1F, 0x7C, 0x07, 0xE0,
  0x3C, 0x03, 0xDF, 0x01, 0xF0, 0x0F, 0x00, 0xF7, 0x80, 0xF8, 0x03, 0xC0,
  0x3D, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x78, 0x0F, 0x00, 0x3C, 0x03, 0xFE,
  0x03, 0xC0, 0x0F, 0x00, 0xFF, 0x81, 0xF0, 0x03, 0xC0, 0x3F, 0xE0, 0x7C,
  0x00, 0xF0, 0x0F, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xFC, 0x07, 0xC0, 0x1F,
  0x00, 0xFF, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xC0, 0x7C, 0x01, 0xF0, 0x0F,
  0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xBE, 0x03, 0xC0, 0x3F, 0x01, 0xEF, 0x80,
  0xF8, 0x0F, 0xC0, 0xF9, 0xE0, 0x3E, 0x07, 0xF8, 0x3C, 0x78, 0x07, 0xF3,
  0xDF, 0x3F, 0x1E, 0x01, 0xFF, 0xE3, 0xFF, 0x87, 0xC0, 0x3F, 0xF8, 0x7F,
  0xC0, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7C,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF8, 0x00, 0xFF, 0x3F, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00,
  0x1F, 0x7E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC7, 0xE0, 0x03, 0xFC, 0xFC, 0x00, 0x1F,
  0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xBF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0x03, 0xFC, 0x00, 0x38,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x08, 0x0F, 0xF8, 0x07, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0x80, 0x0F, 0xF8, 0x3F, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0xF0, 0x1F, 0xC0, 0x00, 0x10, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x7C, 0x00, 0x1F, 0xFF, 0xBE, 0x00,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFF, 0x00, 0x01, 0xF8,
  0x3F, 0xC0, 0x00, 0xFC, 0x0F, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xFA, 0x0F, 0xEF,
  0xFF, 0x3F, 0xFC, 0xFF, 0xE3, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E,
  0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFB, 0xF0, 0x00, 0xFF, 0x1F, 0x80, 0x0F, 0xE1,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFB, 0xC0, 0x00, 0x03, 0xDF, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0xFB, 0xE0,
  0x00, 0x07, 0xDF, 0xF9, 0xF0, 0x00, 0x07, 0x9F, 0xF9, 0xF0, 0x00, 0x0F,
  0x9F, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0xF8, 0xF8, 0x00, 0x0F, 0x1F, 0xF8,
  0xF8, 0x00, 0x1F, 0x1F, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0xF8, 0x7C, 0x00,
  0x1E, 0x1F, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0xF8, 0x7C, 0x00, 0x3E, 0x1F,
  0xF8, 0x3E, 0x00, 0x3C, 0x1F, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0xF8, 0x3E,
  0x00, 0x7C, 0x1F, 0xF8, 0x1F, 0x00, 0x78, 0x1F, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0xF8, 0x07, 0xC1,
  0xE0, 0x1F, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0xF8, 0x03,
  0xE7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xF7,
  0xE0, 0x00, 0x7F, 0xE7, 0xC0, 0x00, 0xFF, 0xCF, 0xC0, 0x01, 0xFF, 0x8F,
  0x80, 0x03, 0xFF, 0x1F, 0x80, 0x07, 0xFE, 0x1F, 0x80, 0x0F, 0xFC, 0x3F,
  0x00, 0x1F, 0xF8, 0x3F, 0x00, 0x3F, 0xF0, 0x3E, 0x00, 0x7F, 0xE0, 0x7E,
  0x00, 0xFF, 0xC0, 0x7C, 0x01, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x00, 0xFC,
  0x07, 0xFE, 0x01, 0xF8, 0x0F, 0xFC, 0x01, 0xF8, 0x1F, 0xF8, 0x03, 0xF0,
  0x3F, 0xF0, 0x03, 0xF0, 0x7F, 0xE0, 0x03, 0xE0, 0xFF, 0xC0, 0x07, 0xE1,
  0xFF, 0x80, 0x07, 0xE3, 0xFF, 0x00, 0x0F, 0xC7, 0xFE, 0x00, 0x0F, 0xCF,
  0xFC, 0x00, 0x1F, 0x9F, 0xF8, 0x00, 0x1F, 0xBF, 0xF0, 0x00, 0x1F, 0x7F,
  0xE0, 0x00, 0x3F, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x0F,
  0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xE0, 0x0F, 0xF3, 0xF0,
  0x01, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x0F, 0xE7, 0xE0, 0x3F,
  0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x17, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F,
  0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xE0, 0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0xE1, 0xFE, 0x7F, 0x00, 0x1C, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0xC0, 0x00, 0xFE, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x68, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xF0,
  0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0xFC, 0x3E, 0x00,
  0x0F, 0x78, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0x83, 0xE0,
  0x01, 0xF7, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xF8, 0x1F,
  0x00, 0x1E, 0x3C, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x01,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0x3C, 0x1E, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0x0F, 0xC0, 0x78, 0x0F, 0x01, 0xF8, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x07, 0xE0, 0xF0, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x1F, 0x0F, 0x80, 0x03, 0xF1, 0xE0, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF,
  0x80, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xC0, 0x01, 0xE7, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80,
  0x07, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1F, 0x1F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x7C,
  0x07, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC1, 0xFE, 0x7F, 0xC1, 0xC0, 0x1F, 0x82, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x7F, 0xF0, 0x7D, 0xFC, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xEF, 0xFF, 0xF3, 0xDF, 0xFF, 0xE7, 0x9F, 0xFF, 0x0F, 0x0F, 0xFC, 0x1E,
  0x01, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x0F, 0x8F, 0xFE, 0x03, 0xE7, 0xFF, 0xC0, 0xFB, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x0F, 0xF8, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xCF, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF3, 0xF8, 0x00,
  0xFC, 0xFF, 0x00, 0x7E, 0x3F, 0xE0, 0x3F, 0x8F, 0x7F, 0xFF, 0xC3, 0xCF,
  0xFF, 0xE0, 0xF1, 0xFF, 0xF0, 0x3C, 0x1F, 0xF8, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xE0, 0x18, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x11, 0xFC, 0x03, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0x01, 0xF0, 0x1F, 0xF8, 0x7C, 0x1F, 0xFF, 0x9F, 0x0F, 0xFF,
  0xF7, 0xC7, 0xFF, 0xFD, 0xF3, 0xF8, 0x07, 0xFC, 0xFC, 0x00, 0xFF, 0x7E,
  0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0xFC, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0xC7, 0xF0, 0x1F, 0xF1, 0xFF,
  0xFF, 0x7C, 0x3F, 0xFF, 0x9F, 0x07, 0xFF, 0xC3, 0xC0, 0x7F, 0xE0, 0xF0,
  0x01, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0xFC, 0x07, 0xF0, 0xFC, 0x01,
  0xF8, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x41, 0xFE, 0x00, 0xE0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x03, 0xFD, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xE0, 0xF0, 0x7F, 0xFE, 0x7C, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF,
  0xF7, 0xC7, 0xE0, 0x1F, 0xF3, 0xF0, 0x03, 0xFC, 0xF8, 0x00, 0x7F, 0x7E,
  0x00, 0x1F, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFD,
  0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3, 0xE0, 0x01,
  0xFC, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x7F, 0xC7, 0xFF, 0xFD, 0xF0, 0xFF,
  0xFE, 0x7C, 0x1F, 0xFF, 0x1F, 0x01, 0xFF, 0x87, 0xC0, 0x07, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x8C, 0x00,
  0x0F, 0xC3, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x7F, 0xF0, 0xF9, 0xFF, 0xF8, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0xFF, 0x80, 0xFE, 0xFF, 0x00, 0x3E, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x79, 0xFF, 0xFF, 0xFD, 0xF1, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x01, 0xE0, 0x1F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x3F, 0x03, 0xE8, 0x7E, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0xFC,
  0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x7E, 0x00,
  0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0,
  0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x78, 0x7F, 0xF0, 0x1F, 0xFC, 0x3C, 0x7F, 0xFC,
  0x1F, 0xFF, 0x1E, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xF8, 0x03, 0xFE, 0x00, 0x7D, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0xF0, 0x7F, 0xF0, 0xF1, 0xFF, 0xF8, 0xF3, 0xFF,
  0xFC, 0xF7, 0xFF, 0xFE, 0xFF, 0x80, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x3C, 0x3F, 0xF8, 0x0F, 0x1F, 0xFF, 0x83, 0xCF, 0xFF, 0xF0,
  0xF7, 0xFF, 0xFC, 0x3F, 0xE0, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xCF,
  0xE0, 0x03, 0xF3, 0xFC, 0x01, 0xF8, 0xFF, 0x80, 0xFE, 0x3F, 0xFF, 0xFF,
  0x0F, 0xBF, 0xFF, 0x83, 0xE7, 0xFF, 0xC0, 0xF8, 0x7F, 0xE0, 0x3E, 0x01,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7F, 0xE0, 0xF0, 0x7F, 0xFE, 0x7C, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0xF7,
  0xC7, 0xE0, 0x1F, 0xF3, 0xF0, 0x03, 0xFC, 0xF8, 0x00, 0x7F, 0x7E, 0x00,
  0x1F, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFD, 0xF0,
  0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF3, 0xE0, 0x01, 0xFC,
  0xFC, 0x00, 0xFF, 0x1F, 0x80, 0x7F, 0xC7, 0xFF, 0xFD, 0xF0, 0xFF, 0xFE,
  0x7C, 0x1F, 0xFF, 0x1F, 0x01, 0xFF, 0x87, 0xC0, 0x06, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x3F, 0xBC, 0x3F, 0xDE,
  0x3F, 0xEF, 0x3F, 0xF7, 0xBF, 0x0B, 0xDE, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xC0, 0x0C, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xF0, 0x07, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0x3F, 0xFE, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x1F, 0xE7, 0xE0, 0x3F,
  0xF3, 0xFF, 0xFE, 0xF8, 0xFF, 0xFE, 0x7C, 0x3F, 0xFE, 0x3E, 0x0F, 0xFE,
  0x0F, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFD,
  0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00,
  0x1F, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x03,
  0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xEF, 0xC0, 0x07, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x7C, 0x00, 0x7F, 0x80, 0x1F, 0x1F, 0x00, 0x3D, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x78, 0x01, 0xF0, 0xF8, 0x03, 0xDF, 0x00, 0x7C, 0x3E,
  0x01, 0xF7, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0xF0, 0x0F, 0x83, 0xE0, 0x1E,
  0x3C, 0x03, 0xE0, 0x7C, 0x07, 0x8F, 0x80, 0xF8, 0x1F, 0x03, 0xE3, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0xF8, 0x1F, 0x01, 0xF0, 0x3C, 0x1E, 0x07, 0xC0,
  0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x3C, 0x3E, 0x00, 0xF8, 0x78, 0x0F, 0x0F, 0x80, 0x1F, 0x3E, 0x03,
  0xE3, 0xE0, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x01, 0xF3, 0xC0, 0x1E, 0x7C,
  0x00, 0x7C, 0xF0, 0x07, 0x9F, 0x00, 0x0F, 0x3C, 0x01, 0xF7, 0x80, 0x03,
  0xFF, 0x00, 0x7D, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE3,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F,
  0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xFC,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x07,
  0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xE0, 0x7C, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFB, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x3E,
  0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7B,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x5F, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xE8, 0x00, 0x7F, 0xE2, 0x00, 0x01, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Regular60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 44, 15, 4, -43 },
  { 40, 16, 16, 24, 4, -43 },
  { 72, 32, 43, 35, 1, -43 },
  { 244, 25, 49, 31, 3, -46 },
  { 398, 40, 44, 46, 3, -43 },
  { 618, 35, 45, 38, 3, -44 },
  { 815, 5, 16, 13, 4, -43 },
  { 825, 13, 52, 18, 3, -43 },
  { 910, 13, 52, 18, 2, -43 },
  { 995, 25, 25, 30, 2, -46 },
  { 1074, 26, 29, 31, 3, -36 },
  { 1169, 9, 15, 15, 2, -7 },
  { 1186, 14, 4, 18, 2, -18 },
  { 1193, 7, 8, 15, 4, -7 },
  { 1200, 21, 43, 22, 1, -43 },
  { 1313, 25, 45, 31, 3, -44 },
  { 1454, 15, 43, 31, 5, -43 },
  { 1535, 25, 43, 31, 3, -43 },
  { 1670, 25, 44, 31, 3, -43 },
  { 1808, 29, 43, 31, 1, -43 },
  { 1964, 25, 44, 31, 3, -43 },
  { 2102, 26, 44, 31, 3, -43 },
  { 2245, 27, 43, 31, 2, -43 },
  { 2391, 26, 44, 31, 3, -43 },
  { 2534, 25, 44, 31, 3, -43 },
  { 2672, 7, 34, 15, 4, -33 },
  { 2702, 9, 41, 15, 2, -33 },
  { 2749, 26, 29, 31, 3, -36 },
  { 2844, 25, 16, 31, 3, -29 },
  { 2894, 26, 29, 31, 3, -36 },
  { 2989, 21, 44, 23, 1, -43 },
  { 3105, 42, 48, 48, 3, -43 },
  { 3357, 34, 43, 34, 0, -43 },
  { 3540, 27, 43, 35, 5, -43 },
  { 3686, 29, 44, 34, 3, -43 },
  { 3846, 31, 43, 39, 5, -43 },
  { 4013, 22, 43, 30, 5, -43 },
  { 4132, 22, 43, 28, 5, -43 },
  { 4251, 33, 44, 40, 3, -43 },
  { 4433, 30, 43, 40, 5, -43 },
  { 4595, 15, 43, 19, 2, -43 },
  { 4676, 14, 54, 15, -4, -43 },
  { 4771, 28, 43, 33, 5, -43 },
  { 4922, 22, 43, 28, 5, -43 },
  { 5041, 40, 43, 50, 5, -43 },
  { 5256, 31, 43, 41, 5, -43 },
  { 5423, 35, 45, 42, 3, -44 },
  { 5620, 25, 43, 33, 5, -43 },
  { 5755, 35, 54, 42, 3, -44 },
  { 5992, 28, 43, 34, 5, -43 },
  { 6143, 24, 44, 30, 3, -43 },
  { 6275, 28, 43, 30, 1, -43 },
  { 6426, 29, 44, 39, 5, -43 },
  { 6586, 33, 43, 33, 0, -43 },
  { 6764, 50, 43, 51, 1, -43 },
  { 7033, 31, 43, 31, 0, -43 },
  { 7200, 30, 43, 30, 0, -43 },
  { 7362, 26, 43, 30, 2, -43 },
  { 7502, 13, 53, 19, 5, -43 },
  { 7589, 21, 43, 22, 1, -43 },
  { 7702, 13, 53, 19, 2, -43 },
  { 7789, 28, 26, 31, 2, -43 },
  { 7880, 27, 4, 26, 0, 5 },
  { 7894, 12, 10, 17, 2, -46 },
  { 7909, 23, 34, 30, 3, -33 },
  { 8007, 26, 47, 34, 5, -46 },
  { 8160, 21, 34, 26, 3, -33 },
  { 8250, 26, 47, 34, 3, -46 },
  { 8403, 25, 34, 31, 3, -33 },
  { 8510, 20, 46, 19, 1, -46 },
  { 8625, 26, 47, 34, 3, -33 },
  { 8778, 24, 46, 34, 5, -46 },
  { 8916, 6, 44, 14, 4, -44 },
  { 8949, 12, 58, 14, -2, -44 },
  { 9036, 24, 46, 29, 5, -46 },
  { 9174, 5, 46, 14, 5, -46 },
  { 9203, 41, 33, 51, 5, -33 },
  { 9373, 24, 33, 34, 5, -33 },
  { 9472, 27, 34, 33, 3, -33 },
  { 9587, 26, 47, 34, 5, -33 },
  { 9740, 26, 47, 34, 3, -33 },
  { 9893, 17, 33, 22, 5, -33 },
  { 9964, 20, 34, 26, 3, -33 },
  { 10049, 17, 41, 19, 1, -40 },
  { 10137, 25, 33, 34, 4, -32 },
  { 10241, 27, 32, 27, 0, -32 },
  { 10349, 42, 32, 43, 1, -32 },
  { 10517, 26, 32, 28, 1, -32 },
  { 10621, 27, 46, 28, 0, -32 },
  { 10777, 21, 32, 25, 2, -32 },
  { 10861, 18, 53, 22, 2, -43 },
  { 10981, 4, 60, 30, 13, -46 },
  { 11011, 18, 53, 22, 2, -43 },
  { 11131, 26, 8, 31, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_Regular60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular60pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR60PT7B_H_
