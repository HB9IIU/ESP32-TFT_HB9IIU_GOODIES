#ifndef _NOTOSANS_SEMICONDENSED_REGULAR42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xEF, 0x7B, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x38, 0x00, 0x03, 0xBF, 0xFF, 0xF8, 0x80, 0xF1, 0xFE, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xDC, 0x1B, 0x83,
  0x00, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38,
  0x01, 0xC0, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01,
  0xC1, 0xC1, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0x03, 0x83,
  0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xC0, 0xE0, 0x07, 0x07, 0x00,
  0x1C, 0x1C, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x18,
  0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xE0, 0x03, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0F, 0xFE, 0x07,
  0xFF, 0xE3, 0xFF, 0xF1, 0xE3, 0x0C, 0x70, 0xC0, 0x3C, 0x30, 0x0F, 0x0C,
  0x03, 0xC3, 0x00, 0xF0, 0xC0, 0x1E, 0x30, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0x3E, 0x00, 0xC7, 0x80,
  0x30, 0xF0, 0x0C, 0x3C, 0x03, 0x0F, 0x00, 0xC3, 0xE0, 0x31, 0xEF, 0x8D,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x0E, 0x03, 0xFC, 0x01, 0xC0,
  0x79, 0xC0, 0x1C, 0x07, 0x1E, 0x03, 0x80, 0xE0, 0xE0, 0x38, 0x0E, 0x0E,
  0x07, 0x00, 0xE0, 0xE0, 0x70, 0x0E, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0xE0,
  0x0E, 0x0E, 0x1C, 0x00, 0xE0, 0xE1, 0xC0, 0x0E, 0x0E, 0x38, 0x00, 0xE0,
  0xE3, 0x8F, 0xCE, 0x0E, 0x71, 0xFE, 0x71, 0xE7, 0x3D, 0xE7, 0xBC, 0xE3,
  0x87, 0x3F, 0xCE, 0x70, 0x71, 0xF9, 0xC7, 0x07, 0x00, 0x1C, 0x70, 0x70,
  0x03, 0xC7, 0x07, 0x00, 0x38, 0x70, 0x70, 0x07, 0x87, 0x07, 0x00, 0x70,
  0x70, 0x70, 0x07, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x70, 0x0E, 0x07, 0x07,
  0x01, 0xC0, 0x38, 0x70, 0x1C, 0x03, 0xDE, 0x03, 0x80, 0x1F, 0xE0, 0x78,
  0x00, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0x38, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xE0, 0x3C, 0x3E, 0xF8, 0x1E, 0x3E, 0x3E, 0x0F, 0x1E, 0x0F,
  0x87, 0x1E, 0x03, 0xC7, 0x8F, 0x00, 0xF3, 0xC7, 0x80, 0x3F, 0xC3, 0xC0,
  0x0F, 0xE1, 0xE0, 0x07, 0xE0, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xFC, 0x1F,
  0x03, 0xFF, 0x0F, 0xFF, 0xE7, 0xC3, 0xFF, 0xE1, 0xE0, 0x7F, 0xC0, 0x7C,
  0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x07, 0x83, 0x83, 0xC3, 0xC1, 0xE1,
  0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x70, 0x38, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1C,
  0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x38,
  0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x01,
  0xC0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x04, 0x0E, 0x0F,
  0xE7, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x01, 0xF8, 0x00, 0xEE,
  0x00, 0xE7, 0x80, 0xF1, 0xC0, 0xF8, 0xF0, 0x78, 0x3C, 0x0C, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x3D, 0xF7, 0x9E,
  0x79, 0xC7, 0x3C, 0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x77, 0xFF, 0xFF,
  0x10, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xF0, 0x7C, 0x3C, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x79, 0xC0, 0x0E,
  0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xE7, 0x00, 0x39, 0xE0, 0x1E,
  0x78, 0x07, 0x8E, 0x03, 0xC3, 0xC1, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFE, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xEE, 0xFB, 0xFE, 0x7B,
  0x8F, 0x21, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xE0, 0x7C, 0x60, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC0,
  0x7C, 0x40, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0xA0, 0x03, 0xEC, 0x01, 0xF3, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x77,
  0x00, 0x07, 0x70, 0x00, 0xF7, 0x00, 0x0E, 0x70, 0x01, 0xC7, 0x00, 0x3C,
  0x70, 0x03, 0x87, 0x00, 0x78, 0x70, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x1E,
  0x07, 0x01, 0xC0, 0x70, 0x38, 0x07, 0x03, 0x80, 0x70, 0x70, 0x07, 0x0F,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0xA0,
  0x03, 0xEE, 0x01, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC3, 0xE0, 0xF3, 0xFE, 0x3D, 0xFF, 0xCF, 0xE1, 0xF3, 0xF0, 0x1E, 0xF8,
  0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xF7, 0x00, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0x8F, 0x01, 0xE3, 0xE0, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF0, 0x3C,
  0x78, 0x07, 0x9C, 0x01, 0xE7, 0x00, 0x39, 0xC0, 0x1E, 0x70, 0x07, 0x9E,
  0x01, 0xE3, 0xC0, 0xF0, 0xF8, 0x78, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xF0, 0x3E, 0x3E, 0x0F, 0x07, 0xC7, 0x80, 0x7B, 0xC0, 0x1E,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xE7, 0x80, 0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x07,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0x78, 0x0F, 0x3C, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xF7, 0x80, 0xFD, 0xF0, 0x7F, 0x3F,
  0xFB, 0xC7, 0xFC, 0xE0, 0x7C, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x77, 0xFF, 0xFF, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xFF, 0xC4, 0x1C, 0x7C,
  0xF9, 0xF3, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF9, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xE1, 0xC7, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0xF1,
  0xFF, 0xF3, 0x81, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x03, 0xC0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x1C, 0x3C, 0x07, 0xF0, 0x38, 0xE0, 0x7F, 0xE0, 0xE7, 0x83, 0xFF, 0x83,
  0x9C, 0x1E, 0x0E, 0x0E, 0x70, 0x70, 0x38, 0x1D, 0xC1, 0xC0, 0xE0, 0x7E,
  0x0E, 0x03, 0x81, 0xF8, 0x38, 0x0E, 0x07, 0xE0, 0xE0, 0x38, 0x1F, 0x83,
  0x80, 0xE0, 0x7E, 0x0E, 0x03, 0x83, 0xB8, 0x38, 0x0E, 0x0E, 0xE0, 0xE0,
  0x78, 0x3B, 0x81, 0xC1, 0xE1, 0xC7, 0x07, 0x9D, 0xCF, 0x1C, 0x0F, 0xF3,
  0xF8, 0x70, 0x1F, 0x87, 0xC1, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x08, 0x00,
  0x7E, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0xE7, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80,
  0x03, 0xC3, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x81, 0xE0,
  0x07, 0x01, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x38,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x70, 0x0F, 0xCE, 0x00, 0x79, 0xC0, 0x0F, 0xB8,
  0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x7B, 0x80, 0x1E, 0x70,
  0x03, 0xCE, 0x01, 0xF1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0xE0,
  0x0F, 0x9C, 0x00, 0xFB, 0x80, 0x0F, 0x70, 0x01, 0xEE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0xFB, 0x80,
  0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFC, 0x06, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x20, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xC0, 0x7F, 0x0E, 0x00,
  0x7C, 0x70, 0x01, 0xF3, 0x80, 0x07, 0x9C, 0x00, 0x1E, 0xE0, 0x00, 0xF7,
  0x00, 0x07, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80, 0x07,
  0xDC, 0x00, 0x3C, 0xE0, 0x03, 0xE7, 0x00, 0x3E, 0x38, 0x0F, 0xE1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x01,
  0xE1, 0xF8, 0x00, 0x43, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x1E, 0x00,
  0x1E, 0x3E, 0x00, 0x3C, 0x3F, 0x00, 0x78, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE1, 0xFC, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x0F, 0x03, 0xC0, 0xF8, 0xFB, 0xFE, 0xFF, 0x3F, 0x00, 0xE0, 0x03, 0xFC,
  0x00, 0x7B, 0x80, 0x1E, 0x70, 0x07, 0x8E, 0x01, 0xE1, 0xC0, 0x3C, 0x38,
  0x0F, 0x07, 0x03, 0xC0, 0xE0, 0xF0, 0x1C, 0x1E, 0x03, 0x87, 0x80, 0x71,
  0xE0, 0x0E, 0x78, 0x01, 0xDF, 0x00, 0x3B, 0xF0, 0x07, 0xFE, 0x00, 0xF9,
  0xE0, 0x1E, 0x3C, 0x03, 0x83, 0xC0, 0x70, 0x7C, 0x0E, 0x07, 0x81, 0xC0,
  0x78, 0x38, 0x0F, 0x87, 0x00, 0xF0, 0xE0, 0x0F, 0x1C, 0x01, 0xF3, 0x80,
  0x1E, 0x70, 0x01, 0xEE, 0x00, 0x3D, 0xC0, 0x03, 0xC0, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xEE, 0x00, 0x0E, 0xFE, 0xF0, 0x00, 0xEF, 0xE7, 0x00,
  0x1C, 0xFE, 0x70, 0x01, 0xCF, 0xE7, 0x80, 0x1C, 0xFE, 0x38, 0x03, 0x8F,
  0xE3, 0x80, 0x38, 0xFE, 0x3C, 0x07, 0x8F, 0xE1, 0xC0, 0x70, 0xFE, 0x1C,
  0x07, 0x0F, 0xE1, 0xE0, 0xF0, 0xFE, 0x0E, 0x0E, 0x0F, 0xE0, 0xE0, 0xE0,
  0xFE, 0x0F, 0x1E, 0x0F, 0xE0, 0x71, 0xC0, 0xFE, 0x07, 0x1C, 0x0F, 0xE0,
  0x7B, 0xC0, 0xFE, 0x03, 0xB8, 0x0F, 0xE0, 0x3B, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0x00, 0xFE, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0x00, 0xFE,
  0x00, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xBC, 0x00, 0xFD, 0xE0, 0x07,
  0xE7, 0x80, 0x3F, 0x3C, 0x01, 0xF8, 0xF0, 0x0F, 0xC3, 0xC0, 0x7E, 0x1E,
  0x03, 0xF0, 0x78, 0x1F, 0x83, 0xC0, 0xFC, 0x0F, 0x07, 0xE0, 0x78, 0x3F,
  0x01, 0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x3C, 0x7E, 0x00, 0xF3, 0xF0, 0x07,
  0x9F, 0x80, 0x1E, 0xFC, 0x00, 0xF7, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0x81, 0xF0,
  0x03, 0xC1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x3F, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9C, 0x0F, 0xEE, 0x00, 0xF7, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7B, 0x80, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xF0, 0x1F,
  0x81, 0xF0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x3F,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0xFF, 0xE0, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x70, 0x3F, 0x8E, 0x00, 0xF1, 0xC0, 0x0F, 0x38, 0x01,
  0xE7, 0x00, 0x3C, 0xE0, 0x07, 0x9C, 0x00, 0xF3, 0x80, 0x1E, 0x70, 0x03,
  0xCE, 0x00, 0xF1, 0xC0, 0x3E, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0xC1, 0xC0, 0x78,
  0x38, 0x07, 0x87, 0x00, 0xF0, 0xE0, 0x0F, 0x1C, 0x01, 0xF3, 0x80, 0x1E,
  0x70, 0x03, 0xEE, 0x00, 0x3D, 0xC0, 0x03, 0xC0, 0x07, 0xFE, 0x0F, 0xFF,
  0xCF, 0xFF, 0xCF, 0x80, 0xE7, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x07, 0xB8, 0x07, 0xDF, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xB8, 0x00,
  0x3D, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x8F,
  0x80, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0xF0,
  0x3C, 0x01, 0xE0, 0x78, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x01, 0xC0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0x39,
  0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0x00, 0x3D, 0xE0, 0x07,
  0xC0, 0x07, 0xBC, 0x00, 0xFC, 0x00, 0xF7, 0x80, 0x1F, 0x80, 0x1C, 0x70,
  0x03, 0xF0, 0x07, 0x8F, 0x00, 0xFE, 0x00, 0xF1, 0xE0, 0x1D, 0xE0, 0x1E,
  0x3C, 0x03, 0x9C, 0x03, 0x83, 0x80, 0x73, 0x80, 0xF0, 0x78, 0x1E, 0x70,
  0x1E, 0x0F, 0x03, 0x8F, 0x03, 0xC1, 0xE0, 0x70, 0xE0, 0x70, 0x1C, 0x1E,
  0x1C, 0x1E, 0x03, 0xC3, 0xC3, 0x83, 0xC0, 0x78, 0x70, 0x78, 0x78, 0x0F,
  0x0E, 0x07, 0x0E, 0x00, 0xE3, 0xC0, 0xE1, 0xC0, 0x1E, 0x78, 0x1E, 0x78,
  0x03, 0xCE, 0x03, 0xCF, 0x00, 0x79, 0xC0, 0x39, 0xC0, 0x07, 0x78, 0x07,
  0x38, 0x00, 0xEF, 0x00, 0xEF, 0x00, 0x1D, 0xC0, 0x1F, 0xE0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x78,
  0x1E, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x38, 0x01, 0xE1, 0xE0, 0x03,
  0x87, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1D, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0x87, 0x00, 0x1E,
  0x1E, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xE0, 0x78, 0x07,
  0x83, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0x7B, 0xC0, 0x01, 0xF0,
  0xF0, 0x00, 0x7B, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0xC0,
  0x1E, 0x0E, 0x00, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x07, 0x80,
  0x78, 0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x3D, 0xE0, 0x01, 0xEF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0xFF, 0xFF, 0xF8, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3B, 0xC0, 0x03,
  0x9C, 0x00, 0x71, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xF0, 0x0E, 0x07, 0x01,
  0xC0, 0x78, 0x1C, 0x03, 0x83, 0x80, 0x3C, 0x38, 0x01, 0xC7, 0x80, 0x1E,
  0x70, 0x00, 0xEF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x78,
  0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x1C,
  0x1E, 0x10, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x3F, 0x0F, 0xFF, 0x3F, 0xFF, 0x7E, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0x7F, 0xF7, 0x7F,
  0xE7, 0x1F, 0xC7, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x7E, 0x0F, 0x3F, 0xE3, 0xDF, 0xFC, 0xFE, 0x1F, 0x3F, 0x01, 0xEF, 0x80,
  0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1E, 0xFC, 0x0F, 0xBF, 0xFF, 0xCE, 0x7F,
  0xE3, 0x8F, 0xF0, 0x01, 0xF8, 0x1F, 0xFC, 0x7F, 0xF1, 0xF8, 0x63, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xF0, 0x11, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0xF8, 0x70, 0xFF, 0x9C,
  0x7F, 0xF7, 0x3E, 0x1F, 0xDF, 0x01, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x80, 0x3D,
  0xE0, 0x1F, 0x3C, 0x0F, 0xCF, 0xFF, 0x71, 0xFF, 0x9C, 0x1F, 0xC7, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xE3, 0xC0, 0xF3, 0xC0, 0x3D,
  0xC0, 0x1E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x31, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xF8,
  0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7F, 0xCF, 0xFF, 0x3F, 0xFC, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xE1, 0xC3, 0xFE,
  0x71, 0xFF, 0xDC, 0xF8, 0x7F, 0x7C, 0x07, 0xDE, 0x00, 0xF7, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0x70, 0x03, 0xDE, 0x00,
  0xF7, 0x80, 0x7C, 0xF0, 0x3F, 0x3F, 0xFD, 0xC7, 0xFE, 0x70, 0x7F, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x40,
  0x07, 0x8E, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0xFC, 0x3C, 0xFF, 0x9E, 0xFF,
  0xEF, 0xE1, 0xF7, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x6F, 0xFF, 0x60, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0x03, 0xC1, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7B, 0xFD, 0xFC, 0xFC, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xFC, 0x03, 0xDE, 0x03, 0xCF,
  0x03, 0xC7, 0x83, 0xC3, 0xC3, 0xC1, 0xE1, 0xC0, 0xF1, 0xE0, 0x79, 0xE0,
  0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xE7, 0x81, 0xE1,
  0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1F, 0x1E, 0x07, 0x8F, 0x01, 0xE7,
  0x80, 0xF3, 0xC0, 0x3D, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8,
  0x0F, 0x87, 0x3F, 0xE1, 0xFF, 0x39, 0xFF, 0x9F, 0xFD, 0xFC, 0x3F, 0xE1,
  0xEF, 0x80, 0xFC, 0x07, 0xFC, 0x03, 0xC0, 0x3F, 0xC0, 0x1E, 0x00, 0xFE,
  0x00, 0xF0, 0x07, 0xF0, 0x07, 0x80, 0x3F, 0x80, 0x3C, 0x01, 0xFC, 0x01,
  0xE0, 0x0F, 0xE0, 0x0F, 0x00, 0x7F, 0x00, 0x78, 0x03, 0xF8, 0x03, 0xC0,
  0x1F, 0xC0, 0x1E, 0x00, 0xFE, 0x00, 0xF0, 0x07, 0xF0, 0x07, 0x80, 0x3F,
  0x80, 0x3C, 0x01, 0xFC, 0x01, 0xE0, 0x0F, 0xE0, 0x0F, 0x00, 0x7F, 0x00,
  0x78, 0x03, 0xF8, 0x03, 0xC0, 0x1F, 0xC0, 0x1E, 0x00, 0xE0, 0xE0, 0xF8,
  0x71, 0xFF, 0x39, 0xFF, 0xDF, 0xC3, 0xEF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0E, 0x03,
  0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC3, 0xC0, 0x78, 0xF0,
  0x07, 0x9E, 0x00, 0xF3, 0x80, 0x0E, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0x70, 0x01, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x1E, 0x07, 0xC1, 0xFF,
  0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0xE1, 0xF8, 0x38, 0xFF, 0x8F, 0x7F,
  0xF3, 0xF8, 0x7E, 0xFC, 0x07, 0xBE, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7B, 0xF0, 0x3E, 0xFF, 0xFF, 0x3D, 0xFF, 0x8F, 0x3F, 0xC3, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE1, 0xC3,
  0xFE, 0x71, 0xFF, 0xDC, 0xF8, 0x7F, 0x7C, 0x07, 0xDE, 0x00, 0xF7, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0x70, 0x03, 0xDE,
  0x00, 0xF7, 0x80, 0x7C, 0xF0, 0x3F, 0x3F, 0xFD, 0xC7, 0xFE, 0x70, 0x7F,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0xFE, 0x3F, 0xE7, 0xFE, 0xFB, 0xFE, 0x0F, 0xC0, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0xE0, 0xFF, 0xF7, 0xFF, 0xFE, 0x0E, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xF0, 0x0F, 0xFF, 0xFB,
  0xFF, 0xC7, 0xFE, 0x00, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xFF, 0x0F, 0xF0, 0x7F, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x03, 0xEF, 0x03, 0xF7, 0xFF, 0xB9, 0xFF, 0x9C, 0x7F, 0x8E, 0xF0,
  0x01, 0xFE, 0x00, 0x3D, 0xC0, 0x07, 0xBC, 0x01, 0xE7, 0x80, 0x3C, 0x70,
  0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x1C, 0x07, 0x83, 0xC0, 0xE0, 0x78,
  0x3C, 0x07, 0x07, 0x80, 0xF0, 0xE0, 0x1E, 0x3C, 0x01, 0xC7, 0x00, 0x3C,
  0xE0, 0x07, 0xBC, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0x3D, 0xC0, 0x1E,
  0x00, 0xF7, 0x80, 0x7C, 0x03, 0x9E, 0x03, 0xF0, 0x1E, 0x78, 0x0F, 0xC0,
  0x78, 0xE0, 0x3F, 0x01, 0xE3, 0xC1, 0xEE, 0x07, 0x0F, 0x07, 0x38, 0x3C,
  0x3C, 0x1C, 0xE0, 0xF0, 0x70, 0x73, 0xC3, 0x81, 0xE3, 0xC7, 0x0E, 0x07,
  0x8E, 0x1C, 0x78, 0x1E, 0x38, 0x71, 0xE0, 0x38, 0xE1, 0xE7, 0x00, 0xE7,
  0x83, 0x9C, 0x03, 0xDC, 0x0E, 0x70, 0x0F, 0x70, 0x3B, 0xC0, 0x1D, 0xC0,
  0xFE, 0x00, 0x76, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F,
  0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xDE,
  0x01, 0xE7, 0x80, 0x78, 0xF0, 0x3C, 0x1C, 0x1E, 0x07, 0x87, 0x80, 0xF3,
  0xC0, 0x3C, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3C, 0xF0, 0x0F, 0x3C, 0x07,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x78, 0x07, 0x9E, 0x01, 0xEF, 0x00,
  0x3C, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xE7, 0x80,
  0x3C, 0x78, 0x07, 0x8F, 0x00, 0xE0, 0xE0, 0x3C, 0x1E, 0x07, 0x83, 0xC0,
  0xE0, 0x38, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xE0, 0x0E, 0x3C, 0x01, 0xC7,
  0x80, 0x3C, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x80, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x0F, 0xC0, 0xFE, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x07, 0xE0, 0x3E, 0x01, 0xFC,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x80,
  0x7E, 0x01, 0xF0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x07, 0xE0,
  0x3F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1E, 0x03, 0xF0, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x01, 0xF8, 0x3F, 0x81, 0xF8, 0x0E, 0x00, 0x00, 0x08, 0x00,
  0x5F, 0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xA0, 0x07, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Regular42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 31, 11, 3, -30 },
  { 21, 11, 11, 17, 3, -30 },
  { 37, 22, 30, 24, 1, -30 },
  { 120, 18, 34, 22, 2, -32 },
  { 197, 28, 30, 32, 2, -30 },
  { 302, 25, 30, 27, 2, -30 },
  { 396, 4, 11, 9, 3, -30 },
  { 402, 9, 37, 12, 2, -30 },
  { 444, 10, 37, 12, 1, -30 },
  { 491, 17, 17, 21, 2, -32 },
  { 528, 18, 20, 22, 2, -25 },
  { 573, 6, 10, 11, 2, -5 },
  { 581, 10, 3, 13, 1, -13 },
  { 585, 5, 6, 11, 3, -5 },
  { 589, 14, 30, 16, 1, -30 },
  { 642, 18, 30, 22, 2, -30 },
  { 710, 11, 30, 22, 3, -30 },
  { 752, 18, 30, 22, 2, -30 },
  { 820, 18, 30, 22, 2, -30 },
  { 888, 20, 30, 22, 1, -30 },
  { 963, 18, 30, 22, 2, -30 },
  { 1031, 18, 30, 22, 2, -30 },
  { 1099, 18, 30, 22, 2, -30 },
  { 1167, 18, 30, 22, 2, -30 },
  { 1235, 18, 30, 22, 2, -30 },
  { 1303, 5, 24, 11, 3, -23 },
  { 1318, 7, 28, 11, 1, -23 },
  { 1343, 18, 20, 22, 2, -25 },
  { 1388, 18, 12, 22, 2, -21 },
  { 1415, 18, 20, 22, 2, -25 },
  { 1460, 15, 31, 16, 0, -30 },
  { 1519, 30, 34, 34, 2, -30 },
  { 1647, 24, 30, 24, 0, -30 },
  { 1737, 19, 30, 25, 4, -30 },
  { 1809, 20, 30, 24, 2, -30 },
  { 1884, 21, 30, 27, 4, -30 },
  { 1963, 15, 30, 21, 4, -30 },
  { 2020, 15, 30, 20, 4, -30 },
  { 2077, 23, 30, 28, 2, -30 },
  { 2164, 20, 30, 28, 4, -30 },
  { 2239, 10, 30, 13, 2, -30 },
  { 2277, 10, 38, 11, -3, -30 },
  { 2325, 19, 30, 23, 4, -30 },
  { 2397, 15, 30, 20, 4, -30 },
  { 2454, 28, 30, 35, 4, -30 },
  { 2559, 21, 30, 29, 4, -30 },
  { 2638, 25, 30, 29, 2, -30 },
  { 2732, 17, 30, 23, 4, -30 },
  { 2796, 25, 37, 29, 2, -30 },
  { 2912, 19, 30, 24, 4, -30 },
  { 2984, 17, 30, 21, 2, -30 },
  { 3048, 20, 30, 21, 0, -30 },
  { 3123, 21, 30, 27, 3, -30 },
  { 3202, 23, 30, 23, 0, -30 },
  { 3289, 35, 30, 36, 0, -30 },
  { 3421, 22, 30, 22, 0, -30 },
  { 3504, 21, 30, 21, 0, -30 },
  { 3583, 18, 30, 21, 1, -30 },
  { 3651, 9, 37, 14, 3, -30 },
  { 3693, 14, 30, 16, 1, -30 },
  { 3746, 9, 37, 14, 1, -30 },
  { 3788, 20, 18, 22, 1, -30 },
  { 3833, 19, 2, 19, 0, 4 },
  { 3838, 8, 7, 12, 2, -32 },
  { 3845, 16, 23, 21, 2, -23 },
  { 3891, 18, 32, 23, 3, -32 },
  { 3963, 15, 23, 18, 2, -23 },
  { 4007, 18, 32, 23, 2, -32 },
  { 4079, 17, 23, 21, 2, -23 },
  { 4128, 14, 32, 13, 1, -32 },
  { 4184, 18, 33, 23, 2, -23 },
  { 4259, 17, 32, 23, 3, -32 },
  { 4327, 4, 31, 10, 3, -31 },
  { 4343, 9, 41, 10, -2, -31 },
  { 4390, 17, 32, 20, 3, -32 },
  { 4458, 4, 32, 10, 3, -32 },
  { 4474, 29, 23, 35, 3, -23 },
  { 4558, 17, 23, 23, 3, -23 },
  { 4607, 19, 23, 23, 2, -23 },
  { 4662, 18, 33, 23, 3, -23 },
  { 4737, 18, 33, 23, 2, -23 },
  { 4812, 12, 23, 16, 3, -23 },
  { 4847, 14, 23, 18, 2, -23 },
  { 4888, 12, 28, 14, 1, -28 },
  { 4930, 17, 23, 23, 3, -23 },
  { 4979, 19, 23, 19, 0, -23 },
  { 5034, 30, 23, 30, 0, -23 },
  { 5121, 18, 23, 20, 1, -23 },
  { 5173, 19, 33, 19, 0, -23 },
  { 5252, 15, 23, 17, 1, -23 },
  { 5296, 13, 37, 16, 1, -30 },
  { 5357, 3, 42, 21, 9, -32 },
  { 5373, 13, 37, 16, 1, -30 },
  { 5434, 18, 6, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_Regular42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR42PT7B_H_
