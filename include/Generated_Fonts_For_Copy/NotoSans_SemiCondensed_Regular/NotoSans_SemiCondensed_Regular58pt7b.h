#ifndef _NOTOSANS_SEMICONDENSED_REGULAR58PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x38, 0x70,
  0xE1, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE7, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7C, 0x70, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xF7, 0x01, 0xEE, 0x03, 0x9C, 0x07, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80,
  0x38, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x3F, 0xBC, 0xFC, 0x7E, 0x3C, 0x0C, 0x7C, 0x3C, 0x00, 0xF8, 0x3C,
  0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C,
  0x00, 0x7C, 0x3C, 0x00, 0x7E, 0x3C, 0x00, 0x7F, 0xBC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3D, 0xFE, 0x00, 0x3C, 0x7F, 0x00, 0x3C,
  0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x3C,
  0x1F, 0x00, 0x3C, 0x1F, 0x80, 0x3C, 0x3F, 0xE0, 0x3C, 0x7E, 0xFE, 0x3F,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x3C, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x03, 0xFF, 0xC0,
  0x01, 0xE0, 0x07, 0x87, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x1E,
  0x01, 0xF0, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x0F, 0x80,
  0x07, 0x80, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x03,
  0xC0, 0xF0, 0x00, 0x3C, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x0F, 0x07, 0x80,
  0x00, 0xF0, 0x1E, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x3C, 0x3F, 0xC3, 0xC0,
  0x78, 0x78, 0xFF, 0xC7, 0x80, 0xF1, 0xE3, 0xFF, 0xC7, 0x83, 0xC3, 0xC7,
  0xCF, 0x8F, 0x87, 0x8F, 0x1F, 0x0F, 0x8F, 0xFF, 0x1E, 0x3C, 0x0F, 0x1F,
  0xFC, 0x78, 0x78, 0x1E, 0x1F, 0xF0, 0xF0, 0xF0, 0x3E, 0x0F, 0x83, 0xC3,
  0xE0, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0xF0,
  0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x00, 0xF8, 0x3C, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x1E,
  0x00, 0x3E, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0xF8, 0x01, 0xF0,
  0x07, 0x81, 0xE0, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0xF0,
  0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x01, 0xF0, 0xFE, 0x7F, 0x00, 0xF8, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F,
  0x81, 0xF8, 0x0F, 0x8F, 0xC0, 0x3F, 0x03, 0xE3, 0xE0, 0x07, 0xE1, 0xF0,
  0xF8, 0x00, 0xFC, 0x7C, 0x3E, 0x00, 0x1F, 0xBE, 0x0F, 0x80, 0x07, 0xFF,
  0x83, 0xE0, 0x00, 0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0xF0, 0x3E, 0x00, 0x03,
  0xF8, 0x0F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0xFE, 0x00,
  0x7F, 0xF8, 0x1F, 0xC0, 0x7F, 0xBF, 0x03, 0xFF, 0xFF, 0xCF, 0xE0, 0xFF,
  0xFF, 0xE1, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xE0, 0x07, 0xF0,
  0x03, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBD, 0xE7,
  0x39, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x3C, 0x03,
  0x7C, 0x3C, 0x3F, 0x7F, 0xDD, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF7, 0x80,
  0x01, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC1, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x03, 0x80, 0xC0, 0x00, 0x80, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x0F, 0xC7, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8,
  0x7C, 0x3C, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0x83, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0x18, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xE7, 0xF8, 0x1F,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC1, 0xFF,
  0x0F, 0xFC, 0x7E, 0xF3, 0xF3, 0xDF, 0x9F, 0xFC, 0x7F, 0xE1, 0xF7, 0x07,
  0xC8, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFE, 0x7F, 0xC1, 0xF0, 0x07, 0xF0,
  0xE0, 0x01, 0xF8, 0x20, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFC, 0x7F, 0xC1, 0xE0, 0x07, 0xF0,
  0xE0, 0x00, 0xF8, 0x20, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xEC, 0x00, 0x07,
  0xF7, 0xC0, 0x0F, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01,
  0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x78, 0x3E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x03, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x3E, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x10,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0xC0, 0x00, 0xFC, 0xF8,
  0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xC0, 0xC0, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x7C, 0x7F,
  0xF8, 0x3E, 0x7F, 0xFE, 0x1F, 0x7F, 0xFF, 0x8F, 0xFC, 0x1F, 0xC7, 0xF8,
  0x03, 0xF3, 0xF8, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC1, 0xF0, 0x07,
  0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xF8,
  0x1F, 0xC1, 0xF8, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7E, 0x01, 0xF8,
  0x1F, 0x81, 0xF8, 0x07, 0xF3, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x8F,
  0xF0, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x1F, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0xC0, 0x03, 0xF3, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xC7, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x01, 0xFF, 0x3F, 0xEF, 0xFF, 0x1F, 0xFF,
  0xDF, 0x0F, 0xFF, 0x9F, 0x07, 0xFE, 0x1F, 0x00, 0x70, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x30, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xF7, 0xFF, 0xFF,
  0xFF, 0xBE, 0x30, 0x0E, 0x1F, 0x8F, 0xC7, 0xF3, 0xF9, 0xFC, 0xFC, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x87, 0xC7, 0xE3, 0xF1,
  0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0x3F, 0xE7, 0x00, 0x7E, 0x40, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0x07, 0xFF, 0x01, 0xE1, 0xF0, 0x07, 0xFF,
  0xC0, 0x78, 0xF0, 0x0F, 0xFF, 0xE0, 0x3C, 0x78, 0x0F, 0xE1, 0xF0, 0x1E,
  0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x3C, 0x07, 0xC0, 0x3C, 0x03, 0xDE, 0x03,
  0xC0, 0x1E, 0x01, 0xEF, 0x03, 0xE0, 0x0F, 0x00, 0xFF, 0x81, 0xF0, 0x07,
  0x80, 0x7F, 0x80, 0xF0, 0x03, 0xC0, 0x3F, 0xC0, 0x78, 0x01, 0xE0, 0x1F,
  0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0x00, 0xF8, 0x07, 0xF8, 0x0F,
  0x00, 0x7C, 0x07, 0xBC, 0x07, 0x80, 0x3E, 0x03, 0xDE, 0x03, 0xC0, 0x1F,
  0x01, 0xEF, 0x01, 0xE0, 0x0F, 0x80, 0xF7, 0x80, 0xF8, 0x0F, 0xC0, 0xF3,
  0xE0, 0x3C, 0x07, 0xE0, 0x78, 0xF0, 0x1F, 0x87, 0x78, 0x78, 0x78, 0x07,
  0xFF, 0x9F, 0xFC, 0x3C, 0x03, 0xFF, 0x8F, 0xFC, 0x1F, 0x00, 0x7F, 0x83,
  0xFC, 0x07, 0x80, 0x06, 0x00, 0x30, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xF8, 0x00,
  0xFF, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0xFC, 0xF8, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x8F, 0x80, 0x07, 0xF3,
  0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFB, 0xE0, 0x00, 0xFE, 0xF8, 0x01, 0xFF, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x1E, 0x0F, 0xE0, 0x00, 0x20,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x20, 0x7F, 0xC0, 0x1E,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xF8, 0x01, 0xFF,
  0x03, 0xE0, 0x00, 0xFE, 0x0F, 0x80, 0x01, 0xFC, 0x3E, 0x00, 0x03, 0xF8,
  0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x3E,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x3F, 0x0F, 0x80, 0x03, 0xF8, 0x3E, 0x00, 0x3F, 0xE0, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0x80, 0x07, 0x81, 0xFC, 0x00, 0x02, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x7C, 0x7F, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0x01, 0xF0,
  0x7F, 0x00, 0x03, 0xE0, 0x7F, 0xC0, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x7F, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0xBB, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x8F,
  0x80, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0xC0, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xEF,
  0xE0, 0x00, 0x7D, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xCF, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x01,
  0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x8F,
  0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x7E, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xEF, 0xFF, 0xE0, 0x00, 0x07, 0xDF, 0xFB, 0xE0, 0x00, 0x0F,
  0xBF, 0xF7, 0xC0, 0x00, 0x1E, 0x7F, 0xEF, 0x80, 0x00, 0x7C, 0xFF, 0xCF,
  0x80, 0x00, 0xF9, 0xFF, 0x9F, 0x00, 0x01, 0xE3, 0xFF, 0x1E, 0x00, 0x07,
  0xC7, 0xFE, 0x3E, 0x00, 0x0F, 0x0F, 0xFC, 0x7C, 0x00, 0x1E, 0x1F, 0xF8,
  0x78, 0x00, 0x7C, 0x3F, 0xF0, 0xF8, 0x00, 0xF0, 0x7F, 0xE1, 0xF0, 0x01,
  0xE0, 0xFF, 0xC1, 0xE0, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0x0F, 0x03, 0xFF,
  0x07, 0xC0, 0x3E, 0x07, 0xFE, 0x07, 0x80, 0x7C, 0x0F, 0xFC, 0x0F, 0x80,
  0xF0, 0x1F, 0xF8, 0x1F, 0x03, 0xE0, 0x3F, 0xF0, 0x1E, 0x07, 0xC0, 0x7F,
  0xE0, 0x3E, 0x0F, 0x00, 0xFF, 0xC0, 0x7C, 0x3E, 0x01, 0xFF, 0x80, 0x78,
  0x7C, 0x03, 0xFF, 0x00, 0xF8, 0xF0, 0x07, 0xFE, 0x01, 0xF3, 0xE0, 0x0F,
  0xFC, 0x01, 0xE7, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x78, 0x00,
  0x3E, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFD, 0xF8, 0x00, 0x1F, 0xFB, 0xE0, 0x00, 0x7F, 0xEF,
  0xC0, 0x01, 0xFF, 0x9F, 0x00, 0x07, 0xFE, 0x7E, 0x00, 0x1F, 0xF8, 0xF8,
  0x00, 0x7F, 0xE3, 0xF0, 0x01, 0xFF, 0x87, 0xE0, 0x07, 0xFE, 0x0F, 0x80,
  0x1F, 0xF8, 0x3F, 0x00, 0x7F, 0xE0, 0x7C, 0x01, 0xFF, 0x81, 0xF8, 0x07,
  0xFE, 0x03, 0xE0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x1F, 0x81, 0xFF,
  0x80, 0x7E, 0x07, 0xFE, 0x00, 0xFC, 0x1F, 0xF8, 0x01, 0xF0, 0x7F, 0xE0,
  0x07, 0xE1, 0xFF, 0x80, 0x0F, 0x87, 0xFE, 0x00, 0x3F, 0x1F, 0xF8, 0x00,
  0x7C, 0x7F, 0xE0, 0x01, 0xF9, 0xFF, 0x80, 0x03, 0xF7, 0xFE, 0x00, 0x07,
  0xDF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xF8, 0x03, 0xFC, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFE, 0xF8,
  0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xBF, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0x80, 0x3F, 0xC1, 0xF0, 0x01, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x01,
  0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0,
  0x07, 0xF0, 0x7C, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x01,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x8F,
  0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7E, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xE0, 0x07, 0x1F, 0x80,
  0x02, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x7F, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x05, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x7C, 0x00,
  0x1F, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1E, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x1E, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x3E, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x78, 0x00, 0xF8, 0x1F, 0x00,
  0x3C, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x3C, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xF0, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x1E, 0x03, 0xE0, 0x07, 0xC0,
  0xF0, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x07, 0xC1,
  0xF0, 0x0F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x0F, 0x07, 0xC0, 0x03, 0xE1,
  0xE0, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x03, 0xE3,
  0xE0, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x01, 0xE3,
  0xC0, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x01, 0xF7,
  0xC0, 0x03, 0xCF, 0x00, 0x01, 0xF7, 0xC0, 0x03, 0xDF, 0x00, 0x00, 0xF7,
  0x80, 0x03, 0xDF, 0x00, 0x00, 0xF7, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xF7,
  0x80, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3F,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0,
  0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0xFC, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0,
  0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x81, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x03, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFE, 0x7F, 0xC1, 0xC0, 0x1F,
  0x81, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xC0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0x80, 0x7C, 0xFC,
  0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x03,
  0xFB, 0xF0, 0x0F, 0xF3, 0xFD, 0xFD, 0xE7, 0xFF, 0xF3, 0xC7, 0xFF, 0xC7,
  0x83, 0xFE, 0x0F, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x07, 0x87,
  0xFE, 0x03, 0xC7, 0xFF, 0xC1, 0xE7, 0xFF, 0xF0, 0xF7, 0xFF, 0xFC, 0x7F,
  0x80, 0x7E, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xE7,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF, 0xC0,
  0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xF8, 0x01, 0xF9, 0xFE, 0x01, 0xF8, 0xF7,
  0xFF, 0xF8, 0x79, 0xFF, 0xFC, 0x3C, 0x7F, 0xF8, 0x1C, 0x1F, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE1, 0xF8, 0x06, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x03, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x0A, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x03, 0x80, 0xF8, 0x1F, 0xF8, 0x7C, 0x1F, 0xFF,
  0x3E, 0x1F, 0xFF, 0xDF, 0x1F, 0xFF, 0xFF, 0x9F, 0xC0, 0x7F, 0xCF, 0xC0,
  0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xF0, 0x01,
  0xFC, 0xFC, 0x00, 0xFE, 0x7F, 0x01, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xF3, 0xC1, 0xFF, 0xF1, 0xE0, 0x7F, 0xE0, 0xF0, 0x01, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xE7, 0xF8, 0x1F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x02, 0x1F, 0xC0, 0x1E, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x04, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0x3E, 0x04, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xFF, 0x83, 0xC1, 0xFF, 0xF1, 0xE1, 0xFF, 0xFD, 0xF1,
  0xFF, 0xFF, 0xF9, 0xFC, 0x07, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0x7F,
  0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xCF, 0xC0, 0x0F, 0xE7,
  0xF0, 0x1F, 0xF1, 0xFF, 0xFE, 0xF8, 0x7F, 0xFF, 0x7C, 0x1F, 0xFF, 0x3E,
  0x07, 0xFE, 0x1F, 0x00, 0x10, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x40, 0x00, 0x7E, 0x38, 0x00, 0x7E, 0x1F, 0xC1, 0xFF, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0,
  0x1E, 0x1F, 0xFC, 0x3C, 0x7F, 0xFC, 0x79, 0xFF, 0xFC, 0xF7, 0xFF, 0xFD,
  0xFE, 0x01, 0xFB, 0xF8, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xF0, 0x31, 0xEF, 0xFF, 0xFD, 0xE3, 0x00,
  0x00, 0x00, 0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x80, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1E,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x8F, 0xEF, 0xFC,
  0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xBC, 0x00, 0x7E,
  0x78, 0x01, 0xF8, 0xF0, 0x07, 0xE1, 0xE0, 0x0F, 0x83, 0xC0, 0x3E, 0x07,
  0x80, 0xF8, 0x0F, 0x03, 0xF0, 0x1E, 0x0F, 0xC0, 0x3C, 0x3F, 0x00, 0x78,
  0x7C, 0x00, 0xF1, 0xF0, 0x01, 0xE7, 0xC0, 0x03, 0xDF, 0xC0, 0x07, 0xBF,
  0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3F,
  0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x7E, 0x03, 0xC0, 0x7E, 0x07, 0x80, 0x7C,
  0x0F, 0x00, 0xFC, 0x1E, 0x00, 0xFC, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF8,
  0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xF3, 0xC0, 0x03, 0xF7, 0x80, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0xF3, 0xFF, 0xE0, 0xFF,
  0xF8, 0xF3, 0xFF, 0xF1, 0xFF, 0xFC, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF,
  0x01, 0xFF, 0x80, 0xFE, 0xFE, 0x00, 0xFF, 0x00, 0x7E, 0xFC, 0x00, 0xFE,
  0x00, 0x3E, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0x00, 0x3E,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x1F, 0x01, 0xE1, 0xFF, 0xC3, 0xC7, 0xFF, 0xC7, 0x9F,
  0xFF, 0xCF, 0x7F, 0xFF, 0xDF, 0xE0, 0x1F, 0xBF, 0x80, 0x1F, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x00, 0x0C,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xF0,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x7F, 0xE0, 0x3C, 0x7F, 0xFC, 0x1E, 0x7F, 0xFF, 0x0F, 0x7F,
  0xFF, 0xC7, 0xF8, 0x07, 0xE3, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0x7C, 0xFC,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0xE0,
  0x1F, 0x8F, 0x7F, 0xFF, 0x87, 0x9F, 0xFF, 0xC3, 0xC7, 0xFF, 0x81, 0xE1,
  0xFF, 0x80, 0xF0, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xFF, 0x83, 0xC1, 0xFF, 0xF1, 0xE1, 0xFF, 0xFD, 0xF1, 0xFF,
  0xFF, 0xF9, 0xFC, 0x07, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0x7F, 0x7C,
  0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x3F, 0x7C, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0,
  0x1F, 0xF1, 0xFF, 0xFE, 0xF8, 0x7F, 0xFF, 0x7C, 0x1F, 0xFF, 0x3E, 0x07,
  0xFE, 0x1F, 0x00, 0x30, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1E,
  0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFE, 0xF7, 0xC0, 0xFF, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFD, 0xFD, 0xF8, 0x03, 0xBE, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x7F, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC1, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x60, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7E,
  0x00, 0xFF, 0x7F, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0x1F,
  0xFF, 0x8F, 0x07, 0xFE, 0x0F, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x87,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x00, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0x00, 0x3E, 0x7C, 0x00, 0xFF,
  0x00, 0x3E, 0x7C, 0x00, 0xFF, 0x00, 0x3E, 0x7C, 0x01, 0xFF, 0x00, 0x3C,
  0x3E, 0x01, 0xEF, 0x80, 0x7C, 0x3E, 0x01, 0xE7, 0x80, 0x7C, 0x3E, 0x01,
  0xE7, 0x80, 0x7C, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0x1E, 0x03, 0xC7, 0xC0,
  0xF8, 0x1F, 0x03, 0xC3, 0xC0, 0xF8, 0x1F, 0x07, 0xC3, 0xC0, 0xF8, 0x1F,
  0x07, 0xC3, 0xE0, 0xF0, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0x0F, 0x87, 0x81,
  0xE1, 0xF0, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x0F, 0x8F, 0x81, 0xF1, 0xE0,
  0x07, 0x8F, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x00, 0xF3, 0xE0, 0x07, 0xDF,
  0x00, 0xF3, 0xE0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x03, 0xDE, 0x00, 0xFB,
  0xC0, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x83, 0xE0, 0x0F,
  0xC1, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x83,
  0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x07, 0xC0,
  0x0F, 0x83, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F,
  0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xF3, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x3E, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x47, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x4F, 0xFF, 0x00, 0x37, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xB8, 0x03, 0xFF, 0xC8, 0x00, 0x1F,
  0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Regular58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 42, 15, 4, -41 },
  { 38, 15, 15, 23, 4, -41 },
  { 67, 31, 41, 34, 1, -41 },
  { 226, 24, 47, 30, 3, -44 },
  { 367, 39, 43, 45, 3, -42 },
  { 577, 34, 43, 37, 3, -42 },
  { 760, 5, 15, 13, 4, -41 },
  { 770, 13, 51, 17, 2, -42 },
  { 853, 13, 51, 17, 2, -42 },
  { 936, 24, 24, 29, 2, -44 },
  { 1008, 26, 27, 30, 2, -34 },
  { 1096, 9, 15, 15, 2, -7 },
  { 1113, 14, 5, 18, 2, -18 },
  { 1122, 7, 8, 15, 4, -7 },
  { 1129, 20, 41, 22, 1, -41 },
  { 1232, 24, 43, 30, 3, -42 },
  { 1361, 14, 41, 30, 5, -41 },
  { 1433, 25, 42, 30, 2, -42 },
  { 1565, 25, 43, 30, 2, -42 },
  { 1700, 28, 42, 30, 1, -42 },
  { 1847, 24, 42, 30, 3, -41 },
  { 1973, 25, 43, 30, 3, -42 },
  { 2108, 26, 41, 30, 2, -41 },
  { 2242, 25, 43, 30, 3, -42 },
  { 2377, 24, 43, 30, 3, -42 },
  { 2506, 7, 33, 15, 4, -32 },
  { 2535, 9, 40, 15, 2, -32 },
  { 2580, 26, 28, 30, 2, -35 },
  { 2671, 24, 16, 30, 3, -28 },
  { 2719, 26, 28, 30, 2, -35 },
  { 2810, 20, 43, 23, 1, -42 },
  { 2918, 41, 47, 47, 3, -42 },
  { 3159, 33, 42, 33, 0, -42 },
  { 3333, 26, 41, 34, 5, -41 },
  { 3467, 28, 43, 33, 3, -42 },
  { 3618, 30, 41, 38, 5, -41 },
  { 3772, 21, 41, 29, 5, -41 },
  { 3880, 21, 41, 27, 5, -41 },
  { 3988, 31, 43, 38, 3, -42 },
  { 4155, 28, 41, 39, 5, -41 },
  { 4299, 14, 41, 18, 2, -41 },
  { 4371, 14, 52, 15, -4, -41 },
  { 4462, 27, 41, 32, 5, -41 },
  { 4601, 21, 41, 27, 5, -41 },
  { 4709, 39, 41, 49, 5, -41 },
  { 4909, 30, 41, 40, 5, -41 },
  { 5063, 34, 43, 40, 3, -42 },
  { 5246, 24, 41, 32, 5, -41 },
  { 5369, 34, 52, 40, 3, -42 },
  { 5590, 27, 41, 33, 5, -41 },
  { 5729, 23, 43, 29, 3, -42 },
  { 5853, 27, 41, 29, 1, -41 },
  { 5992, 28, 42, 38, 5, -41 },
  { 6139, 31, 41, 31, 0, -41 },
  { 6298, 48, 41, 49, 1, -41 },
  { 6544, 30, 41, 30, 0, -41 },
  { 6698, 29, 41, 29, 0, -41 },
  { 6847, 25, 41, 29, 2, -41 },
  { 6976, 13, 51, 19, 4, -42 },
  { 7059, 20, 41, 22, 1, -41 },
  { 7162, 12, 51, 19, 2, -42 },
  { 7239, 27, 25, 30, 2, -42 },
  { 7324, 26, 4, 26, 0, 5 },
  { 7337, 12, 9, 16, 2, -44 },
  { 7351, 23, 33, 29, 2, -32 },
  { 7446, 25, 45, 32, 5, -44 },
  { 7587, 20, 33, 25, 3, -32 },
  { 7670, 25, 45, 32, 3, -44 },
  { 7811, 24, 33, 30, 3, -32 },
  { 7910, 19, 44, 18, 1, -44 },
  { 8015, 25, 46, 32, 3, -32 },
  { 8159, 23, 44, 32, 5, -44 },
  { 8286, 6, 43, 14, 4, -43 },
  { 8319, 12, 57, 14, -2, -43 },
  { 8405, 23, 44, 28, 5, -44 },
  { 8532, 4, 44, 14, 5, -44 },
  { 8554, 40, 32, 49, 5, -32 },
  { 8714, 23, 32, 32, 5, -32 },
  { 8806, 26, 33, 32, 3, -32 },
  { 8914, 25, 46, 32, 5, -32 },
  { 9058, 25, 46, 32, 3, -32 },
  { 9202, 16, 32, 22, 5, -32 },
  { 9266, 19, 33, 25, 3, -32 },
  { 9345, 17, 39, 19, 1, -38 },
  { 9428, 24, 32, 32, 4, -31 },
  { 9524, 26, 31, 27, 0, -31 },
  { 9625, 40, 31, 42, 1, -31 },
  { 9780, 25, 31, 27, 1, -31 },
  { 9877, 27, 45, 27, 0, -31 },
  { 10029, 20, 31, 24, 2, -31 },
  { 10107, 18, 50, 22, 2, -41 },
  { 10220, 5, 58, 29, 12, -44 },
  { 10257, 18, 50, 22, 2, -41 },
  { 10370, 26, 7, 30, 2, -24 },
};

const GFXfont NotoSans_SemiCondensed_Regular58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular58pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR58PT7B_H_
