#ifndef _NOTOSANS_SEMICONDENSED_REGULAR57PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF0,
  0xE1, 0xC3, 0x87, 0x00, 0x00, 0x00, 0x00, 0xE7, 0xEF, 0xFF, 0xFF, 0xFE,
  0x7C, 0x60, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC0, 0xF7, 0x80,
  0xEF, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x03, 0xC0, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x0F,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80,
  0x78, 0x07, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x7F, 0x38, 0x3C, 0x7C, 0x38, 0x04, 0xF8, 0x38, 0x00, 0xF8, 0x38,
  0x00, 0xF8, 0x38, 0x00, 0xF8, 0x38, 0x00, 0xF8, 0x38, 0x00, 0xF8, 0x38,
  0x00, 0x7C, 0x38, 0x00, 0x7F, 0x38, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x3B, 0xFC, 0x00, 0x38, 0xFE, 0x00, 0x38, 0x3E, 0x00, 0x38,
  0x1F, 0x00, 0x38, 0x1F, 0x00, 0x38, 0x1F, 0x00, 0x38, 0x1F, 0x00, 0x38,
  0x1F, 0x00, 0x38, 0x3E, 0xC0, 0x38, 0x7E, 0xFC, 0x39, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x00,
  0xF0, 0x03, 0xFF, 0x80, 0x03, 0xC0, 0x1F, 0x3E, 0x00, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0x0F, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x81, 0xE0,
  0x00, 0xF0, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x3C, 0x00, 0x0F, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x1E, 0x1E, 0x0F,
  0x83, 0xC0, 0x78, 0xF8, 0xFF, 0x8F, 0x03, 0xE3, 0xC7, 0xFF, 0x1E, 0x0F,
  0x1F, 0x1F, 0xFC, 0x78, 0x3C, 0x78, 0xF0, 0xF9, 0xF3, 0xE3, 0xE3, 0xC1,
  0xE3, 0xFF, 0x8F, 0x1E, 0x07, 0xC7, 0xFC, 0x7C, 0x78, 0x0F, 0x0F, 0xE1,
  0xE1, 0xE0, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0xF0, 0x00, 0x3C, 0x1E, 0x03,
  0xC0, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0x1E, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0xF0, 0x03, 0xC0,
  0x1E, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0x03, 0xE3, 0xE0, 0x0F, 0x00, 0x07, 0xFF, 0x00, 0x3C, 0x00,
  0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x7E, 0x7E, 0x00, 0xF8, 0x7E,
  0x1F, 0x80, 0x7C, 0x7E, 0x07, 0xE0, 0x7C, 0x7E, 0x03, 0xF8, 0x3E, 0x3E,
  0x00, 0xFC, 0x1F, 0x1F, 0x00, 0x3F, 0x1F, 0x0F, 0x80, 0x0F, 0xCF, 0x87,
  0xC0, 0x03, 0xFF, 0x83, 0xE0, 0x00, 0xFF, 0xC1, 0xF0, 0x00, 0x3F, 0xC0,
  0xF8, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xFC,
  0x1F, 0xC0, 0x0F, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xE7,
  0xE0, 0xFF, 0xFF, 0xE1, 0xF8, 0x3F, 0xFF, 0xC0, 0x7E, 0x07, 0xFF, 0x80,
  0x1F, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF7,
  0xBD, 0xEF, 0x39, 0xC0, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x70, 0x3C, 0x0E, 0x7F, 0x3C, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xE7, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0xC3, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0x80, 0xE0, 0x01,
  0x00, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x0F, 0xC7, 0xC3, 0xE3, 0xF1,
  0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x39, 0xFB, 0xF7, 0xFF, 0xFF,
  0x9F, 0x18, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x83, 0xF8,
  0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x10, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0xDF, 0x7E, 0x3F, 0xF8, 0x7C, 0xE0, 0xF8,
  0x81, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xC1,
  0xE0, 0x07, 0xE0, 0x60, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xF0, 0x1F, 0xC1, 0xE0, 0x03, 0xF0,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xD8, 0x00, 0x0F, 0xCF, 0x80, 0x1F,
  0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x00, 0x14, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x3C,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00,
  0x7C, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0,
  0x78, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1C, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0xC0, 0x00, 0xFC, 0xF0, 0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xD0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07,
  0xF8, 0x04, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x0C, 0x00, 0xF8,
  0x7F, 0xC0, 0xF9, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFF, 0xF7, 0xFC, 0xFF,
  0x80, 0xFC, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x7C, 0x1F,
  0x80, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0x01, 0xFC, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0xC3, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xCF, 0xF0, 0x3F,
  0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x3F, 0xEF, 0xFC, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x7E,
  0x01, 0xF8, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x3F,
  0x83, 0xDF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9E, 0x07, 0xFE, 0x1E, 0x01,
  0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39,
  0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x18, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E,
  0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7C, 0x0F, 0xE6, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xFF, 0xF8, 0x1E,
  0x3C, 0x01, 0xFF, 0xF8, 0x1E, 0x3C, 0x03, 0xFF, 0xF8, 0x1E, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x78, 0x0F, 0x00, 0xF8,
  0x0F, 0x78, 0x1F, 0x00, 0xF8, 0x0F, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0xF0,
  0x1E, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0x00,
  0xF0, 0x0F, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0x00, 0xF0, 0x0F,
  0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0xF0, 0x1E,
  0x01, 0xF0, 0x1E, 0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0xF0, 0x1F, 0x03, 0xF8,
  0x3C, 0x78, 0x0F, 0x87, 0xB8, 0x7C, 0x78, 0x0F, 0xFF, 0x3F, 0xF8, 0x78,
  0x07, 0xFF, 0x1F, 0xF0, 0x7C, 0x03, 0xFE, 0x0F, 0xE0, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x7C,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x3F,
  0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E,
  0x3E, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0x80, 0x0F, 0xE3, 0xE0, 0x00, 0xFC, 0xF8,
  0x00, 0x1F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB, 0xE0,
  0x01, 0xFC, 0xF8, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0x07,
  0xC0, 0x7F, 0x00, 0x0C, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x01, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x7F, 0x83, 0xE0, 0x00, 0xFE, 0x1F,
  0x00, 0x03, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0xFE, 0x3E, 0x00, 0x0F, 0xE1, 0xF0, 0x01, 0xFE, 0x0F, 0x80, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F,
  0x80, 0xFF, 0x00, 0x07, 0x03, 0xF8, 0x00, 0x02, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x7F, 0x80, 0x01,
  0xF0, 0x7F, 0xC0, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x7F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0xBF, 0xFC,
  0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xDF, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE1,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x03,
  0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0x81, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7D,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0x80,
  0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xE0,
  0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1,
  0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0xF8, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x78, 0x00, 0x00, 0xFF, 0xFD, 0xF0, 0x00, 0x03, 0xDF, 0xF7,
  0xC0, 0x00, 0x0F, 0x7F, 0xEF, 0x00, 0x00, 0x7D, 0xFF, 0xBE, 0x00, 0x01,
  0xE7, 0xFE, 0xF8, 0x00, 0x07, 0x9F, 0xF9, 0xE0, 0x00, 0x3E, 0x7F, 0xE7,
  0xC0, 0x00, 0xF1, 0xFF, 0x9F, 0x00, 0x03, 0xC7, 0xFE, 0x3E, 0x00, 0x1F,
  0x1F, 0xF8, 0xF8, 0x00, 0x78, 0x7F, 0xE1, 0xE0, 0x01, 0xE1, 0xFF, 0x87,
  0xC0, 0x0F, 0x87, 0xFE, 0x1F, 0x00, 0x3C, 0x1F, 0xF8, 0x3C, 0x01, 0xF0,
  0x7F, 0xE0, 0xF8, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0x1E, 0x07, 0xFE, 0x07,
  0x80, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0x01,
  0xFF, 0x80, 0xF0, 0x7C, 0x07, 0xFE, 0x03, 0xE1, 0xF0, 0x1F, 0xF8, 0x0F,
  0x87, 0x80, 0x7F, 0xE0, 0x1E, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0xF0, 0x07,
  0xFE, 0x01, 0xF3, 0xC0, 0x1F, 0xF8, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFE, 0xF8, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x7F, 0x9F, 0x00, 0x03,
  0xFC, 0xFC, 0x00, 0x1F, 0xF3, 0xE0, 0x00, 0xFF, 0x9F, 0x80, 0x07, 0xFC,
  0x7C, 0x00, 0x3F, 0xE3, 0xF0, 0x01, 0xFF, 0x0F, 0x80, 0x0F, 0xF8, 0x3E,
  0x00, 0x7F, 0xC1, 0xF8, 0x03, 0xFE, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0x00,
  0xFF, 0x80, 0xF8, 0x07, 0xFC, 0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0x01, 0xFF,
  0x00, 0x7C, 0x0F, 0xF8, 0x03, 0xF0, 0x7F, 0xC0, 0x0F, 0x83, 0xFE, 0x00,
  0x7E, 0x1F, 0xF0, 0x01, 0xF0, 0xFF, 0x80, 0x0F, 0xC7, 0xFC, 0x00, 0x3E,
  0x3F, 0xE0, 0x01, 0xF9, 0xFF, 0x00, 0x07, 0xEF, 0xF8, 0x00, 0x1F, 0x7F,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xF8, 0x03, 0xFC, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xFC, 0xF8,
  0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x7F,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x3E, 0x00, 0x7F, 0x0F, 0x80, 0x0F, 0xE3, 0xE0, 0x01, 0xF8, 0xF8,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0xFC,
  0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0,
  0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFC,
  0x1F, 0x8F, 0xC0, 0x03, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF4, 0x00, 0x07, 0xEF, 0x80, 0x3F, 0x9F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x02, 0xA0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x81,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFB, 0xC0, 0x03,
  0xE1, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xCF, 0x80, 0x1F,
  0x03, 0xE0, 0x0F, 0x8F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x1E, 0x00, 0x7C,
  0x0F, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0x81, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x3E, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xF0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x07,
  0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0x0F, 0x8F, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x1E, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x79, 0xF0, 0x00, 0x3C,
  0xF8, 0x00, 0xF3, 0xE0, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0, 0x00, 0xFB,
  0xC0, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7C,
  0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3E, 0xFC, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x78, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0xC0, 0xF0,
  0x01, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x1F, 0x00,
  0x3C, 0x07, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x3C,
  0x00, 0x0F, 0x1E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xF8, 0x1F, 0xC0, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x3F, 0xE0, 0x3E, 0x7E, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C,
  0x00, 0xFE, 0xF8, 0x01, 0xFD, 0xF8, 0x0F, 0xF9, 0xFC, 0x7F, 0xF3, 0xFF,
  0xF9, 0xE3, 0xFF, 0xE3, 0xC3, 0xFF, 0x07, 0x80, 0x70, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x83, 0xF8, 0x07, 0xC7, 0xFF, 0x03, 0xE7, 0xFF, 0xE1, 0xF7, 0xFF, 0xF8,
  0xFF, 0xC1, 0xFC, 0x7F, 0x80, 0x3F, 0x3F, 0x80, 0x0F, 0x9F, 0xC0, 0x03,
  0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF,
  0x80, 0x03, 0xEF, 0xE0, 0x03, 0xF7, 0xF8, 0x01, 0xF3, 0xFE, 0x03, 0xF9,
  0xF7, 0xFF, 0xF8, 0xFB, 0xFF, 0xF8, 0x78, 0xFF, 0xF8, 0x3C, 0x1F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xC1, 0xE3, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x31,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x01, 0xFE, 0x0F, 0x07, 0xFF, 0x8F, 0x0F, 0xFF, 0xCF, 0x1F, 0xFF, 0xEF,
  0x3F, 0x81, 0xFF, 0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0x1F, 0xFF, 0xEF,
  0x0F, 0xFF, 0xCF, 0x07, 0xFF, 0x8F, 0x03, 0xFF, 0x0F, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81,
  0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x08, 0x7E, 0x00, 0x70, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0A, 0x00, 0x00, 0x0C, 0x00, 0x0F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x0F, 0x07, 0xFF, 0x8F, 0x0F,
  0xFF, 0xCF, 0x1F, 0xFF, 0xEF, 0x1F, 0xC1, 0xFF, 0x3F, 0x00, 0x7F, 0x7E,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x3F,
  0x80, 0xFF, 0x1F, 0xFF, 0xEF, 0x0F, 0xFF, 0xCF, 0x07, 0xFF, 0x8F, 0x03,
  0xFF, 0x0F, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x20,
  0x00, 0x7E, 0x38, 0x00, 0xFE, 0x3F, 0xEF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x7A, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0xC0, 0xF8,
  0xFF, 0xF0, 0xF9, 0xFF, 0xF8, 0xFB, 0xFF, 0xFC, 0xFF, 0xC0, 0xFC, 0xFF,
  0x00, 0x7E, 0xFE, 0x00, 0x3E, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7B, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xE0, 0x01, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x07,
  0x80, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x07, 0xFF, 0x00, 0x1F, 0xBE, 0x00, 0x7E, 0x7C, 0x01, 0xF8, 0xF8,
  0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x83,
  0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF0,
  0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xEF, 0xC0, 0x3F, 0x8F, 0x80, 0x7C, 0x1F, 0x80, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xF8, 0x00, 0xFD, 0xF0,
  0x00, 0xFB, 0xE0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x3F, 0x80, 0x1F,
  0xE0, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xF9, 0xFF, 0xF0, 0xFF, 0xFC, 0xFB,
  0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xC1, 0xFB, 0xE0, 0xFE, 0xFF, 0x00, 0xFF,
  0x80, 0x7E, 0xFE, 0x00, 0x7F, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0xF0, 0xFF,
  0xF0, 0xF9, 0xFF, 0xF8, 0xFB, 0xFF, 0xFC, 0xFF, 0xC0, 0xFC, 0xFF, 0x00,
  0x7E, 0xFE, 0x00, 0x3E, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x07, 0xE0, 0x3F, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0xF0, 0x3F, 0xC0, 0x7C,
  0x7F, 0xF8, 0x3E, 0x7F, 0xFE, 0x1F, 0x7F, 0xFF, 0x8F, 0xFC, 0x1F, 0xC7,
  0xF8, 0x03, 0xF3, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFE,
  0x00, 0x3F, 0x7F, 0x80, 0x3F, 0x3F, 0xE0, 0x3F, 0x9F, 0x7F, 0xFF, 0x8F,
  0xBF, 0xFF, 0x87, 0xCF, 0xFF, 0x83, 0xE1, 0xFF, 0x81, 0xF0, 0x08, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0x07, 0xFF, 0x8F, 0x0F,
  0xFF, 0xCF, 0x1F, 0xFF, 0xEF, 0x1F, 0x81, 0xFF, 0x3F, 0x00, 0x7F, 0x7E,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x3F,
  0x80, 0xFF, 0x1F, 0xFF, 0xEF, 0x0F, 0xFF, 0xCF, 0x07, 0xFF, 0x8F, 0x03,
  0xFF, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xBE, 0x7F, 0xDF, 0x3F, 0xEF, 0xBF, 0xF7, 0xFE, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xC0, 0x3D, 0xF0, 0x01, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF,
  0xFE, 0x1F, 0xFF, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x10,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7C, 0x00, 0x7E,
  0xF8, 0x01, 0xFD, 0xF8, 0x07, 0xF9, 0xFF, 0xFE, 0xF3, 0xFF, 0xF9, 0xE3,
  0xFF, 0xE3, 0xC1, 0xFF, 0x87, 0x80, 0x70, 0x00, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xE0,
  0x03, 0xCF, 0x80, 0x3F, 0xE0, 0x0F, 0x9F, 0x00, 0x7B, 0xC0, 0x1F, 0x3E,
  0x00, 0xF7, 0x80, 0x3E, 0x3E, 0x01, 0xEF, 0x00, 0x78, 0x7C, 0x07, 0xDF,
  0x01, 0xF0, 0xF8, 0x0F, 0x1E, 0x03, 0xE1, 0xF0, 0x1E, 0x3C, 0x07, 0xC1,
  0xE0, 0x3C, 0x7C, 0x0F, 0x03, 0xE0, 0xF8, 0xF8, 0x3E, 0x07, 0xC1, 0xE0,
  0xF0, 0x7C, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x0F, 0x0F, 0x83, 0xE1, 0xE0,
  0x1F, 0x1F, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x07, 0x8F, 0x80, 0x7C, 0x78,
  0x0F, 0x1F, 0x00, 0x79, 0xF0, 0x1F, 0x3C, 0x00, 0xFB, 0xC0, 0x3E, 0x78,
  0x01, 0xF7, 0x80, 0x3D, 0xF0, 0x03, 0xEF, 0x00, 0x7B, 0xE0, 0x03, 0xDE,
  0x00, 0xF7, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xE0, 0x0F, 0xC1, 0xF0, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xE3,
  0xF0, 0x01, 0xF1, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x3F, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F,
  0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1F,
  0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3E,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x6F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xE0,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFE, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x9F, 0xFC, 0x00,
  0x5F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFB, 0x00, 0x0F, 0xF9, 0x00, 0x00, 0x60,
};

const GFXglyph NotoSans_SemiCondensed_Regular57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 42, 15, 4, -41 },
  { 38, 15, 15, 23, 4, -41 },
  { 67, 31, 41, 33, 1, -41 },
  { 226, 24, 46, 30, 3, -43 },
  { 364, 38, 42, 44, 3, -41 },
  { 564, 33, 42, 36, 3, -41 },
  { 738, 5, 15, 12, 4, -41 },
  { 748, 13, 50, 17, 2, -41 },
  { 830, 12, 50, 17, 2, -41 },
  { 905, 24, 23, 28, 2, -43 },
  { 974, 25, 28, 30, 2, -34 },
  { 1062, 9, 14, 14, 2, -7 },
  { 1078, 13, 5, 17, 2, -18 },
  { 1087, 7, 8, 14, 4, -7 },
  { 1094, 20, 41, 21, 1, -41 },
  { 1197, 24, 42, 30, 3, -41 },
  { 1323, 15, 41, 30, 4, -41 },
  { 1400, 25, 41, 30, 2, -41 },
  { 1529, 25, 42, 30, 2, -41 },
  { 1661, 28, 41, 30, 1, -41 },
  { 1805, 24, 42, 30, 3, -41 },
  { 1931, 24, 42, 30, 3, -41 },
  { 2057, 25, 41, 30, 2, -41 },
  { 2186, 24, 42, 30, 3, -41 },
  { 2312, 24, 42, 30, 3, -41 },
  { 2438, 7, 32, 14, 4, -31 },
  { 2466, 8, 38, 14, 2, -31 },
  { 2504, 25, 27, 30, 2, -34 },
  { 2589, 24, 16, 30, 3, -28 },
  { 2637, 25, 27, 30, 2, -34 },
  { 2722, 20, 42, 22, 1, -41 },
  { 2827, 40, 46, 46, 3, -41 },
  { 3057, 32, 41, 32, 0, -41 },
  { 3221, 26, 41, 33, 5, -41 },
  { 3355, 28, 42, 32, 3, -41 },
  { 3502, 29, 41, 37, 5, -41 },
  { 3651, 20, 41, 29, 5, -41 },
  { 3754, 20, 41, 27, 5, -41 },
  { 3857, 31, 42, 38, 3, -41 },
  { 4020, 28, 41, 38, 5, -41 },
  { 4164, 14, 41, 18, 2, -41 },
  { 4236, 14, 52, 15, -4, -41 },
  { 4327, 27, 41, 32, 5, -41 },
  { 4466, 20, 41, 27, 5, -41 },
  { 4569, 38, 41, 48, 5, -41 },
  { 4764, 29, 41, 39, 5, -41 },
  { 4913, 33, 42, 40, 3, -41 },
  { 5087, 24, 41, 31, 5, -41 },
  { 5210, 33, 51, 40, 3, -41 },
  { 5421, 26, 41, 32, 5, -41 },
  { 5555, 23, 42, 28, 3, -41 },
  { 5676, 26, 41, 28, 1, -41 },
  { 5810, 28, 42, 37, 5, -41 },
  { 5957, 31, 41, 31, 0, -41 },
  { 6116, 47, 41, 49, 1, -41 },
  { 6357, 29, 41, 30, 0, -41 },
  { 6506, 29, 41, 29, 0, -41 },
  { 6655, 24, 41, 28, 2, -41 },
  { 6778, 13, 50, 18, 4, -41 },
  { 6860, 20, 41, 21, 1, -41 },
  { 6963, 12, 50, 18, 2, -41 },
  { 7038, 26, 24, 30, 2, -41 },
  { 7116, 25, 4, 25, 0, 5 },
  { 7129, 11, 9, 16, 2, -44 },
  { 7142, 23, 32, 29, 2, -31 },
  { 7234, 25, 44, 32, 4, -43 },
  { 7372, 20, 32, 25, 3, -31 },
  { 7452, 24, 44, 32, 3, -43 },
  { 7584, 23, 32, 29, 3, -31 },
  { 7676, 19, 44, 18, 1, -44 },
  { 7781, 24, 45, 32, 3, -31 },
  { 7916, 24, 43, 32, 4, -43 },
  { 8045, 6, 42, 14, 4, -42 },
  { 8077, 12, 56, 14, -2, -42 },
  { 8161, 23, 43, 28, 4, -43 },
  { 8285, 5, 43, 14, 4, -43 },
  { 8312, 40, 31, 48, 4, -31 },
  { 8467, 24, 31, 32, 4, -31 },
  { 8560, 25, 32, 31, 3, -31 },
  { 8660, 25, 45, 32, 4, -31 },
  { 8801, 24, 45, 32, 3, -31 },
  { 8936, 17, 31, 21, 4, -31 },
  { 9002, 19, 32, 24, 3, -31 },
  { 9078, 16, 39, 18, 1, -38 },
  { 9156, 23, 32, 32, 4, -31 },
  { 9248, 26, 31, 26, 0, -31 },
  { 9349, 39, 31, 41, 1, -31 },
  { 9501, 25, 31, 27, 1, -31 },
  { 9598, 26, 45, 26, 0, -31 },
  { 9745, 19, 31, 23, 2, -31 },
  { 9819, 17, 50, 21, 2, -41 },
  { 9926, 4, 57, 28, 12, -43 },
  { 9955, 17, 50, 21, 2, -41 },
  { 10062, 25, 8, 30, 2, -24 },
};

const GFXfont NotoSans_SemiCondensed_Regular57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR57PT7B_H_
