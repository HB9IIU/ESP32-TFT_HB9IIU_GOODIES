#ifndef _NOTOSANS_SEMICONDENSED_REGULAR8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB4, 0x55, 0xF5, 0xE6, 0x6B, 0xE3, 0x3E, 0x4A, 0xCB, 0x9D,
  0x35, 0x30, 0x62, 0x98, 0xD9, 0x34, 0xC0, 0x5A, 0xA4, 0x95, 0x5C, 0x4F,
  0x60, 0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x69, 0x99, 0x96,
  0x75, 0x50, 0xE1, 0x12, 0x4F, 0xE1, 0x26, 0x1E, 0x22, 0x6A, 0xF2, 0x68,
  0xE1, 0x1E, 0x24, 0xE9, 0x96, 0xF1, 0x22, 0x44, 0x69, 0x66, 0x96, 0x69,
  0x97, 0x16, 0x90, 0x98, 0x16, 0xC3, 0xFF, 0x86, 0x3C, 0xC4, 0xA0, 0x80,
  0x39, 0x1B, 0xEB, 0xBD, 0x03, 0x80, 0x21, 0x14, 0xE9, 0x44, 0xD6, 0xFB,
  0xC0, 0x34, 0x88, 0x47, 0xE9, 0x99, 0x9E, 0xF2, 0x69, 0xC0, 0xF2, 0x69,
  0x00, 0x3A, 0x21, 0x34, 0xBC, 0x99, 0x9F, 0x99, 0xD5, 0x70, 0x55, 0x56,
  0xB7, 0x6B, 0x40, 0x92, 0x49, 0xC0, 0x8C, 0x67, 0xBE, 0xD4, 0x99, 0xDD,
  0xB9, 0x32, 0x63, 0x14, 0xB8, 0xD6, 0xE9, 0x00, 0x32, 0x63, 0x14, 0xB8,
  0x60, 0xD6, 0xEB, 0x40, 0x78, 0x42, 0x1E, 0xF4, 0x44, 0x44, 0x99, 0x99,
  0x9E, 0x99, 0x56, 0x62, 0x93, 0x26, 0xD3, 0x66, 0xC9, 0x00, 0x96, 0x66,
  0x69, 0x99, 0x64, 0x22, 0xF2, 0x24, 0x4F, 0xFE, 0x91, 0x24, 0x40, 0xD5,
  0x5C, 0x26, 0x59, 0xF0, 0xC0, 0xEE, 0xF0, 0x9A, 0xDB, 0xC0, 0x72, 0x30,
  0x13, 0x59, 0x97, 0x7F, 0x87, 0x6B, 0x24, 0x80, 0x79, 0x97, 0x16, 0x9A,
  0xDB, 0x40, 0xBC, 0xBF, 0x97, 0x4D, 0x40, 0xFC, 0xFD, 0x6B, 0x50, 0xF6,
  0xD0, 0x79, 0x96, 0xF6, 0xF9, 0x00, 0x79, 0x97, 0x11, 0xEA, 0xE8, 0xF0,
  0x6A, 0x40, 0xB6, 0xF0, 0x9A, 0x64, 0xA6, 0xE5, 0x92, 0xF4, 0x6B, 0x9A,
  0x64, 0x4C, 0xE9, 0x70, 0x29, 0x64, 0x98, 0xFF, 0x89, 0x34, 0xB0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Regular8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 3, 2, 3, 0, -6 },
  { 3, 4, 6, 5, 0, -6 },
  { 6, 4, 6, 4, 0, -6 },
  { 9, 6, 6, 6, 0, -6 },
  { 14, 5, 6, 5, 0, -6 },
  { 18, 1, 2, 2, 0, -6 },
  { 19, 2, 7, 2, 0, -6 },
  { 21, 2, 7, 2, 0, -6 },
  { 23, 4, 3, 4, 0, -6 },
  { 25, 4, 4, 4, 0, -5 },
  { 27, 1, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 1, 1, 2, 1, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 4, 6, 4, 0, -6 },
  { 36, 2, 6, 4, 1, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 1, 4, 2, 1, -4 },
  { 63, 1, 5, 2, 0, -4 },
  { 64, 4, 4, 4, 0, -5 },
  { 66, 4, 2, 4, 0, -4 },
  { 67, 4, 4, 4, 0, -5 },
  { 69, 3, 6, 3, 0, -6 },
  { 72, 6, 7, 6, 0, -6 },
  { 78, 5, 6, 5, 0, -6 },
  { 82, 3, 6, 5, 1, -6 },
  { 85, 4, 6, 5, 0, -6 },
  { 88, 4, 6, 5, 1, -6 },
  { 91, 3, 6, 4, 1, -6 },
  { 94, 3, 6, 4, 1, -6 },
  { 97, 5, 6, 5, 0, -6 },
  { 101, 4, 6, 5, 1, -6 },
  { 104, 2, 6, 3, 0, -6 },
  { 106, 2, 8, 2, -1, -6 },
  { 108, 3, 6, 4, 1, -6 },
  { 111, 3, 6, 4, 1, -6 },
  { 114, 5, 6, 7, 1, -6 },
  { 118, 4, 6, 6, 1, -6 },
  { 121, 5, 6, 6, 0, -6 },
  { 125, 3, 6, 4, 1, -6 },
  { 128, 5, 7, 6, 0, -6 },
  { 133, 3, 6, 5, 1, -6 },
  { 136, 4, 6, 4, 0, -6 },
  { 139, 4, 6, 4, 0, -6 },
  { 142, 4, 6, 5, 1, -6 },
  { 145, 4, 6, 4, 0, -6 },
  { 148, 7, 6, 7, 0, -6 },
  { 154, 4, 6, 4, 0, -6 },
  { 157, 4, 6, 4, 0, -6 },
  { 160, 4, 6, 4, 0, -6 },
  { 163, 1, 7, 3, 1, -6 },
  { 164, 3, 6, 3, 0, -6 },
  { 167, 2, 7, 3, 0, -6 },
  { 169, 4, 4, 4, 0, -6 },
  { 171, 4, 1, 4, 0, 0 },
  { 172, 2, 1, 2, 0, -6 },
  { 173, 3, 4, 4, 0, -4 },
  { 175, 3, 6, 4, 1, -6 },
  { 178, 3, 4, 3, 0, -4 },
  { 180, 4, 6, 4, 0, -6 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 3, 6, 2, 0, -6 },
  { 188, 4, 6, 4, 0, -4 },
  { 191, 3, 6, 4, 1, -6 },
  { 194, 1, 6, 2, 0, -6 },
  { 195, 1, 8, 2, 0, -6 },
  { 196, 3, 6, 4, 1, -6 },
  { 199, 1, 6, 2, 0, -6 },
  { 200, 5, 4, 7, 1, -4 },
  { 203, 3, 4, 4, 1, -4 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 3, 6, 4, 1, -4 },
  { 210, 4, 6, 4, 0, -4 },
  { 213, 2, 4, 3, 1, -4 },
  { 214, 3, 4, 3, 0, -4 },
  { 216, 2, 5, 3, 0, -5 },
  { 218, 3, 4, 4, 1, -4 },
  { 220, 4, 4, 4, 0, -4 },
  { 222, 6, 4, 6, 0, -4 },
  { 225, 4, 4, 4, 0, -4 },
  { 227, 4, 6, 4, 0, -4 },
  { 230, 3, 4, 3, 0, -4 },
  { 232, 3, 7, 3, 0, -6 },
  { 235, 1, 8, 4, 1, -6 },
  { 236, 3, 7, 3, 0, -6 },
  { 239, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Regular8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR8PT7B_H_
