#ifndef _NOTOSANS_SEMICONDENSED_REGULAR12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xB6, 0xD0, 0x24, 0x48, 0xA3, 0xF2, 0x85, 0x37, 0x24,
  0x50, 0x27, 0xA9, 0x46, 0x18, 0xBE, 0x21, 0x00, 0xC4, 0xA4, 0xA8, 0xA8,
  0xB6, 0xD9, 0x29, 0x29, 0x46, 0x61, 0x22, 0x43, 0x86, 0x16, 0xA5, 0x44,
  0xF6, 0xF0, 0x5A, 0xAA, 0xA4, 0x89, 0x12, 0x49, 0x2B, 0x00, 0x35, 0x5C,
  0x64, 0x80, 0x21, 0x3E, 0x42, 0x10, 0x58, 0xE0, 0x80, 0x11, 0x12, 0x24,
  0x44, 0x80, 0x64, 0xA5, 0x18, 0xC6, 0x72, 0x70, 0x2E, 0x92, 0x49, 0x20,
  0x64, 0x84, 0x21, 0x11, 0x10, 0xF8, 0x31, 0x20, 0x82, 0x30, 0x20, 0x42,
  0xF8, 0x08, 0x62, 0x8A, 0x49, 0x2F, 0xC2, 0x08, 0xF4, 0x21, 0x0F, 0x0C,
  0x22, 0xF0, 0x32, 0x21, 0x0F, 0x46, 0x33, 0x70, 0xFC, 0x10, 0x82, 0x10,
  0x43, 0x08, 0x60, 0x64, 0xA5, 0x26, 0x4A, 0x31, 0xF0, 0x64, 0xA5, 0x19,
  0xB4, 0x42, 0xE0, 0xC2, 0x50, 0x05, 0x80, 0x0C, 0xCC, 0x18, 0x1C, 0x10,
  0xF8, 0x3E, 0x83, 0x06, 0x6C, 0x40, 0x69, 0x11, 0x22, 0x40, 0x60, 0x18,
  0x66, 0x81, 0xBD, 0xA5, 0xA5, 0xAD, 0x92, 0xC0, 0x7C, 0x10, 0x20, 0xA1,
  0x42, 0x8F, 0x91, 0x22, 0x82, 0xE4, 0xE3, 0x1F, 0x46, 0x31, 0xF8, 0x3A,
  0x61, 0x08, 0x42, 0x18, 0x78, 0xE2, 0x68, 0x61, 0x86, 0x18, 0x62, 0xF0,
  0xF8, 0x88, 0xF8, 0x88, 0xF0, 0xF8, 0x88, 0xF8, 0x88, 0x80, 0x39, 0x18,
  0x20, 0x9E, 0x18, 0x71, 0x7C, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x84,
  0xE9, 0x24, 0x92, 0xE0, 0x24, 0x92, 0x49, 0x27, 0x80, 0x8E, 0x29, 0x28,
  0xE2, 0x89, 0x22, 0x8C, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC3, 0xC3, 0xC3,
  0xA5, 0xA5, 0xA5, 0x99, 0x99, 0x99, 0x87, 0x1C, 0x69, 0xB6, 0x58, 0xE3,
  0x84, 0x30, 0x9A, 0x14, 0x38, 0x30, 0x61, 0x62, 0x78, 0xE4, 0xE3, 0x19,
  0xF2, 0x10, 0x80, 0x30, 0x9A, 0x14, 0x38, 0x30, 0x61, 0x62, 0x78, 0x10,
  0x30, 0xE2, 0x68, 0xA2, 0x93, 0xC9, 0x22, 0x8C, 0x79, 0x88, 0x61, 0x11,
  0xF0, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x63, 0x78, 0x87, 0x09, 0x12, 0x64, 0x85, 0x0A, 0x18, 0x10, 0x84,
  0x63, 0x14, 0xC5, 0x32, 0x52, 0x94, 0xA3, 0x28, 0xC4, 0x21, 0x00, 0x85,
  0x24, 0x8C, 0x10, 0xC4, 0x92, 0x84, 0x87, 0x34, 0x9A, 0x30, 0xC3, 0x0C,
  0x30, 0x78, 0x20, 0x84, 0x30, 0x84, 0x10, 0xFC, 0xF2, 0x49, 0x24, 0x93,
  0x80, 0x84, 0x44, 0x22, 0x21, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x10,
  0xC3, 0x12, 0x4A, 0x10, 0xF8, 0xC4, 0x12, 0x42, 0x74, 0xE5, 0xE0, 0x84,
  0x29, 0xB8, 0xC6, 0x31, 0xF0, 0x2D, 0x88, 0x88, 0x70, 0x08, 0x5B, 0x38,
  0xC6, 0x31, 0xF8, 0x64, 0xA5, 0xF8, 0x41, 0xC0, 0x34, 0x7C, 0x44, 0x44,
  0x40, 0x64, 0xE3, 0x18, 0xC7, 0xE1, 0x1F, 0x80, 0x84, 0x29, 0xB8, 0xC6,
  0x31, 0x88, 0xDF, 0x80, 0x51, 0x55, 0x56, 0x84, 0x23, 0x2A, 0x72, 0x92,
  0x98, 0xFF, 0x80, 0x22, 0xDD, 0x89, 0x89, 0x89, 0x89, 0x89, 0x26, 0xE3,
  0x18, 0xC6, 0x20, 0x26, 0xA3, 0x18, 0xC5, 0xC0, 0x26, 0xE3, 0x18, 0xC7,
  0xD0, 0x84, 0x00, 0x64, 0xE3, 0x18, 0xCF, 0xA1, 0x08, 0x40, 0x3E, 0x49,
  0x20, 0x69, 0x8C, 0x21, 0xE0, 0x47, 0xC4, 0x44, 0x47, 0x8C, 0x63, 0x19,
  0xF4, 0x8A, 0x54, 0xA3, 0x10, 0x89, 0xAC, 0x95, 0x4A, 0xA6, 0x61, 0x10,
  0xCB, 0x8C, 0x65, 0xE4, 0x8A, 0x56, 0xA3, 0x18, 0x84, 0xC0, 0x70, 0x88,
  0xC4, 0x7C, 0x12, 0x22, 0x2C, 0x22, 0x22, 0x30, 0xFF, 0xF0, 0x86, 0x22,
  0x23, 0x22, 0x22, 0xC0, 0x76, 0x20,
};

const GFXglyph NotoSans_SemiCondensed_Regular12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 4, 5, 1, -9 },
  { 5, 7, 9, 7, 0, -9 },
  { 13, 5, 10, 6, 1, -9 },
  { 20, 8, 9, 9, 1, -9 },
  { 29, 7, 9, 8, 1, -9 },
  { 37, 1, 4, 3, 1, -9 },
  { 38, 2, 11, 4, 1, -9 },
  { 41, 3, 11, 4, 0, -9 },
  { 46, 5, 5, 6, 0, -9 },
  { 50, 5, 6, 6, 1, -7 },
  { 54, 2, 3, 3, 0, -1 },
  { 55, 3, 1, 4, 0, -4 },
  { 56, 1, 1, 3, 1, -1 },
  { 57, 4, 9, 4, 0, -9 },
  { 62, 5, 9, 6, 1, -9 },
  { 68, 3, 9, 6, 1, -9 },
  { 72, 5, 9, 6, 1, -9 },
  { 78, 6, 9, 6, 0, -9 },
  { 85, 6, 9, 6, 0, -9 },
  { 92, 5, 9, 6, 1, -9 },
  { 98, 5, 9, 6, 1, -9 },
  { 104, 6, 9, 6, 0, -9 },
  { 111, 5, 9, 6, 1, -9 },
  { 117, 5, 9, 6, 1, -9 },
  { 123, 1, 7, 3, 1, -7 },
  { 124, 2, 9, 3, 0, -7 },
  { 127, 6, 6, 6, 0, -7 },
  { 132, 5, 3, 6, 1, -6 },
  { 134, 5, 6, 6, 1, -7 },
  { 138, 4, 9, 5, 0, -9 },
  { 143, 8, 10, 10, 1, -9 },
  { 153, 7, 9, 7, 0, -9 },
  { 161, 5, 9, 7, 1, -9 },
  { 167, 5, 9, 7, 1, -9 },
  { 173, 6, 9, 8, 1, -9 },
  { 180, 4, 9, 6, 1, -9 },
  { 185, 4, 9, 6, 1, -9 },
  { 190, 6, 9, 8, 1, -9 },
  { 197, 6, 9, 8, 1, -9 },
  { 204, 3, 9, 4, 0, -9 },
  { 208, 3, 11, 3, -1, -9 },
  { 213, 6, 9, 7, 1, -9 },
  { 220, 4, 9, 6, 1, -9 },
  { 225, 8, 9, 10, 1, -9 },
  { 234, 6, 9, 8, 1, -9 },
  { 241, 7, 9, 8, 1, -9 },
  { 249, 5, 9, 7, 1, -9 },
  { 255, 7, 11, 8, 1, -9 },
  { 265, 6, 9, 7, 1, -9 },
  { 272, 4, 9, 6, 1, -9 },
  { 277, 6, 9, 6, 0, -9 },
  { 284, 6, 9, 8, 1, -9 },
  { 291, 7, 9, 7, 0, -9 },
  { 299, 10, 9, 10, 0, -9 },
  { 311, 6, 9, 6, 0, -9 },
  { 318, 6, 9, 6, 0, -9 },
  { 325, 6, 9, 6, 0, -9 },
  { 332, 3, 11, 4, 1, -9 },
  { 337, 4, 9, 4, 0, -9 },
  { 342, 3, 11, 4, 0, -9 },
  { 347, 6, 6, 6, 0, -9 },
  { 352, 5, 1, 5, 0, 1 },
  { 353, 3, 2, 3, 0, -9 },
  { 354, 5, 7, 6, 0, -7 },
  { 359, 5, 9, 7, 1, -9 },
  { 365, 4, 7, 5, 1, -7 },
  { 369, 5, 9, 7, 1, -9 },
  { 375, 5, 7, 6, 1, -7 },
  { 380, 4, 9, 4, 0, -9 },
  { 385, 5, 10, 7, 1, -7 },
  { 392, 5, 9, 7, 1, -9 },
  { 398, 1, 9, 3, 1, -9 },
  { 400, 2, 12, 3, 0, -9 },
  { 403, 5, 9, 6, 1, -9 },
  { 409, 1, 9, 3, 1, -9 },
  { 411, 8, 7, 10, 1, -7 },
  { 418, 5, 7, 7, 1, -7 },
  { 423, 5, 7, 7, 1, -7 },
  { 428, 5, 10, 7, 1, -7 },
  { 435, 5, 10, 7, 1, -7 },
  { 442, 3, 7, 4, 1, -7 },
  { 445, 4, 7, 5, 1, -7 },
  { 449, 4, 8, 4, 0, -8 },
  { 453, 5, 6, 7, 1, -6 },
  { 457, 5, 6, 5, 0, -6 },
  { 461, 9, 6, 9, 0, -6 },
  { 468, 5, 6, 6, 0, -6 },
  { 472, 5, 9, 6, 0, -6 },
  { 478, 5, 6, 5, 0, -6 },
  { 482, 4, 11, 4, 0, -9 },
  { 488, 1, 12, 6, 2, -9 },
  { 490, 4, 11, 4, 0, -9 },
  { 496, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_SemiCondensed_Regular12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR12PT7B_H_
