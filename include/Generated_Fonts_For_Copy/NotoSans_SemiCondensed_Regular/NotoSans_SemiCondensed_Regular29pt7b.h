#ifndef _NOTOSANS_SEMICONDENSED_REGULAR29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0x6D, 0xB6, 0xD8, 0x03, 0xFE, 0xE7, 0xC7, 0xC7,
  0xC7, 0xC6, 0xC6, 0xC6, 0xC2, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x31,
  0x80, 0x63, 0x01, 0x86, 0x1F, 0xFF, 0xBF, 0xFF, 0x0C, 0x30, 0x18, 0xC0,
  0x31, 0x80, 0xC3, 0x01, 0x86, 0x1F, 0xFF, 0xBF, 0xFF, 0x0C, 0x60, 0x18,
  0xC0, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x1C, 0x00, 0x04, 0x00, 0x40,
  0x06, 0x07, 0xFE, 0xFF, 0xEE, 0x42, 0xC4, 0x0C, 0x40, 0xC4, 0x0F, 0x40,
  0x7C, 0x03, 0xF8, 0x07, 0xC0, 0x4E, 0x04, 0x70, 0x47, 0x04, 0x78, 0x4E,
  0xFF, 0xEF, 0xF8, 0x1C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x3C, 0x03, 0x07,
  0xE0, 0x70, 0x67, 0x06, 0x06, 0x30, 0xE0, 0xE3, 0x0C, 0x0C, 0x30, 0xC0,
  0xC3, 0x18, 0x0C, 0x31, 0x80, 0xC3, 0x31, 0x86, 0x33, 0x7E, 0x67, 0x66,
  0x67, 0xE6, 0xE3, 0x3C, 0xCC, 0x30, 0x0C, 0xC3, 0x01, 0x8C, 0x30, 0x18,
  0xC3, 0x03, 0x0C, 0x30, 0x30, 0xC3, 0x06, 0x06, 0x60, 0x60, 0x7E, 0x0E,
  0x03, 0xC0, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0x8E, 0x00, 0xE1, 0x80, 0x30,
  0x60, 0x0E, 0x18, 0x03, 0x8E, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xEE, 0x0C, 0x71, 0xC3, 0x18, 0x39, 0xCE, 0x07, 0x63,
  0x81, 0xF8, 0xE0, 0x3C, 0x38, 0x0F, 0x07, 0x07, 0xE1, 0xFF, 0x9C, 0x1F,
  0xC3, 0xC0, 0xFB, 0x6D, 0xB6, 0x0E, 0x18, 0x61, 0xC3, 0x0E, 0x1C, 0x30,
  0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xC1, 0x83, 0x83, 0x06,
  0x0E, 0x0C, 0x0C, 0x1C, 0xC1, 0x87, 0x0C, 0x38, 0x61, 0x87, 0x1C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x71, 0xC6, 0x38, 0xE3, 0x1C, 0x63, 0x00,
  0x06, 0x00, 0x60, 0x06, 0x08, 0x61, 0xF6, 0xFF, 0xFF, 0x07, 0x00, 0xF0,
  0x1D, 0x83, 0x9C, 0x38, 0xE1, 0x08, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x77, 0x76, 0x6E, 0xC0, 0xFF, 0xFC, 0xFF,
  0x80, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x06,
  0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07,
  0x01, 0x80, 0xE0, 0x00, 0x0F, 0x80, 0xFE, 0x0E, 0x38, 0xE0, 0xE7, 0x07,
  0x30, 0x19, 0x80, 0xDC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1D, 0x80, 0xCC, 0x06, 0x70, 0x73, 0x83, 0x8E, 0x38, 0x7F,
  0xC0, 0xF8, 0x00, 0x07, 0x0F, 0x1F, 0x3F, 0xF7, 0x67, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x1F, 0x83, 0xFE, 0x3C, 0x38, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0x83, 0xFF, 0x3C, 0x38, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x30, 0x03, 0xB0, 0x3D, 0xFF, 0xC7, 0xF8, 0x00, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xD8, 0x03, 0xE0, 0x1B, 0x80, 0xEE, 0x03, 0x38,
  0x18, 0xE0, 0xE3, 0x83, 0x0E, 0x1C, 0x38, 0x60, 0xE3, 0x03, 0x8F, 0xFF,
  0xFF, 0xFF, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x7F,
  0xC7, 0xFC, 0x7F, 0xC6, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xDE,
  0x0F, 0xF8, 0x67, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x81, 0xCF, 0xFC, 0xFF, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0x80,
  0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x67, 0xC3, 0x7F, 0x3E,
  0x1D, 0xE0, 0x6E, 0x03, 0xB0, 0x1D, 0x80, 0xEC, 0x07, 0x70, 0x3B, 0x81,
  0x8E, 0x1C, 0x3F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xE0, 0xE6,
  0x03, 0x30, 0x19, 0xC1, 0xCE, 0x0C, 0x3C, 0xE0, 0xFC, 0x03, 0xE0, 0x7B,
  0xC7, 0x0F, 0x30, 0x3B, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xDC, 0x1C,
  0x7F, 0xC1, 0xFC, 0x00, 0x0F, 0x81, 0xFE, 0x1E, 0x38, 0xE0, 0xE6, 0x07,
  0x70, 0x1B, 0x80, 0xDC, 0x07, 0xE0, 0x3B, 0x03, 0xDC, 0x1E, 0x7F, 0xE1,
  0xFB, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x7F,
  0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x37, 0x77, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x76, 0x6E, 0xCC, 0x00, 0x18, 0x03, 0xC0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xE0, 0x0C, 0x00, 0x00, 0x3F, 0x1F, 0xF1, 0x87, 0x00, 0x60, 0x0E, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0xF8, 0x00,
  0x7F, 0xE0, 0x0F, 0x07, 0x81, 0xC0, 0x1C, 0x30, 0x00, 0xC7, 0x00, 0x06,
  0x60, 0xFC, 0x6E, 0x3F, 0xC7, 0xC3, 0x0C, 0x3C, 0x70, 0xC3, 0xC6, 0x0C,
  0x3C, 0x60, 0xC3, 0xC6, 0x0C, 0x3C, 0x60, 0xC3, 0xC6, 0x1C, 0x6C, 0x71,
  0x46, 0xC3, 0xF7, 0xCE, 0x1C, 0x38, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x02, 0x01, 0xF1, 0xE0, 0x0F, 0xFE, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x3B, 0x00, 0x19, 0xC0,
  0x0C, 0x60, 0x0E, 0x30, 0x06, 0x1C, 0x03, 0x0E, 0x03, 0x83, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x60, 0x1C, 0x70, 0x0E, 0x38, 0x03, 0x18,
  0x01, 0xDC, 0x00, 0xEE, 0x00, 0x38, 0xFF, 0x07, 0xFE, 0x31, 0xF9, 0x80,
  0xEC, 0x07, 0x60, 0x3B, 0x01, 0xD8, 0x0E, 0xC0, 0xE7, 0xFE, 0x3F, 0xF1,
  0x83, 0xCC, 0x07, 0x60, 0x1B, 0x00, 0xF8, 0x07, 0xC0, 0x36, 0x03, 0xB0,
  0x3D, 0xFF, 0xCF, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0xF3, 0xE3, 0x8E, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x87, 0xFE, 0x0F, 0xF8, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x30,
  0x1C, 0xC0, 0x3B, 0x00, 0x6C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x06, 0xC0, 0x3B,
  0x01, 0xCC, 0x1F, 0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xEF, 0xFB, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFB,
  0xFE, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x78, 0x71, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0x70, 0x06, 0xF0, 0x0C, 0xF0,
  0x18, 0xFF, 0xF0, 0x7F, 0xC0, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1C, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE7, 0xFF,
  0xE0, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFD, 0xF0,
  0x80, 0xC0, 0x3E, 0x03, 0xB0, 0x39, 0x81, 0x8C, 0x1C, 0x61, 0xC3, 0x1C,
  0x18, 0xC0, 0xCC, 0x06, 0xE0, 0x3F, 0x01, 0xFC, 0x0E, 0x70, 0x63, 0x83,
  0x0E, 0x18, 0x38, 0xC1, 0xC6, 0x07, 0x30, 0x1D, 0x80, 0xEC, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFF, 0xFF, 0xC0, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xB0, 0x0F, 0xF6, 0x01, 0xBE, 0xE0, 0x37, 0xCC, 0x0C,
  0xF9, 0x81, 0x9F, 0x38, 0x33, 0xE3, 0x0C, 0x7C, 0x61, 0x8F, 0x8E, 0x71,
  0xF0, 0xCC, 0x3E, 0x19, 0x87, 0xC3, 0xF0, 0xF8, 0x3C, 0x1F, 0x07, 0x83,
  0xE0, 0xF0, 0x7C, 0x0C, 0x0E, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0x60, 0x3D, 0xC0, 0xF3, 0x83, 0xCE, 0x0F, 0x1C, 0x3C, 0x30,
  0xF0, 0xE3, 0xC1, 0x8F, 0x07, 0x3C, 0x0E, 0xF0, 0x3B, 0xC0, 0x7F, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1C, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0x0F,
  0x0F, 0x01, 0xC7, 0x00, 0x67, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x06, 0xC0,
  0x03, 0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x37, 0x00, 0x1B,
  0x80, 0x1D, 0xC0, 0x0E, 0x70, 0x06, 0x38, 0x07, 0x0F, 0x07, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0xFC, 0x0F, 0xF8, 0xFF, 0xCC, 0x0E, 0xC0, 0x6C, 0x07,
  0xC0, 0x7C, 0x06, 0xC0, 0x6C, 0x0E, 0xC7, 0xCF, 0xF8, 0xFE, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x07,
  0xE0, 0x0F, 0xFC, 0x0F, 0x0F, 0x0F, 0x01, 0xC7, 0x00, 0x67, 0x00, 0x3B,
  0x80, 0x1D, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x1D, 0xC0, 0x0E, 0x70, 0x07, 0x38,
  0x07, 0x0F, 0x07, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x80, 0xFE, 0x07, 0xFC, 0x3F, 0xF9,
  0x81, 0xCC, 0x06, 0x60, 0x3B, 0x01, 0xD8, 0x0C, 0xC0, 0xE6, 0x07, 0x3F,
  0xF1, 0xFE, 0x0C, 0x30, 0x61, 0xC3, 0x06, 0x18, 0x38, 0xC0, 0xC6, 0x07,
  0x30, 0x1D, 0x80, 0xEC, 0x03, 0x80, 0x0F, 0xC3, 0xFF, 0x7C, 0xE7, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x07, 0xC0, 0xEF, 0xFE,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x06, 0x60, 0x0C, 0xE0,
  0x39, 0xE0, 0xE1, 0xFF, 0xC0, 0xFE, 0x00, 0xE0, 0x07, 0xE0, 0x06, 0x60,
  0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x30, 0x1C, 0x38, 0x1C, 0x38, 0x18, 0x18,
  0x18, 0x18, 0x38, 0x1C, 0x38, 0x0C, 0x30, 0x0C, 0x70, 0x0E, 0x70, 0x0E,
  0x60, 0x06, 0xE0, 0x06, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0xE0, 0x1C, 0x03, 0x60, 0x1C, 0x03, 0x60, 0x3C, 0x07, 0x70, 0x3C,
  0x07, 0x70, 0x3E, 0x06, 0x30, 0x36, 0x06, 0x30, 0x76, 0x0E, 0x38, 0x66,
  0x0E, 0x38, 0x67, 0x0C, 0x18, 0x63, 0x0C, 0x18, 0xE3, 0x1C, 0x1C, 0xC3,
  0x9C, 0x1C, 0xC3, 0x98, 0x1C, 0xC1, 0x98, 0x0D, 0xC1, 0x98, 0x0D, 0x81,
  0xB8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x60, 0x0E, 0xE0, 0x38, 0xE0, 0x61, 0xC1, 0xC1,
  0xC3, 0x03, 0x8E, 0x03, 0xB8, 0x03, 0x70, 0x07, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3E, 0x00, 0x6C, 0x01, 0xDC, 0x03, 0x18, 0x0E, 0x38, 0x18, 0x30,
  0x70, 0x70, 0xC0, 0x73, 0x80, 0xEE, 0x00, 0xE0, 0xE0, 0x0E, 0xC0, 0x39,
  0xC0, 0x71, 0x81, 0xC3, 0x83, 0x87, 0x0E, 0x07, 0x1C, 0x0E, 0x30, 0x0C,
  0xE0, 0x1D, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xFC, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01,
  0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0xFF, 0xF0,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xF0, 0x02, 0x00, 0x38, 0x01, 0xC0, 0x1B,
  0x00, 0xD8, 0x0C, 0x60, 0x63, 0x06, 0x0C, 0x30, 0x63, 0x81, 0x98, 0x0D,
  0xC0, 0x3C, 0x01, 0x80, 0xFF, 0xF8, 0xE1, 0xC3, 0x87, 0x0F, 0x83, 0xFC,
  0x30, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x71, 0xFF, 0x7E, 0x77, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0x7F, 0xF3, 0xF3, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9E, 0x1D, 0xFC, 0xF8, 0xE7,
  0x83, 0xB8, 0x0D, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xB8, 0x1D, 0xE0, 0xED, 0xFE, 0x67, 0xE0, 0x07, 0x83, 0xFC,
  0xF3, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80,
  0x30, 0x07, 0x00, 0x70, 0x4F, 0xF0, 0x7E, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x3C, 0xE3, 0xFB, 0x3C, 0xFB, 0x83, 0xDC,
  0x0E, 0xC0, 0x76, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0x60, 0x3B, 0x01,
  0xDC, 0x0E, 0xF0, 0xF3, 0xFD, 0x8F, 0xCC, 0x07, 0x81, 0xFC, 0x38, 0xE7,
  0x07, 0x70, 0x36, 0x03, 0x60, 0x3F, 0xFF, 0xFF, 0xF6, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x03, 0x81, 0x1F, 0xF0, 0xFE, 0x07, 0xC3, 0xF1, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0xFB, 0xFE, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x0F,
  0x18, 0xFE, 0xCE, 0x36, 0xE0, 0xF7, 0x03, 0xB0, 0x1D, 0x80, 0xFC, 0x07,
  0xE0, 0x1F, 0x01, 0xD8, 0x0E, 0xC0, 0x77, 0x03, 0x9C, 0x3C, 0xFF, 0x63,
  0xF3, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x67, 0x0F, 0x3F, 0xF0, 0x7E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8E,
  0xFE, 0xF8, 0xEF, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xFD, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1C, 0x70, 0xC0, 0x00, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0xEF, 0xBC, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x6E, 0x0E, 0xE1, 0xCE, 0x38, 0xE7, 0x0E, 0x60, 0xEC, 0x0F, 0xE0,
  0xFE, 0x0E, 0x70, 0xE3, 0x0E, 0x38, 0xE1, 0xCE, 0x1C, 0xE0, 0xEE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC7, 0x83, 0xCD,
  0xFC, 0xFE, 0xF9, 0xFC, 0xFF, 0x07, 0x07, 0xE0, 0x70, 0x3E, 0x07, 0x03,
  0xE0, 0x70, 0x3E, 0x06, 0x03, 0xE0, 0x60, 0x3E, 0x06, 0x03, 0xE0, 0x60,
  0x3E, 0x06, 0x03, 0xE0, 0x60, 0x3E, 0x06, 0x03, 0xE0, 0x60, 0x3E, 0x06,
  0x03, 0xC7, 0x8C, 0xFE, 0xF8, 0xEF, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0x07, 0x80, 0xFF, 0x0F, 0x3C, 0xE0, 0x67, 0x03, 0xB0, 0x0D, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xD8, 0x06, 0xC0, 0x77, 0x03, 0x9C, 0x38,
  0x7F, 0x81, 0xF8, 0xC7, 0x86, 0x7F, 0x3E, 0x39, 0xE0, 0xEE, 0x03, 0x70,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x6E, 0x07,
  0x78, 0x3B, 0xFF, 0x9D, 0xF8, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x0F, 0x18, 0xFE, 0xCF, 0x36, 0xE0, 0xF7,
  0x03, 0xB0, 0x1D, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x01, 0xD8, 0x0E, 0xC0,
  0x77, 0x03, 0xBC, 0x3C, 0xFF, 0x63, 0xF7, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xC7, 0xCF, 0xDF, 0xF0, 0xF0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1F,
  0x1F, 0xF7, 0x1B, 0x80, 0xE0, 0x38, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x1C, 0x03, 0x00, 0xE0, 0x7F, 0xF9, 0xFC, 0x18, 0x0C, 0x06, 0x07, 0xFF,
  0xF9, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x18, 0x0F, 0xC3, 0xE0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x77, 0x0F, 0x7F, 0xB3, 0xF3, 0xE0, 0x1F, 0x01, 0xD8, 0x0E, 0xE0, 0x67,
  0x07, 0x18, 0x38, 0xE1, 0x87, 0x1C, 0x18, 0xE0, 0xC6, 0x07, 0x70, 0x1B,
  0x80, 0xD8, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0xE0, 0x70, 0x3B, 0x03, 0x81,
  0x98, 0x1C, 0x0C, 0xE1, 0xB0, 0xE7, 0x0D, 0x87, 0x18, 0x6C, 0x30, 0xC7,
  0x61, 0x87, 0x33, 0x9C, 0x39, 0x8C, 0xE0, 0xCC, 0x66, 0x06, 0xE3, 0xB0,
  0x36, 0x0F, 0x81, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x38, 0x1E, 0x01, 0xC0,
  0x70, 0x70, 0x3B, 0x81, 0x8E, 0x1C, 0x31, 0xC1, 0xCC, 0x06, 0xE0, 0x3E,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0x70, 0x39, 0x81, 0x8E, 0x1C, 0x39,
  0xC0, 0xDC, 0x07, 0xE0, 0x1F, 0x01, 0xD8, 0x0E, 0xE0, 0x67, 0x07, 0x18,
  0x38, 0xE1, 0x83, 0x1C, 0x18, 0xE0, 0xE6, 0x03, 0x70, 0x1B, 0x80, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x7E, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x03, 0x01,
  0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0F, 0xFF,
  0xFF, 0x01, 0x83, 0xC3, 0xC3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x07, 0x0F, 0x07, 0x80, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x1E, 0x07, 0x80, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x78, 0x1E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x01, 0xC0, 0x78, 0x3C, 0x38, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x61, 0xF0, 0xF0, 0x60, 0x00, 0x7C, 0x0F, 0xFD,
  0xF0, 0xFD, 0x01, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Regular29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 21, 7, 2, -21 },
  { 9, 8, 8, 12, 2, -21 },
  { 17, 15, 21, 17, 1, -21 },
  { 57, 12, 24, 15, 2, -22 },
  { 93, 20, 21, 22, 1, -21 },
  { 146, 18, 21, 19, 1, -21 },
  { 194, 3, 8, 6, 2, -21 },
  { 197, 7, 26, 9, 1, -21 },
  { 220, 6, 26, 9, 1, -21 },
  { 240, 12, 12, 14, 1, -22 },
  { 258, 13, 14, 15, 1, -17 },
  { 281, 4, 7, 7, 1, -3 },
  { 285, 7, 2, 9, 1, -9 },
  { 287, 3, 3, 7, 2, -3 },
  { 289, 10, 21, 11, 0, -21 },
  { 316, 13, 21, 15, 1, -21 },
  { 351, 8, 21, 15, 2, -21 },
  { 372, 13, 21, 15, 1, -21 },
  { 407, 13, 21, 15, 1, -21 },
  { 442, 14, 21, 15, 1, -21 },
  { 479, 12, 21, 15, 2, -21 },
  { 511, 13, 21, 15, 1, -21 },
  { 546, 13, 21, 15, 1, -21 },
  { 581, 13, 21, 15, 1, -21 },
  { 616, 13, 21, 15, 1, -21 },
  { 651, 3, 16, 7, 2, -16 },
  { 657, 4, 20, 7, 1, -16 },
  { 667, 13, 13, 15, 1, -17 },
  { 689, 13, 8, 15, 1, -14 },
  { 702, 13, 13, 15, 1, -17 },
  { 724, 11, 21, 11, 0, -21 },
  { 753, 20, 24, 23, 2, -21 },
  { 813, 17, 21, 17, 0, -21 },
  { 858, 13, 21, 17, 3, -21 },
  { 893, 14, 21, 16, 2, -21 },
  { 930, 14, 21, 19, 3, -21 },
  { 967, 10, 21, 15, 3, -21 },
  { 994, 10, 21, 14, 3, -21 },
  { 1021, 15, 21, 19, 2, -21 },
  { 1061, 14, 21, 19, 3, -21 },
  { 1098, 7, 21, 9, 1, -21 },
  { 1117, 7, 27, 7, -2, -21 },
  { 1141, 13, 21, 16, 3, -21 },
  { 1176, 10, 21, 14, 3, -21 },
  { 1203, 19, 21, 24, 3, -21 },
  { 1253, 14, 21, 20, 3, -21 },
  { 1290, 17, 21, 20, 2, -21 },
  { 1335, 12, 21, 16, 3, -21 },
  { 1367, 17, 26, 20, 2, -21 },
  { 1423, 13, 21, 16, 3, -21 },
  { 1458, 12, 21, 14, 1, -21 },
  { 1490, 14, 21, 14, 0, -21 },
  { 1527, 15, 21, 19, 2, -21 },
  { 1567, 16, 21, 16, 0, -21 },
  { 1609, 24, 21, 25, 0, -21 },
  { 1672, 15, 21, 15, 0, -21 },
  { 1712, 15, 21, 15, 0, -21 },
  { 1752, 12, 21, 14, 1, -21 },
  { 1784, 7, 26, 9, 2, -21 },
  { 1807, 10, 21, 11, 0, -21 },
  { 1834, 6, 26, 9, 1, -21 },
  { 1854, 13, 13, 15, 1, -21 },
  { 1876, 13, 1, 13, 0, 3 },
  { 1878, 6, 4, 8, 1, -22 },
  { 1881, 12, 16, 15, 1, -16 },
  { 1905, 13, 22, 16, 2, -22 },
  { 1941, 11, 16, 13, 1, -16 },
  { 1963, 13, 22, 16, 1, -22 },
  { 1999, 12, 16, 15, 1, -16 },
  { 2023, 10, 22, 9, 0, -22 },
  { 2051, 13, 23, 16, 1, -16 },
  { 2089, 12, 22, 16, 2, -22 },
  { 2122, 3, 21, 7, 2, -21 },
  { 2130, 6, 28, 7, -1, -21 },
  { 2151, 12, 22, 14, 2, -22 },
  { 2184, 3, 22, 7, 2, -22 },
  { 2193, 20, 16, 24, 2, -16 },
  { 2233, 12, 16, 16, 2, -16 },
  { 2257, 13, 16, 16, 1, -16 },
  { 2283, 13, 23, 16, 2, -16 },
  { 2321, 13, 23, 16, 1, -16 },
  { 2359, 8, 16, 11, 2, -16 },
  { 2375, 10, 16, 12, 1, -16 },
  { 2395, 9, 19, 9, 0, -19 },
  { 2417, 12, 16, 16, 2, -16 },
  { 2441, 13, 16, 13, 0, -16 },
  { 2467, 21, 16, 21, 0, -16 },
  { 2509, 13, 16, 14, 0, -16 },
  { 2535, 13, 23, 13, 0, -16 },
  { 2573, 10, 16, 12, 1, -16 },
  { 2593, 9, 26, 11, 1, -21 },
  { 2623, 2, 29, 14, 6, -22 },
  { 2631, 9, 26, 11, 1, -21 },
  { 2661, 13, 4, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_Regular29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR29PT7B_H_
