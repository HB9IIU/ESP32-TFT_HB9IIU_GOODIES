#ifndef _NOTOSANS_SEMICONDENSED_REGULAR14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular14pt7bBitmaps[] PROGMEM = {
  0x00, 0xEA, 0xA8, 0xB0, 0xBB, 0x99, 0x12, 0x14, 0x14, 0x7F, 0x24, 0x24,
  0xFE, 0x28, 0x28, 0x48, 0x20, 0x8F, 0xA8, 0xA3, 0x83, 0x8B, 0x2F, 0xE2,
  0x08, 0xE2, 0x51, 0x29, 0x14, 0x8A, 0xBF, 0x64, 0x52, 0x29, 0x24, 0xB1,
  0xC0, 0x70, 0xC8, 0x48, 0x50, 0x20, 0xF2, 0x9A, 0x8E, 0x8E, 0xFB, 0xF0,
  0x6A, 0x49, 0x24, 0x91, 0x30, 0xC6, 0x22, 0x23, 0x32, 0x22, 0x6C, 0x21,
  0x2E, 0xC5, 0x6C, 0x20, 0x82, 0x3F, 0x20, 0x80, 0xEA, 0xF0, 0xB0, 0x08,
  0x84, 0x22, 0x11, 0x88, 0x46, 0x00, 0x72, 0x28, 0xA3, 0x8E, 0x38, 0xE2,
  0x89, 0xC0, 0x35, 0xB3, 0x33, 0x33, 0x33, 0xF2, 0x20, 0x82, 0x18, 0x42,
  0x10, 0x83, 0xF0, 0xFA, 0x20, 0x82, 0x70, 0x60, 0x83, 0x8B, 0xC0, 0x0C,
  0x28, 0x51, 0x22, 0x48, 0xB1, 0x7F, 0x04, 0x08, 0xFA, 0x08, 0x20, 0xF8,
  0x20, 0xC2, 0x8B, 0xC0, 0x39, 0x08, 0x20, 0xFA, 0x28, 0xE3, 0xC9, 0xE0,
  0xFC, 0x20, 0x86, 0x10, 0x42, 0x08, 0x61, 0x00, 0x7A, 0x28, 0xB2, 0x73,
  0x68, 0xA3, 0x8B, 0xE0, 0x72, 0x28, 0xA3, 0x8F, 0xF0, 0x82, 0x1B, 0xC0,
  0xB0, 0x0B, 0x4C, 0x00, 0x1A, 0x58, 0x0C, 0xCC, 0x30, 0x30, 0x30, 0xFC,
  0x00, 0x3F, 0x81, 0x81, 0x87, 0x62, 0x00, 0xF0, 0x42, 0x11, 0x10, 0x80,
  0x23, 0x00, 0x1E, 0x18, 0x44, 0x0A, 0x7A, 0x92, 0x68, 0x9A, 0x2A, 0x5A,
  0x89, 0x10, 0x03, 0xE0, 0x18, 0x18, 0x18, 0x24, 0x24, 0x24, 0x7E, 0x42,
  0x42, 0x81, 0xF9, 0x0A, 0x14, 0x2F, 0x91, 0xA1, 0x43, 0x85, 0xF0, 0x3D,
  0x0C, 0x20, 0x82, 0x08, 0x30, 0x40, 0xF0, 0xF9, 0x0A, 0x0C, 0x18, 0x30,
  0x60, 0xC3, 0x85, 0xF0, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x87, 0xC0, 0xFC,
  0x21, 0x08, 0x7E, 0x10, 0x84, 0x00, 0x3E, 0xC7, 0x04, 0x08, 0x11, 0xE0,
  0xE1, 0x42, 0x7C, 0x83, 0x06, 0x0C, 0x1F, 0xF0, 0x60, 0xC1, 0x83, 0x04,
  0xE9, 0x24, 0x92, 0x5C, 0x24, 0x92, 0x49, 0x24, 0xFC, 0x87, 0x12, 0x64,
  0x8A, 0x1A, 0x26, 0x44, 0x8D, 0x0C, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87,
  0xC0, 0xC0, 0xF8, 0x7A, 0x1E, 0x87, 0xB2, 0xE4, 0xB9, 0x6E, 0x73, 0x8C,
  0xE3, 0x30, 0xC3, 0xC6, 0x8D, 0x99, 0x33, 0x62, 0xC3, 0x87, 0x04, 0x3C,
  0x42, 0xC3, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x42, 0x3C, 0xFA, 0x38, 0x61,
  0x8F, 0xE8, 0x20, 0x82, 0x00, 0x3C, 0x42, 0xC3, 0x81, 0x81, 0x81, 0x81,
  0xC3, 0x42, 0x3C, 0x0C, 0x07, 0xF9, 0x1A, 0x14, 0x28, 0xDE, 0x26, 0x44,
  0x8D, 0x0C, 0x7C, 0x21, 0x06, 0x1C, 0x21, 0x8F, 0x80, 0xFE, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x46, 0xF8, 0x83, 0xC2, 0x42, 0x44, 0x64, 0x24, 0x2C, 0x38, 0x18,
  0x18, 0xC6, 0x3C, 0x62, 0x46, 0x24, 0xE2, 0x49, 0x66, 0x94, 0x29, 0x43,
  0x94, 0x30, 0xC3, 0x08, 0xC6, 0x88, 0xB1, 0x41, 0x83, 0x0A, 0x32, 0x45,
  0x84, 0xC6, 0x89, 0x11, 0x42, 0x82, 0x04, 0x08, 0x10, 0x20, 0x7C, 0x10,
  0x82, 0x10, 0xC2, 0x18, 0x43, 0xF0, 0xF2, 0x49, 0x24, 0x92, 0x70, 0xC2,
  0x10, 0xC2, 0x10, 0x42, 0x10, 0x40, 0xE4, 0x92, 0x49, 0x24, 0xF0, 0x10,
  0x50, 0xA1, 0x24, 0x58, 0x40, 0xFC, 0xB4, 0x76, 0xC2, 0x7C, 0xC6, 0x7D,
  0x82, 0x08, 0x2C, 0xCA, 0x18, 0x61, 0x87, 0x3B, 0x80, 0x3E, 0xA1, 0x08,
  0x43, 0x0F, 0x04, 0x10, 0x49, 0xDE, 0x38, 0x61, 0x8E, 0x37, 0x40, 0x33,
  0x68, 0xBE, 0x86, 0x0C, 0x1E, 0x39, 0x18, 0xEE, 0x31, 0x8C, 0x63, 0x18,
  0x27, 0x78, 0xE1, 0x86, 0x38, 0xDD, 0x04, 0x3F, 0x80, 0x82, 0x08, 0x2C,
  0xCE, 0x18, 0x61, 0x86, 0x18, 0x40, 0xBF, 0xC0, 0x20, 0x92, 0x49, 0x24,
  0x9E, 0x82, 0x08, 0x23, 0x9A, 0x4A, 0x38, 0x92, 0x68, 0xC0, 0xFF, 0xE0,
  0xB1, 0x33, 0xA8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xB3, 0x38,
  0x61, 0x86, 0x18, 0x61, 0x33, 0x28, 0xE1, 0x86, 0x18, 0xDE, 0xB3, 0x38,
  0x61, 0x86, 0x1C, 0xEE, 0x82, 0x08, 0x00, 0x27, 0x78, 0xE1, 0x86, 0x38,
  0xDD, 0x04, 0x10, 0x40, 0x9F, 0xC8, 0x88, 0x88, 0x69, 0x8C, 0x71, 0x1F,
  0x47, 0xC4, 0x44, 0x44, 0x30, 0x86, 0x18, 0x61, 0x86, 0x38, 0xDD, 0x87,
  0x14, 0xD2, 0x68, 0xA3, 0x0C, 0x8C, 0x73, 0x34, 0xC9, 0x3A, 0x52, 0x9C,
  0xA3, 0x30, 0xCC, 0xC5, 0x32, 0x8C, 0x30, 0xA4, 0xB1, 0x87, 0x14, 0x52,
  0x68, 0xA3, 0x0C, 0x10, 0x8E, 0x00, 0x78, 0x46, 0x22, 0x31, 0x1F, 0x19,
  0x08, 0x42, 0x33, 0x84, 0x21, 0x08, 0x30, 0xFF, 0xFC, 0xC1, 0x08, 0x42,
  0x18, 0x64, 0x21, 0x09, 0xC0, 0xE6, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Regular14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 4, 4, 6, 1, -10 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 6, 12, 7, 1, -11 },
  { 25, 9, 10, 11, 1, -10 },
  { 37, 8, 10, 9, 1, -10 },
  { 47, 1, 4, 3, 1, -10 },
  { 48, 3, 12, 4, 1, -10 },
  { 53, 4, 12, 4, 0, -10 },
  { 59, 5, 6, 7, 1, -11 },
  { 63, 6, 6, 7, 1, -8 },
  { 68, 2, 4, 4, 1, -2 },
  { 69, 4, 1, 4, 0, -4 },
  { 70, 2, 2, 4, 1, -2 },
  { 71, 5, 10, 5, 0, -10 },
  { 78, 6, 10, 7, 1, -10 },
  { 86, 4, 10, 7, 1, -10 },
  { 91, 6, 10, 7, 1, -10 },
  { 99, 6, 10, 7, 1, -10 },
  { 107, 7, 10, 7, 0, -10 },
  { 116, 6, 10, 7, 1, -10 },
  { 124, 6, 10, 7, 1, -10 },
  { 132, 6, 10, 7, 1, -10 },
  { 140, 6, 10, 7, 1, -10 },
  { 148, 6, 10, 7, 1, -10 },
  { 156, 2, 8, 4, 1, -8 },
  { 158, 3, 10, 4, 0, -8 },
  { 162, 6, 6, 7, 1, -8 },
  { 167, 6, 4, 7, 1, -7 },
  { 170, 6, 6, 7, 1, -8 },
  { 175, 5, 10, 5, 0, -10 },
  { 182, 10, 11, 11, 1, -10 },
  { 196, 8, 10, 8, 0, -10 },
  { 206, 7, 10, 8, 1, -10 },
  { 215, 6, 10, 8, 1, -10 },
  { 223, 7, 10, 9, 1, -10 },
  { 232, 5, 10, 7, 1, -10 },
  { 239, 5, 10, 7, 1, -10 },
  { 246, 7, 10, 9, 1, -10 },
  { 255, 7, 10, 9, 1, -10 },
  { 264, 3, 10, 4, 1, -10 },
  { 268, 3, 13, 4, -1, -10 },
  { 273, 7, 10, 8, 1, -10 },
  { 282, 5, 10, 7, 1, -10 },
  { 289, 10, 10, 12, 1, -10 },
  { 302, 7, 10, 10, 1, -10 },
  { 311, 8, 10, 10, 1, -10 },
  { 321, 6, 10, 8, 1, -10 },
  { 329, 8, 12, 10, 1, -10 },
  { 341, 7, 10, 8, 1, -10 },
  { 350, 5, 10, 7, 1, -10 },
  { 357, 7, 10, 7, 0, -10 },
  { 366, 7, 10, 9, 1, -10 },
  { 375, 8, 10, 8, 0, -10 },
  { 385, 12, 10, 12, 0, -10 },
  { 400, 7, 10, 7, 0, -10 },
  { 409, 7, 10, 7, 0, -10 },
  { 418, 6, 10, 7, 0, -10 },
  { 426, 3, 12, 5, 1, -10 },
  { 431, 5, 10, 5, 0, -10 },
  { 438, 3, 12, 5, 0, -10 },
  { 443, 7, 6, 7, 0, -10 },
  { 449, 6, 1, 6, 0, 1 },
  { 450, 2, 3, 4, 1, -11 },
  { 451, 5, 8, 7, 1, -8 },
  { 456, 6, 11, 8, 1, -11 },
  { 465, 5, 8, 6, 1, -8 },
  { 470, 6, 11, 8, 1, -11 },
  { 479, 6, 8, 7, 1, -8 },
  { 485, 5, 11, 4, 0, -11 },
  { 492, 6, 11, 8, 1, -8 },
  { 501, 6, 11, 8, 1, -11 },
  { 510, 1, 10, 3, 1, -10 },
  { 512, 3, 13, 3, -1, -10 },
  { 517, 6, 11, 7, 1, -11 },
  { 526, 1, 11, 3, 1, -11 },
  { 528, 10, 8, 12, 1, -8 },
  { 538, 6, 8, 8, 1, -8 },
  { 544, 6, 8, 8, 1, -8 },
  { 550, 6, 11, 8, 1, -8 },
  { 559, 6, 11, 8, 1, -8 },
  { 568, 4, 8, 5, 1, -8 },
  { 572, 4, 8, 6, 1, -8 },
  { 576, 4, 9, 5, 0, -9 },
  { 581, 6, 8, 8, 1, -8 },
  { 587, 6, 8, 6, 0, -8 },
  { 593, 10, 8, 10, 0, -8 },
  { 603, 6, 8, 7, 0, -8 },
  { 609, 6, 11, 6, 0, -8 },
  { 618, 5, 8, 6, 0, -8 },
  { 623, 5, 12, 5, 0, -10 },
  { 631, 1, 14, 7, 3, -11 },
  { 633, 5, 12, 5, 0, -10 },
  { 641, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_Regular14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR14PT7B_H_
