#ifndef _NOTOSANS_SEMICONDENSED_REGULAR43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xBD, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x38, 0x00, 0x00, 0x1D, 0xFF, 0xFF, 0xE4, 0xF1, 0xFE, 0x3F,
  0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0x80, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x60,
  0x01, 0xC1, 0xC0, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0,
  0x38, 0x1C, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03,
  0x83, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x81, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0,
  0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xF9, 0xFB,
  0x3E, 0x78, 0xC0, 0xBC, 0x30, 0x0F, 0x0C, 0x03, 0xC3, 0x00, 0xF0, 0xC0,
  0x1E, 0x30, 0x07, 0xCC, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xC7, 0xC0, 0x30, 0xF0, 0x0C, 0x1C, 0x03,
  0x07, 0x00, 0xC1, 0xC0, 0x30, 0xFC, 0x0C, 0x7F, 0xF3, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x0E, 0x01, 0xFE, 0x00, 0x70, 0x1F,
  0xF0, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0x07, 0x0E, 0x03, 0x80, 0x70, 0x70,
  0x1C, 0x03, 0x83, 0xC1, 0xE0, 0x1C, 0x0E, 0x0E, 0x00, 0xE0, 0x70, 0xF0,
  0x07, 0x03, 0x87, 0x00, 0x38, 0x1C, 0x78, 0x01, 0xC0, 0xE3, 0x80, 0x0E,
  0x0F, 0x3C, 0x78, 0x70, 0x71, 0xC7, 0xF1, 0xC3, 0x9E, 0x7F, 0x8E, 0x1C,
  0xE7, 0x8E, 0x7F, 0xC7, 0x38, 0x71, 0xFE, 0x71, 0xC1, 0xC7, 0xC3, 0x8E,
  0x0E, 0x00, 0x38, 0x70, 0x70, 0x01, 0xC7, 0x03, 0x80, 0x1C, 0x38, 0x1C,
  0x00, 0xE1, 0xC0, 0xE0, 0x0E, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x38, 0x07,
  0x01, 0xC1, 0xC0, 0x38, 0x0E, 0x0E, 0x03, 0x80, 0x70, 0xE0, 0x1C, 0x01,
  0xEF, 0x01, 0xC0, 0x0F, 0xF0, 0x0E, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xE0, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0x87, 0x80, 0x01, 0xE7, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF8, 0x0F, 0x1F, 0x3C, 0x07, 0x1E, 0x0F, 0x07, 0x8F, 0x03, 0xC3, 0xCF,
  0x01, 0xF1, 0xE7, 0x80, 0x7D, 0xE3, 0xC0, 0x1F, 0xF1, 0xE0, 0x07, 0xF0,
  0xF0, 0x01, 0xF0, 0x78, 0x00, 0xFC, 0x3E, 0x00, 0xFE, 0x0F, 0x81, 0xFF,
  0x87, 0xFF, 0xFB, 0xE1, 0xFF, 0xF0, 0xF8, 0x3F, 0xE0, 0x3E, 0xFF, 0xFF,
  0xEE, 0xEE, 0xEE, 0xE0, 0x03, 0x83, 0xC3, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0,
  0x78, 0x38, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0F, 0x07,
  0x83, 0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0xF0,
  0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x78, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x0F, 0x1C, 0x3B, 0xFF, 0xFE, 0xFF, 0xFF, 0x8F, 0xFF, 0x90, 0x3E, 0x00,
  0x1D, 0xC0, 0x0F, 0x78, 0x03, 0x8E, 0x01, 0xE3, 0xC0, 0xF8, 0x78, 0x1C,
  0x1C, 0x01, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x3C, 0xF7, 0x9E, 0x79, 0xC7, 0x3C, 0xE3, 0x8C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x77, 0xFF, 0xFF, 0x90, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xF8, 0x7C, 0x3C, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x0E,
  0x70, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x0F,
  0x78, 0x03, 0x9E, 0x01, 0xE3, 0xC0, 0x78, 0xF8, 0x3C, 0x1F, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0xE0, 0x3C, 0x0F, 0x87, 0xF1, 0xFE, 0x7D,
  0xFF, 0x3B, 0x87, 0x20, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xE3, 0xF0, 0x7C, 0x70, 0x0F, 0x88, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F,
  0xFF, 0x0F, 0xFF, 0xF3, 0xE0, 0x7C, 0x60, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0x7B, 0x80, 0x7E,
  0xFF, 0xFF, 0x3F, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xE7, 0x80, 0x0E, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x0F, 0x00, 0x70, 0x78, 0x07, 0x83, 0xC0, 0x38, 0x1E, 0x03, 0xC0,
  0xF0, 0x1C, 0x07, 0x81, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xF0, 0xE1, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE8, 0x00, 0xFB, 0x80, 0x7C, 0xFF, 0xFF, 0x3F, 0xFF,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x71, 0xFC, 0x3D, 0xFF, 0xCF, 0x7F,
  0xF3, 0xF8, 0x3E, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0x78, 0x03, 0xDE,
  0x00, 0xF3, 0xC0, 0x78, 0xF8, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x07,
  0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xF8, 0x3E, 0x78, 0x07, 0x9E, 0x00,
  0xE7, 0x00, 0x3D, 0xC0, 0x0F, 0x70, 0x03, 0x9E, 0x01, 0xE7, 0x80, 0x78,
  0xF0, 0x3C, 0x1F, 0x1E, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x1F,
  0xFE, 0x0F, 0x8F, 0xC7, 0xC0, 0xF9, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3D,
  0xF0, 0x1E, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xF0, 0x03,
  0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x7C, 0x78, 0x0F, 0x1E, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x7D, 0xE0, 0x3F, 0x3F, 0x7F, 0xCF,
  0xFE, 0xF0, 0xFF, 0x3C, 0x06, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xF7, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xFF, 0xE4, 0x3C, 0x7C,
  0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF9, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xE1, 0xC3, 0x8E, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70,
  0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03,
  0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0xE3, 0xFF,
  0xE7, 0x83, 0xE4, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x02, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xC0,
  0x03, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x3F, 0xF0, 0xF3, 0x81, 0xFF, 0xC1,
  0xDE, 0x0F, 0x07, 0x07, 0x70, 0x78, 0x1C, 0x1D, 0xC1, 0xC0, 0x70, 0x77,
  0x07, 0x01, 0xC1, 0xFC, 0x3C, 0x07, 0x07, 0xE0, 0xE0, 0x3C, 0x1F, 0x83,
  0x80, 0xF0, 0x7E, 0x0E, 0x03, 0xC1, 0xF8, 0x38, 0x0F, 0x07, 0xE0, 0xF0,
  0x3C, 0x1F, 0x81, 0xC0, 0xF0, 0x77, 0x07, 0x06, 0xC3, 0x9C, 0x1F, 0x7B,
  0xBE, 0x70, 0x3F, 0xCF, 0xF1, 0xE0, 0x7E, 0x1F, 0x83, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x20, 0x01, 0xF8, 0x07, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x77,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x80, 0x01, 0xE3,
  0x80, 0x01, 0xC3, 0xC0, 0x01, 0xC3, 0xC0, 0x03, 0xC1, 0xC0, 0x03, 0x81,
  0xE0, 0x03, 0x81, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0x00,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1E, 0x00,
  0x78, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0x00, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0,
  0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xCF, 0x00, 0x79, 0xFF,
  0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x9E, 0x00, 0xFB, 0xC0,
  0x0F, 0x78, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0x78, 0x0F, 0xEF, 0xFF,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x1F, 0xC1, 0xE0, 0xF8, 0x01, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x60, 0x7F, 0xFF, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0xF0, 0x0F, 0xC3, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00,
  0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x01,
  0xF3, 0xC0, 0x0F, 0x8F, 0x00, 0x7C, 0x3C, 0x0F, 0xE0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFD, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFB, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xF0, 0x7C, 0x0F, 0x80, 0x04, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x70, 0x03, 0xFF, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x7C, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1F, 0x80,
  0x0F, 0x0F, 0xE0, 0x1F, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x7F, 0xBF,
  0xFF, 0xFC, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3E, 0x3F, 0xFF,
  0xBF, 0xCF, 0xE0, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00,
  0x78, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0xF0,
  0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F,
  0x78, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0x9E, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x80, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x3E,
  0x0F, 0x01, 0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00,
  0x7C, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFE, 0xE0, 0x00, 0x77, 0xEE, 0x00, 0x07, 0x7E, 0xF0, 0x00, 0xF7,
  0xE7, 0x00, 0x0E, 0x7E, 0x70, 0x00, 0xE7, 0xE7, 0x80, 0x1E, 0x7E, 0x38,
  0x01, 0xC7, 0xE3, 0x80, 0x1C, 0x7E, 0x3C, 0x03, 0xC7, 0xE1, 0xC0, 0x38,
  0x7E, 0x1C, 0x07, 0x87, 0xE1, 0xE0, 0x78, 0x7E, 0x0E, 0x07, 0x07, 0xE0,
  0xF0, 0xF0, 0x7E, 0x0F, 0x0E, 0x07, 0xE0, 0x70, 0xE0, 0x7E, 0x07, 0x9E,
  0x07, 0xE0, 0x79, 0xC0, 0x7E, 0x03, 0x9C, 0x07, 0xE0, 0x3F, 0xC0, 0x7E,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x70, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFE, 0xF0, 0x03, 0xFB, 0xC0, 0x0F, 0xE7, 0x80, 0x3F, 0x9E, 0x00,
  0xFE, 0x3C, 0x03, 0xF8, 0xF8, 0x0F, 0xE1, 0xE0, 0x3F, 0x83, 0xC0, 0xFE,
  0x0F, 0x03, 0xF8, 0x1E, 0x0F, 0xE0, 0x78, 0x3F, 0x80, 0xF0, 0xFE, 0x03,
  0xE3, 0xF8, 0x07, 0x8F, 0xE0, 0x0F, 0x3F, 0x80, 0x3C, 0xFE, 0x00, 0x7B,
  0xF8, 0x01, 0xE7, 0xE0, 0x03, 0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x87, 0xF0,
  0x1F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x81,
  0xF0, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xF0, 0x1F, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF,
  0x00, 0xF3, 0xC1, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0x87, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x01,
  0xF0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0xF0, 0x1F, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0xF0,
  0x07, 0x8F, 0x00, 0x7C, 0xF0, 0x03, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xF0,
  0x03, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xF9, 0xFC, 0x7C, 0x78, 0x01, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE8, 0x00,
  0xFB, 0x80, 0x7C, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xDE, 0x00, 0x1E, 0xF0,
  0x00, 0xF7, 0x80, 0x07, 0x9E, 0x00, 0x78, 0xFC, 0x0F, 0xC3, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D,
  0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xC7, 0x80, 0x07, 0x8F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0xE0, 0x78,
  0x03, 0xC0, 0x70, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x78, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x0E, 0x0F,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x38, 0xF0, 0x00, 0x79, 0xC0,
  0x00, 0xF7, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x00, 0x0F, 0x78, 0x00, 0xF8,
  0x00, 0xF7, 0x80, 0x0F, 0x80, 0x0E, 0x78, 0x01, 0xF8, 0x01, 0xE3, 0xC0,
  0x1F, 0x80, 0x1E, 0x3C, 0x01, 0xFC, 0x01, 0xE3, 0xC0, 0x1D, 0xC0, 0x1E,
  0x3C, 0x03, 0xDC, 0x03, 0xC1, 0xC0, 0x39, 0xE0, 0x3C, 0x1E, 0x03, 0x9E,
  0x03, 0xC1, 0xE0, 0x78, 0xE0, 0x3C, 0x1E, 0x07, 0x8E, 0x03, 0x80, 0xE0,
  0x70, 0xF0, 0x78, 0x0F, 0x07, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x70, 0x78,
  0x0F, 0x0F, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x78, 0xF0, 0x07, 0x8E, 0x07,
  0x8F, 0x00, 0x79, 0xE0, 0x38, 0xF0, 0x07, 0x9E, 0x03, 0x8E, 0x00, 0x39,
  0xC0, 0x3D, 0xE0, 0x03, 0x9C, 0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x1D, 0xE0,
  0x03, 0xFC, 0x01, 0xDC, 0x00, 0x1F, 0x80, 0x1D, 0xC0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0xF0,
  0x01, 0xE3, 0xC0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x0F, 0x1C, 0x00,
  0x1C, 0xF0, 0x00, 0x7B, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x73, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x03,
  0xC0, 0xF0, 0x0F, 0x03, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x7D, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9F, 0x00, 0x3C, 0x3C, 0x00, 0xF0,
  0xF0, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x3C,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x38,
  0x00, 0x1D, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3D, 0xC0, 0x03, 0x9C, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00,
  0x70, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x3C,
  0x38, 0x01, 0xC3, 0x80, 0x1E, 0x78, 0x00, 0xEF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x0F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xC7, 0xFF,
  0xE7, 0xFF, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xF7, 0xFF, 0xFB, 0xFF, 0x9C,
  0x7F, 0x0E, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC7, 0xF0, 0x7B, 0xFF, 0x8F, 0xFF, 0xF9, 0xFC, 0x0F, 0x3E,
  0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0xC0, 0x3D, 0xFC,
  0x0F, 0x3F, 0xFF, 0xE7, 0x3F, 0xF8, 0xE1, 0xFC, 0x00, 0x07, 0xFE, 0x1F,
  0xFC, 0x7F, 0xF9, 0xF0, 0x23, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x11, 0xFF,
  0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x1F, 0xE7, 0x8F, 0xFE, 0xF3, 0xFF, 0xFE,
  0x7C, 0x0F, 0xDF, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xF7,
  0xC0, 0x3E, 0x7C, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xE7, 0x07, 0xF0, 0xE0,
  0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF0, 0x3C, 0x38, 0x07, 0x9E,
  0x00, 0xE7, 0x00, 0x3D, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x06, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0x83, 0xE2, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x07, 0xFF, 0x3F,
  0xFC, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x07, 0xF8, 0xE3, 0xFF, 0xBC, 0x7F, 0xFF, 0x9F, 0x07, 0xF7,
  0xC0, 0x7E, 0xF0, 0x07, 0xDE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0x9F,
  0x03, 0xF3, 0xFF, 0xFE, 0x3F, 0xFB, 0xC1, 0xFC, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE4, 0x00, 0x3C, 0x60,
  0x1F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x1F, 0xE3, 0xDF, 0xFC,
  0xFF, 0xFF, 0xBF, 0x81, 0xEF, 0xC0, 0x7B, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xC0,
  0x6F, 0xFF, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x03, 0xC1, 0xE0, 0xF0, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3F,
  0xFE, 0xFF, 0x7F, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0xFB, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F,
  0x07, 0x83, 0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x3C, 0x03, 0xDE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xDE, 0x03, 0xE7, 0xC0, 0xF0, 0xF0,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x3E, 0x3C, 0x07, 0x8F,
  0x00, 0xF3, 0xC0, 0x3E, 0xF0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE3, 0xFC, 0x1F, 0xE3, 0xDF, 0xF8, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xBF,
  0x03, 0xF8, 0x1E, 0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0xFF, 0x80,
  0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E,
  0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80,
  0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F,
  0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC,
  0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00,
  0x78, 0x03, 0xC0, 0xE1, 0xFE, 0x3D, 0xFF, 0xCF, 0xFF, 0xFB, 0xF0, 0x1E,
  0xF8, 0x07, 0xBE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C, 0x07, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1F, 0x03, 0xC7, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7B, 0x80, 0x0F, 0x78, 0x01, 0xEF,
  0x00, 0x78, 0xF0, 0x0F, 0x1F, 0x03, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00,
  0xFF, 0x00, 0xE3, 0xFC, 0x1E, 0xFF, 0xE3, 0xFF, 0xFE, 0x7E, 0x03, 0xCF,
  0x80, 0x7D, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xF0, 0x1F, 0x7F,
  0x07, 0xCF, 0xFF, 0xF9, 0xEF, 0xFE, 0x3C, 0x7F, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0xE3,
  0xFF, 0xBC, 0x7F, 0xFF, 0x9F, 0x03, 0xF7, 0xC0, 0x3E, 0xF0, 0x07, 0xDE,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x78,
  0x01, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0x9F, 0x03, 0xF3, 0xFF, 0xFE, 0x3F,
  0xFB, 0xC1, 0xFC, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0xE1, 0xFE, 0x3F, 0xF7, 0xFF, 0xF0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xF9, 0xFF, 0xF7, 0x80, 0x4F, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x76, 0x01, 0xEF, 0xFF, 0xDF, 0xFF, 0x1F, 0xF8, 0x00, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E,
  0x01, 0xFF, 0x0F, 0xF0, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xF7, 0x80, 0xFD,
  0xE0, 0x7F, 0x7F, 0xFF, 0xCF, 0xFE, 0xF1, 0xFE, 0x1C, 0xF0, 0x00, 0xF7,
  0x00, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x38, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x03, 0x81, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x0E, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1E, 0x00, 0x79,
  0xC0, 0x03, 0x9C, 0x00, 0x3B, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x1D, 0xE0,
  0x1F, 0x00, 0xF7, 0x80, 0x7C, 0x03, 0xDE, 0x03, 0xF8, 0x0F, 0x38, 0x0E,
  0xE0, 0x38, 0xF0, 0x3B, 0x81, 0xE3, 0xC0, 0xEE, 0x07, 0x8F, 0x07, 0xBC,
  0x1E, 0x1C, 0x1C, 0x70, 0x70, 0x70, 0x71, 0xC3, 0xC1, 0xE1, 0xC7, 0x0F,
  0x07, 0x8F, 0x1E, 0x3C, 0x0E, 0x38, 0x38, 0xE0, 0x38, 0xE0, 0xE3, 0x80,
  0xF7, 0x83, 0x9E, 0x03, 0xDE, 0x0F, 0x78, 0x07, 0x70, 0x1D, 0xC0, 0x1D,
  0xC0, 0x77, 0x00, 0x77, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0,
  0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x03,
  0xCF, 0x00, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0x81, 0xE0, 0xE0, 0x3C, 0x3C,
  0x03, 0xCF, 0x00, 0x3D, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x79, 0xE0,
  0x0F, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x87, 0x80, 0x78,
  0xF0, 0x07, 0xBC, 0x00, 0xF8, 0xF0, 0x00, 0xF7, 0x00, 0x1E, 0x78, 0x01,
  0xE7, 0x80, 0x1C, 0x38, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0x81, 0xC0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x0E, 0x0F, 0x00, 0xF0, 0xF0, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0x07, 0x9E, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1C, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFF,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x01,
  0xFC, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x03,
  0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x2F, 0xF8, 0x0F,
  0xFF, 0xEF, 0xF0, 0xFF, 0xE8, 0x07, 0xF9, 0x00, 0x0C, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 32, 11, 3, -31 },
  { 21, 11, 11, 17, 3, -31 },
  { 37, 23, 31, 25, 1, -31 },
  { 127, 18, 36, 22, 2, -33 },
  { 208, 29, 31, 33, 2, -31 },
  { 321, 25, 31, 27, 2, -31 },
  { 418, 4, 11, 9, 3, -31 },
  { 424, 9, 38, 13, 2, -31 },
  { 467, 10, 38, 13, 1, -31 },
  { 515, 18, 18, 21, 2, -33 },
  { 556, 18, 20, 22, 2, -25 },
  { 601, 6, 11, 11, 2, -5 },
  { 610, 11, 3, 13, 1, -13 },
  { 615, 5, 6, 11, 3, -5 },
  { 619, 15, 31, 16, 1, -31 },
  { 678, 18, 31, 22, 2, -31 },
  { 748, 11, 31, 22, 3, -31 },
  { 791, 18, 31, 22, 2, -31 },
  { 861, 18, 31, 22, 2, -31 },
  { 931, 21, 31, 22, 1, -31 },
  { 1013, 18, 31, 22, 2, -31 },
  { 1083, 18, 31, 22, 2, -31 },
  { 1153, 18, 31, 22, 2, -31 },
  { 1223, 18, 31, 22, 2, -31 },
  { 1293, 18, 31, 22, 2, -31 },
  { 1363, 5, 24, 11, 3, -23 },
  { 1378, 7, 29, 11, 1, -23 },
  { 1404, 19, 21, 22, 2, -26 },
  { 1454, 18, 12, 22, 2, -21 },
  { 1481, 19, 21, 22, 2, -26 },
  { 1531, 15, 32, 17, 1, -31 },
  { 1591, 30, 35, 35, 2, -31 },
  { 1723, 24, 31, 25, 0, -31 },
  { 1816, 19, 31, 25, 4, -31 },
  { 1890, 21, 31, 24, 2, -31 },
  { 1972, 22, 31, 28, 4, -31 },
  { 2058, 15, 31, 22, 4, -31 },
  { 2117, 15, 31, 20, 4, -31 },
  { 2176, 24, 31, 28, 2, -31 },
  { 2269, 21, 31, 29, 4, -31 },
  { 2351, 10, 31, 14, 2, -31 },
  { 2390, 10, 39, 11, -3, -31 },
  { 2439, 20, 31, 24, 4, -31 },
  { 2517, 15, 31, 20, 4, -31 },
  { 2576, 28, 31, 36, 4, -31 },
  { 2685, 22, 31, 30, 4, -31 },
  { 2771, 26, 31, 30, 2, -31 },
  { 2872, 18, 31, 23, 4, -31 },
  { 2942, 26, 38, 30, 2, -31 },
  { 3066, 20, 31, 24, 4, -31 },
  { 3144, 18, 31, 21, 2, -31 },
  { 3214, 21, 31, 21, 0, -31 },
  { 3296, 21, 31, 28, 4, -31 },
  { 3378, 23, 31, 23, 0, -31 },
  { 3468, 36, 31, 37, 0, -31 },
  { 3608, 22, 31, 22, 0, -31 },
  { 3694, 22, 31, 22, 0, -31 },
  { 3780, 19, 31, 21, 1, -31 },
  { 3854, 10, 38, 14, 3, -31 },
  { 3902, 15, 31, 16, 1, -31 },
  { 3961, 10, 38, 14, 1, -31 },
  { 4009, 20, 18, 23, 1, -31 },
  { 4054, 19, 3, 19, 0, 4 },
  { 4062, 8, 7, 12, 2, -33 },
  { 4069, 17, 23, 22, 2, -23 },
  { 4118, 19, 33, 24, 3, -33 },
  { 4197, 15, 23, 19, 2, -23 },
  { 4241, 19, 33, 24, 2, -33 },
  { 4320, 18, 23, 22, 2, -23 },
  { 4372, 14, 33, 13, 1, -33 },
  { 4430, 19, 33, 24, 2, -23 },
  { 4509, 18, 33, 24, 3, -33 },
  { 4584, 4, 32, 10, 3, -32 },
  { 4600, 9, 42, 10, -2, -32 },
  { 4648, 18, 33, 21, 3, -33 },
  { 4723, 4, 33, 10, 3, -33 },
  { 4740, 30, 23, 36, 3, -23 },
  { 4827, 18, 23, 24, 3, -23 },
  { 4879, 19, 23, 23, 2, -23 },
  { 4934, 19, 33, 24, 3, -23 },
  { 5013, 19, 33, 24, 2, -23 },
  { 5092, 12, 23, 16, 3, -23 },
  { 5127, 15, 23, 18, 2, -23 },
  { 5171, 12, 28, 14, 1, -28 },
  { 5213, 18, 23, 24, 3, -23 },
  { 5265, 20, 23, 20, 0, -23 },
  { 5323, 30, 23, 31, 0, -23 },
  { 5410, 19, 23, 20, 1, -23 },
  { 5465, 20, 33, 20, 0, -23 },
  { 5548, 15, 23, 18, 1, -23 },
  { 5592, 14, 38, 16, 1, -31 },
  { 5659, 3, 43, 21, 9, -33 },
  { 5676, 14, 38, 16, 1, -31 },
  { 5743, 19, 6, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_Regular43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR43PT7B_H_
