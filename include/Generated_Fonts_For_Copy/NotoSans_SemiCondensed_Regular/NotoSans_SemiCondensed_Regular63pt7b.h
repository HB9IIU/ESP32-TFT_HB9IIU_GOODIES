#ifndef _NOTOSANS_SEMICONDENSED_REGULAR63PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular63pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x1C, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x1E, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0x79, 0xFC, 0x3F, 0x8F,
  0x01, 0x87, 0xE1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x3F, 0x07, 0x80, 0x07,
  0xE0, 0xF0, 0x00, 0xFC, 0x1E, 0x00, 0x1F, 0x83, 0xC0, 0x01, 0xF0, 0x78,
  0x00, 0x3F, 0x0F, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x3C, 0x7F, 0x80, 0x07, 0x83, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x07,
  0xC0, 0x03, 0xC0, 0xFC, 0x00, 0x78, 0x1F, 0x80, 0x0F, 0x03, 0xF0, 0x01,
  0xE0, 0x7C, 0x00, 0x3C, 0x1F, 0xB8, 0x07, 0x87, 0xF7, 0xE0, 0xF3, 0xFC,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF8,
  0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x7C,
  0x00, 0x07, 0x80, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x83, 0xE0, 0x00,
  0x1E, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0x3E, 0x1F, 0x01, 0x80, 0x7C,
  0x07, 0xC3, 0xC1, 0xFE, 0x0F, 0x80, 0xF8, 0xF8, 0x7F, 0xE0, 0xF0, 0x1E,
  0x1E, 0x1F, 0xFE, 0x1E, 0x07, 0xC7, 0xC7, 0xE7, 0xE3, 0xE0, 0xF8, 0xF8,
  0xF8, 0x7C, 0x3E, 0x7E, 0x3E, 0x3E, 0x07, 0x87, 0xFF, 0xC7, 0xC7, 0xC0,
  0xF8, 0x7F, 0xF1, 0xF0, 0xF0, 0x0F, 0x07, 0xFC, 0x3E, 0x1E, 0x01, 0xE0,
  0x18, 0x07, 0x83, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x78, 0x07, 0x80, 0x00,
  0x3C, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x01, 0xE0,
  0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x00, 0xF0,
  0x0F, 0x80, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x3C,
  0x00, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x00,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xE0, 0xFE, 0x7F, 0x00, 0x3E, 0x0F, 0xE1, 0xFC, 0x01, 0xF0, 0x7E,
  0x07, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0xC0, 0xFC, 0x3F, 0x00, 0x7E, 0x07,
  0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0xF8, 0x00,
  0x3F, 0xBF, 0x07, 0xC0, 0x00, 0xFF, 0xF8, 0x3E, 0x00, 0x03, 0xFF, 0x81,
  0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x01,
  0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x7F,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0x0F, 0xFD, 0xFC, 0x0F, 0xFF, 0xFF, 0xC7,
  0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0x01, 0xFF,
  0xF0, 0x01, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x70, 0x1F, 0x01, 0xCF, 0xC1, 0xC1, 0xF9, 0xFF, 0xBB, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x01, 0xC0, 0x30, 0x00, 0x10,
  0x04, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC7, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C,
  0x1E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x10, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xE0,
  0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0xF8, 0x00,
  0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xDF, 0x1F, 0x9F, 0x7F, 0x1F, 0xFE,
  0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0x30, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xC0,
  0x01, 0xF8, 0x10, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7, 0xC0, 0x07, 0xF0, 0xC0, 0x00,
  0xFE, 0x20, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFA, 0x00, 0x00, 0xFE, 0xE0, 0x00, 0x7F,
  0xBF, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C,
  0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8,
  0x0F, 0x80, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFA, 0x00, 0x01, 0xFD, 0x80, 0x01, 0xFC, 0xFC, 0x07, 0xFC, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0x40, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x02, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x7F, 0xC0, 0x3E, 0x3F, 0xFE, 0x07, 0xCF,
  0xFF, 0xE1, 0xFB, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xE7, 0xFC, 0x01, 0xFC,
  0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0x7E, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x0F, 0xE1, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE1, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x83, 0xF8,
  0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFC, 0x7F, 0xC0,
  0x7F, 0x03, 0xFC, 0x1F, 0x80, 0x3F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0x7F,
  0x00, 0x1F, 0xC7, 0xF0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0x83, 0xFC, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x3E,
  0x7E, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFE, 0xFC, 0x00,
  0x3F, 0xDF, 0x80, 0x07, 0xF1, 0xF8, 0x03, 0xFE, 0x3F, 0xC1, 0xFF, 0xC3,
  0xFF, 0xFE, 0xF8, 0x3F, 0xFF, 0x9F, 0x03, 0xFF, 0xE3, 0xE0, 0x1F, 0xF0,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xFC, 0x02, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E,
  0x38, 0x1F, 0x87, 0xE3, 0xF8, 0xFF, 0x3F, 0xCF, 0xE1, 0xF8, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xF8, 0x1F, 0xE7, 0x00, 0x1F, 0x90,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x7F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0xFF, 0x80, 0xF0, 0x78, 0x01, 0xFF,
  0xFC, 0x07, 0x87, 0xC0, 0x1F, 0xFF, 0xE0, 0x3E, 0x3E, 0x01, 0xF8, 0x1F,
  0x00, 0xF1, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x9F, 0x01, 0xF8, 0x07, 0xC0,
  0x3C, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xE7, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0x3C, 0x07, 0xC0, 0x0F, 0x80, 0x7D, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xEF,
  0x01, 0xF0, 0x03, 0xE0, 0x1F, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF7, 0xC0,
  0x7C, 0x00, 0xF8, 0x07, 0xBE, 0x03, 0xE0, 0x07, 0xC0, 0x3D, 0xF0, 0x1F,
  0x00, 0x3E, 0x01, 0xEF, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x7C, 0x07, 0xC0,
  0x1F, 0x00, 0xF9, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0x8F, 0x00, 0xF0, 0x0F,
  0xE0, 0x3C, 0x78, 0x07, 0xC0, 0x77, 0x03, 0xE3, 0xC0, 0x3F, 0x07, 0xBC,
  0x3E, 0x1F, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0xF8, 0x03, 0xFF, 0xC7, 0xFF,
  0x03, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xEF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0x80, 0x07, 0xF8, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0xFC, 0xF8,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00,
  0x7F, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0x8F, 0x80,
  0x01, 0xFC, 0xF8, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFE, 0xF8, 0x00, 0x1F, 0xEF,
  0x80, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xB8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0x03,
  0xFC, 0x00, 0x04, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x10, 0x1F, 0xFC, 0x0F, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0x00, 0x1F, 0xF8, 0x3E, 0x00, 0x07, 0xF8, 0x7C, 0x00, 0x07,
  0xF8, 0xF8, 0x00, 0x07, 0xF1, 0xF0, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x1F, 0xCF, 0x80, 0x00, 0x7F, 0x1F, 0x00, 0x01, 0xFC, 0x3E, 0x00, 0x0F,
  0xF8, 0x7C, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x78, 0x1F, 0xE0, 0x00, 0x04, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x01, 0xF3, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x7F, 0x00,
  0x00, 0x3E, 0x1F, 0xE0, 0x00, 0x1F, 0x07, 0xF8, 0x00, 0x0F, 0x81, 0xFF,
  0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF4, 0x0F, 0xEF, 0xFF, 0x9F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xE0, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F,
  0x3E, 0x00, 0x03, 0xF9, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF8, 0x7C,
  0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x3F,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x7D, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x3F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x80,
  0xFE, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x7F,
  0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xE0, 0x3E, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x7F, 0x3E, 0x00, 0x01, 0xFD, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xDF, 0x00, 0x00, 0x07, 0xFF, 0xEF, 0x80, 0x00, 0x03, 0xFF, 0xF7, 0xE0,
  0x00, 0x03, 0xEF, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xFE, 0xF8, 0x00, 0x00,
  0xF3, 0xFF, 0x7E, 0x00, 0x00, 0xF9, 0xFF, 0x9F, 0x00, 0x00, 0x7C, 0xFF,
  0xCF, 0x80, 0x00, 0x3C, 0x7F, 0xE7, 0xE0, 0x00, 0x3E, 0x3F, 0xF1, 0xF0,
  0x00, 0x1F, 0x1F, 0xF8, 0xF8, 0x00, 0x0F, 0x0F, 0xFC, 0x7E, 0x00, 0x0F,
  0x87, 0xFE, 0x1F, 0x00, 0x07, 0xC3, 0xFF, 0x0F, 0x80, 0x07, 0xC1, 0xFF,
  0x87, 0xE0, 0x03, 0xE0, 0xFF, 0xC1, 0xF0, 0x01, 0xF0, 0x7F, 0xE0, 0xF8,
  0x01, 0xF0, 0x3F, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0x00, 0x7C,
  0x0F, 0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3E, 0x03, 0xFF,
  0x01, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x1F, 0x00, 0xFF, 0xC0, 0x3E,
  0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x87, 0xC0,
  0x1F, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0xFC, 0x01, 0xF1, 0xF0, 0x07, 0xFE,
  0x00, 0xF9, 0xF0, 0x03, 0xFF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x78, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xE0, 0x00, 0x1F, 0xF7, 0xE0, 0x00, 0x1F,
  0xF3, 0xF0, 0x00, 0x1F, 0xF1, 0xF8, 0x00, 0x1F, 0xF9, 0xF8, 0x00, 0x1F,
  0xF8, 0xFC, 0x00, 0x1F, 0xF8, 0xFC, 0x00, 0x1F, 0xF8, 0x7E, 0x00, 0x1F,
  0xF8, 0x7E, 0x00, 0x1F, 0xF8, 0x3F, 0x00, 0x1F, 0xF8, 0x3F, 0x80, 0x1F,
  0xF8, 0x1F, 0x80, 0x1F, 0xF8, 0x0F, 0xC0, 0x1F, 0xF8, 0x0F, 0xC0, 0x1F,
  0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x03, 0xF0, 0x1F,
  0xF8, 0x03, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x1F, 0xF8, 0x00, 0xFC, 0x1F,
  0xF8, 0x00, 0xFC, 0x1F, 0xF8, 0x00, 0x7E, 0x1F, 0xF8, 0x00, 0x7E, 0x1F,
  0xF8, 0x00, 0x3F, 0x1F, 0xF8, 0x00, 0x3F, 0x1F, 0xF8, 0x00, 0x1F, 0x9F,
  0xF8, 0x00, 0x1F, 0xDF, 0xF8, 0x00, 0x0F, 0xDF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F,
  0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x7F, 0xCF,
  0x80, 0x07, 0xF3, 0xE0, 0x00, 0xFE, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x7F,
  0x3E, 0x00, 0x3F, 0x8F, 0x80, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0xFF, 0x83, 0xE0, 0x01,
  0xFC, 0x1F, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC,
  0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0x7C,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x7E,
  0x0F, 0x80, 0x0F, 0xE0, 0x7C, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3E, 0x03,
  0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x07,
  0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x0F, 0x80,
  0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03,
  0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7F, 0x3E, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFC, 0x3F, 0xC3, 0xF8, 0x00, 0xF1, 0xFC, 0x00, 0x04, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFA, 0x00, 0x00, 0xFE, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7B, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x0F,
  0x81, 0xF0, 0x01, 0xF9, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x81, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0xC0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x9F,
  0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x0F,
  0x9E, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x7C,
  0x03, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x7C, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0x80, 0xFE, 0x0C, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF,
  0x3F, 0x80, 0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x7E, 0x03, 0xFF,
  0x7F, 0xFF, 0xCF, 0x3F, 0xFF, 0x8F, 0x1F, 0xFF, 0x0F, 0x0F, 0xFE, 0x0F,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x0F, 0xF8, 0x07, 0xC7, 0xFF, 0xC0, 0xF9, 0xFF, 0xFC,
  0x1F, 0x7F, 0xFF, 0xC3, 0xFF, 0x83, 0xFC, 0x7F, 0xC0, 0x1F, 0xCF, 0xF0,
  0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xBF,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0xE0, 0x03,
  0xF3, 0xFE, 0x00, 0xFE, 0x7F, 0xE0, 0x3F, 0x8F, 0xBF, 0xFF, 0xE1, 0xF3,
  0xFF, 0xFC, 0x3C, 0x3F, 0xFE, 0x07, 0x83, 0xFF, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xF8, 0xF8, 0x7F, 0x00, 0x23, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x04, 0x7F, 0x80, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00,
  0x68, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x3F, 0xE0, 0xF8, 0x1F, 0xFF, 0x1F, 0x07, 0xFF, 0xF3, 0xE1,
  0xFF, 0xFF, 0x7C, 0x7F, 0x83, 0xFF, 0x8F, 0xC0, 0x1F, 0xF3, 0xF0, 0x01,
  0xFE, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7C,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x3F, 0xF0, 0xFF, 0xFF, 0xBE, 0x0F, 0xFF,
  0xE3, 0xC0, 0xFF, 0xF8, 0x78, 0x0F, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF7, 0xC0, 0x00, 0xFD,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x83, 0xFC,
  0x03, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xCF, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0x81, 0xE0, 0x7F, 0xFC, 0x3C, 0x1F, 0xFF, 0xC7, 0x87, 0xFF,
  0xFD, 0xF1, 0xFF, 0x0F, 0xFE, 0x3F, 0x00, 0x7F, 0xCF, 0xC0, 0x07, 0xF9,
  0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF0, 0x00,
  0x1F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF3, 0xF8,
  0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0xFE, 0xF8, 0x3F, 0xFF, 0x9F,
  0x03, 0xFF, 0xE3, 0xE0, 0x3F, 0xF8, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x80, 0x00,
  0x7F, 0x1E, 0x00, 0x1F, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xFF, 0xC1, 0xF1, 0xFF, 0xF8,
  0xF9, 0xFF, 0xFE, 0x7D, 0xFF, 0xFF, 0xBF, 0xF8, 0x3F, 0xDF, 0xF0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0x10, 0xF9, 0xFF, 0xFF, 0xEF, 0xDF, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x20,
  0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xFD, 0xF0, 0x00,
  0xFC, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0xFE, 0x3E, 0x00, 0x7E, 0x1F, 0x00,
  0x7E, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x7E, 0x01, 0xF0,
  0x3F, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x1F,
  0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xDF, 0xC0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xE0,
  0x1F, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x81, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x3E, 0x00,
  0x7F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xF3, 0xE0,
  0x00, 0xFD, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xE0, 0x07, 0xFC, 0x1E, 0x1F, 0xFF, 0x03, 0xFF, 0xE3, 0xE7, 0xFF,
  0xF0, 0xFF, 0xFE, 0x7D, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFE, 0x1F, 0xEF,
  0xC3, 0xFD, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0xF0, 0x3F, 0xF0, 0x78, 0x7F, 0xFE, 0x3E, 0x7F, 0xFF, 0x9F,
  0x7F, 0xFF, 0xEF, 0xFE, 0x0F, 0xF7, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF, 0x81, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xF0, 0x3F, 0xE0, 0x1E, 0x1F, 0xFF, 0x03, 0xE7,
  0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xF1, 0xFF, 0x00, 0x7F,
  0x3F, 0xC0, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F,
  0x80, 0x0F, 0xCF, 0xF8, 0x03, 0xF9, 0xFF, 0x80, 0xFE, 0x3E, 0xFF, 0xFF,
  0x87, 0xCF, 0xFF, 0xF0, 0xF8, 0xFF, 0xF8, 0x1F, 0x07, 0xFE, 0x03, 0xE0,
  0x1E, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x81, 0xE0, 0x7F, 0xFC, 0x3C, 0x1F, 0xFF, 0xC7,
  0x87, 0xFF, 0xFD, 0xF1, 0xFE, 0x0F, 0xFE, 0x3F, 0x00, 0x7F, 0xCF, 0xC0,
  0x07, 0xF9, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD,
  0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x07,
  0xF3, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0xFE, 0xF8, 0x3F,
  0xFF, 0x9F, 0x03, 0xFF, 0xE3, 0xE0, 0x3F, 0xF8, 0x7C, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0xF0, 0x3F, 0xFC, 0x1F, 0xEF, 0x0F, 0xFB, 0xE7, 0xFE, 0xFB, 0xFF, 0xBE,
  0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x8F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE7, 0xF0, 0x1F, 0x7E, 0x00, 0x13, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x10, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0xC0, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x07, 0xFB, 0xF8, 0x0F, 0xFC,
  0xFF, 0xFF, 0xBE, 0x7F, 0xFF, 0x8F, 0x1F, 0xFF, 0x87, 0x83, 0xFF, 0x83,
  0xC0, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7E, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xEF, 0xC0, 0x03, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0xC0, 0x07, 0xE7,
  0xC0, 0x07, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x7B, 0xC0, 0x07, 0xC7, 0xE0,
  0x07, 0xBE, 0x00, 0xFC, 0x3E, 0x00, 0xFB, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F,
  0xBE, 0x00, 0xF8, 0x3F, 0x00, 0xF9, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0x1F,
  0x00, 0xF8, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x1F, 0x01,
  0xF0, 0x1F, 0x81, 0xF0, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x0F, 0x81, 0xF0,
  0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x0F,
  0x83, 0xE0, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0x07, 0xC7,
  0xC0, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0x80,
  0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x3E,
  0x78, 0x00, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x03, 0xEF, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x3F,
  0x0F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xFC,
  0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x06, 0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x2F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xA0, 0x00, 0xFF, 0xE4,
  0x00, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Regular63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 8, 46, 16, 4, -45 },
  { 47, 17, 16, 25, 4, -45 },
  { 81, 34, 45, 36, 1, -45 },
  { 273, 27, 52, 33, 3, -48 },
  { 449, 43, 47, 49, 3, -46 },
  { 702, 37, 47, 40, 3, -46 },
  { 920, 6, 16, 14, 4, -45 },
  { 932, 14, 55, 19, 3, -45 },
  { 1029, 14, 55, 19, 2, -45 },
  { 1126, 27, 26, 31, 2, -48 },
  { 1214, 27, 30, 33, 3, -37 },
  { 1316, 10, 15, 16, 2, -7 },
  { 1335, 15, 5, 19, 2, -19 },
  { 1345, 8, 9, 16, 4, -8 },
  { 1354, 22, 45, 23, 1, -45 },
  { 1478, 27, 47, 33, 3, -46 },
  { 1637, 16, 45, 33, 5, -45 },
  { 1727, 27, 46, 33, 3, -46 },
  { 1883, 26, 47, 33, 3, -46 },
  { 2036, 31, 45, 33, 1, -45 },
  { 2211, 25, 46, 33, 4, -45 },
  { 2355, 27, 47, 33, 3, -46 },
  { 2514, 28, 45, 33, 2, -45 },
  { 2672, 27, 47, 33, 3, -46 },
  { 2831, 27, 47, 33, 3, -46 },
  { 2990, 8, 35, 16, 4, -34 },
  { 3025, 10, 42, 16, 2, -34 },
  { 3078, 27, 30, 33, 3, -38 },
  { 3180, 27, 17, 33, 3, -31 },
  { 3238, 27, 30, 33, 3, -38 },
  { 3340, 22, 47, 25, 1, -46 },
  { 3470, 45, 50, 51, 3, -45 },
  { 3752, 36, 45, 36, 0, -45 },
  { 3955, 28, 45, 37, 6, -45 },
  { 4113, 30, 47, 36, 4, -46 },
  { 4290, 31, 45, 41, 6, -45 },
  { 4465, 22, 45, 32, 6, -45 },
  { 4589, 22, 45, 29, 6, -45 },
  { 4713, 33, 47, 42, 4, -46 },
  { 4907, 30, 45, 42, 6, -45 },
  { 5076, 16, 45, 20, 2, -45 },
  { 5166, 15, 57, 16, -4, -45 },
  { 5273, 29, 45, 35, 6, -45 },
  { 5437, 22, 45, 29, 6, -45 },
  { 5561, 41, 45, 53, 6, -45 },
  { 5792, 32, 45, 43, 6, -45 },
  { 5972, 36, 47, 44, 4, -46 },
  { 6184, 26, 45, 34, 6, -45 },
  { 6331, 36, 57, 44, 4, -46 },
  { 6588, 29, 45, 35, 6, -45 },
  { 6752, 26, 47, 31, 3, -46 },
  { 6905, 29, 45, 31, 1, -45 },
  { 7069, 31, 46, 41, 5, -45 },
  { 7248, 34, 45, 34, 0, -45 },
  { 7440, 52, 45, 54, 1, -45 },
  { 7733, 32, 45, 33, 0, -45 },
  { 7913, 32, 45, 32, 0, -45 },
  { 8093, 27, 45, 31, 2, -45 },
  { 8245, 14, 55, 20, 5, -45 },
  { 8342, 22, 45, 23, 1, -45 },
  { 8466, 14, 55, 20, 2, -45 },
  { 8563, 29, 27, 33, 2, -45 },
  { 8661, 28, 5, 28, 0, 5 },
  { 8679, 12, 10, 17, 3, -48 },
  { 8694, 24, 35, 32, 3, -34 },
  { 8799, 27, 49, 35, 5, -48 },
  { 8965, 22, 35, 27, 3, -34 },
  { 9062, 27, 49, 35, 3, -48 },
  { 9228, 26, 35, 32, 3, -34 },
  { 9342, 21, 48, 20, 1, -48 },
  { 9468, 27, 49, 35, 3, -34 },
  { 9634, 25, 48, 35, 5, -48 },
  { 9784, 7, 47, 15, 4, -47 },
  { 9826, 14, 62, 15, -3, -47 },
  { 9935, 25, 48, 31, 5, -48 },
  { 10085, 5, 48, 15, 5, -48 },
  { 10115, 43, 34, 53, 5, -34 },
  { 10298, 25, 34, 35, 5, -34 },
  { 10405, 28, 35, 34, 3, -34 },
  { 10528, 27, 49, 35, 5, -34 },
  { 10694, 27, 49, 35, 3, -34 },
  { 10860, 18, 34, 24, 5, -34 },
  { 10937, 21, 35, 27, 3, -34 },
  { 11029, 18, 43, 20, 1, -42 },
  { 11126, 25, 35, 35, 5, -34 },
  { 11236, 29, 34, 29, 0, -34 },
  { 11360, 44, 34, 45, 1, -34 },
  { 11547, 28, 34, 30, 1, -34 },
  { 11666, 29, 49, 29, 0, -34 },
  { 11844, 22, 34, 26, 2, -34 },
  { 11938, 19, 55, 24, 2, -45 },
  { 12069, 5, 63, 31, 13, -48 },
  { 12109, 19, 55, 24, 2, -45 },
  { 12240, 27, 8, 33, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_Regular63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular63pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR63PT7B_H_
