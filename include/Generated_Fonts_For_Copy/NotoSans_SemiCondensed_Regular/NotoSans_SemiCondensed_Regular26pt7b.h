#ifndef _NOTOSANS_SEMICONDENSED_REGULAR26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xB6, 0xDB, 0x64, 0x80, 0xFF, 0x80, 0xCF, 0x9F, 0x3E,
  0x7C, 0x58, 0xB1, 0x00, 0x04, 0x20, 0x61, 0x03, 0x18, 0x18, 0xC0, 0xC6,
  0x06, 0x33, 0xFF, 0xFF, 0xFF, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x8F,
  0xFF, 0x98, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x81, 0x8C, 0x08, 0x40, 0x04,
  0x00, 0x80, 0x18, 0x1F, 0xF7, 0xDC, 0xC8, 0x39, 0x07, 0x20, 0x64, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x4E, 0x08, 0xC1, 0x18, 0x23, 0xE5, 0xFF, 0xF8,
  0x78, 0x02, 0x00, 0x40, 0x08, 0x00, 0x38, 0x0C, 0x1F, 0x03, 0x06, 0x61,
  0x83, 0x18, 0x60, 0xC6, 0x10, 0x31, 0x8C, 0x0C, 0x63, 0x03, 0x19, 0x80,
  0xC6, 0x6F, 0x19, 0xB6, 0x67, 0xCD, 0x88, 0xE6, 0x63, 0x01, 0x98, 0xC0,
  0xC6, 0x30, 0x31, 0x8C, 0x18, 0x63, 0x06, 0x18, 0x83, 0x03, 0x60, 0xC0,
  0xF0, 0x0E, 0x00, 0x1F, 0x80, 0x39, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30,
  0xC0, 0x39, 0x80, 0x1B, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0x0E, 0x63,
  0x8C, 0xE1, 0xCC, 0xE0, 0xF8, 0xC0, 0x78, 0xE0, 0x70, 0x60, 0xF8, 0x7F,
  0xDC, 0x3F, 0x8F, 0xFF, 0xFC, 0x0C, 0x63, 0x8C, 0x71, 0x86, 0x18, 0xE3,
  0x8C, 0x30, 0xC3, 0x0E, 0x38, 0x61, 0x87, 0x0C, 0x30, 0x61, 0xC0, 0xC3,
  0x86, 0x0C, 0x30, 0xE1, 0x86, 0x18, 0x61, 0xC7, 0x1C, 0x71, 0x86, 0x18,
  0xE3, 0x0C, 0x71, 0x8C, 0x00, 0x0E, 0x01, 0x80, 0x30, 0x42, 0x1F, 0x5F,
  0xFF, 0xC3, 0x80, 0xD8, 0x3B, 0x8E, 0x30, 0x44, 0x00, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x61, 0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x76, 0x66, 0xCC, 0xFF, 0xF0, 0xFF, 0x80, 0x01, 0x80, 0xC0,
  0xE0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x81,
  0xC0, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x00, 0x0F, 0x07, 0xF0, 0xC7, 0x30,
  0x66, 0x0E, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E,
  0x07, 0xC0, 0xD8, 0x1B, 0x07, 0x70, 0xC7, 0xF8, 0x7C, 0x00, 0x06, 0x3C,
  0xFB, 0xFE, 0xE9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x1F, 0x0F, 0xF3, 0x87, 0x20, 0x60, 0x0E, 0x01, 0xC0,
  0x30, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01,
  0x80, 0x60, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0x0F, 0xF3, 0x87, 0x20, 0x60,
  0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x1F, 0x83, 0xE0, 0x1F, 0x00, 0x70, 0x06,
  0x00, 0xC0, 0x18, 0x07, 0x80, 0xDF, 0xFB, 0xFC, 0x00, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x6C, 0x07, 0xC0, 0xDC, 0x1D, 0xC1, 0x9C, 0x31, 0xC3, 0x1C,
  0x61, 0xCC, 0x1C, 0xC1, 0xCF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0xFF, 0xBF, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xFF, 0x3F, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x83, 0xBF,
  0xEF, 0xE0, 0x07, 0xC1, 0xF8, 0x70, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x38, 0xFF, 0xDF, 0x3B, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xD8, 0x1B, 0x03,
  0x70, 0xE7, 0xF8, 0x7E, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x00, 0x0F, 0x07, 0xF9, 0xC3,
  0x30, 0x76, 0x06, 0xC0, 0xD8, 0x31, 0x8E, 0x1F, 0x83, 0xE0, 0xEF, 0x38,
  0x6E, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0x60, 0xEF, 0xF8, 0xFE, 0x00, 0x0E,
  0x07, 0xF1, 0xC7, 0x30, 0x6E, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0xEC,
  0x1D, 0xFD, 0x8F, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x8F, 0xE1,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x77, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x66, 0xEC, 0xC0, 0x00, 0x20, 0x0C, 0x07, 0x83, 0xC1, 0xE0,
  0x70, 0x38, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x30, 0x02, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x18, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x07, 0x07, 0x83, 0xC1, 0xE0,
  0x70, 0x08, 0x00, 0x3E, 0x3F, 0xC6, 0x38, 0x06, 0x01, 0xC0, 0x60, 0x18,
  0x0E, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x07, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x38, 0x1C, 0x0E, 0x01,
  0xC3, 0x00, 0x18, 0x60, 0xC1, 0x98, 0x7F, 0x33, 0x1C, 0x42, 0x63, 0x18,
  0x68, 0xC3, 0x0F, 0x18, 0x61, 0xE3, 0x0C, 0x2C, 0x61, 0x8C, 0x8C, 0x31,
  0x98, 0xFF, 0xE3, 0x0F, 0x3C, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x9E, 0x00, 0x7F, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x36,
  0x00, 0x6C, 0x00, 0xD8, 0x03, 0x38, 0x06, 0x30, 0x0C, 0x60, 0x30, 0xE0,
  0x60, 0xC0, 0xFF, 0x83, 0xFF, 0x86, 0x03, 0x1C, 0x06, 0x38, 0x0E, 0x60,
  0x0D, 0xC0, 0x1B, 0x80, 0x38, 0xFE, 0x0F, 0xFC, 0xE3, 0xEE, 0x06, 0xE0,
  0x6E, 0x06, 0xE0, 0x6E, 0x0E, 0xFF, 0xCF, 0xF8, 0xE1, 0xEE, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xEF, 0xFE, 0xFF, 0x80, 0x03, 0xE0,
  0x7F, 0xC7, 0x8C, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x08, 0xFF, 0x81, 0xFC, 0xFE, 0x07, 0xFE, 0x38, 0xF9, 0xC0, 0xEE,
  0x03, 0x70, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0E, 0xE0, 0xE7, 0xFE, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xBF,
  0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F,
  0xEF, 0xFB, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00,
  0x01, 0xF0, 0x3F, 0xF1, 0xE1, 0xCE, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x81, 0xFE, 0x07, 0xD8, 0x03, 0x60, 0x0D, 0x80,
  0x37, 0x00, 0xCE, 0x03, 0x3C, 0x0C, 0x7F, 0xF0, 0x7F, 0xC0, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x06, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xFF, 0xC0, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x7F, 0xFC, 0xE0, 0x3E, 0x06, 0xE0, 0xEE, 0x1C, 0xE1, 0x8E, 0x30, 0xE7,
  0x0E, 0xE0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0E, 0x70, 0xE3, 0x0E, 0x38, 0xE1,
  0xCE, 0x0C, 0xE0, 0xEE, 0x07, 0xE0, 0x30, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFC, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x60, 0x1F, 0xD8, 0x07, 0xF6, 0x03, 0x7C, 0xC0, 0xDF, 0x30,
  0x37, 0xCC, 0x19, 0xF1, 0x86, 0x7C, 0x61, 0x9F, 0x18, 0xC7, 0xC3, 0x31,
  0xF0, 0xCC, 0x7C, 0x36, 0x1F, 0x07, 0x87, 0xC1, 0xE1, 0xF0, 0x70, 0x7C,
  0x0C, 0x1C, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xD8, 0x0F, 0x70,
  0x3C, 0xC0, 0xF3, 0x83, 0xC7, 0x0F, 0x0C, 0x3C, 0x38, 0xF0, 0x63, 0xC1,
  0xCF, 0x03, 0x3C, 0x0E, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xC0,
  0x03, 0xE0, 0x0F, 0xF0, 0x3C, 0x38, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07,
  0x60, 0x06, 0x60, 0x06, 0x70, 0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x1F, 0xF8,
  0x07, 0xF0, 0xF8, 0x1F, 0xF3, 0x9F, 0x70, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0xFC, 0x7B, 0xFE, 0x7E, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0xF0, 0x3C, 0x3C, 0x38,
  0x1C, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x06, 0x60, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x60, 0x07, 0x60, 0x06, 0x60, 0x06, 0x70, 0x0E, 0x30,
  0x0C, 0x38, 0x1C, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1E, 0xFC, 0x0F, 0xF8, 0xE7, 0xCE, 0x0E, 0xE0, 0x6E, 0x06,
  0xE0, 0x6E, 0x0E, 0xE0, 0xCF, 0xFC, 0xFF, 0x0E, 0x30, 0xE3, 0x8E, 0x18,
  0xE1, 0xCE, 0x0C, 0xE0, 0xEE, 0x06, 0xE0, 0x70, 0x0F, 0x87, 0xF9, 0xE3,
  0x30, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x07, 0x81, 0xDF, 0xFB, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0xEC, 0x06, 0x70, 0x71, 0xFF, 0x07,
  0xF0, 0xC0, 0x0F, 0x80, 0x76, 0x01, 0x98, 0x06, 0x70, 0x38, 0xC0, 0xE3,
  0x03, 0x0E, 0x0C, 0x18, 0x70, 0x61, 0x81, 0x86, 0x07, 0x38, 0x0C, 0xC0,
  0x33, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x30, 0x00, 0xE0,
  0x30, 0x0F, 0x80, 0xC0, 0x76, 0x07, 0x81, 0x98, 0x1E, 0x06, 0x70, 0x78,
  0x19, 0xC1, 0xF0, 0xE3, 0x0C, 0xC3, 0x0C, 0x33, 0x0C, 0x30, 0xCC, 0x30,
  0xE3, 0x39, 0xC1, 0x98, 0x66, 0x06, 0x61, 0x98, 0x19, 0x86, 0x60, 0x76,
  0x0D, 0x80, 0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x07,
  0x00, 0x60, 0x1C, 0x00, 0x60, 0x1B, 0x81, 0x8C, 0x1C, 0x70, 0xC1, 0x8E,
  0x0E, 0x60, 0x37, 0x01, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x1F, 0x00,
  0xDC, 0x0C, 0x60, 0x63, 0x86, 0x0C, 0x70, 0x73, 0x01, 0xF8, 0x06, 0xC0,
  0x1B, 0x01, 0xD8, 0x0C, 0xE0, 0xE3, 0x06, 0x1C, 0x70, 0x63, 0x03, 0xB8,
  0x0D, 0x80, 0x7C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x60,
  0x1C, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x60, 0x1C, 0x03, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0xFF, 0xC0, 0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x18, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0xFF, 0xE0, 0x04, 0x00, 0xE0, 0x0E, 0x00, 0xB0, 0x1B, 0x01,
  0x18, 0x31, 0x83, 0x0C, 0x60, 0xC6, 0x06, 0xC0, 0x70, 0xFF, 0xFF, 0xFF,
  0xE3, 0x0C, 0x30, 0x3F, 0x9F, 0xF2, 0x0C, 0x03, 0x00, 0xC0, 0x33, 0xFD,
  0xC3, 0xE0, 0xF0, 0x3C, 0x0F, 0x87, 0x7F, 0xDF, 0x90, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x33, 0xE6, 0xFE, 0xE0, 0xDC, 0x1F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0xFC, 0x1B, 0xFF, 0x6F,
  0xC0, 0x1F, 0x9F, 0xDC, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30,
  0x18, 0x0E, 0x03, 0xF8, 0xFC, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x1F, 0x73, 0xFF, 0x70, 0xF6, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0x77, 0x0F, 0x3F, 0xF1, 0xF3, 0x1F,
  0x87, 0xF9, 0xC3, 0x30, 0x76, 0x07, 0xC0, 0xFF, 0xFF, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x38, 0x13, 0xFC, 0x3F, 0x80, 0x07, 0x8F, 0xC6, 0x03, 0x03,
  0x81, 0xC1, 0xFD, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x1F, 0x33, 0xFF, 0x70, 0xF6, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0x77, 0x0F,
  0x3F, 0xF1, 0xF7, 0x00, 0x70, 0x06, 0x00, 0x64, 0x0E, 0x7F, 0xC7, 0xF8,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x33, 0xE6, 0xFE, 0xE0,
  0xDC, 0x1B, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x70, 0xF4, 0x3F, 0xFF, 0xFF, 0xFC, 0x18, 0xC2, 0x00,
  0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F,
  0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x1F, 0x0E, 0xC3,
  0x31, 0x8C, 0xC3, 0x70, 0xFC, 0x3F, 0x0E, 0xE3, 0x1C, 0xC3, 0x30, 0xEC,
  0x1B, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0x1F, 0x3F, 0xEF, 0xEE,
  0x1E, 0x1F, 0x83, 0x83, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03,
  0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0,
  0xF0, 0x30, 0x30, 0xCF, 0x9B, 0xFB, 0x83, 0x70, 0x6C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xC0, 0x1F,
  0x83, 0xFC, 0x70, 0xE6, 0x06, 0x60, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x36, 0x07, 0x60, 0x67, 0x0E, 0x3F, 0xC1, 0xF8, 0xCF, 0x9B, 0xFB, 0x83,
  0x70, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0xF0,
  0x6F, 0xFD, 0x9F, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00,
  0x1F, 0x33, 0xFF, 0x70, 0xF6, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0x60, 0x77, 0x0F, 0x3F, 0xF1, 0xF7, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xCF, 0xBF, 0xC7, 0x0E, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x00, 0x3F, 0x3F, 0xF8, 0x18, 0x0E,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xC0, 0x70, 0x3F, 0xF7, 0xF0, 0x10,
  0x10, 0x30, 0x7F, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x38, 0x1F, 0x1F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0xF7, 0xFE, 0x7C, 0xC0,
  0xE0, 0x76, 0x06, 0x60, 0x66, 0x0E, 0x30, 0xC3, 0x0C, 0x31, 0xC1, 0x98,
  0x19, 0x81, 0x98, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0xE0, 0xE0, 0xD8,
  0x38, 0x36, 0x1E, 0x0D, 0x86, 0xC7, 0x71, 0xB1, 0x8C, 0x6C, 0x63, 0x33,
  0x18, 0xCC, 0x6E, 0x3B, 0x1B, 0x06, 0xC6, 0xC1, 0xE1, 0xB0, 0x78, 0x2C,
  0x1E, 0x0E, 0x03, 0x03, 0x80, 0x60, 0x73, 0x0E, 0x38, 0xC1, 0x9C, 0x1D,
  0x80, 0xF0, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xD8, 0x19, 0xC3, 0x0C, 0x70,
  0xEE, 0x07, 0xE0, 0x76, 0x06, 0x60, 0x67, 0x0E, 0x30, 0xC3, 0x0C, 0x38,
  0xC1, 0x98, 0x19, 0x81, 0x98, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0xF8, 0x0F, 0x00, 0xFF, 0xFF, 0xC0, 0xC0,
  0xE0, 0x60, 0x60, 0x70, 0x30, 0x38, 0x18, 0x18, 0x1C, 0x0F, 0xFF, 0xFC,
  0x01, 0x0F, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0xE0,
  0xF0, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x0F, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0xF0, 0x70, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x1C, 0x07, 0x0F, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38,
  0xF0, 0xE0, 0x78, 0x3F, 0xEE, 0x1F, 0xC0, 0x40,
};

const GFXglyph NotoSans_SemiCondensed_Regular26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 7, 7, 10, 2, -19 },
  { 16, 13, 19, 15, 1, -19 },
  { 47, 11, 22, 14, 1, -20 },
  { 78, 18, 19, 20, 1, -19 },
  { 121, 16, 19, 17, 1, -19 },
  { 159, 2, 7, 6, 2, -19 },
  { 161, 6, 23, 8, 1, -19 },
  { 179, 6, 23, 8, 1, -19 },
  { 197, 11, 11, 13, 1, -20 },
  { 213, 11, 12, 14, 1, -15 },
  { 230, 4, 6, 7, 1, -3 },
  { 233, 6, 2, 8, 1, -8 },
  { 235, 3, 3, 7, 2, -3 },
  { 237, 9, 19, 10, 0, -19 },
  { 259, 11, 19, 14, 1, -19 },
  { 286, 7, 19, 14, 2, -19 },
  { 303, 11, 19, 14, 1, -19 },
  { 330, 11, 19, 14, 1, -19 },
  { 357, 12, 19, 14, 1, -19 },
  { 386, 10, 19, 14, 2, -19 },
  { 410, 11, 19, 14, 1, -19 },
  { 437, 11, 19, 14, 1, -19 },
  { 464, 11, 19, 14, 1, -19 },
  { 491, 11, 19, 14, 1, -19 },
  { 518, 3, 14, 7, 2, -14 },
  { 524, 4, 17, 7, 1, -14 },
  { 533, 11, 13, 14, 1, -16 },
  { 551, 11, 7, 14, 1, -13 },
  { 561, 11, 13, 14, 1, -16 },
  { 579, 10, 19, 10, 0, -19 },
  { 603, 19, 21, 21, 1, -19 },
  { 653, 15, 19, 15, 0, -19 },
  { 689, 12, 19, 15, 2, -19 },
  { 718, 13, 19, 15, 1, -19 },
  { 749, 13, 19, 17, 2, -19 },
  { 780, 10, 19, 13, 2, -19 },
  { 804, 10, 19, 12, 2, -19 },
  { 828, 14, 19, 17, 1, -19 },
  { 862, 13, 19, 17, 2, -19 },
  { 893, 6, 19, 8, 1, -19 },
  { 908, 6, 24, 7, -2, -19 },
  { 926, 12, 19, 14, 2, -19 },
  { 955, 10, 19, 12, 2, -19 },
  { 979, 18, 19, 22, 2, -19 },
  { 1022, 14, 19, 18, 2, -19 },
  { 1056, 16, 19, 18, 1, -19 },
  { 1094, 11, 19, 14, 2, -19 },
  { 1121, 16, 23, 18, 1, -19 },
  { 1167, 12, 19, 15, 2, -19 },
  { 1196, 11, 19, 13, 1, -19 },
  { 1223, 13, 19, 13, 0, -19 },
  { 1254, 13, 19, 17, 2, -19 },
  { 1285, 14, 19, 14, 0, -19 },
  { 1319, 22, 19, 22, 0, -19 },
  { 1372, 13, 19, 13, 0, -19 },
  { 1403, 13, 19, 13, 0, -19 },
  { 1434, 11, 19, 13, 1, -19 },
  { 1461, 6, 23, 8, 2, -19 },
  { 1479, 9, 19, 10, 0, -19 },
  { 1501, 5, 23, 8, 1, -19 },
  { 1516, 12, 11, 14, 1, -19 },
  { 1533, 12, 2, 11, 0, 2 },
  { 1536, 5, 4, 7, 1, -20 },
  { 1539, 10, 14, 13, 1, -14 },
  { 1557, 11, 20, 15, 2, -20 },
  { 1585, 9, 14, 11, 1, -14 },
  { 1601, 12, 20, 15, 1, -20 },
  { 1631, 11, 14, 13, 1, -14 },
  { 1651, 9, 20, 8, 0, -20 },
  { 1674, 12, 20, 15, 1, -14 },
  { 1704, 11, 20, 15, 2, -20 },
  { 1732, 2, 19, 6, 2, -19 },
  { 1737, 5, 25, 6, -1, -19 },
  { 1753, 10, 20, 13, 2, -20 },
  { 1778, 2, 20, 6, 2, -20 },
  { 1783, 18, 14, 22, 2, -14 },
  { 1815, 11, 14, 15, 2, -14 },
  { 1835, 12, 14, 14, 1, -14 },
  { 1856, 11, 20, 15, 2, -14 },
  { 1884, 12, 20, 15, 1, -14 },
  { 1914, 7, 14, 10, 2, -14 },
  { 1927, 9, 14, 11, 1, -14 },
  { 1943, 8, 17, 8, 0, -17 },
  { 1960, 11, 14, 15, 2, -14 },
  { 1980, 12, 14, 12, 0, -14 },
  { 2001, 18, 14, 19, 0, -14 },
  { 2033, 12, 14, 12, 0, -14 },
  { 2054, 12, 20, 12, 0, -14 },
  { 2084, 9, 14, 11, 1, -14 },
  { 2100, 8, 23, 10, 1, -19 },
  { 2123, 1, 26, 13, 6, -20 },
  { 2127, 8, 23, 10, 1, -19 },
  { 2150, 11, 4, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_Regular26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR26PT7B_H_
