#ifndef _NOTOSANS_SEMICONDENSED_REGULAR49PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular49pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x00, 0x00, 0x00, 0xE7,
  0xFF, 0xFF, 0xF7, 0xC4, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3D, 0xC1, 0xEE, 0x0F, 0x70, 0x7B, 0x83, 0xDC, 0x0E, 0xE0, 0x77,
  0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x81, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x03,
  0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x0E, 0x03, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x78, 0x1C, 0x00,
  0x1E, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x3C,
  0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x3F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x81,
  0xE0, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x03, 0xC0,
  0x01, 0xC0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x03,
  0x80, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xF8, 0xE0, 0xCF, 0x0E, 0x00, 0xF0, 0xE0, 0x0F,
  0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0xCE, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0xE7, 0xE0, 0x0E, 0x1F, 0x00, 0xE0, 0xF0, 0x0E,
  0x0F, 0x00, 0xE0, 0xF0, 0x0E, 0x0F, 0x00, 0xE1, 0xF8, 0x0E, 0x1E, 0xF8,
  0xEF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0x02, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x0F, 0xC0, 0x01, 0xE0, 0x1F, 0xF0, 0x00, 0xE0, 0x0F, 0xFC, 0x00, 0xF0,
  0x0F, 0x0E, 0x00, 0x70, 0x07, 0x07, 0x80, 0x78, 0x03, 0x81, 0xC0, 0x38,
  0x03, 0xC0, 0xE0, 0x3C, 0x01, 0xE0, 0x70, 0x1C, 0x00, 0xF0, 0x3C, 0x1E,
  0x00, 0x78, 0x1E, 0x0E, 0x00, 0x3C, 0x0F, 0x0F, 0x00, 0x1E, 0x07, 0x87,
  0x80, 0x0F, 0x03, 0xC7, 0x80, 0x07, 0x81, 0xC3, 0xC0, 0x01, 0xC0, 0xE3,
  0xC7, 0xF0, 0xE0, 0x71, 0xE7, 0xFC, 0x78, 0x78, 0xE3, 0xFF, 0x3C, 0x38,
  0xF3, 0xC3, 0x8F, 0xFC, 0x71, 0xC1, 0xE3, 0xFC, 0x78, 0xE0, 0xF0, 0xFC,
  0x38, 0xF0, 0x38, 0x00, 0x3C, 0x78, 0x1C, 0x00, 0x1C, 0x3C, 0x0E, 0x00,
  0x1E, 0x1E, 0x07, 0x00, 0x0E, 0x0F, 0x03, 0x80, 0x0F, 0x07, 0x81, 0xC0,
  0x07, 0x03, 0xC0, 0xE0, 0x07, 0x81, 0xE0, 0x70, 0x03, 0x80, 0xF0, 0x38,
  0x03, 0xC0, 0x38, 0x3C, 0x01, 0xC0, 0x1C, 0x1E, 0x01, 0xE0, 0x0F, 0x0E,
  0x00, 0xE0, 0x03, 0xFF, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78,
  0x0F, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x78, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x03, 0xC3, 0xF3, 0xE0, 0x1E, 0x1F, 0x0F, 0x80, 0xF1, 0xF0, 0x3E, 0x0F,
  0x0F, 0x00, 0xF8, 0x78, 0xF8, 0x03, 0xE7, 0xC7, 0xC0, 0x0F, 0xBC, 0x3E,
  0x00, 0x7F, 0xE1, 0xF0, 0x01, 0xFE, 0x0F, 0x80, 0x07, 0xF0, 0x7C, 0x00,
  0x1F, 0x01, 0xF0, 0x03, 0xFC, 0x0F, 0x80, 0x3F, 0xF0, 0x3F, 0x8F, 0xF7,
  0xC1, 0xFF, 0xFF, 0x1F, 0x07, 0xFF, 0xE0, 0xFC, 0x0F, 0xFC, 0x03, 0xF0,
  0xFF, 0xFF, 0xEF, 0x79, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x01, 0xE0, 0x78,
  0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0,
  0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF8, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x60, 0x70, 0x7F, 0xE6, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF0,
  0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x0E, 0x07, 0x00, 0x20, 0x40, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9E, 0x3C, 0x78, 0xE3, 0xC7, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x39, 0xFF, 0xFF, 0xFD, 0xE1, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0x01, 0xF8, 0xFC, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0x87, 0x80, 0x3E, 0x7C,
  0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xF7, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00,
  0x3C, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF8, 0x07, 0x83,
  0xC0, 0x7C, 0x1F, 0x8F, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0x1F, 0xF3, 0xFF, 0x7C, 0xFF,
  0x8F, 0x70, 0xF2, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF1, 0xFE, 0x1F, 0x87, 0x80, 0x3E, 0x18, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFC, 0x1F,
  0xC7, 0x00, 0x3E, 0x10, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFB, 0x00, 0x0F, 0xDF,
  0x03, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x79,
  0xE0, 0x00, 0x71, 0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xE1,
  0xE0, 0x03, 0xC1, 0xE0, 0x03, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x01,
  0xE0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x3C, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x83, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x80, 0x07,
  0xCF, 0x81, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xE0, 0x40, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x3F, 0x01,
  0xE7, 0xFE, 0x0F, 0x7F, 0xF8, 0x7F, 0xFF, 0xE3, 0xF8, 0x0F, 0xBF, 0x80,
  0x3D, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF8, 0x00,
  0xF3, 0xC0, 0x0F, 0x9F, 0x00, 0x78, 0x7C, 0x07, 0xC3, 0xF0, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7E,
  0x0F, 0xC3, 0xE0, 0x1F, 0x3E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E,
  0x78, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xE0,
  0x3E, 0x0F, 0xC3, 0xE0, 0x3F, 0x7E, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x1F, 0x83, 0xE0, 0x3E, 0x3E, 0x00,
  0xF9, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xF0, 0x07,
  0xC7, 0xE0, 0x7E, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0x1F, 0x83, 0xE0, 0x3E,
  0x3E, 0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3D,
  0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x7C, 0x01, 0xF9, 0xF0, 0x1F, 0xCF, 0xFF,
  0xDE, 0x3F, 0xFC, 0xF0, 0xFF, 0xC7, 0x81, 0xF8, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x04, 0x07, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x39, 0xFF, 0xFF, 0xFD, 0xF3,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7,
  0xFF, 0xFF, 0xF7, 0xC4, 0x18, 0x7D, 0xFB, 0xF7, 0xE7, 0xC6, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xCF,
  0x9E, 0x7C, 0xF9, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0x07, 0xE6, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xE0,
  0x00, 0x40, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x1C, 0x01, 0xE3, 0x80, 0x7F,
  0xF0, 0x79, 0xE0, 0x3F, 0xFC, 0x0E, 0x78, 0x1F, 0x9F, 0x03, 0x9C, 0x0F,
  0x81, 0xC0, 0xFF, 0x03, 0xC0, 0x70, 0x3F, 0xC1, 0xE0, 0x1C, 0x07, 0xE0,
  0x78, 0x0F, 0x01, 0xF8, 0x1E, 0x03, 0xC0, 0x7E, 0x07, 0x00, 0xF0, 0x3F,
  0x81, 0xC0, 0x3C, 0x07, 0xE0, 0x70, 0x0F, 0x03, 0xF8, 0x1C, 0x03, 0xC0,
  0xFE, 0x07, 0x00, 0xF0, 0x3B, 0x81, 0xE0, 0x3C, 0x0E, 0xE0, 0x78, 0x1F,
  0x07, 0xB8, 0x1F, 0x06, 0xC1, 0xCF, 0x03, 0xF7, 0xBD, 0xF3, 0xC0, 0x7F,
  0xCF, 0xF8, 0x70, 0x0F, 0xE1, 0xFC, 0x1E, 0x00, 0xC0, 0x08, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x1F, 0xC0, 0x1E, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x7C,
  0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x7C, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E,
  0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xF8, 0x03, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE,
  0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00,
  0x1E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3E, 0x00, 0x7E, 0xF8,
  0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0xC3, 0xE0, 0xFC, 0x00, 0xC3, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0x07, 0xFE,
  0x7E, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x80,
  0x3F, 0x87, 0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0x9F, 0x00,
  0x07, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x0F, 0xE1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xF8, 0xFE, 0x0F, 0xE0, 0x03, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3F, 0x00, 0x03,
  0xC7, 0xE0, 0x00, 0xF0, 0xFC, 0x00, 0x3C, 0x3F, 0xF0, 0x7F, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0xFF, 0xDF, 0xFB, 0xFE, 0x7F, 0x00, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80,
  0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x01, 0xF0, 0x3C, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0x80,
  0x1F, 0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xF7, 0xC0, 0x0F, 0xC7, 0xC0, 0x1F,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xBF,
  0xDE, 0x00, 0x03, 0xDF, 0xEF, 0x00, 0x01, 0xEF, 0xF7, 0x80, 0x00, 0xE7,
  0xF9, 0xE0, 0x00, 0xF3, 0xFC, 0xF0, 0x00, 0x79, 0xFE, 0x7C, 0x00, 0x38,
  0xFF, 0x1E, 0x00, 0x3C, 0x7F, 0x8F, 0x00, 0x1E, 0x3F, 0xC3, 0xC0, 0x1E,
  0x1F, 0xE1, 0xE0, 0x0F, 0x0F, 0xF0, 0xF0, 0x07, 0x87, 0xF8, 0x3C, 0x07,
  0x83, 0xFC, 0x1E, 0x03, 0xC1, 0xFE, 0x0F, 0x01, 0xE0, 0xFF, 0x03, 0xC1,
  0xE0, 0x7F, 0x81, 0xE0, 0xF0, 0x3F, 0xC0, 0xF0, 0x78, 0x1F, 0xE0, 0x3C,
  0x78, 0x0F, 0xF0, 0x1E, 0x3C, 0x07, 0xF8, 0x0F, 0x1E, 0x03, 0xFC, 0x03,
  0xDE, 0x01, 0xFE, 0x01, 0xEF, 0x00, 0xFF, 0x00, 0xF7, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0xF0,
  0x03, 0xE0, 0x07, 0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0x01, 0xE0,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xDF,
  0x00, 0x1F, 0xF3, 0xC0, 0x07, 0xFC, 0xF8, 0x01, 0xFF, 0x1E, 0x00, 0x7F,
  0xC7, 0xC0, 0x1F, 0xF0, 0xF0, 0x07, 0xFC, 0x3E, 0x01, 0xFF, 0x07, 0xC0,
  0x7F, 0xC1, 0xF0, 0x1F, 0xF0, 0x3E, 0x07, 0xFC, 0x07, 0x81, 0xFF, 0x01,
  0xF0, 0x7F, 0xC0, 0x3C, 0x1F, 0xF0, 0x0F, 0x87, 0xFC, 0x01, 0xF1, 0xFF,
  0x00, 0x7C, 0x3F, 0xC0, 0x0F, 0x8F, 0xF0, 0x03, 0xE3, 0xFC, 0x00, 0x7C,
  0xFF, 0x00, 0x0F, 0x3F, 0xC0, 0x03, 0xEF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0x01,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x1F, 0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xF9,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0x80,
  0x7E, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xF7,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x7C, 0x00,
  0x7B, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x07, 0xE7, 0xC1, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8,
  0xFF, 0x01, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x3C, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0x78, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0,
  0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3E, 0x00,
  0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x0F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0x03, 0xC0, 0x3E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07,
  0xC0, 0x1F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x7C,
  0x00, 0x7C, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xF8, 0x03,
  0xFF, 0x80, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFC, 0x7E, 0x7E, 0x00, 0x67,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xC0, 0x03, 0xEF, 0xE1, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0xC3, 0xFC,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x78,
  0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x07, 0x80,
  0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x03, 0xE0, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x03,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x7C,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xBC, 0x00, 0x1F, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xC0, 0x03, 0xEF,
  0x80, 0x07, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xF0, 0x00, 0xF1, 0xE0, 0x03,
  0xF8, 0x00, 0x78, 0xF0, 0x01, 0xFE, 0x00, 0x7C, 0x7C, 0x00, 0xEF, 0x00,
  0x3C, 0x1E, 0x00, 0xF7, 0x80, 0x1E, 0x0F, 0x00, 0x79, 0xC0, 0x0F, 0x07,
  0x80, 0x3C, 0xF0, 0x0F, 0x83, 0xE0, 0x1E, 0x78, 0x07, 0xC1, 0xF0, 0x1E,
  0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x87, 0x81,
  0xF0, 0x1F, 0x03, 0xC3, 0xC0, 0xF8, 0x0F, 0x83, 0xC1, 0xE0, 0x78, 0x03,
  0xC1, 0xE0, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x3C, 0x1E, 0x00, 0xF0, 0x78,
  0x1E, 0x1F, 0x00, 0x7C, 0x78, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x03,
  0xEF, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0x1E, 0xE0, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x9E,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0x83, 0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xC0,
  0x7C, 0x03, 0xC0, 0x1E, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x03, 0xC1, 0xF0,
  0x01, 0xF0, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x7C,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xBE, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0xC0, 0x03,
  0xC1, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x3C,
  0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0xBC, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xE0,
  0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x3C, 0x00,
  0x3C, 0x3E, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xE3, 0xC0, 0x03, 0xC7,
  0x80, 0x07, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0x78, 0xE0, 0x00, 0xF3, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x3E, 0x07,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF8, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xC0, 0x7C, 0x20, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3F, 0xF0,
  0x7F, 0xFE, 0x3F, 0xFF, 0xCF, 0xF0, 0x7B, 0xE0, 0x0F, 0x78, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x01, 0xFB, 0xE0, 0xFF, 0x7F, 0xFC, 0xE7, 0xFF, 0x1C, 0x7F, 0xC3, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x1E, 0x01, 0xE3, 0xFE, 0x0F, 0x7F, 0xF8, 0x7F, 0xFF,
  0xE3, 0xF8, 0x1F, 0x9F, 0x80, 0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xBE,
  0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x3E,
  0xFC, 0x03, 0xE7, 0xF8, 0x3F, 0x3D, 0xFF, 0xF1, 0xC7, 0xFF, 0x0E, 0x1F,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F,
  0x81, 0x8F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x04, 0x7E, 0x0E, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x07, 0xC1, 0xFF, 0x9F,
  0x0F, 0xFF, 0x3C, 0x7F, 0xFE, 0xF1, 0xF0, 0x3F, 0xCF, 0x80, 0x7F, 0x3C,
  0x00, 0xFD, 0xF0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00,
  0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0,
  0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x00, 0x3F, 0x3E, 0x01, 0xFC, 0x7E, 0x0F,
  0xF1, 0xFF, 0xFB, 0xC3, 0xFF, 0xCF, 0x03, 0xFC, 0x3C, 0x00, 0x78, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xF0, 0x3E, 0x1F, 0x00,
  0xF0, 0xF0, 0x07, 0xCF, 0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0xDE,
  0x00, 0x3E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x43, 0xF8, 0x1E,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x07, 0xC2, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0xF8, 0xF0, 0xFF, 0xF3, 0xC7, 0xFF, 0xEF, 0x1F, 0x03, 0xFC,
  0xF8, 0x07, 0xF3, 0xC0, 0x0F, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0,
  0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7,
  0x80, 0x07, 0xDE, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xF0, 0x03, 0xF3, 0xE0,
  0x1F, 0xC7, 0xE0, 0xEF, 0x1F, 0xFF, 0xBC, 0x3F, 0xFD, 0xF0, 0x3F, 0xC7,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x80, 0x07, 0xC3, 0x80, 0x3F, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x3C, 0x0F, 0x1F, 0xF0, 0xF7, 0xFF, 0xCF, 0x7F, 0xFC, 0xFE, 0x07, 0xEF,
  0xC0, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x7B, 0xFE, 0xF7, 0x80, 0x00,
  0x00, 0x1E, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF0, 0x03, 0xC0, 0xF0, 0x7C, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C,
  0x1F, 0xFF, 0xBF, 0xEF, 0xF1, 0xF0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0xEF, 0x00,
  0x79, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x81, 0xF0, 0xF0, 0x7C, 0x1E, 0x1F,
  0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x0F, 0x3E, 0x01, 0xEF, 0x80, 0x3D, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xBE, 0x03, 0xE3, 0xE0, 0x78, 0x3C,
  0x0F, 0x07, 0xC1, 0xE0, 0x7C, 0x3C, 0x07, 0x87, 0x80, 0xF8, 0xF0, 0x0F,
  0x9E, 0x01, 0xF3, 0xC0, 0x1F, 0x78, 0x01, 0xEF, 0x00, 0x3E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x38, 0xFF, 0xC1,
  0xFF, 0x8E, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFC, 0xFE, 0x07,
  0xFC, 0x1F, 0xBF, 0x00, 0xFE, 0x03, 0xEF, 0x80, 0x3F, 0x00, 0x7B, 0xE0,
  0x0F, 0x80, 0x1F, 0xF0, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0x78, 0x01, 0xFF,
  0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x07, 0x80, 0x1F, 0xF0, 0x01, 0xE0, 0x07,
  0xFC, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x07, 0x80,
  0x1F, 0xF0, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x1E,
  0x00, 0x7F, 0xC0, 0x07, 0x80, 0x1F, 0xF0, 0x01, 0xE0, 0x07, 0xFC, 0x00,
  0x78, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x07, 0x80, 0x1F, 0xF0,
  0x01, 0xE0, 0x07, 0xFC, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0x3C, 0x0E, 0x1F, 0xF0, 0xE7, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE, 0x07,
  0xEF, 0xC0, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0x03, 0xF0, 0xF8, 0x03,
  0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0x7D, 0xE0, 0x00, 0xF7,
  0x80, 0x03, 0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03,
  0xDF, 0x00, 0x1F, 0x3C, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x07,
  0xE0, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3C, 0x07, 0x0F, 0xF8, 0x39, 0xFF, 0xE1, 0xEF, 0xFF, 0x8F, 0xE0, 0x7E,
  0x7E, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xEF, 0x80, 0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x0F, 0x9F,
  0xE0, 0xFC, 0xF7, 0xFF, 0xC7, 0x9F, 0xFC, 0x3C, 0x7F, 0x81, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0xF0,
  0xFF, 0xF3, 0xC7, 0xFF, 0xEF, 0x1F, 0x03, 0xFC, 0xF8, 0x07, 0xF3, 0xC0,
  0x0F, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07,
  0xDE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00,
  0x1F, 0x7C, 0x00, 0x7C, 0xF0, 0x03, 0xF3, 0xE0, 0x1F, 0xC7, 0xE0, 0xEF,
  0x1F, 0xFF, 0xBC, 0x3F, 0xFD, 0xF0, 0x3F, 0xC7, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7B, 0x87, 0xFE, 0x3F, 0xB9,
  0xFE, 0xFF, 0x8B, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0x8F, 0xFF,
  0xEF, 0xFF, 0xE7, 0xC0, 0x77, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x3E, 0xFF, 0xFE, 0x7F,
  0xFE, 0x0F, 0xFE, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x84, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0x7E, 0x1F, 0xF7, 0xFF, 0xEF,
  0x3F, 0xFC, 0xF1, 0xFF, 0x0F, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0x80,
  0x07, 0x9F, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xE0, 0x0F,
  0x07, 0x80, 0x7C, 0x1E, 0x01, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0,
  0x01, 0xEE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xEF, 0x00, 0x3E,
  0x00, 0x79, 0xE0, 0x07, 0xE0, 0x0F, 0x3E, 0x01, 0xFC, 0x01, 0xE3, 0xC0,
  0x3F, 0x80, 0x7C, 0x78, 0x07, 0x78, 0x0F, 0x0F, 0x01, 0xEF, 0x01, 0xE1,
  0xF0, 0x3D, 0xE0, 0x3C, 0x1E, 0x07, 0x9C, 0x0F, 0x83, 0xC0, 0xE3, 0xC1,
  0xE0, 0x78, 0x3C, 0x78, 0x3C, 0x0F, 0x87, 0x8F, 0x07, 0x80, 0xF0, 0xF0,
  0xE1, 0xE0, 0x1E, 0x1C, 0x1E, 0x3C, 0x03, 0xC7, 0x83, 0xC7, 0x80, 0x3C,
  0xF0, 0x78, 0xF0, 0x07, 0x9E, 0x07, 0x1C, 0x00, 0xF3, 0x80, 0xF7, 0x80,
  0x1E, 0xF0, 0x1E, 0xF0, 0x01, 0xDE, 0x03, 0xDE, 0x00, 0x3F, 0x80, 0x3B,
  0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x1F, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0xFB, 0xE0, 0x0F, 0x8F, 0x80, 0x78, 0x3C, 0x07, 0xC1, 0xF0, 0x3C,
  0x07, 0x83, 0xC0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0x03, 0xDF, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x3C, 0x78, 0x03, 0xE3,
  0xE0, 0x1E, 0x0F, 0x01, 0xF0, 0x7C, 0x0F, 0x01, 0xF0, 0xF0, 0x07, 0x8F,
  0x80, 0x3E, 0x78, 0x00, 0xF7, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x3D, 0xE0,
  0x01, 0xF7, 0x80, 0x07, 0x9F, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x03,
  0xC3, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x1E, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xEE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x01,
  0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x03, 0xF8, 0x0F, 0xE0,
  0x1E, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xC0, 0x7F, 0x81, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x7F, 0x80, 0xFE, 0x01,
  0xF8, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x0B, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFC, 0x03, 0xFF, 0x40, 0x03, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Regular49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 36, 13, 3, -35 },
  { 28, 13, 13, 19, 3, -35 },
  { 50, 26, 35, 28, 1, -35 },
  { 164, 20, 40, 25, 3, -37 },
  { 264, 33, 35, 38, 2, -35 },
  { 409, 29, 36, 31, 2, -36 },
  { 540, 5, 13, 11, 3, -35 },
  { 549, 11, 43, 15, 2, -35 },
  { 609, 11, 43, 15, 1, -35 },
  { 669, 20, 20, 24, 2, -37 },
  { 719, 21, 23, 25, 2, -29 },
  { 780, 7, 12, 12, 2, -6 },
  { 791, 11, 4, 15, 2, -15 },
  { 797, 6, 7, 12, 3, -6 },
  { 803, 17, 35, 18, 1, -35 },
  { 878, 21, 36, 25, 2, -36 },
  { 973, 12, 35, 25, 4, -35 },
  { 1026, 21, 35, 25, 2, -35 },
  { 1118, 21, 35, 25, 2, -35 },
  { 1210, 24, 35, 25, 1, -35 },
  { 1315, 20, 35, 25, 3, -35 },
  { 1403, 21, 35, 25, 2, -35 },
  { 1495, 21, 35, 25, 2, -35 },
  { 1587, 21, 35, 25, 2, -35 },
  { 1679, 21, 35, 25, 2, -35 },
  { 1771, 6, 28, 12, 3, -27 },
  { 1792, 7, 33, 12, 2, -27 },
  { 1821, 21, 23, 25, 2, -29 },
  { 1882, 21, 13, 25, 2, -24 },
  { 1917, 21, 23, 25, 2, -29 },
  { 1978, 17, 36, 19, 1, -35 },
  { 2055, 34, 39, 40, 3, -35 },
  { 2221, 28, 35, 28, 0, -35 },
  { 2344, 22, 35, 29, 4, -35 },
  { 2441, 23, 35, 28, 3, -35 },
  { 2542, 25, 35, 32, 4, -35 },
  { 2652, 18, 35, 25, 4, -35 },
  { 2731, 18, 35, 23, 4, -35 },
  { 2810, 26, 35, 32, 3, -35 },
  { 2924, 24, 35, 33, 4, -35 },
  { 3029, 12, 35, 16, 2, -35 },
  { 3082, 11, 44, 13, -3, -35 },
  { 3143, 23, 35, 27, 4, -35 },
  { 3244, 18, 35, 23, 4, -35 },
  { 3323, 33, 35, 41, 4, -35 },
  { 3468, 26, 35, 34, 4, -35 },
  { 3582, 28, 36, 34, 3, -36 },
  { 3708, 21, 35, 27, 4, -35 },
  { 3800, 28, 44, 34, 3, -36 },
  { 3954, 23, 35, 28, 4, -35 },
  { 4055, 20, 35, 24, 2, -35 },
  { 4143, 24, 35, 24, 0, -35 },
  { 4248, 24, 35, 32, 4, -35 },
  { 4353, 27, 35, 27, 0, -35 },
  { 4472, 41, 35, 42, 0, -35 },
  { 4652, 25, 35, 25, 0, -35 },
  { 4762, 25, 35, 25, 0, -35 },
  { 4872, 21, 35, 24, 2, -35 },
  { 4964, 11, 43, 16, 4, -35 },
  { 5024, 17, 35, 18, 1, -35 },
  { 5099, 11, 43, 16, 1, -35 },
  { 5159, 23, 21, 26, 1, -35 },
  { 5220, 22, 3, 22, 0, 4 },
  { 5229, 10, 8, 14, 2, -38 },
  { 5239, 19, 27, 25, 2, -27 },
  { 5304, 21, 37, 27, 4, -37 },
  { 5402, 18, 27, 21, 2, -27 },
  { 5463, 22, 37, 27, 2, -37 },
  { 5565, 21, 27, 25, 2, -27 },
  { 5636, 16, 37, 15, 1, -37 },
  { 5710, 22, 39, 27, 2, -27 },
  { 5818, 20, 37, 27, 4, -37 },
  { 5911, 5, 36, 12, 3, -36 },
  { 5934, 10, 48, 12, -2, -36 },
  { 5994, 19, 37, 24, 4, -37 },
  { 6082, 4, 37, 12, 4, -37 },
  { 6101, 34, 27, 41, 4, -27 },
  { 6216, 20, 27, 27, 4, -27 },
  { 6284, 22, 27, 27, 2, -27 },
  { 6359, 21, 39, 27, 4, -27 },
  { 6462, 22, 39, 27, 2, -27 },
  { 6570, 14, 27, 18, 4, -27 },
  { 6618, 17, 27, 21, 2, -27 },
  { 6676, 14, 32, 16, 1, -32 },
  { 6732, 20, 26, 27, 4, -26 },
  { 6797, 22, 26, 22, 0, -26 },
  { 6869, 35, 26, 35, 0, -26 },
  { 6983, 21, 26, 23, 1, -26 },
  { 7052, 22, 38, 22, 0, -26 },
  { 7157, 16, 26, 20, 2, -26 },
  { 7209, 15, 43, 18, 2, -35 },
  { 7290, 4, 49, 24, 10, -37 },
  { 7315, 15, 43, 18, 2, -35 },
  { 7396, 21, 6, 25, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_Regular49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR49PT7B_H_
