#ifndef _NOTOSANS_SEMICONDENSED_REGULAR20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular20pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x24, 0x92, 0x48, 0x0F, 0xC0, 0xCF, 0x3C, 0xD2, 0x48, 0x0C,
  0xC1, 0x10, 0x22, 0x04, 0x47, 0xFE, 0x33, 0x06, 0x40, 0x88, 0xFF, 0xFF,
  0xFC, 0x4C, 0x19, 0x83, 0x20, 0x44, 0x00, 0x08, 0x08, 0x7F, 0xC9, 0xC8,
  0xC8, 0x68, 0x3C, 0x0F, 0x0B, 0x09, 0x09, 0xEF, 0xFC, 0x08, 0x08, 0x78,
  0x66, 0x42, 0x22, 0x31, 0x11, 0x08, 0x98, 0x44, 0x9B, 0x2D, 0xEF, 0x59,
  0x06, 0x88, 0x24, 0x43, 0x22, 0x11, 0x91, 0x8C, 0x88, 0x38, 0x08, 0x03,
  0xE0, 0x62, 0x06, 0x20, 0x62, 0x02, 0x60, 0x3C, 0x03, 0x80, 0x6C, 0x6C,
  0x66, 0xC3, 0xCC, 0x3C, 0xC1, 0xCE, 0x7C, 0x7E, 0x70, 0xFD, 0x40, 0x32,
  0x64, 0xCC, 0xCC, 0xCC, 0xCC, 0xC4, 0x62, 0x30, 0xC4, 0x62, 0x33, 0x33,
  0x33, 0x33, 0x36, 0x64, 0xC0, 0x18, 0x18, 0x99, 0xFF, 0x18, 0x3C, 0x66,
  0x24, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C,
  0x00, 0x7B, 0x68, 0xF0, 0xFC, 0x06, 0x0C, 0x10, 0x60, 0x83, 0x06, 0x08,
  0x30, 0x60, 0x83, 0x04, 0x18, 0x00, 0x08, 0x3E, 0x66, 0xC3, 0xC3, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0x43, 0x66, 0x3C, 0x3B, 0xF7, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7E, 0xC7, 0x03, 0x03, 0x03, 0x02,
  0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0xFE, 0xC7, 0x03, 0x03,
  0x03, 0x06, 0x38, 0x0E, 0x03, 0x03, 0x03, 0x03, 0xC7, 0xFC, 0x03, 0x01,
  0xC0, 0x50, 0x34, 0x1B, 0x04, 0xC3, 0x30, 0x8C, 0x43, 0x3F, 0xFF, 0xFC,
  0x0C, 0x03, 0x00, 0xC0, 0x7E, 0x40, 0x40, 0x40, 0x40, 0xFC, 0x7E, 0x03,
  0x03, 0x01, 0x03, 0x03, 0xC6, 0xFC, 0x1F, 0x18, 0x18, 0x08, 0x0C, 0x06,
  0xF3, 0xDD, 0x86, 0xC1, 0x60, 0xF0, 0x48, 0x66, 0x71, 0xF0, 0xFF, 0x80,
  0x80, 0xC0, 0x60, 0x60, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x06, 0x06, 0x03,
  0x03, 0x00, 0x7E, 0x31, 0xB0, 0xD8, 0x64, 0x33, 0xB0, 0x70, 0xFC, 0xC3,
  0x60, 0xB0, 0x78, 0x2E, 0x33, 0xF0, 0x7E, 0x66, 0xC3, 0xC1, 0xC1, 0xC3,
  0xC3, 0x7D, 0x39, 0x03, 0x03, 0x06, 0x8E, 0x78, 0x5D, 0x00, 0x00, 0x1F,
  0x80, 0x5D, 0x00, 0x00, 0x0F, 0x69, 0x00, 0x00, 0x81, 0xC3, 0x87, 0x0E,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x40, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x3C, 0x70, 0xE0, 0xC0, 0x40,
  0x00, 0xFC, 0x8C, 0x08, 0x10, 0x60, 0x83, 0x0C, 0x10, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x0F, 0xE0, 0x60, 0xC3, 0x01, 0x98, 0x02, 0x47, 0xCF, 0x31,
  0x1C, 0x84, 0x72, 0x11, 0x88, 0xC7, 0x23, 0x3C, 0xDF, 0x91, 0xCC, 0x60,
  0x00, 0xC0, 0x01, 0xFE, 0x01, 0xE0, 0x06, 0x01, 0xC0, 0x2C, 0x05, 0x81,
  0x90, 0x33, 0x04, 0x61, 0x8C, 0x3F, 0xC7, 0xF9, 0x83, 0x30, 0x34, 0x07,
  0x80, 0xC0, 0xFE, 0x63, 0xB0, 0xD8, 0x2C, 0x36, 0x3B, 0xF1, 0x8E, 0xC1,
  0xE0, 0xF0, 0x78, 0x7F, 0xF7, 0xF0, 0x1F, 0xCC, 0x26, 0x01, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x38, 0x87, 0xE0,
  0xFE, 0x31, 0xCC, 0x1B, 0x06, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x1B, 0x0E, 0xFF, 0x3F, 0x00, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x3F,
  0xE0, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xC0, 0xFF, 0x83, 0x06, 0x0C, 0x18,
  0x3F, 0xFF, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x00, 0x1F, 0xE7, 0x09, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x30, 0xFE, 0x1F, 0xC0, 0x78, 0x0D, 0x81, 0xB0,
  0x33, 0x8E, 0x3F, 0xC0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F,
  0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30, 0xFB, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x7C, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x13, 0xFE, 0xC3, 0xE1, 0xB1, 0x99, 0x8D, 0x86, 0x83, 0xC1,
  0xF0, 0xCC, 0x66, 0x31, 0x98, 0x6C, 0x36, 0x0C, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xC0, 0xE0, 0x3F, 0x01,
  0xE8, 0x1F, 0x60, 0xFB, 0x05, 0xC8, 0x6E, 0x63, 0x73, 0x13, 0x89, 0x9C,
  0x6C, 0xE3, 0x47, 0x0E, 0x38, 0x71, 0xC3, 0x0C, 0xC0, 0xF8, 0x3A, 0x0E,
  0xC3, 0x98, 0xE6, 0x38, 0xCE, 0x33, 0x86, 0xE1, 0xB8, 0x3E, 0x07, 0x81,
  0xE0, 0x30, 0x04, 0x01, 0xF8, 0x30, 0xC6, 0x06, 0x40, 0x6C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x06, 0x60, 0x63, 0x9C, 0x1F,
  0x80, 0xFC, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xFC, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x04, 0x01, 0xF8, 0x30, 0xC6, 0x06, 0x40, 0x6C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x06, 0x60, 0x63, 0x9C,
  0x1F, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0xFE, 0x63, 0xB0, 0xD8, 0x6C, 0x36,
  0x1B, 0x39, 0xF8, 0xCC, 0x62, 0x31, 0x98, 0x6C, 0x36, 0x0C, 0x7F, 0xE2,
  0xC0, 0xC0, 0xC0, 0x60, 0x3C, 0x0E, 0x03, 0x03, 0x03, 0x03, 0xC6, 0xFC,
  0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x36, 0x31, 0xF0, 0xC0, 0x68,
  0x19, 0x83, 0x30, 0x62, 0x08, 0x63, 0x0C, 0x61, 0x88, 0x13, 0x03, 0x60,
  0x68, 0x05, 0x00, 0xE0, 0x1C, 0x00, 0xC1, 0xC1, 0xA0, 0xE0, 0x98, 0x50,
  0xCC, 0x28, 0x66, 0x36, 0x31, 0x1B, 0x10, 0xC8, 0x98, 0x64, 0x4C, 0x36,
  0x36, 0x0B, 0x1A, 0x05, 0x05, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0x60, 0xC0,
  0xE0, 0xD8, 0x63, 0x10, 0x4C, 0x1A, 0x03, 0x80, 0xC0, 0x38, 0x1E, 0x04,
  0xC3, 0x11, 0x86, 0x60, 0xB0, 0x30, 0xC0, 0xD8, 0x66, 0x18, 0xCC, 0x33,
  0x04, 0x81, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xFF, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x60, 0xC0,
  0xFF, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC0,
  0xC1, 0x81, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x60, 0xC0,
  0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x18, 0x0E, 0x0D,
  0x04, 0xC6, 0x22, 0x1B, 0x05, 0x03, 0xFF, 0x80, 0xC6, 0x30, 0x3C, 0x7E,
  0x03, 0x03, 0x03, 0x7F, 0xC3, 0xC3, 0xC3, 0xC7, 0x7B, 0x80, 0x80, 0x80,
  0x80, 0xBC, 0xFE, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xE6, 0xBC,
  0x3E, 0xFD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xC4, 0xF8, 0x01, 0x80,
  0xC0, 0x60, 0x33, 0xDB, 0xFD, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1B, 0x1C, 0xF6, 0x3C, 0x7E, 0x43, 0xC3, 0xC1, 0xFF, 0xC0, 0xC0, 0x40,
  0x71, 0x3F, 0x1E, 0x60, 0xC1, 0x87, 0xDF, 0x8C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x00, 0x3D, 0xBF, 0xD0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xB1, 0xCF, 0x60, 0x30, 0x18, 0x19, 0xFC, 0x78, 0x80, 0x80,
  0x80, 0x80, 0x9C, 0xFE, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x74, 0x55, 0x55, 0x54, 0x13, 0x10, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x13, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x86, 0x8C, 0x88, 0x98, 0xB0,
  0xF0, 0xD8, 0x98, 0x8C, 0x86, 0x87, 0xFF, 0xFE, 0xBC, 0xF7, 0xFF, 0xF1,
  0xC7, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10,
  0x60, 0x82, 0x9C, 0xFE, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x3C, 0x3F, 0x90, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x41, 0x31,
  0x8F, 0x80, 0xBC, 0xFE, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xE6,
  0xBC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3D, 0xBF, 0xD0, 0xF8, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC3, 0xB1, 0xCF, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x9D, 0xF1, 0x88, 0x42, 0x10, 0x84, 0x20, 0x7F, 0xFB, 0x06, 0x0E, 0x07,
  0x03, 0x03, 0x07, 0x1B, 0xF0, 0x20, 0x87, 0xFF, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x0C, 0x3C, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0x43, 0xB3, 0xCF, 0x60, 0xC1, 0xE0, 0xD8, 0x4C, 0x66, 0x31, 0x10, 0xD8,
  0x6C, 0x14, 0x0E, 0x07, 0x00, 0xC3, 0x0D, 0x0C, 0x34, 0x38, 0xD9, 0xA2,
  0x66, 0x98, 0x93, 0x62, 0x4D, 0x8F, 0x14, 0x3C, 0x50, 0x61, 0xC1, 0x87,
  0x00, 0xE1, 0xB1, 0x8C, 0xC6, 0xC1, 0xC0, 0x60, 0x70, 0x6C, 0x33, 0x31,
  0xB8, 0x60, 0xC1, 0xE0, 0xD8, 0x4C, 0x62, 0x31, 0x90, 0xD8, 0x2C, 0x14,
  0x0E, 0x03, 0x01, 0x01, 0x80, 0xC3, 0xC1, 0xC0, 0xFD, 0xF8, 0x30, 0xC1,
  0x86, 0x08, 0x30, 0xC1, 0x83, 0xF8, 0x1C, 0xC3, 0x0C, 0x30, 0xC3, 0x18,
  0xC1, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x0C, 0xC3, 0x0C, 0x30, 0xC2, 0x18,
  0xC0, 0xF9, 0xC7, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Regular20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 8, 1, -14 },
  { 11, 11, 14, 12, 0, -14 },
  { 31, 8, 16, 10, 1, -15 },
  { 47, 13, 14, 15, 1, -14 },
  { 70, 12, 15, 13, 1, -15 },
  { 93, 2, 5, 4, 1, -14 },
  { 95, 4, 17, 6, 1, -14 },
  { 104, 4, 17, 6, 1, -14 },
  { 113, 8, 8, 10, 1, -15 },
  { 121, 9, 10, 10, 1, -12 },
  { 133, 3, 5, 5, 1, -2 },
  { 135, 4, 1, 6, 1, -6 },
  { 136, 3, 2, 5, 1, -2 },
  { 137, 7, 14, 7, 0, -14 },
  { 150, 8, 15, 10, 1, -15 },
  { 165, 5, 14, 10, 2, -14 },
  { 174, 8, 14, 10, 1, -14 },
  { 188, 8, 14, 10, 1, -14 },
  { 202, 10, 14, 10, 0, -14 },
  { 220, 8, 14, 10, 1, -14 },
  { 234, 9, 14, 10, 1, -14 },
  { 250, 9, 14, 10, 1, -14 },
  { 266, 9, 14, 10, 1, -14 },
  { 282, 8, 14, 10, 1, -14 },
  { 296, 3, 11, 5, 1, -11 },
  { 301, 3, 14, 5, 1, -11 },
  { 307, 9, 10, 10, 1, -12 },
  { 319, 8, 6, 10, 1, -10 },
  { 325, 9, 10, 10, 1, -12 },
  { 337, 7, 14, 8, 0, -14 },
  { 350, 14, 16, 16, 1, -14 },
  { 378, 11, 14, 11, 0, -14 },
  { 398, 9, 14, 12, 2, -14 },
  { 414, 10, 14, 11, 1, -14 },
  { 432, 10, 14, 13, 2, -14 },
  { 450, 7, 14, 10, 2, -14 },
  { 463, 7, 14, 9, 2, -14 },
  { 476, 11, 14, 13, 1, -14 },
  { 496, 10, 14, 13, 2, -14 },
  { 514, 5, 14, 6, 1, -14 },
  { 523, 4, 18, 5, -1, -14 },
  { 532, 9, 14, 11, 2, -14 },
  { 548, 7, 14, 9, 2, -14 },
  { 561, 13, 14, 17, 2, -14 },
  { 584, 10, 14, 14, 2, -14 },
  { 602, 12, 15, 14, 1, -15 },
  { 625, 8, 14, 11, 2, -14 },
  { 639, 12, 18, 14, 1, -15 },
  { 666, 9, 14, 11, 2, -14 },
  { 682, 8, 14, 10, 1, -14 },
  { 696, 10, 14, 10, 0, -14 },
  { 714, 9, 14, 13, 2, -14 },
  { 730, 11, 14, 11, 0, -14 },
  { 750, 17, 14, 17, 0, -14 },
  { 780, 10, 14, 10, 0, -14 },
  { 798, 10, 14, 10, 0, -14 },
  { 816, 8, 14, 10, 1, -14 },
  { 830, 4, 17, 6, 2, -14 },
  { 839, 7, 14, 7, 0, -14 },
  { 852, 4, 17, 6, 1, -14 },
  { 861, 9, 8, 10, 1, -14 },
  { 870, 9, 1, 9, 0, 2 },
  { 872, 4, 3, 6, 1, -15 },
  { 874, 8, 11, 10, 1, -11 },
  { 885, 8, 15, 11, 2, -15 },
  { 900, 7, 11, 9, 1, -11 },
  { 910, 9, 15, 11, 1, -15 },
  { 927, 8, 11, 10, 1, -11 },
  { 938, 7, 15, 6, 0, -15 },
  { 952, 9, 16, 11, 1, -11 },
  { 970, 8, 15, 11, 2, -15 },
  { 985, 2, 15, 5, 1, -15 },
  { 989, 4, 20, 5, -1, -15 },
  { 999, 8, 15, 10, 2, -15 },
  { 1014, 1, 15, 5, 2, -15 },
  { 1016, 13, 11, 17, 2, -11 },
  { 1034, 8, 11, 11, 2, -11 },
  { 1045, 9, 11, 11, 1, -11 },
  { 1058, 8, 16, 11, 2, -11 },
  { 1074, 9, 16, 11, 1, -11 },
  { 1092, 5, 11, 7, 2, -11 },
  { 1099, 7, 11, 9, 1, -11 },
  { 1109, 6, 13, 6, 0, -13 },
  { 1119, 9, 11, 11, 1, -11 },
  { 1132, 9, 11, 9, 0, -11 },
  { 1145, 14, 11, 14, 0, -11 },
  { 1165, 9, 11, 9, 0, -11 },
  { 1178, 9, 16, 9, 0, -11 },
  { 1196, 7, 11, 8, 1, -11 },
  { 1206, 6, 17, 7, 1, -14 },
  { 1219, 2, 20, 10, 4, -15 },
  { 1224, 6, 17, 7, 1, -14 },
  { 1237, 9, 2, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Regular20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR20PT7B_H_
