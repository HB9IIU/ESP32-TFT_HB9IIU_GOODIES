#ifndef _NOTOSANS_SEMICONDENSED_REGULAR55PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00,
  0x00, 0x33, 0xFF, 0xFF, 0xFF, 0xFF, 0xCC, 0xFC, 0x3E, 0xF8, 0x7D, 0xE0,
  0xFB, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E,
  0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0x80, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x70, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x07, 0x80, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x07, 0x80, 0x00, 0xF0,
  0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x0F,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x78, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0xFE, 0x71, 0xF1, 0xF0, 0xE0, 0x27, 0xC1, 0xC0, 0x0F,
  0x83, 0x80, 0x1E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0x7C, 0x1C, 0x00, 0xF8,
  0x38, 0x00, 0xF8, 0x70, 0x01, 0xFC, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x77, 0xF8, 0x00, 0xE3, 0xF0, 0x01, 0xC1, 0xF0, 0x03, 0x83,
  0xE0, 0x07, 0x07, 0xC0, 0x0E, 0x0F, 0x80, 0x1C, 0x1F, 0x00, 0x38, 0x3D,
  0x00, 0x70, 0xFB, 0xE0, 0xE7, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x04, 0x00, 0xFF, 0x00, 0x03, 0xC0, 0x0F, 0xFC, 0x00, 0x1E,
  0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x00, 0x78, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x78, 0x00,
  0xF0, 0x3C, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x3C, 0x00, 0x38, 0x07, 0x01,
  0xE0, 0x01, 0xC0, 0x3C, 0x1E, 0x00, 0x0E, 0x01, 0xE0, 0xF0, 0x00, 0x70,
  0x0F, 0x0F, 0x00, 0x03, 0x80, 0x70, 0x78, 0x00, 0x1E, 0x07, 0x87, 0xC0,
  0x00, 0xF0, 0x3C, 0x3C, 0x3F, 0x07, 0x81, 0xE3, 0xE3, 0xFE, 0x3C, 0x0F,
  0x1E, 0x3F, 0xF1, 0xE0, 0x78, 0xF3, 0xE7, 0xC7, 0x87, 0x8F, 0x1E, 0x1F,
  0x3F, 0xFC, 0x78, 0xF0, 0x78, 0xFF, 0xC7, 0x8F, 0x03, 0xC3, 0xFC, 0x3C,
  0x78, 0x0E, 0x07, 0x83, 0xC3, 0xC0, 0x78, 0x00, 0x1E, 0x1E, 0x03, 0xC0,
  0x01, 0xE0, 0xF0, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3C,
  0x07, 0x80, 0x07, 0x81, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x1E, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x00,
  0x1F, 0x1E, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x07, 0x80, 0x01, 0xFF, 0x00,
  0x3C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x01, 0xF0, 0x7E, 0x3E, 0x00, 0xF8, 0x7E, 0x0F, 0x80, 0x78,
  0x3E, 0x07, 0xE0, 0x7C, 0x3E, 0x01, 0xF8, 0x3E, 0x1F, 0x00, 0x7E, 0x1E,
  0x0F, 0x80, 0x1F, 0x9F, 0x0F, 0x80, 0x07, 0xFF, 0x87, 0xC0, 0x01, 0xFF,
  0x83, 0xE0, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x0F, 0xFC, 0x07, 0xE0, 0x1F,
  0xFF, 0x03, 0xFF, 0xFF, 0xCF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF0, 0x3F, 0xFF,
  0x80, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFD,
  0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0xF8,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x30, 0x1C, 0x06, 0x7E, 0x38, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7B, 0xC0, 0x01,
  0xF7, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x80, 0x3E, 0x0F, 0x80, 0xFC,
  0x1F, 0x80, 0xF8, 0x1E, 0x00, 0x60, 0x38, 0x00, 0x40, 0x40, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x1F, 0x3F, 0x3E,
  0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x33, 0xEF, 0xFF, 0xFF, 0xFF, 0xCC, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFC, 0xFF, 0x07, 0xE0, 0x3E,
  0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xDF, 0x00, 0x0F, 0x9E, 0x00, 0x1F,
  0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x78, 0xF8, 0x01, 0xF0, 0xF8, 0x07, 0xE1,
  0xF8, 0x1F, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF,
  0x07, 0xFC, 0x7E, 0xF3, 0xF3, 0xDF, 0x8F, 0xFC, 0x3D, 0xE0, 0xF3, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x7F, 0x87, 0xF8, 0x7C, 0x01, 0xF8, 0x38, 0x00, 0xFC, 0x10,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0xFF, 0x87, 0xF8, 0x7C, 0x00, 0xFC, 0x30, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x80, 0x00, 0x7C, 0xF0,
  0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x7C, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xE0, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x01, 0xF0,
  0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x01, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC0, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFD, 0x00, 0x03, 0xF3, 0x80, 0x0F,
  0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x00, 0x20, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x7F, 0x81, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x0E,
  0x00, 0xF8, 0xFF, 0xC1, 0xF3, 0xFF, 0xC3, 0xEF, 0xFF, 0xC7, 0xFE, 0x1F,
  0xCF, 0xF0, 0x0F, 0xDF, 0xC0, 0x0F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C,
  0x00, 0x3C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xC1,
  0xFC, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x3C, 0x00,
  0x3E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xE3,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xC3, 0xF8, 0x1F, 0x01, 0xFC, 0x3E, 0x00,
  0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x78, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0xE3,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00,
  0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x3E, 0x00,
  0x7F, 0x3F, 0x00, 0xFF, 0x1F, 0xFF, 0xDF, 0x1F, 0xFF, 0xDF, 0x07, 0xFF,
  0x9E, 0x03, 0xFE, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x1E, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0x00, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C,
  0x78, 0x78, 0xF0, 0xF0, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xE3,
  0xFC, 0xE0, 0x0F, 0x90, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x01, 0xE1, 0xF0, 0x0F, 0xFF,
  0x83, 0xC3, 0xC0, 0x3F, 0xFF, 0x03, 0xCF, 0x80, 0xFF, 0xFE, 0x07, 0x9E,
  0x03, 0xE0, 0x3C, 0x0F, 0x3C, 0x07, 0x80, 0xF8, 0x1E, 0x78, 0x1E, 0x01,
  0xE0, 0x1D, 0xE0, 0x3C, 0x03, 0xC0, 0x3B, 0xC0, 0xF8, 0x07, 0x80, 0x7F,
  0x81, 0xE0, 0x0F, 0x00, 0xFF, 0x03, 0xC0, 0x1E, 0x01, 0xFE, 0x07, 0x80,
  0x3C, 0x03, 0xBC, 0x0F, 0x00, 0x78, 0x07, 0x78, 0x1E, 0x00, 0xF0, 0x1E,
  0xF0, 0x3C, 0x01, 0xE0, 0x3D, 0xE0, 0x78, 0x07, 0xC0, 0x7B, 0xC0, 0xF8,
  0x0F, 0x80, 0xE7, 0x80, 0xF0, 0x1F, 0x03, 0xCF, 0x01, 0xF0, 0x77, 0x0F,
  0x8F, 0x01, 0xFB, 0xEF, 0xFE, 0x1E, 0x03, 0xFF, 0x9F, 0xF8, 0x3C, 0x03,
  0xFE, 0x1F, 0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x02,
  0x00, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7C,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0x80,
  0x1F, 0xC7, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF,
  0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC7, 0xC0, 0x07, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0x7E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0xFF, 0x9F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0xE0, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x06, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x02,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0xF8, 0x03, 0xFE, 0x0F, 0x80, 0x07, 0xF0, 0xF8,
  0x00, 0x3F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x0F,
  0xE0, 0xF8, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xDF, 0xF0, 0x1F, 0xE0, 0x03, 0xC0,
  0xFE, 0x00, 0x01, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0x7C, 0x7F, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x07,
  0xC1, 0xFE, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xD0, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x7F, 0xFB, 0xFF, 0x9F, 0xF8, 0xFF, 0x80, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE3, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x03,
  0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x81, 0xF8,
  0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F,
  0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x9F, 0x80,
  0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07,
  0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3E,
  0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xFC,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x3F, 0x3E, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF7, 0x80, 0x00, 0x1E, 0xFF, 0x7C, 0x00, 0x01, 0xEF, 0xF7, 0xC0,
  0x00, 0x3C, 0xFF, 0x3C, 0x00, 0x03, 0xCF, 0xF3, 0xE0, 0x00, 0x3C, 0xFF,
  0x3E, 0x00, 0x07, 0x8F, 0xF1, 0xE0, 0x00, 0x78, 0xFF, 0x1F, 0x00, 0x0F,
  0x8F, 0xF1, 0xF0, 0x00, 0xF0, 0xFF, 0x0F, 0x00, 0x0F, 0x0F, 0xF0, 0xF8,
  0x01, 0xF0, 0xFF, 0x0F, 0x80, 0x1E, 0x0F, 0xF0, 0x78, 0x01, 0xE0, 0xFF,
  0x07, 0xC0, 0x3E, 0x0F, 0xF0, 0x7C, 0x03, 0xC0, 0xFF, 0x03, 0xC0, 0x3C,
  0x0F, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0x01, 0xE0, 0x78, 0x0F, 0xF0, 0x1E,
  0x07, 0x80, 0xFF, 0x01, 0xF0, 0xF8, 0x0F, 0xF0, 0x0F, 0x0F, 0x00, 0xFF,
  0x00, 0xF0, 0xF0, 0x0F, 0xF0, 0x0F, 0x9F, 0x00, 0xFF, 0x00, 0x79, 0xE0,
  0x0F, 0xF0, 0x07, 0x9E, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0x00,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x7C, 0x00, 0x0F, 0xF7, 0xC0,
  0x00, 0xFF, 0x3E, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0xFF, 0x1F, 0x00, 0x0F,
  0xF1, 0xF8, 0x00, 0xFF, 0x0F, 0x80, 0x0F, 0xF0, 0x7C, 0x00, 0xFF, 0x07,
  0xC0, 0x0F, 0xF0, 0x3E, 0x00, 0xFF, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0x00,
  0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x0F, 0x80, 0xFF, 0x00, 0x7C, 0x0F, 0xF0,
  0x07, 0xC0, 0xFF, 0x00, 0x3E, 0x0F, 0xF0, 0x03, 0xF0, 0xFF, 0x00, 0x1F,
  0x0F, 0xF0, 0x01, 0xF8, 0xFF, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0xFC, 0xFF,
  0x00, 0x07, 0xCF, 0xF0, 0x00, 0x3E, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x02, 0x80, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x80, 0x7F, 0x9F, 0x00, 0x3F,
  0x3E, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xBE,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xE0,
  0x0F, 0xE7, 0xC7, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x02, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x80, 0x7F, 0x87, 0xC0, 0x0F, 0xE3, 0xE0,
  0x03, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE3,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC,
  0x3E, 0x07, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF7,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xF8, 0x01, 0xC7, 0xC0,
  0x01, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE8, 0x00, 0x1F, 0xBC, 0x00, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F,
  0x9F, 0x80, 0x07, 0xE3, 0xF8, 0x07, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x28, 0x00, 0xF8,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0,
  0x3E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF8, 0x00,
  0x1E, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xE3, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xBC, 0x00, 0x3C,
  0x1F, 0x00, 0x1E, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFB, 0xC0, 0x07, 0xC1,
  0xF0, 0x03, 0xCF, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x3E, 0x00, 0x7C, 0x0F,
  0x00, 0x3C, 0x78, 0x03, 0xE0, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x80, 0xF8,
  0x07, 0x87, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x78, 0x3C, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0xF0, 0x1F, 0x00, 0x7C, 0x0F,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x78, 0x3E, 0x00, 0x3E, 0x1E, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0x07, 0x8F, 0x80, 0x3E, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0xF9,
  0xF0, 0x00, 0x7C, 0xF0, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xC0, 0x07, 0x9E,
  0x00, 0x03, 0xDF, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x07,
  0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00,
  0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x00, 0xF7, 0xC0,
  0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0,
  0x0F, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0x01, 0xF8, 0x20, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F,
  0x80, 0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0x7C, 0x01, 0xFD,
  0xF0, 0x0F, 0xF7, 0xF0, 0xFB, 0xCF, 0xFF, 0xCF, 0x1F, 0xFE, 0x3C, 0x3F,
  0xF0, 0xF0, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0xFF, 0xE0, 0xF9,
  0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFF, 0x81, 0xFC, 0xFF, 0x00, 0xFC, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x7C, 0xFF, 0x00, 0xFC, 0xFF,
  0xE7, 0xF8, 0xF3, 0xFF, 0xF0, 0xF1, 0xFF, 0xE0, 0xF0, 0xFF, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFC, 0x1C, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x0C, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03,
  0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x01, 0xFC, 0x1F, 0x07, 0xFF, 0x1F, 0x0F, 0xFF,
  0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0x81, 0xFF, 0x3E, 0x00, 0xFF, 0x7E, 0x00,
  0x7F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x1F, 0xE7,
  0xDF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x9F, 0x03, 0xFE, 0x0F, 0x00, 0x20,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x81, 0xF0, 0x3F, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x78, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x04, 0x7F, 0x00, 0x30, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x02, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xE0, 0x81, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x1F,
  0x0F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0x83, 0xFF, 0x3E, 0x00, 0xFF,
  0x7E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0xFF,
  0x1F, 0xE7, 0xDF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x9F, 0x03, 0xFE, 0x1F,
  0x00, 0x20, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x20, 0x00, 0xFC,
  0x3C, 0x01, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x83, 0xF8, 0x1F, 0x1F, 0xFC, 0x3E, 0x7F, 0xFC, 0x7D, 0xFF,
  0xFC, 0xFF, 0x81, 0xFD, 0xFE, 0x01, 0xFB, 0xF8, 0x01, 0xF7, 0xE0, 0x03,
  0xEF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7C, 0x27, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0xFB, 0xFF, 0x7F, 0xEF, 0xF9, 0xFC, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xEF,
  0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x81,
  0xF8, 0x3E, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80,
  0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xF9, 0xF0, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xFC, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x7E, 0xF8,
  0x00, 0xFB, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x3F,
  0x83, 0xC3, 0xFF, 0x03, 0xFF, 0x8F, 0x3F, 0xFE, 0x1F, 0xFF, 0x3E, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0xC1, 0xFB, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x00,
  0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x01,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0x0F,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0xE0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0x00, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x3F, 0x81, 0xE1, 0xFF,
  0xC3, 0xC7, 0xFF, 0xC7, 0xDF, 0xFF, 0xCF, 0xF8, 0x1F, 0xDF, 0xE0, 0x1F,
  0xBF, 0x80, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x81,
  0xF8, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0xE7, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x80, 0xF0, 0xFF,
  0xE0, 0xF1, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFF, 0x81, 0xFC, 0xFF, 0x00,
  0xFC, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7C, 0xFF, 0x00,
  0xFC, 0xFF, 0xF7, 0xF8, 0xFB, 0xFF, 0xF0, 0xF9, 0xFF, 0xE0, 0xF8, 0x7F,
  0xC0, 0xF8, 0x04, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x1F, 0x0F, 0xFF,
  0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0x83, 0xFF, 0x3E, 0x00, 0xFF, 0x7E, 0x00,
  0x7F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x1F, 0xEF,
  0xDF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x9F, 0x03, 0xFE, 0x1F, 0x00, 0x20,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF3, 0xFE, 0xF3, 0xF6, 0xFF,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xE0,
  0x3C, 0xF8, 0x00, 0xBE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x03,
  0xFC, 0x00, 0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0xFC,
  0x00, 0x20, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xF7, 0x07, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x10, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xDF, 0x00, 0x3F, 0x7E,
  0x03, 0xFD, 0xFF, 0xFE, 0xF3, 0xFF, 0xFB, 0xC7, 0xFF, 0xCF, 0x0F, 0xFC,
  0x1C, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x07, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xC0,
  0x07, 0xBE, 0x00, 0x7F, 0x00, 0x1E, 0x78, 0x01, 0xFE, 0x00, 0xF9, 0xF0,
  0x07, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0xE0, 0x0F, 0x1F, 0x00, 0xF7, 0x80,
  0x3C, 0x3C, 0x03, 0xDF, 0x01, 0xF0, 0xF8, 0x0F, 0x3C, 0x07, 0xC3, 0xE0,
  0x7C, 0xF0, 0x1E, 0x0F, 0x81, 0xE3, 0xC0, 0x78, 0x1E, 0x07, 0x8F, 0x83,
  0xE0, 0x78, 0x1E, 0x1E, 0x0F, 0x81, 0xF0, 0xF8, 0x78, 0x3C, 0x07, 0xC3,
  0xC1, 0xE0, 0xF0, 0x0F, 0x0F, 0x07, 0xC7, 0xC0, 0x3C, 0x3C, 0x0F, 0x1F,
  0x00, 0xF9, 0xF0, 0x3C, 0x78, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x07, 0x9E,
  0x03, 0xE7, 0x80, 0x1E, 0x78, 0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x1E, 0xF0,
  0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0x81, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE7,
  0xC0, 0x01, 0xE7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xC3,
  0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0x9F, 0x00, 0x07, 0xC7, 0x80,
  0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3E,
  0x00, 0x78, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x07, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x7E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF0, 0x01,
  0xC0, 0x00, 0x0F, 0xC0, 0x01, 0x3F, 0xF0, 0x01, 0x7F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFE, 0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Regular55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 40, 14, 4, -39 },
  { 31, 15, 14, 22, 3, -39 },
  { 58, 30, 39, 32, 1, -39 },
  { 205, 23, 45, 29, 3, -42 },
  { 335, 37, 41, 42, 3, -40 },
  { 525, 33, 41, 35, 2, -40 },
  { 695, 6, 14, 12, 3, -39 },
  { 706, 13, 48, 16, 2, -39 },
  { 784, 12, 48, 16, 2, -39 },
  { 856, 23, 23, 27, 2, -42 },
  { 923, 24, 27, 29, 2, -33 },
  { 1004, 8, 13, 14, 2, -6 },
  { 1017, 13, 4, 17, 2, -17 },
  { 1024, 6, 8, 14, 4, -7 },
  { 1030, 19, 39, 20, 1, -39 },
  { 1123, 23, 41, 29, 3, -40 },
  { 1241, 14, 39, 29, 4, -39 },
  { 1310, 24, 40, 29, 2, -40 },
  { 1430, 24, 41, 29, 2, -40 },
  { 1553, 27, 40, 29, 1, -40 },
  { 1688, 23, 40, 29, 3, -39 },
  { 1803, 23, 41, 29, 3, -40 },
  { 1921, 24, 39, 29, 2, -39 },
  { 2038, 24, 41, 29, 2, -40 },
  { 2161, 24, 41, 29, 2, -40 },
  { 2284, 6, 31, 14, 4, -30 },
  { 2308, 8, 37, 14, 2, -30 },
  { 2345, 24, 26, 29, 2, -33 },
  { 2423, 23, 15, 29, 3, -27 },
  { 2467, 24, 26, 29, 2, -33 },
  { 2545, 19, 41, 22, 1, -40 },
  { 2643, 39, 44, 44, 3, -39 },
  { 2858, 31, 39, 31, 0, -39 },
  { 3010, 25, 39, 32, 5, -39 },
  { 3132, 26, 41, 31, 3, -40 },
  { 3266, 28, 39, 36, 5, -39 },
  { 3403, 19, 39, 28, 5, -39 },
  { 3496, 19, 39, 26, 5, -39 },
  { 3589, 30, 41, 36, 3, -40 },
  { 3743, 27, 39, 37, 5, -39 },
  { 3875, 13, 39, 17, 2, -39 },
  { 3939, 13, 50, 14, -4, -39 },
  { 4021, 26, 39, 31, 5, -39 },
  { 4148, 20, 39, 26, 5, -39 },
  { 4246, 36, 39, 46, 5, -39 },
  { 4422, 28, 39, 38, 5, -39 },
  { 4559, 32, 41, 38, 3, -40 },
  { 4723, 23, 39, 30, 5, -39 },
  { 4836, 32, 49, 38, 3, -40 },
  { 5032, 25, 39, 31, 5, -39 },
  { 5154, 22, 41, 27, 3, -40 },
  { 5267, 25, 39, 27, 1, -39 },
  { 5389, 26, 40, 36, 5, -39 },
  { 5519, 30, 39, 30, 0, -39 },
  { 5666, 46, 39, 47, 0, -39 },
  { 5891, 28, 39, 28, 0, -39 },
  { 6028, 28, 39, 28, 0, -39 },
  { 6165, 23, 39, 27, 2, -39 },
  { 6278, 12, 48, 18, 4, -39 },
  { 6350, 19, 39, 20, 1, -39 },
  { 6443, 13, 48, 18, 1, -39 },
  { 6521, 25, 23, 29, 2, -39 },
  { 6593, 24, 3, 24, 0, 5 },
  { 6602, 11, 9, 15, 2, -42 },
  { 6615, 22, 31, 28, 2, -30 },
  { 6701, 24, 43, 31, 4, -42 },
  { 6830, 19, 31, 24, 3, -30 },
  { 6904, 24, 43, 31, 3, -42 },
  { 7033, 23, 31, 28, 3, -30 },
  { 7123, 18, 42, 17, 1, -42 },
  { 7218, 24, 43, 31, 3, -30 },
  { 7347, 23, 42, 31, 4, -42 },
  { 7468, 5, 41, 13, 4, -41 },
  { 7494, 11, 54, 13, -2, -41 },
  { 7569, 22, 42, 27, 4, -42 },
  { 7685, 5, 42, 13, 4, -42 },
  { 7712, 38, 30, 46, 4, -30 },
  { 7855, 23, 30, 31, 4, -30 },
  { 7942, 24, 31, 30, 3, -30 },
  { 8035, 24, 43, 31, 4, -30 },
  { 8164, 24, 43, 31, 3, -30 },
  { 8293, 16, 30, 21, 4, -30 },
  { 8353, 19, 31, 24, 2, -30 },
  { 8427, 16, 37, 18, 1, -36 },
  { 8501, 22, 30, 31, 4, -29 },
  { 8584, 25, 29, 25, 0, -29 },
  { 8675, 38, 30, 40, 1, -30 },
  { 8818, 24, 29, 26, 1, -29 },
  { 8905, 25, 42, 25, 0, -29 },
  { 9037, 19, 29, 23, 2, -29 },
  { 9106, 17, 48, 21, 2, -39 },
  { 9208, 4, 55, 27, 12, -42 },
  { 9236, 17, 48, 21, 2, -39 },
  { 9338, 24, 7, 29, 2, -23 },
};

const GFXfont NotoSans_SemiCondensed_Regular55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular55pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR55PT7B_H_
