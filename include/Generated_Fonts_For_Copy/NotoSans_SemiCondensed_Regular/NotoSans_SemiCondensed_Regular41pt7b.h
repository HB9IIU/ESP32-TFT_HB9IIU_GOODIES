#ifndef _NOTOSANS_SEMICONDENSED_REGULAR41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular41pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x00, 0x00, 0x77, 0xBF, 0xFF, 0x00, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE0, 0xDC, 0x18, 0x00, 0xE0,
  0xE0, 0x03, 0x03, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0,
  0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x60, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0C, 0x0C,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x0F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0,
  0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0C, 0x00, 0x30, 0x30, 0x01, 0xC1, 0xC0,
  0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0xFF, 0xF1, 0xFF, 0xF9, 0xFF, 0xFC, 0xF3, 0x82, 0xF1,
  0xC0, 0x78, 0xE0, 0x3C, 0x70, 0x1E, 0x38, 0x07, 0x1C, 0x03, 0xEE, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x38,
  0xF0, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x81, 0xC7, 0xF8,
  0xEF, 0xBF, 0xFF, 0x9F, 0xFF, 0x81, 0xFE, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xC0,
  0x7F, 0x80, 0x38, 0x07, 0x1C, 0x03, 0x80, 0xE1, 0xC0, 0x70, 0x0E, 0x0E,
  0x07, 0x00, 0xE0, 0xE0, 0xF0, 0x0E, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0xE0,
  0x0E, 0x0E, 0x1C, 0x00, 0xE0, 0xE1, 0xC0, 0x0E, 0x0E, 0x38, 0x00, 0xE0,
  0xE3, 0x8F, 0x0E, 0x0E, 0x71, 0xFC, 0x61, 0xC7, 0x3F, 0xC7, 0x1C, 0xE7,
  0x0E, 0x7F, 0xCE, 0x70, 0xE3, 0xF9, 0xC7, 0x0E, 0x0E, 0x1C, 0x70, 0x70,
  0x03, 0x86, 0x07, 0x00, 0x38, 0x60, 0x70, 0x07, 0x06, 0x07, 0x00, 0x70,
  0x60, 0x70, 0x0E, 0x06, 0x07, 0x00, 0xE0, 0x70, 0xE0, 0x1C, 0x07, 0x0E,
  0x01, 0xC0, 0x70, 0xE0, 0x38, 0x03, 0x9E, 0x03, 0x80, 0x3F, 0xC0, 0x78,
  0x01, 0xF8, 0x01, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1E,
  0x3E, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x3C,
  0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xE0, 0x02, 0x3E, 0xF0, 0x1C, 0x7C, 0x78, 0x1C, 0x78, 0x7C, 0x3C, 0xF0,
  0x3E, 0x3C, 0xF0, 0x1F, 0x38, 0xE0, 0x0F, 0xF8, 0xE0, 0x07, 0xF0, 0xF0,
  0x03, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xF0, 0x78, 0x0F, 0xF8, 0x7F,
  0xFF, 0x7C, 0x3F, 0xFE, 0x3E, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0x87, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x1C,
  0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C,
  0x0E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0xF0, 0x38,
  0x1E, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0,
  0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x18, 0x07, 0x0C, 0x1B, 0xF6, 0xFD, 0xFF,
  0xFE, 0x7F, 0xFE, 0x81, 0xF0, 0x01, 0xF8, 0x01, 0xCE, 0x01, 0xE7, 0x80,
  0xF1, 0xE0, 0xF0, 0xF0, 0x38, 0x30, 0x04, 0x10, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3D, 0xE7, 0x9E, 0x79, 0xCF, 0x38, 0xE3, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x77, 0xBF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0xEF, 0xC3, 0xC1, 0xE3, 0xC0, 0x79, 0xE0,
  0x1C, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3D, 0xC0, 0x1E, 0xE0,
  0x0E, 0x78, 0x07, 0x3C, 0x07, 0x8F, 0x07, 0x83, 0xFF, 0xC1, 0xFF, 0xC0,
  0x3F, 0x80, 0x01, 0xE0, 0x7C, 0x3F, 0x8F, 0xF3, 0xDE, 0xF3, 0xFC, 0x7B,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x0F, 0xFC, 0x1F, 0xFF,
  0x1F, 0xCF, 0xC7, 0x01, 0xF2, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0,
  0x0F, 0xFC, 0x1F, 0xFF, 0x1F, 0xCF, 0xC6, 0x01, 0xF2, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xB0, 0x07, 0xDF, 0xFF, 0xCF, 0xFF, 0xC3,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1C, 0xF0, 0x01, 0xCF,
  0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x70, 0xF0, 0x0E, 0x0F, 0x01, 0xE0,
  0xF0, 0x1C, 0x0F, 0x03, 0x80, 0xF0, 0x38, 0x0F, 0x07, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x80, 0xFC, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x60, 0x0F, 0xBF, 0xFF,
  0x9F, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0x01, 0xFF, 0x81,
  0xF8, 0x41, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x3F, 0xC7, 0xBF, 0xF3, 0xFF,
  0xFD, 0xF8, 0x1E, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x78, 0x07, 0x9C, 0x03,
  0xCF, 0x03, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0xFC, 0x78, 0x0F, 0x1C, 0x01,
  0xC7, 0x00, 0x79, 0xC0, 0x1E, 0x70, 0x07, 0x9C, 0x01, 0xC7, 0x80, 0xF0,
  0xF0, 0x78, 0x1F, 0x3C, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F,
  0x7C, 0x0F, 0x07, 0xC7, 0x80, 0xF3, 0xC0, 0x1E, 0xF0, 0x03, 0xB8, 0x00,
  0xEE, 0x00, 0x3F, 0x80, 0x0E, 0xF0, 0x03, 0xBC, 0x01, 0xE7, 0x80, 0xF9,
  0xFD, 0xFC, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0xEF, 0xC7, 0x81, 0xE3, 0x80, 0x7B, 0xC0, 0x1D, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3D, 0xC0, 0x3E, 0xF8, 0x3F, 0x3F, 0xFB, 0x8F, 0xF9, 0xC3, 0xF9, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xF7,
  0xFF, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xBD, 0xFF,
  0xF8, 0x3C, 0x78, 0xF9, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x1E, 0x3C, 0x70, 0xE3,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x3C, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0x08, 0x00, 0x00, 0x07, 0x80, 0x7F, 0xE3, 0xFF, 0xE3, 0xF7, 0xE6, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x0E, 0x38, 0x0F, 0xF8, 0x71, 0xC1, 0xFF, 0xC3,
  0x9C, 0x1E, 0x0E, 0x0E, 0xE0, 0xE0, 0x70, 0x77, 0x0F, 0x03, 0x83, 0xF0,
  0x70, 0x1C, 0x1F, 0x83, 0x80, 0xE0, 0xFC, 0x1C, 0x07, 0x07, 0xE0, 0xE0,
  0x78, 0x3F, 0x07, 0x03, 0x81, 0xF8, 0x38, 0x1C, 0x0D, 0xC1, 0xC0, 0xE0,
  0xEE, 0x0E, 0x0F, 0x87, 0x38, 0x38, 0x6C, 0x71, 0xC1, 0xFE, 0x7F, 0x8E,
  0x07, 0xE1, 0xF8, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x40, 0x03, 0xE0, 0x1E,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0xF3, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x8F, 0x00, 0x0F, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x3C, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xF0, 0x0F, 0x00,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xE0, 0x07,
  0x03, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x3C,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0x77, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0x80, 0x7E, 0xE0, 0x07, 0xB8,
  0x01, 0xEE, 0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x07, 0xB8, 0x01, 0xEE, 0x00,
  0x73, 0x80, 0x3C, 0xFF, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0xE3, 0x80, 0xFC,
  0xE0, 0x07, 0xB8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xB8, 0x07, 0xEF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFE, 0x03,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0x80, 0x61, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x20, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0E, 0x01, 0xF8, 0xE0, 0x07, 0xCE, 0x00, 0x3C,
  0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1E, 0xE0, 0x03, 0xEE, 0x00, 0x3C, 0xE0, 0x0F, 0x8E,
  0x03, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0x80, 0x18, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xF7, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x78,
  0x00, 0x1D, 0xE0, 0x00, 0x77, 0x80, 0x01, 0xCF, 0x00, 0x07, 0x3E, 0x00,
  0x1C, 0x7C, 0x00, 0x70, 0xFC, 0x01, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xCF, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x1F, 0xDF, 0xFF,
  0xF8, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xE3, 0xEF, 0xFB, 0xFC, 0x78, 0x00,
  0xE0, 0x03, 0xDC, 0x00, 0xF3, 0x80, 0x3C, 0x70, 0x0F, 0x0E, 0x01, 0xE1,
  0xC0, 0x78, 0x38, 0x1E, 0x07, 0x07, 0x80, 0xE0, 0xF0, 0x1C, 0x3C, 0x03,
  0x8F, 0x00, 0x73, 0xC0, 0x0E, 0x70, 0x01, 0xDF, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xF9, 0xE0, 0x1E, 0x3E, 0x03, 0x83, 0xC0, 0x70, 0x3C, 0x0E,
  0x07, 0x81, 0xC0, 0x78, 0x38, 0x07, 0x87, 0x00, 0xF0, 0xE0, 0x0F, 0x1C,
  0x01, 0xF3, 0x80, 0x1E, 0x70, 0x01, 0xEE, 0x00, 0x3E, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFB, 0x80, 0x07, 0x7F,
  0x78, 0x00, 0xEF, 0xEF, 0x00, 0x3D, 0xFC, 0xE0, 0x07, 0x3F, 0x9E, 0x00,
  0xE7, 0xF1, 0xC0, 0x3C, 0xFE, 0x38, 0x07, 0x1F, 0xC7, 0x80, 0xE3, 0xF8,
  0x70, 0x3C, 0x7F, 0x0E, 0x07, 0x0F, 0xE1, 0xE0, 0xE1, 0xFC, 0x1C, 0x3C,
  0x3F, 0x83, 0x87, 0x07, 0xF0, 0x78, 0xE0, 0xFE, 0x07, 0x3C, 0x1F, 0xC0,
  0xE7, 0x03, 0xF8, 0x1E, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x78, 0x07, 0xF0, 0x0F, 0x00, 0xFE, 0x01,
  0xE0, 0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xBC, 0x01, 0xFD, 0xE0, 0x0F, 0xE7,
  0x80, 0x7F, 0x3C, 0x03, 0xF8, 0xF0, 0x1F, 0xC3, 0xC0, 0xFE, 0x1E, 0x07,
  0xF0, 0x78, 0x3F, 0x83, 0xC1, 0xFC, 0x0F, 0x0F, 0xE0, 0x78, 0x7F, 0x01,
  0xE3, 0xF8, 0x07, 0x1F, 0xC0, 0x3C, 0xFE, 0x00, 0xF7, 0xF0, 0x07, 0xBF,
  0x80, 0x1E, 0xFC, 0x00, 0xF7, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xF7, 0xF0, 0x1F, 0x00, 0xF8, 0x3E, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x7C, 0x1F, 0x80, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9C, 0x07, 0xCE, 0x00, 0xF7,
  0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xDC, 0x01, 0xEE, 0x00, 0xF7, 0x00, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF,
  0xF0, 0x7F, 0x80, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xF7, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3E,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1F, 0x80, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x70, 0x1F, 0x8E, 0x00, 0xF1, 0xC0, 0x1E, 0x38, 0x01, 0xC7, 0x00,
  0x3C, 0xE0, 0x07, 0x9C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x8E, 0x01,
  0xF1, 0xC0, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1C, 0x1E,
  0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0xC1, 0xC0, 0x78, 0x38, 0x07,
  0x87, 0x00, 0xF0, 0xE0, 0x0F, 0x1C, 0x00, 0xF3, 0x80, 0x1E, 0x70, 0x01,
  0xEE, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE7,
  0x80, 0x23, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0xB0, 0x07,
  0xDF, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x77, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x01, 0xE3, 0xE0,
  0x3E, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xF0, 0x00, 0x3D,
  0xC0, 0x00, 0xF7, 0x80, 0x03, 0x9E, 0x00, 0x1E, 0x38, 0x00, 0x78, 0xF0,
  0x01, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x78, 0x07,
  0x81, 0xE0, 0x1E, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xC0, 0x3C, 0x0F, 0x00,
  0x70, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x38,
  0x70, 0x00, 0xF3, 0xC0, 0x01, 0xCF, 0x00, 0x07, 0x38, 0x00, 0x1E, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xEF, 0x00, 0x3E,
  0x00, 0x79, 0xE0, 0x07, 0xC0, 0x0F, 0x3C, 0x00, 0xF8, 0x01, 0xE3, 0x80,
  0x3F, 0x00, 0x38, 0x70, 0x07, 0x70, 0x07, 0x0F, 0x00, 0xEE, 0x01, 0xE1,
  0xE0, 0x1D, 0xC0, 0x3C, 0x1C, 0x07, 0xBC, 0x07, 0x03, 0x80, 0xE7, 0x80,
  0xE0, 0x78, 0x1C, 0x70, 0x3C, 0x0F, 0x03, 0x8E, 0x07, 0x81, 0xE0, 0xF1,
  0xE0, 0xE0, 0x1C, 0x1C, 0x1C, 0x1C, 0x03, 0xC3, 0x83, 0x87, 0x80, 0x78,
  0xF0, 0x70, 0xF0, 0x0F, 0x1E, 0x0F, 0x1C, 0x00, 0xE3, 0x80, 0xE3, 0x80,
  0x1C, 0x70, 0x1C, 0xF0, 0x03, 0xCE, 0x03, 0x9E, 0x00, 0x7B, 0xC0, 0x7B,
  0xC0, 0x07, 0x70, 0x07, 0x70, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0x1D, 0xC0,
  0x1D, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0xF9, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x3C, 0x03, 0x80, 0xE0,
  0x3C, 0x07, 0x81, 0xC0, 0x1C, 0x1E, 0x00, 0xF0, 0xE0, 0x03, 0x8F, 0x00,
  0x1E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0E, 0xF0, 0x00,
  0xF3, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x70, 0x07, 0x83, 0xC0, 0x38, 0x0F,
  0x03, 0xC0, 0x78, 0x1C, 0x01, 0xE1, 0xE0, 0x0F, 0x0E, 0x00, 0x3C, 0xF0,
  0x01, 0xEF, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1C, 0x0E, 0x01, 0xE0, 0x78, 0x0E, 0x01,
  0xC0, 0xF0, 0x0F, 0x07, 0x00, 0x38, 0x78, 0x01, 0xE3, 0x80, 0x07, 0x3C,
  0x00, 0x3D, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xC7, 0x00, 0x38, 0xE0,
  0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0x38,
  0x70, 0x07, 0x9E, 0x00, 0x73, 0x80, 0x0F, 0xF0, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x0F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFE, 0x10, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x07, 0xFF, 0x3F, 0xFF, 0x7F, 0x0F, 0x78, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0x7D,
  0xF7, 0x7F, 0xE7, 0x3F, 0xC7, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0xFE, 0x0F, 0x7F, 0xE3, 0xFF, 0xFC, 0xFC, 0x0F, 0x3E, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xBC, 0x01, 0xEF, 0x80, 0x7B, 0xF0, 0x3C, 0xEF, 0xFF, 0x39, 0xFF,
  0x8E, 0x3F, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xF1, 0xE0, 0x27, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x11, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC3, 0xFC, 0xF1, 0xFF, 0xBC, 0xFF, 0xFF,
  0x3C, 0x0F, 0xDE, 0x01, 0xF7, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x7C, 0xF0, 0x3F,
  0x3F, 0xFF, 0xC7, 0xFE, 0x70, 0xFF, 0x1C, 0x07, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x87, 0x81, 0xE7, 0x80, 0xF3, 0x80, 0x39, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x43,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x03, 0xFF, 0x3F, 0xF9,
  0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x07, 0xF1, 0xC7,
  0xFE, 0x73, 0xFF, 0xFC, 0xF0, 0x3F, 0x78, 0x07, 0xDE, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x70, 0x03, 0xDE,
  0x01, 0xF3, 0xC0, 0xFC, 0xFF, 0xFF, 0x1F, 0xFB, 0xC3, 0xFC, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x79, 0x00, 0x1E,
  0x38, 0x1F, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xC0, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x79, 0xFE, 0x3D, 0xFF, 0x9F, 0xFF, 0xEF, 0xC0,
  0xF7, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1E, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE8, 0xF7,
  0xFB, 0xF8, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x07,
  0xBC, 0x07, 0x9E, 0x07, 0x8F, 0x07, 0x87, 0x87, 0x83, 0xC3, 0x81, 0xE3,
  0xC0, 0xF3, 0xC0, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07,
  0xCF, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x0F,
  0x1E, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE3, 0xF8, 0x3F, 0xCE, 0x7F, 0xC7, 0xFE, 0xEF, 0xFE, 0xFF, 0xFF,
  0xC1, 0xFC, 0x0F, 0xF8, 0x0F, 0x80, 0xFF, 0x00, 0xF8, 0x07, 0xF0, 0x07,
  0x00, 0x7F, 0x00, 0x70, 0x07, 0xF0, 0x07, 0x00, 0x7F, 0x00, 0x70, 0x07,
  0xF0, 0x07, 0x00, 0x7F, 0x00, 0x70, 0x07, 0xF0, 0x07, 0x00, 0x7F, 0x00,
  0x70, 0x07, 0xF0, 0x07, 0x00, 0x7F, 0x00, 0x70, 0x07, 0xF0, 0x07, 0x00,
  0x7F, 0x00, 0x70, 0x07, 0xF0, 0x07, 0x00, 0x7F, 0x00, 0x70, 0x07, 0xF0,
  0x07, 0x00, 0x7F, 0x00, 0x70, 0x07, 0xE3, 0xFC, 0x73, 0xFF, 0x3B, 0xFF,
  0xDF, 0x81, 0xEF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3C, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xF0, 0x3E, 0x78, 0x07, 0x9E, 0x00, 0xF7, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3D, 0xC0, 0x0F, 0x78, 0x03, 0xDE, 0x01, 0xE3, 0xC0, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xE3, 0xF8, 0x39, 0xFF, 0x8E,
  0xFF, 0xF3, 0xF0, 0x3C, 0xF8, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3B, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0E, 0xF0, 0x07, 0xBE, 0x01, 0xEF,
  0xC0, 0xF3, 0xFF, 0xFC, 0xF7, 0xFE, 0x3C, 0xFE, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF1, 0xC7, 0xFE, 0x73,
  0xFF, 0xDC, 0xF0, 0x3F, 0x78, 0x07, 0xDE, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x03, 0xDE, 0x01, 0xF3,
  0xC0, 0xFC, 0xFF, 0xFF, 0x1F, 0xFB, 0xC3, 0xFC, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xE3, 0xFE, 0x7F, 0xEF, 0xEE,
  0xE0, 0xFC, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x1F, 0xF1, 0xFF, 0xF7, 0xFF, 0xBC, 0x02, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x07, 0xBF, 0xFE, 0xFF, 0xF1, 0xFF, 0x80, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x07, 0xFE, 0xFF, 0xEF, 0xFE, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0xF0, 0xFF, 0x07, 0xF0,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xDE, 0x07, 0xEF, 0xFF, 0xF3, 0xFF, 0x38, 0xFF, 0x1C, 0xF0,
  0x01, 0xEE, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xE3, 0x80, 0x38, 0x70,
  0x0F, 0x0F, 0x01, 0xE0, 0xE0, 0x38, 0x1C, 0x0F, 0x03, 0xC1, 0xE0, 0x38,
  0x38, 0x07, 0x0F, 0x00, 0xF1, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x3D,
  0xE0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x7B, 0x80, 0x7C, 0x03, 0xDE,
  0x03, 0xE0, 0x1C, 0xF0, 0x1F, 0x80, 0xE3, 0x80, 0xFC, 0x0F, 0x1C, 0x0E,
  0xE0, 0x78, 0xF0, 0x77, 0x03, 0x87, 0x83, 0x9C, 0x1C, 0x1C, 0x3C, 0xE1,
  0xE0, 0xE1, 0xC7, 0x0F, 0x07, 0x8E, 0x3C, 0x70, 0x3C, 0x70, 0xE3, 0x80,
  0xE7, 0x87, 0x1C, 0x07, 0x38, 0x39, 0xE0, 0x39, 0xC1, 0xEE, 0x01, 0xEE,
  0x07, 0x70, 0x07, 0x60, 0x3B, 0x80, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x80,
  0xF0, 0x07, 0x9E, 0x01, 0xC3, 0x80, 0xF0, 0xF0, 0x78, 0x1E, 0x1E, 0x07,
  0x8F, 0x00, 0xF3, 0x80, 0x1D, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xF7, 0x80, 0x38, 0xF0,
  0x1E, 0x1C, 0x0F, 0x07, 0x83, 0xC0, 0xF1, 0xE0, 0x3C, 0x70, 0x07, 0xBC,
  0x01, 0xF0, 0xF0, 0x01, 0xEE, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xE3,
  0x80, 0x38, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0xE0, 0x38, 0x1E, 0x0F, 0x03,
  0xC1, 0xE0, 0x38, 0x38, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x0E, 0x38, 0x01,
  0xE7, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x0F,
  0xC0, 0xFE, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x03, 0xE0, 0xFE,
  0x07, 0x80, 0x3F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xF8, 0x03, 0xC0, 0x7E, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x7E, 0x07, 0xF0, 0x3E, 0x01, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFE, 0x80, 0x7F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 29, 11, 3, -29 },
  { 20, 11, 10, 16, 3, -29 },
  { 34, 22, 29, 24, 1, -29 },
  { 114, 17, 33, 21, 2, -31 },
  { 185, 28, 30, 32, 2, -30 },
  { 290, 24, 30, 26, 2, -30 },
  { 380, 3, 10, 9, 3, -29 },
  { 384, 9, 35, 12, 2, -29 },
  { 424, 9, 35, 12, 1, -29 },
  { 464, 17, 17, 20, 2, -31 },
  { 501, 17, 19, 21, 2, -24 },
  { 542, 6, 10, 10, 2, -5 },
  { 550, 10, 4, 12, 1, -13 },
  { 555, 5, 5, 10, 3, -5 },
  { 559, 14, 29, 15, 1, -29 },
  { 610, 17, 30, 21, 2, -30 },
  { 674, 11, 29, 21, 3, -29 },
  { 714, 17, 30, 21, 2, -30 },
  { 778, 17, 30, 21, 2, -30 },
  { 842, 20, 29, 21, 1, -29 },
  { 915, 17, 29, 21, 2, -29 },
  { 977, 17, 30, 21, 2, -30 },
  { 1041, 17, 29, 21, 2, -29 },
  { 1103, 18, 30, 21, 2, -30 },
  { 1171, 17, 30, 21, 2, -30 },
  { 1235, 5, 22, 10, 3, -22 },
  { 1249, 7, 27, 10, 1, -22 },
  { 1273, 18, 19, 21, 2, -24 },
  { 1316, 17, 11, 21, 2, -20 },
  { 1340, 18, 19, 21, 2, -24 },
  { 1383, 15, 30, 16, 0, -30 },
  { 1440, 29, 33, 33, 2, -29 },
  { 1560, 23, 29, 23, 0, -29 },
  { 1644, 18, 29, 24, 4, -29 },
  { 1710, 20, 30, 23, 2, -30 },
  { 1785, 20, 29, 27, 4, -29 },
  { 1858, 14, 29, 21, 4, -29 },
  { 1909, 14, 29, 19, 4, -29 },
  { 1960, 22, 30, 27, 2, -30 },
  { 2043, 20, 29, 27, 4, -29 },
  { 2116, 9, 29, 13, 2, -29 },
  { 2149, 10, 37, 10, -3, -29 },
  { 2196, 19, 29, 23, 4, -29 },
  { 2265, 14, 29, 19, 4, -29 },
  { 2316, 27, 29, 34, 4, -29 },
  { 2414, 21, 29, 28, 4, -29 },
  { 2491, 24, 30, 29, 2, -30 },
  { 2581, 17, 29, 22, 4, -29 },
  { 2643, 24, 37, 29, 2, -30 },
  { 2754, 19, 29, 23, 4, -29 },
  { 2823, 17, 30, 20, 2, -30 },
  { 2887, 20, 29, 20, 0, -29 },
  { 2960, 20, 29, 27, 3, -29 },
  { 3033, 22, 29, 22, 0, -29 },
  { 3113, 35, 29, 35, 0, -29 },
  { 3240, 21, 29, 21, 0, -29 },
  { 3317, 21, 29, 21, 0, -29 },
  { 3394, 18, 29, 20, 1, -29 },
  { 3460, 9, 36, 13, 3, -29 },
  { 3501, 14, 29, 15, 1, -29 },
  { 3552, 9, 36, 13, 1, -29 },
  { 3593, 19, 17, 21, 1, -29 },
  { 3634, 18, 2, 18, 0, 4 },
  { 3639, 8, 6, 11, 2, -31 },
  { 3645, 16, 22, 21, 2, -22 },
  { 3689, 18, 31, 23, 3, -31 },
  { 3759, 15, 22, 18, 2, -22 },
  { 3801, 18, 31, 23, 2, -31 },
  { 3871, 17, 22, 21, 2, -22 },
  { 3918, 13, 31, 13, 1, -31 },
  { 3969, 18, 32, 23, 2, -22 },
  { 4041, 17, 31, 23, 3, -31 },
  { 4107, 4, 30, 10, 3, -30 },
  { 4122, 9, 40, 10, -2, -30 },
  { 4167, 17, 31, 20, 3, -31 },
  { 4233, 4, 31, 10, 3, -31 },
  { 4249, 28, 22, 35, 3, -22 },
  { 4326, 17, 22, 23, 3, -22 },
  { 4373, 18, 22, 22, 2, -22 },
  { 4423, 18, 32, 23, 3, -22 },
  { 4495, 18, 32, 23, 2, -22 },
  { 4567, 12, 22, 15, 3, -22 },
  { 4600, 14, 22, 18, 2, -22 },
  { 4639, 12, 27, 13, 1, -27 },
  { 4680, 17, 22, 23, 3, -22 },
  { 4727, 19, 22, 19, 0, -22 },
  { 4780, 29, 22, 30, 0, -22 },
  { 4860, 18, 22, 19, 1, -22 },
  { 4910, 19, 32, 19, 0, -22 },
  { 4986, 14, 22, 17, 1, -22 },
  { 5025, 13, 36, 15, 1, -29 },
  { 5084, 3, 41, 20, 9, -31 },
  { 5100, 13, 36, 15, 1, -29 },
  { 5159, 18, 5, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_Regular41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR41PT7B_H_
