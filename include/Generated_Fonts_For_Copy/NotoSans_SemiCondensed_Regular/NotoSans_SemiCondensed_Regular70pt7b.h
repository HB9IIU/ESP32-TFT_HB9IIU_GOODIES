#ifndef _NOTOSANS_SEMICONDENSED_REGULAR70PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular70pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x3C, 0xFE, 0x07, 0xFF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF,
  0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xE0, 0x3F, 0x7C,
  0x07, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xDF, 0x00, 0xF3, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00,
  0x3C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0x9E, 0x1F, 0x87, 0xF0,
  0xF0, 0x0C, 0x7F, 0x07, 0x80, 0x03, 0xF0, 0x3C, 0x00, 0x1F, 0x81, 0xE0,
  0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x3F, 0x03, 0xC0, 0x01,
  0xF8, 0x1E, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x7F, 0x07, 0x80, 0x01, 0xFE,
  0x3C, 0x00, 0x0F, 0xFD, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xEF, 0xFC, 0x00,
  0x0F, 0x1F, 0xF0, 0x00, 0x78, 0x3F, 0x80, 0x03, 0xC0, 0xFE, 0x00, 0x1E,
  0x03, 0xF0, 0x00, 0xF0, 0x1F, 0x80, 0x07, 0x80, 0xFC, 0x00, 0x3C, 0x07,
  0xE0, 0x01, 0xE0, 0x3F, 0x00, 0x0F, 0x01, 0xFC, 0x00, 0x78, 0x1F, 0xB0,
  0x03, 0xC1, 0xFD, 0xF8, 0x1E, 0x3F, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x06, 0x00,
  0x7C, 0x03, 0xE1, 0xF8, 0x3F, 0xC0, 0x7C, 0x03, 0xE1, 0xF0, 0xFF, 0xF0,
  0x7C, 0x07, 0xC1, 0xF0, 0xFF, 0xF8, 0x7C, 0x07, 0xC3, 0xE1, 0xFF, 0xF8,
  0x3E, 0x07, 0xC3, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xC3, 0xE0, 0x7C,
  0x1F, 0xFF, 0x87, 0xC3, 0xE0, 0x3E, 0x1F, 0xFF, 0x0F, 0x87, 0xC0, 0x3E,
  0x0F, 0xFE, 0x0F, 0x87, 0xC0, 0x3E, 0x07, 0xFC, 0x1F, 0x07, 0xC0, 0x3E,
  0x00, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0xE3, 0xFC,
  0x00, 0x7E, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xC0, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x1F,
  0x80, 0x0F, 0xF0, 0x7E, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0x83, 0xF8, 0x00,
  0x3F, 0xCF, 0xC0, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0x00, 0x00, 0xFF,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0xE0,
  0x00, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x07,
  0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x3F,
  0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFF, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBE, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x3C, 0x78, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x40, 0x0F, 0x80, 0x13, 0xC0, 0x78, 0x07, 0xBF,
  0xC3, 0xC3, 0xFD, 0xFF, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0xF0, 0x07,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC7, 0xF1,
  0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF8,
  0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0x01,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x3F, 0xDF, 0x3F, 0xCF, 0xBF, 0xCF, 0xFF,
  0xC7, 0xFF, 0x83, 0xF7, 0x81, 0xF9, 0x80, 0xFC, 0x80, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07,
  0xF8, 0x03, 0xFE, 0x0F, 0x80, 0x03, 0xF8, 0x18, 0x00, 0x07, 0xE0, 0x40,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07,
  0xF0, 0x01, 0xFE, 0x0F, 0x00, 0x03, 0xF8, 0x30, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xA0, 0x00, 0x01, 0xFC, 0xC0, 0x00,
  0x0F, 0xF3, 0xE0, 0x00, 0xFF, 0x8F, 0xFF, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xEF, 0xC0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xEF, 0xFF, 0xC0, 0x80, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x20, 0x00, 0x03,
  0xF9, 0x80, 0x00, 0x3F, 0x8F, 0x80, 0x07, 0xFC, 0x7F, 0xF7, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFB, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x80, 0x7E, 0x3F,
  0xFF, 0x03, 0xF3, 0xFF, 0xFE, 0x1F, 0xBF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x81, 0xFC, 0x00,
  0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xC0,
  0x7F, 0x80, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x1F, 0xC3, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xE8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7E,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFC,
  0xFE, 0x00, 0x3F, 0xF3, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xBF, 0x0F,
  0xFF, 0xFC, 0xFC, 0x1F, 0xFF, 0xE3, 0xE0, 0x3F, 0xFF, 0x0F, 0x80, 0x3F,
  0xF0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x01, 0xF3, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x0F, 0x83, 0xF8, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7F,
  0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF1, 0xF0, 0x03, 0xFC, 0x60, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x02, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0xFE, 0x00, 0xF8,
  0x7E, 0x00, 0x3F, 0xFF, 0xC0, 0x7C, 0x3E, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0x1F, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0x9F, 0x80, 0x3F, 0x00, 0xF8, 0x07,
  0xCF, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xE7, 0xC0, 0x3F, 0x00, 0x3E, 0x00,
  0xFB, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x0F, 0x80,
  0x3F, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x07, 0xE0,
  0x0F, 0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xFE, 0x01, 0xF0, 0x01, 0xF8,
  0x03, 0xFF, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x7C,
  0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x1F,
  0x00, 0x3D, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0xF8, 0x07, 0xC0, 0x07,
  0xC0, 0x1F, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xBE, 0x01, 0xF0, 0x03,
  0xF0, 0x0F, 0x9F, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xCF, 0x80, 0x3F, 0x01,
  0xFE, 0x07, 0xC7, 0xE0, 0x1F, 0xC3, 0xEF, 0x87, 0xE1, 0xF0, 0x07, 0xFF,
  0xF3, 0xFF, 0xE0, 0xF8, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x7C, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x3F, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0x0F,
  0xF8, 0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x03, 0xFF, 0xF0, 0xFC, 0x00, 0x0F,
  0xF8, 0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x07, 0xFC, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7C, 0x0F, 0xF8,
  0x00, 0x0E, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x1F,
  0xFC, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xC0, 0x00, 0x0F,
  0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0x1F,
  0xE0, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F,
  0x00, 0xFF, 0x80, 0x00, 0x38, 0x07, 0xFC, 0x00, 0x00, 0x20, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xFE, 0x00, 0x01,
  0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x60, 0xFF, 0xBF, 0xFF, 0x9F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x01, 0xFB, 0xFE, 0x00, 0x00, 0xFD,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xF9, 0xFC, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xE0,
  0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03,
  0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x3F, 0xC7, 0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xBF, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x7F, 0xFB, 0xE0, 0x00, 0x00, 0x7E, 0xFF, 0xF7,
  0xE0, 0x00, 0x00, 0xF9, 0xFF, 0xEF, 0xC0, 0x00, 0x01, 0xF3, 0xFF, 0xCF,
  0x80, 0x00, 0x07, 0xE7, 0xFF, 0x9F, 0x80, 0x00, 0x0F, 0x8F, 0xFF, 0x3F,
  0x00, 0x00, 0x1F, 0x1F, 0xFE, 0x3E, 0x00, 0x00, 0x7E, 0x7F, 0xFC, 0x7E,
  0x00, 0x00, 0xF8, 0xFF, 0xF8, 0xFC, 0x00, 0x01, 0xF1, 0xFF, 0xF0, 0xF8,
  0x00, 0x07, 0xE3, 0xFF, 0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xFF, 0xC3, 0xF0,
  0x00, 0x3F, 0x0F, 0xFF, 0x83, 0xE0, 0x00, 0x7E, 0x1F, 0xFF, 0x07, 0xE0,
  0x00, 0xF8, 0x3F, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0xFC, 0x0F, 0xC0,
  0x07, 0xE0, 0xFF, 0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xFF, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xFF, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xFF, 0xC0, 0x7E, 0x00,
  0xF8, 0x0F, 0xFF, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xFF, 0x00, 0xFC, 0x07,
  0xC0, 0x3F, 0xFE, 0x01, 0xF8, 0x0F, 0x80, 0x7F, 0xFC, 0x01, 0xF0, 0x3F,
  0x00, 0xFF, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xFF, 0xF0, 0x07, 0xE0, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xC7, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0x3F, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xBF,
  0x80, 0x00, 0x3F, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xDF, 0xC0, 0x00, 0x3F,
  0xFC, 0xFC, 0x00, 0x03, 0xFF, 0xCF, 0xE0, 0x00, 0x3F, 0xFC, 0x7F, 0x00,
  0x03, 0xFF, 0xC7, 0xF0, 0x00, 0x3F, 0xFC, 0x3F, 0x80, 0x03, 0xFF, 0xC1,
  0xF8, 0x00, 0x3F, 0xFC, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0x3F,
  0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xF0,
  0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xC0, 0x3F, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F,
  0xFC, 0x00, 0x7F, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xFC, 0x00, 0x3F,
  0x83, 0xFF, 0xC0, 0x03, 0xF8, 0x3F, 0xFC, 0x00, 0x1F, 0xC3, 0xFF, 0xC0,
  0x00, 0xFC, 0x3F, 0xFC, 0x00, 0x0F, 0xE1, 0xFF, 0xC0, 0x00, 0x7E, 0x1F,
  0xFC, 0x00, 0x07, 0xF1, 0xFF, 0xC0, 0x00, 0x3F, 0x9F, 0xFC, 0x00, 0x03,
  0xF9, 0xFF, 0xC0, 0x00, 0x1F, 0xDF, 0xFC, 0x00, 0x00, 0xFD, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x7E, 0x01, 0xFF, 0xF3, 0xF0, 0x00, 0xFF, 0x9F, 0x80, 0x01, 0xFE, 0xFC,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x3F, 0xDF, 0x80, 0x03, 0xFC, 0xFC, 0x00, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0xE0, 0xFC,
  0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xC0, 0x1F, 0x87, 0xF8, 0x00, 0x18, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFD, 0x00, 0x00, 0x0F, 0xEE, 0x00, 0x01, 0xFE, 0x7F, 0x00,
  0x3F, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0,
  0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x07, 0xDF, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x3F,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x3F,
  0x80, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80,
  0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x00, 0x3F,
  0x01, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xE0,
  0x07, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0x80, 0x7F, 0x81, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0x00, 0x7E,
  0x7F, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0x7F, 0x00, 0x7F, 0xEF, 0xF8, 0x3F, 0x7C, 0xFF, 0xFF, 0xCF, 0x8F,
  0xFF, 0xF1, 0xF0, 0xFF, 0xFC, 0x1E, 0x0F, 0xFF, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x03, 0xFC, 0x00, 0xFC, 0x3F, 0xFE, 0x01, 0xF8, 0xFF, 0xFF, 0x03, 0xF3,
  0xFF, 0xFF, 0x07, 0xEF, 0xFF, 0xFF, 0x0F, 0xFF, 0x01, 0xFE, 0x1F, 0xF8,
  0x00, 0xFE, 0x3F, 0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0xFF, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x1F, 0x9F, 0xF0, 0x00, 0x7F, 0x3F,
  0xF0, 0x01, 0xFC, 0x7F, 0xF0, 0x07, 0xF8, 0xFD, 0xFC, 0x7F, 0xE1, 0xFB,
  0xFF, 0xFF, 0x83, 0xE3, 0xFF, 0xFE, 0x07, 0xC3, 0xFF, 0xF8, 0x0F, 0x81,
  0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0,
  0x1E, 0x1F, 0xC0, 0x02, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x01, 0x1F, 0xE0, 0x07, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x3F, 0x00, 0xFF, 0xF8, 0x7E, 0x07, 0xFF,
  0xF8, 0xFC, 0x1F, 0xFF, 0xF9, 0xF8, 0x7F, 0xFF, 0xFB, 0xF0, 0xFF, 0x01,
  0xFF, 0xE3, 0xF8, 0x00, 0xFF, 0xC7, 0xF0, 0x00, 0xFF, 0x9F, 0xC0, 0x00,
  0xFF, 0x3F, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0x0F, 0xFC,
  0x7F, 0x7E, 0x0F, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xF9, 0xF8, 0x0F, 0xFF,
  0xE1, 0xF0, 0x07, 0xFF, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0,
  0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x02, 0x1F, 0xE0, 0x01, 0xE0, 0xFF, 0xE3, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x3E, 0x01, 0xFF, 0xF0, 0x7C, 0x0F,
  0xFF, 0xF0, 0xF8, 0x3F, 0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0xF7, 0xE1, 0xFE,
  0x03, 0xFF, 0xC7, 0xF8, 0x01, 0xFF, 0x8F, 0xE0, 0x01, 0xFF, 0x3F, 0x80,
  0x01, 0xFE, 0x7E, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x0F, 0xFE, 0x1F,
  0xF8, 0xFE, 0xFC, 0x1F, 0xFF, 0xFD, 0xF8, 0x1F, 0xFF, 0xF3, 0xF0, 0x1F,
  0xFF, 0xC7, 0xE0, 0x0F, 0xFE, 0x0F, 0xC0, 0x03, 0xC0, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x08, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0x80, 0xFC,
  0x3F, 0xFF, 0x07, 0xE3, 0xFF, 0xFC, 0x3F, 0x3F, 0xFF, 0xF1, 0xFB, 0xFF,
  0xFF, 0xCF, 0xDF, 0x01, 0xFE, 0x7F, 0xE0, 0x03, 0xFB, 0xFE, 0x00, 0x0F,
  0xDF, 0xE0, 0x00, 0x7E, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE0,
  0x00, 0x10, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x63, 0xFC,
  0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0xC7, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xFC, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFD, 0xF8, 0x00, 0xFF, 0x9F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE,
  0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x80, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00,
  0x1F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x7C, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x1F, 0x9F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0x01, 0xFE, 0xFC, 0x0F, 0xF3, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFD, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0xF8, 0x07, 0xFC, 0x07, 0xC1, 0xFF, 0xF8, 0x3F, 0x1F, 0xFF, 0xE1,
  0xF9, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xFE, 0x7F, 0xF8, 0x0F, 0xF3, 0xFF,
  0x00, 0x1F, 0xDF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xF7, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0xF8, 0x01, 0xF0,
  0x7F, 0xFC, 0x03, 0xF1, 0xFF, 0xFE, 0x07, 0xE7, 0xFF, 0xFE, 0x0F, 0xDF,
  0xFF, 0xFE, 0x1F, 0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFC, 0x7F, 0xC0,
  0x01, 0xFC, 0xFF, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0x9F,
  0xE0, 0x00, 0x7F, 0x3F, 0xE0, 0x00, 0xFE, 0x7F, 0xE0, 0x03, 0xF8, 0xFF,
  0xE0, 0x0F, 0xF1, 0xFB, 0xFC, 0xFF, 0xC3, 0xF7, 0xFF, 0xFF, 0x07, 0xE7,
  0xFF, 0xFC, 0x0F, 0xC3, 0xFF, 0xF0, 0x1F, 0x83, 0xFF, 0xC0, 0x3F, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x3E, 0x01, 0xFF, 0xF0,
  0x7C, 0x0F, 0xFF, 0xF0, 0xF8, 0x3F, 0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0xF7,
  0xE1, 0xFE, 0x03, 0xFF, 0xC7, 0xF0, 0x01, 0xFF, 0x8F, 0xE0, 0x01, 0xFF,
  0x3F, 0x80, 0x01, 0xFE, 0x7E, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x8F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x0F,
  0xFE, 0x1F, 0xF8, 0xFE, 0xFC, 0x1F, 0xFF, 0xFD, 0xF8, 0x1F, 0xFF, 0xF3,
  0xF0, 0x1F, 0xFF, 0x87, 0xE0, 0x0F, 0xFE, 0x0F, 0xC0, 0x03, 0xC0, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0xEF, 0xFD, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0x00, 0x3C, 0x7E, 0x00, 0x0C, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0xFE, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE7, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFD, 0xF8, 0x00,
  0x3F, 0xEF, 0xE0, 0x03, 0xFF, 0x7F, 0x80, 0x3F, 0xF9, 0xFF, 0x9F, 0xEF,
  0xCF, 0xFF, 0xFF, 0x7E, 0x3F, 0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0x0F, 0x81,
  0xFF, 0xE0, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xF3, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0xBE, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x9F, 0x00, 0x3F, 0x03, 0xE0,
  0x07, 0xCF, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xC0, 0xFC,
  0x03, 0xF1, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xF8, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x7E, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x00,
  0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x3E, 0x1F, 0x80,
  0x07, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0, 0x07, 0xC7, 0xC0,
  0x01, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0xF8, 0x01, 0xF3, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x43, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0xFF, 0xF8,
  0x00, 0x17, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xA0, 0x00, 0x3F, 0xFC,
  0x80, 0x00, 0x0F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Regular70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 8, 51, 18, 5, -50 },
  { 52, 19, 18, 28, 4, -50 },
  { 95, 37, 50, 40, 2, -50 },
  { 327, 29, 57, 36, 4, -53 },
  { 534, 48, 52, 54, 3, -51 },
  { 846, 42, 52, 45, 3, -51 },
  { 1119, 7, 18, 15, 4, -50 },
  { 1135, 16, 61, 21, 3, -50 },
  { 1257, 16, 61, 21, 2, -50 },
  { 1379, 29, 28, 35, 3, -53 },
  { 1481, 30, 33, 36, 3, -41 },
  { 1605, 10, 17, 18, 3, -8 },
  { 1627, 17, 6, 21, 2, -22 },
  { 1640, 8, 9, 18, 5, -8 },
  { 1649, 24, 50, 26, 1, -50 },
  { 1799, 30, 52, 36, 3, -51 },
  { 1994, 17, 50, 36, 6, -50 },
  { 2101, 30, 51, 36, 3, -51 },
  { 2293, 30, 52, 36, 3, -51 },
  { 2488, 34, 50, 36, 1, -50 },
  { 2701, 29, 51, 36, 4, -50 },
  { 2886, 29, 52, 36, 4, -51 },
  { 3075, 30, 50, 36, 3, -50 },
  { 3263, 30, 52, 36, 3, -51 },
  { 3458, 30, 52, 36, 3, -51 },
  { 3653, 8, 39, 18, 5, -38 },
  { 3692, 11, 47, 18, 2, -38 },
  { 3757, 30, 33, 36, 3, -42 },
  { 3881, 30, 19, 36, 3, -34 },
  { 3953, 30, 33, 36, 3, -42 },
  { 4077, 25, 52, 27, 1, -51 },
  { 4240, 49, 56, 57, 4, -50 },
  { 4583, 40, 50, 40, 0, -50 },
  { 4833, 32, 50, 41, 6, -50 },
  { 5033, 33, 52, 39, 4, -51 },
  { 5248, 36, 50, 46, 6, -50 },
  { 5473, 25, 50, 35, 6, -50 },
  { 5630, 25, 50, 33, 6, -50 },
  { 5787, 38, 52, 46, 4, -51 },
  { 6034, 34, 50, 47, 6, -50 },
  { 6247, 17, 50, 22, 3, -50 },
  { 6354, 17, 63, 18, -5, -50 },
  { 6488, 33, 50, 39, 6, -50 },
  { 6695, 25, 50, 33, 6, -50 },
  { 6852, 47, 50, 59, 6, -50 },
  { 7146, 36, 50, 48, 6, -50 },
  { 7371, 41, 52, 49, 4, -51 },
  { 7638, 29, 50, 38, 6, -50 },
  { 7820, 41, 63, 49, 4, -51 },
  { 8143, 32, 50, 39, 6, -50 },
  { 8343, 29, 52, 35, 3, -51 },
  { 8532, 33, 50, 34, 1, -50 },
  { 8739, 34, 51, 46, 6, -50 },
  { 8956, 38, 50, 38, 0, -50 },
  { 9194, 58, 50, 60, 1, -50 },
  { 9557, 36, 50, 36, 0, -50 },
  { 9782, 35, 50, 35, 0, -50 },
  { 10001, 30, 50, 35, 2, -50 },
  { 10189, 16, 61, 23, 5, -50 },
  { 10311, 24, 50, 26, 1, -50 },
  { 10461, 15, 61, 23, 2, -50 },
  { 10576, 33, 30, 37, 2, -50 },
  { 10700, 31, 5, 31, 0, 6 },
  { 10720, 14, 12, 19, 3, -54 },
  { 10741, 27, 39, 36, 3, -38 },
  { 10873, 31, 54, 39, 5, -53 },
  { 11083, 24, 39, 30, 4, -38 },
  { 11200, 31, 54, 39, 3, -53 },
  { 11410, 28, 39, 36, 4, -38 },
  { 11547, 23, 54, 22, 1, -54 },
  { 11703, 31, 55, 39, 3, -38 },
  { 11917, 29, 53, 39, 5, -53 },
  { 12110, 7, 52, 17, 5, -52 },
  { 12156, 15, 69, 17, -3, -52 },
  { 12286, 28, 53, 34, 5, -53 },
  { 12472, 6, 53, 17, 5, -53 },
  { 12512, 49, 38, 59, 5, -38 },
  { 12745, 29, 38, 39, 5, -38 },
  { 12883, 32, 39, 38, 3, -38 },
  { 13039, 31, 55, 39, 5, -38 },
  { 13253, 31, 55, 39, 3, -38 },
  { 13467, 20, 38, 26, 5, -38 },
  { 13562, 24, 39, 30, 3, -38 },
  { 13679, 20, 47, 23, 1, -46 },
  { 13797, 29, 39, 39, 5, -38 },
  { 13939, 32, 38, 32, 0, -38 },
  { 14091, 49, 38, 50, 1, -38 },
  { 14324, 31, 38, 33, 1, -38 },
  { 14472, 32, 55, 32, 0, -38 },
  { 14692, 24, 38, 29, 2, -38 },
  { 14806, 22, 61, 26, 2, -50 },
  { 14974, 5, 70, 35, 15, -53 },
  { 15018, 22, 61, 26, 2, -50 },
  { 15186, 30, 9, 36, 3, -29 },
};

const GFXfont NotoSans_SemiCondensed_Regular70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular70pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR70PT7B_H_
