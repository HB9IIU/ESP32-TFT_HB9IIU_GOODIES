#ifndef _NOTOSANS_SEMICONDENSED_REGULAR54PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00,
  0x00, 0x03, 0xEF, 0xFF, 0xFF, 0xFF, 0x8C, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFB, 0xC1, 0xF7, 0x83, 0xEF, 0x07, 0xDE, 0x0F, 0xBC, 0x0F, 0x78, 0x1E,
  0xF0, 0x39, 0xE0, 0x73, 0xC0, 0xE7, 0x81, 0xCF, 0x03, 0x80, 0x00, 0x1C,
  0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0xF0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x70, 0x1E, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xF1, 0xE1, 0xCF,
  0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07,
  0x80, 0x3E, 0x1E, 0x00, 0xF8, 0x78, 0x01, 0xF9, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xE3, 0xF0, 0x07, 0x87, 0xC0, 0x1E,
  0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x1F,
  0x80, 0x78, 0x7F, 0xC1, 0xE7, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x07, 0xFE, 0x00, 0x1E, 0x00, 0x7C,
  0xF8, 0x00, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x78, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x1E,
  0x03, 0xC0, 0x03, 0x80, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x81, 0xE0, 0x01,
  0xE0, 0x3C, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x0F, 0x07,
  0x80, 0x01, 0xC0, 0x78, 0x78, 0x00, 0x0E, 0x03, 0xC3, 0xC1, 0xC0, 0x78,
  0x1E, 0x3C, 0x3F, 0x83, 0xC0, 0xF1, 0xE3, 0xFE, 0x1E, 0x0F, 0x1E, 0x3F,
  0xF8, 0x78, 0x78, 0xF1, 0xE3, 0xE3, 0xE7, 0xCF, 0x1E, 0x0F, 0x0F, 0xFC,
  0x78, 0xF0, 0x38, 0x3F, 0xC7, 0x87, 0x81, 0xE0, 0xFC, 0x3C, 0x38, 0x0F,
  0x00, 0x03, 0xC1, 0xC0, 0x78, 0x00, 0x1E, 0x1E, 0x03, 0xC0, 0x00, 0xF0,
  0xF0, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x3C, 0x07, 0x80,
  0x07, 0x81, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x01, 0xE0, 0x03, 0xC0, 0x38,
  0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x0F, 0x03, 0x80, 0x0F,
  0x00, 0x78, 0x3C, 0x00, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0x80, 0x0F, 0xFE,
  0x00, 0x78, 0x00, 0x3F, 0xE0, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x3C, 0x1F, 0x9F, 0x80, 0x7C, 0x3F, 0x0F, 0xC0, 0x7C, 0x3E, 0x07,
  0xE0, 0x7C, 0x7C, 0x03, 0xF0, 0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x78, 0x01,
  0xF8, 0xF8, 0xF8, 0x00, 0xFD, 0xF0, 0xF8, 0x00, 0x7F, 0xF0, 0xF8, 0x00,
  0x3F, 0xE0, 0xF8, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x1F, 0xE0, 0x7E, 0x00, 0x3F, 0xF0, 0x3F, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFD, 0xF8, 0x1F, 0xFF, 0xF8, 0xFC, 0x0F, 0xFF, 0xE0, 0x7E, 0x03, 0xFF,
  0x80, 0x3F, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBC, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x38,
  0x1C, 0x1E, 0x7F, 0x39, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0x10, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xE7,
  0xC0, 0x07, 0xC7, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0xFC, 0x1F,
  0x80, 0x70, 0x1C, 0x00, 0x20, 0x20, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFB,
  0xFF, 0xFF, 0xFF, 0xE3, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x78, 0x3E,
  0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F,
  0xF1, 0xFB, 0xCF, 0xDF, 0xFC, 0x7D, 0xE1, 0xF3, 0x07, 0xC8, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF0,
  0x3F, 0x87, 0x80, 0x1F, 0x04, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x87, 0xE0, 0x3F, 0x87, 0x00, 0x1F, 0x08, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7D, 0x00, 0x01, 0xFB, 0xC0, 0x07, 0xE7, 0xFC, 0xFF, 0xCF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D,
  0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xC7, 0x80, 0x01,
  0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0x80,
  0x07, 0x81, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x07,
  0x80, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x03, 0xE0,
  0x07, 0x80, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0x87,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFA, 0x00, 0x07, 0xEE, 0x00, 0x3F, 0x3F, 0xDF, 0xF8, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x3F, 0xC0, 0xF9, 0xFF, 0xC1, 0xE7, 0xFF, 0xE3,
  0xDF, 0xFF, 0xC7, 0xF8, 0x0F, 0xCF, 0xE0, 0x0F, 0x9F, 0x80, 0x0F, 0xBE,
  0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0x9E, 0x00,
  0x0F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xFC, 0x07,
  0xE0, 0xFF, 0x7F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0x81, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x1F, 0x80, 0xF8, 0x0F, 0xC3, 0xF0,
  0x07, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0xC7, 0xF0, 0x1F, 0x83, 0xF8, 0x3E, 0x00, 0xFC,
  0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0xC3, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x2C, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81,
  0xF8, 0x3F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x3C, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF9, 0xF0, 0x07, 0xF3, 0xF8, 0x3D,
  0xE3, 0xFF, 0xFB, 0xC3, 0xFF, 0xE7, 0x83, 0xFF, 0x1F, 0x00, 0x70, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0xE7, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xE3,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x3E, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C,
  0x78, 0x78, 0x78, 0xF0, 0xF0, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0x81, 0xFC, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x3F, 0xE0,
  0x3C, 0x3C, 0x03, 0xFF, 0xE0, 0x78, 0xF0, 0x1F, 0xFF, 0x81, 0xE7, 0x80,
  0xFC, 0x1E, 0x07, 0x9E, 0x03, 0xC0, 0x78, 0x0E, 0x78, 0x1E, 0x01, 0xE0,
  0x3F, 0xC0, 0x78, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x1E, 0x03, 0xFC, 0x0F,
  0x00, 0x78, 0x0F, 0xF0, 0x3C, 0x01, 0xE0, 0x3F, 0xC0, 0xF0, 0x07, 0x80,
  0xFF, 0x03, 0xC0, 0x1E, 0x03, 0xFC, 0x0F, 0x00, 0xF8, 0x0E, 0xF0, 0x3C,
  0x03, 0xE0, 0x3B, 0xC0, 0xF0, 0x0F, 0x81, 0xEF, 0x03, 0xC0, 0x3E, 0x07,
  0xBC, 0x0F, 0x81, 0xF8, 0x1C, 0xF0, 0x1E, 0x07, 0xE0, 0xF3, 0xC0, 0x7E,
  0x7B, 0xCF, 0x87, 0x80, 0xFF, 0xE7, 0xFE, 0x1E, 0x01, 0xFF, 0x0F, 0xF0,
  0x78, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x00, 0x00, 0xFE, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF0,
  0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xF8, 0x01, 0xFC, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xFC, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8,
  0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0x83, 0xF8, 0x00, 0x40, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x38, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x06, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xF0, 0x03, 0xFC, 0x3E, 0x00, 0x1F, 0xC7,
  0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x3F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF8,
  0xF8, 0x00, 0x7F, 0x1F, 0x00, 0x1F, 0xC3, 0xE0, 0x1F, 0xF0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F,
  0x03, 0xF8, 0x00, 0x30, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF8, 0x7F, 0x00, 0x07, 0xC1, 0xFC, 0x00,
  0x3E, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x10, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x7F, 0xFB, 0xFF, 0x9F, 0xF8,
  0xFF, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F,
  0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC1,
  0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0,
  0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x03, 0xF1,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7E,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF7, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x78, 0x00, 0x03,
  0xDF, 0xF7, 0x80, 0x00, 0x3D, 0xFF, 0x7C, 0x00, 0x07, 0xDF, 0xF3, 0xC0,
  0x00, 0x79, 0xFF, 0x3C, 0x00, 0x07, 0x9F, 0xF3, 0xE0, 0x00, 0xF9, 0xFF,
  0x1E, 0x00, 0x0F, 0x1F, 0xF1, 0xE0, 0x00, 0xF1, 0xFF, 0x1F, 0x00, 0x1F,
  0x1F, 0xF0, 0xF0, 0x01, 0xE1, 0xFF, 0x0F, 0x00, 0x1E, 0x1F, 0xF0, 0xF8,
  0x03, 0xE1, 0xFF, 0x07, 0x80, 0x3C, 0x1F, 0xF0, 0x7C, 0x03, 0xC1, 0xFF,
  0x07, 0xC0, 0x7C, 0x1F, 0xF0, 0x3C, 0x07, 0x81, 0xFF, 0x03, 0xE0, 0x78,
  0x1F, 0xF0, 0x3E, 0x0F, 0x81, 0xFF, 0x01, 0xE0, 0xF0, 0x1F, 0xF0, 0x1F,
  0x0F, 0x01, 0xFF, 0x00, 0xF1, 0xE0, 0x1F, 0xF0, 0x0F, 0x1E, 0x01, 0xFF,
  0x00, 0xF9, 0xE0, 0x1F, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x7B, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x03,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x01, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xF7, 0xC0, 0x01, 0xFF, 0x7C, 0x00, 0x1F, 0xF3, 0xE0, 0x01, 0xFF,
  0x3F, 0x00, 0x1F, 0xF1, 0xF0, 0x01, 0xFF, 0x0F, 0x80, 0x1F, 0xF0, 0xF8,
  0x01, 0xFF, 0x07, 0xC0, 0x1F, 0xF0, 0x7C, 0x01, 0xFF, 0x03, 0xE0, 0x1F,
  0xF0, 0x3F, 0x01, 0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x1F, 0x81, 0xFF, 0x00,
  0xF8, 0x1F, 0xF0, 0x07, 0xC1, 0xFF, 0x00, 0x7C, 0x1F, 0xF0, 0x03, 0xE1,
  0xFF, 0x00, 0x3F, 0x1F, 0xF0, 0x01, 0xF1, 0xFF, 0x00, 0x1F, 0x9F, 0xF0,
  0x00, 0xF9, 0xFF, 0x00, 0x07, 0xDF, 0xF0, 0x00, 0x7D, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xC0,
  0x07, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xE0, 0x0F, 0xEF, 0x80,
  0x1F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x3F, 0x3E, 0x03,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xC0, 0x1F,
  0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0,
  0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0xFC, 0x3E, 0x01, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xCF, 0x80,
  0x03, 0xE7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0x87, 0xE0,
  0x03, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7D, 0x00, 0x01, 0xFB, 0xC0, 0x0F,
  0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF0,
  0x7E, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7C, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xC0, 0x3E,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x07, 0xBE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x9F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0xF7, 0xC0, 0x07, 0x81, 0xF0, 0x03, 0xCF, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0x3C, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0xF0, 0x03, 0xE0, 0x3C, 0x01, 0xE3,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x87, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC0, 0x1E, 0x03, 0xC1, 0xF0,
  0x1E, 0x00, 0x7C, 0x0F, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x3C, 0x0F, 0x03,
  0xE0, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0xF8, 0x3C,
  0x00, 0x3E, 0x1E, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x07, 0x87, 0xC0,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x00, 0x7C, 0xF0, 0x03, 0xCF, 0x80, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x00, 0xF7,
  0x80, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0xF0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x03, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E,
  0x00, 0x3E, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xCF, 0x00, 0x01,
  0xE7, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xF0,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x03,
  0xC7, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0x8F, 0xE0, 0xC0, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF0, 0x0F,
  0x7E, 0x00, 0x7B, 0xE0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x00, 0x3F, 0x7C, 0x03, 0xFB,
  0xF8, 0x7F, 0xCF, 0xFF, 0xDE, 0x3F, 0xFC, 0x70, 0xFF, 0x83, 0x80, 0x40,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x8F, 0xF8, 0x1F, 0x3F, 0xFC, 0x3E, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF,
  0x00, 0xF9, 0xFC, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xF0, 0x03, 0xEF, 0xF0, 0x0F, 0x9E,
  0xF8, 0xFF, 0x3C, 0xFF, 0xFC, 0x78, 0xFF, 0xF0, 0xF0, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xF0, 0x08, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x43, 0xFD, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x3F, 0xE3, 0xE1, 0xFF, 0xE7, 0xC7, 0xFF, 0xE7, 0x9F, 0xE7, 0xEF,
  0x3F, 0x01, 0xFE, 0xFC, 0x01, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3E, 0xF0, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xF3, 0xF0, 0x1F,
  0xE7, 0xF8, 0xFB, 0xC7, 0xFF, 0xE7, 0x87, 0xFF, 0x8F, 0x03, 0xFE, 0x1E,
  0x00, 0x60, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xF1, 0xFC, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x9E, 0x00,
  0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x18,
  0x7F, 0xDF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0x20, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xFE, 0x1E, 0x1F, 0xFE, 0x3C, 0x7F, 0xFE, 0x78, 0xFF, 0xFE, 0xF3, 0xF0,
  0x1F, 0xEF, 0xC0, 0x1F, 0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xEF,
  0x00, 0x07, 0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x7F, 0x3F, 0x01, 0xFE, 0x7F,
  0x8F, 0xBC, 0x7F, 0xFE, 0xF8, 0x7F, 0xF9, 0xF0, 0x3F, 0xE3, 0xE0, 0x06,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE2, 0x00, 0x0F, 0xC7, 0x80, 0x7F,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0xFF, 0xC3,
  0xE7, 0xFF, 0x8F, 0xBF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0x00, 0xFB, 0xF8,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3C, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E,
  0x07, 0xDF, 0xFB, 0xFE, 0x7F, 0x8F, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x3E,
  0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x78,
  0x00, 0xFB, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFE, 0x7C, 0x03, 0xF1, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xFC, 0x3E, 0x01, 0xF0, 0xF8, 0x03,
  0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7E, 0xF8, 0x00, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0x8F, 0xFE, 0x0F, 0xFF, 0x3C,
  0xFF, 0xF8, 0xFF, 0xFD, 0xEF, 0xDF, 0xEF, 0xDF, 0xEF, 0xF0, 0x1F, 0xF0,
  0x1F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0x80, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xC0, 0x03,
  0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0x80, 0x07, 0xFC, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x01, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0x00, 0x0F, 0xF8, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xC0,
  0x03, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0x80, 0x07, 0xFC, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x01, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF8, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x03,
  0xC0, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0x80, 0x07, 0x80, 0xF0, 0xFF, 0xC3, 0xC7, 0xFF, 0x8F, 0x3F,
  0xFF, 0x3D, 0xFF, 0xFE, 0xFF, 0x00, 0xFB, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3C, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xEF,
  0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3F, 0x00, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0xF0, 0xFF, 0x81, 0xE3, 0xFF,
  0xC3, 0xCF, 0xFF, 0xC7, 0xFF, 0x3F, 0xCF, 0xF0, 0x1F, 0x9F, 0xC0, 0x1F,
  0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0x7F, 0x00, 0x7E, 0xFF, 0x00, 0xF9, 0xFF, 0xCF, 0xF3, 0xEF, 0xFF,
  0xC7, 0xCF, 0xFF, 0x0F, 0x8F, 0xF8, 0x1F, 0x01, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x1E, 0x1F,
  0xFE, 0x3C, 0x7F, 0xFE, 0x78, 0xFE, 0x7E, 0xF3, 0xF0, 0x1F, 0xEF, 0xC0,
  0x1F, 0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDF,
  0x00, 0x1F, 0xBF, 0x00, 0x7F, 0x3F, 0x01, 0xFE, 0x7F, 0x8F, 0xBC, 0x7F,
  0xFE, 0xF8, 0x7F, 0xF9, 0xF0, 0x3F, 0xE3, 0xE0, 0x04, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0xF0, 0x7F, 0xE3,
  0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x78, 0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0xC7, 0xE7, 0xC0, 0x18, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xE0, 0x07, 0xDF, 0xC7, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xFF,
  0xC0, 0x01, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xE6, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0,
  0x02, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0x7E, 0x03, 0xFD, 0xFE,
  0x7E, 0xF3, 0xFF, 0xF3, 0xC7, 0xFF, 0x8F, 0x0F, 0xFC, 0x3C, 0x01, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x3C,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3C, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0xC0,
  0x0F, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x03,
  0xF8, 0x01, 0xE7, 0x80, 0x1F, 0xC0, 0x0F, 0x3E, 0x01, 0xEF, 0x00, 0xF9,
  0xF0, 0x0F, 0x78, 0x07, 0xCF, 0x80, 0x7B, 0xC0, 0x3C, 0x3C, 0x03, 0xDE,
  0x01, 0xE1, 0xF0, 0x3C, 0xF8, 0x1F, 0x0F, 0x81, 0xE3, 0xC0, 0xF8, 0x7C,
  0x0F, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0xF0, 0x3C, 0x0F, 0x07, 0x87, 0xC3,
  0xE0, 0x7C, 0x3C, 0x1E, 0x1F, 0x03, 0xE1, 0xE0, 0xF0, 0xF0, 0x0F, 0x1F,
  0x07, 0x87, 0x80, 0x78, 0xF0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0xF3, 0xE0,
  0x1F, 0x3C, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x03, 0xDE, 0x00,
  0xF7, 0x80, 0x1E, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x1F,
  0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03,
  0xC7, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x07,
  0xC7, 0xC0, 0x07, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF,
  0x80, 0x03, 0xE3, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x3C, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x1F, 0x07,
  0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x78,
  0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x1F, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0xFF, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x01, 0x3F, 0xE0, 0x01, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0x9F, 0xF9,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x80, 0x07, 0xF8, 0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 40, 14, 4, -39 },
  { 31, 15, 14, 21, 3, -39 },
  { 58, 29, 39, 31, 1, -39 },
  { 200, 22, 44, 28, 3, -41 },
  { 321, 37, 40, 42, 2, -39 },
  { 506, 32, 40, 35, 2, -39 },
  { 666, 5, 14, 12, 3, -39 },
  { 675, 12, 48, 16, 2, -39 },
  { 747, 12, 48, 16, 2, -39 },
  { 819, 23, 22, 27, 2, -41 },
  { 883, 24, 26, 28, 2, -32 },
  { 961, 8, 13, 14, 2, -6 },
  { 974, 13, 5, 16, 2, -17 },
  { 983, 6, 7, 14, 4, -6 },
  { 989, 19, 39, 20, 1, -39 },
  { 1082, 24, 40, 28, 2, -39 },
  { 1202, 14, 39, 28, 4, -39 },
  { 1271, 23, 39, 28, 2, -39 },
  { 1384, 23, 40, 28, 2, -39 },
  { 1499, 26, 39, 28, 1, -39 },
  { 1626, 22, 40, 28, 3, -39 },
  { 1736, 23, 40, 28, 3, -39 },
  { 1851, 24, 39, 28, 2, -39 },
  { 1968, 24, 40, 28, 2, -39 },
  { 2088, 23, 40, 28, 2, -39 },
  { 2203, 6, 30, 14, 4, -29 },
  { 2226, 8, 36, 14, 2, -29 },
  { 2262, 24, 25, 28, 2, -32 },
  { 2337, 23, 14, 28, 2, -26 },
  { 2378, 24, 25, 28, 2, -32 },
  { 2453, 19, 40, 21, 1, -39 },
  { 2548, 38, 44, 44, 3, -39 },
  { 2757, 31, 39, 31, 0, -39 },
  { 2909, 24, 39, 32, 5, -39 },
  { 3026, 26, 40, 30, 3, -39 },
  { 3156, 27, 39, 35, 5, -39 },
  { 3288, 19, 39, 27, 5, -39 },
  { 3381, 19, 39, 25, 5, -39 },
  { 3474, 29, 40, 36, 3, -39 },
  { 3619, 26, 39, 36, 5, -39 },
  { 3746, 13, 39, 17, 2, -39 },
  { 3810, 13, 49, 14, -4, -39 },
  { 3890, 25, 39, 30, 5, -39 },
  { 4012, 19, 39, 25, 5, -39 },
  { 4105, 36, 39, 45, 5, -39 },
  { 4281, 28, 39, 37, 5, -39 },
  { 4418, 32, 40, 38, 3, -39 },
  { 4578, 22, 39, 29, 5, -39 },
  { 4686, 32, 48, 38, 3, -39 },
  { 4878, 25, 39, 30, 5, -39 },
  { 5000, 23, 40, 27, 2, -39 },
  { 5115, 25, 39, 27, 1, -39 },
  { 5237, 27, 40, 35, 4, -39 },
  { 5372, 29, 39, 29, 0, -39 },
  { 5514, 46, 39, 46, 0, -39 },
  { 5739, 28, 39, 28, 0, -39 },
  { 5876, 27, 39, 27, 0, -39 },
  { 6008, 23, 39, 27, 2, -39 },
  { 6121, 12, 48, 17, 4, -39 },
  { 6193, 19, 39, 20, 1, -39 },
  { 6286, 12, 48, 17, 1, -39 },
  { 6358, 25, 23, 28, 2, -39 },
  { 6430, 24, 3, 24, 0, 5 },
  { 6439, 11, 8, 15, 2, -41 },
  { 6450, 21, 30, 27, 2, -29 },
  { 6529, 23, 42, 30, 4, -41 },
  { 6650, 19, 30, 23, 3, -29 },
  { 6722, 23, 42, 30, 3, -41 },
  { 6843, 22, 30, 28, 3, -29 },
  { 6926, 18, 41, 17, 1, -41 },
  { 7019, 23, 42, 30, 3, -29 },
  { 7140, 22, 41, 30, 4, -41 },
  { 7253, 5, 40, 13, 4, -40 },
  { 7278, 11, 53, 13, -2, -40 },
  { 7351, 22, 41, 26, 4, -41 },
  { 7464, 5, 41, 13, 4, -41 },
  { 7490, 37, 29, 45, 4, -29 },
  { 7625, 22, 29, 30, 4, -29 },
  { 7705, 24, 30, 29, 3, -29 },
  { 7795, 23, 42, 30, 4, -29 },
  { 7916, 23, 42, 30, 3, -29 },
  { 8037, 15, 29, 20, 4, -29 },
  { 8092, 19, 30, 23, 2, -29 },
  { 8164, 15, 37, 18, 1, -36 },
  { 8234, 22, 30, 30, 4, -29 },
  { 8317, 25, 29, 25, 0, -29 },
  { 8408, 37, 29, 39, 1, -29 },
  { 8543, 24, 29, 25, 1, -29 },
  { 8630, 25, 42, 25, 0, -29 },
  { 8762, 18, 29, 22, 2, -29 },
  { 8828, 16, 48, 20, 2, -39 },
  { 8924, 4, 54, 27, 11, -41 },
  { 8951, 16, 48, 20, 2, -39 },
  { 9047, 24, 8, 28, 2, -23 },
};

const GFXfont NotoSans_SemiCondensed_Regular54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR54PT7B_H_
