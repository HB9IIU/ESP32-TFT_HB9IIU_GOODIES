#ifndef _NOTOSANS_SEMICONDENSED_REGULAR52PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x00, 0x00, 0x00,
  0x1E, 0xFB, 0xFF, 0xFF, 0xF8, 0x80, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE0, 0xF7,
  0x03, 0xDC, 0x0F, 0x70, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x1C,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0,
  0x70, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7C, 0x70, 0xE7, 0xC3, 0x80, 0xBC, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07,
  0x00, 0x78, 0x38, 0x03, 0xC1, 0xC0, 0x1F, 0x0E, 0x00, 0x7E, 0x70, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x0E, 0x7E, 0x00, 0x70, 0xF8, 0x03, 0x83, 0xC0,
  0x1C, 0x1E, 0x00, 0xE0, 0xF0, 0x07, 0x07, 0x80, 0x38, 0x3E, 0x01, 0xC3,
  0xFC, 0x0E, 0x3E, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0x80, 0x1F, 0xF0, 0x00, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0x00,
  0x38, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xC0, 0x1E, 0x00, 0x78, 0x3C, 0x03,
  0xC0, 0x07, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x1C, 0x07, 0x80, 0x0F, 0x01,
  0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0x1E, 0x1E, 0x00, 0x0F, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x1C, 0x3C,
  0x00, 0x07, 0x01, 0xC3, 0xC1, 0xC0, 0x70, 0x3C, 0x78, 0x7F, 0x07, 0x83,
  0xC7, 0x8F, 0xF8, 0x78, 0x3C, 0x71, 0xF7, 0xC3, 0xC7, 0x8F, 0x1C, 0x3C,
  0x3F, 0xF8, 0xE3, 0xC1, 0xE1, 0xFF, 0x1E, 0x3C, 0x1E, 0x0F, 0xE1, 0xC3,
  0x80, 0xE0, 0x38, 0x3C, 0x38, 0x0E, 0x00, 0x03, 0x83, 0x80, 0xF0, 0x00,
  0x78, 0x78, 0x0F, 0x00, 0x07, 0x87, 0x80, 0xF0, 0x00, 0xF0, 0x78, 0x0F,
  0x00, 0x0F, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x38, 0x0F, 0x00, 0x1E, 0x03,
  0x80, 0xE0, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0x3C, 0x03, 0xC1, 0xE0, 0x07,
  0x80, 0x3C, 0x1E, 0x00, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x00, 0x1F, 0xFC,
  0x00, 0xF0, 0x00, 0xFF, 0x80, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0x83,
  0xE3, 0xE0, 0x1F, 0x0F, 0x83, 0xE0, 0x3E, 0x3E, 0x03, 0xE0, 0x78, 0x7C,
  0x03, 0xE1, 0xF0, 0xF0, 0x07, 0xE3, 0xE3, 0xE0, 0x07, 0xEF, 0x87, 0xC0,
  0x07, 0xFF, 0x0F, 0x80, 0x07, 0xFC, 0x1F, 0x00, 0x07, 0xF8, 0x3E, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x7F, 0xC0, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF, 0x8F, 0xC0, 0xFF, 0xFC,
  0x0F, 0xC0, 0xFF, 0xE0, 0x0F, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDC, 0xE7, 0x00, 0x01, 0xF0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07,
  0x81, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x18, 0x1C, 0x0E, 0x7E, 0x71, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF3,
  0xC0, 0x07, 0x8F, 0x80, 0x3E, 0x1E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8,
  0x07, 0x03, 0x80, 0x08, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C,
  0x7C, 0x7C, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7C, 0xFB, 0xFF, 0xF7, 0xCF, 0x84, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFC, 0x7E, 0x03, 0xE0,
  0x3E, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0xF8, 0x00,
  0xF9, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07,
  0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xBC, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x8F, 0x00,
  0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x3F, 0xBF,
  0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xBC, 0xF9,
  0xFF, 0x8F, 0x78, 0x7B, 0x83, 0xC8, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7F, 0x0F, 0xF1, 0xF0, 0x07, 0xC3, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x78, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0x07,
  0xF1, 0xE0, 0x07, 0xC2, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFB, 0x80, 0x07, 0xEF, 0xE1, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0,
  0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x81,
  0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xEF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0C, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xD0, 0x00, 0x3E, 0xC0, 0x07, 0xE7, 0xE1, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xF0,
  0x20, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x3F, 0xC0, 0xF3, 0xFF, 0xC3, 0xDF, 0xFF,
  0x8F, 0x7C, 0x7F, 0x3F, 0x80, 0x7C, 0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0x80, 0x07,
  0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xF0, 0xFC, 0x07, 0xC1, 0xFC, 0xFE, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8, 0x3F,
  0x07, 0xC0, 0x1F, 0x0F, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x87,
  0xC0, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xE3, 0xF0, 0x07, 0xEF, 0xC0, 0x07,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xF0,
  0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF0, 0x00,
  0x7B, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0x7C, 0x00, 0x7C, 0xFC, 0x01, 0xF8,
  0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xF0, 0x1F, 0x87, 0xE0, 0xF8, 0x07, 0xC3, 0xC0, 0x0F, 0x1F, 0x00,
  0x3E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78,
  0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xCF, 0x80, 0x7F, 0x3F, 0xFF,
  0xBC, 0x7F, 0xFE, 0xF0, 0xFF, 0xF3, 0xC0, 0xFF, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x01, 0x07, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x10, 0x00, 0x00, 0xFB, 0xEF, 0xFF, 0xFB, 0xE2, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBE, 0xFF, 0xFF, 0xFE,
  0x20, 0x3E, 0x3E, 0x7F, 0x7F, 0x3E, 0x3E, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xE0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFC, 0x3F, 0x98, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0xFF, 0x01, 0xE3, 0xC0, 0x3F, 0xFC,
  0x0E, 0x78, 0x0F, 0xFF, 0xC0, 0xF7, 0x80, 0xF8, 0x3C, 0x0F, 0x78, 0x1E,
  0x03, 0xC0, 0xF7, 0x03, 0xE0, 0x3C, 0x0F, 0xF0, 0x3C, 0x03, 0xC0, 0xFF,
  0x03, 0xC0, 0x3C, 0x07, 0xF0, 0x38, 0x03, 0xC0, 0x7F, 0x07, 0x80, 0x3C,
  0x07, 0xE0, 0x78, 0x03, 0xC0, 0x7E, 0x07, 0x80, 0x3C, 0x0F, 0xE0, 0x78,
  0x07, 0xC0, 0xFE, 0x07, 0x80, 0x78, 0x0F, 0xF0, 0x38, 0x07, 0xC0, 0xEF,
  0x03, 0xC0, 0x7C, 0x1E, 0xF0, 0x3C, 0x0F, 0xC1, 0xEF, 0x03, 0xE1, 0xDE,
  0x3C, 0xF0, 0x1F, 0xFC, 0xFF, 0x87, 0x80, 0xFF, 0x8F, 0xF8, 0x78, 0x07,
  0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x20, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x00,
  0x3F, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07,
  0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0x78, 0x07, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x8F, 0x00, 0x1F, 0x9E,
  0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0x78, 0x00, 0x7E, 0xF0, 0x03, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xE7, 0xF0, 0x7F, 0x00, 0x30, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x01, 0x81, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x06, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0xF0, 0x03, 0xFC, 0x3C, 0x00, 0x3F, 0x0F, 0x00, 0x07, 0xE3, 0xC0,
  0x00, 0xFC, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xEF, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x3C, 0x00,
  0x0F, 0x8F, 0x00, 0x07, 0xE3, 0xC0, 0x07, 0xF0, 0xF0, 0x07, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x1F, 0xE0, 0x7F, 0x00, 0x1C, 0x0F, 0xC0,
  0x00, 0x41, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3F, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0xC0, 0x01, 0xF0, 0xFF, 0x00, 0x1F,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x87, 0xEF, 0xFC, 0xFF, 0xCF, 0xF0,
  0xFC, 0x00, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0,
  0x00, 0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0,
  0x0F, 0xC0, 0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0,
  0x7C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0xF8, 0x00, 0xF1, 0xF0, 0x00, 0xF3,
  0xE0, 0x00, 0xF3, 0xE0, 0x00, 0xF7, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7E, 0x00, 0xF0,
  0x3E, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0x80, 0xF0, 0x0F, 0x80, 0xF0,
  0x07, 0xC0, 0xF0, 0x07, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0,
  0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1E, 0xFF, 0xF8, 0x00, 0x07, 0xBF, 0xDE,
  0x00, 0x01, 0xEF, 0xF7, 0x80, 0x00, 0xF3, 0xFD, 0xF0, 0x00, 0x3C, 0xFF,
  0x3C, 0x00, 0x0F, 0x3F, 0xCF, 0x00, 0x07, 0x8F, 0xF3, 0xE0, 0x01, 0xE3,
  0xFC, 0x78, 0x00, 0x78, 0xFF, 0x1E, 0x00, 0x3C, 0x3F, 0xC7, 0xC0, 0x0F,
  0x0F, 0xF0, 0xF0, 0x03, 0xC3, 0xFC, 0x3C, 0x01, 0xE0, 0xFF, 0x0F, 0x80,
  0x78, 0x3F, 0xC1, 0xE0, 0x1E, 0x0F, 0xF0, 0x78, 0x0F, 0x03, 0xFC, 0x1F,
  0x03, 0xC0, 0xFF, 0x03, 0xC0, 0xF0, 0x3F, 0xC0, 0xF0, 0x78, 0x0F, 0xF0,
  0x3E, 0x1E, 0x03, 0xFC, 0x07, 0x8F, 0x80, 0xFF, 0x01, 0xE3, 0xC0, 0x3F,
  0xC0, 0x7C, 0xF0, 0x0F, 0xF0, 0x0F, 0x7C, 0x03, 0xFC, 0x03, 0xDE, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x0F,
  0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFE, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF7, 0xC0, 0x03,
  0xFD, 0xF0, 0x00, 0xFF, 0x3E, 0x00, 0x3F, 0xC7, 0xC0, 0x0F, 0xF1, 0xF0,
  0x03, 0xFC, 0x3E, 0x00, 0xFF, 0x0F, 0x80, 0x3F, 0xC1, 0xF0, 0x0F, 0xF0,
  0x7C, 0x03, 0xFC, 0x0F, 0x80, 0xFF, 0x03, 0xE0, 0x3F, 0xC0, 0x7C, 0x0F,
  0xF0, 0x0F, 0x83, 0xFC, 0x03, 0xE0, 0xFF, 0x00, 0x7C, 0x3F, 0xC0, 0x1F,
  0x0F, 0xF0, 0x03, 0xE3, 0xFC, 0x00, 0xF8, 0xFF, 0x00, 0x1F, 0x3F, 0xC0,
  0x03, 0xEF, 0xF0, 0x00, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFC, 0x7F, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x07, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0,
  0x3F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x00, 0xFF,
  0x78, 0x01, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x3F, 0x3C, 0x1F,
  0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFD, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xF0, 0x07,
  0xF0, 0xF0, 0x03, 0xF0, 0xF0, 0x01, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x03,
  0xE0, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x03,
  0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF8, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3F, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x3F, 0xEF, 0xF0, 0xFC, 0x01, 0xC7, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x80, 0x01, 0xFB, 0xC0, 0x0F, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x78,
  0x00, 0x07, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x3F, 0x80, 0x7F, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF7,
  0xC0, 0x01, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x80, 0x01, 0xE7, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0xC0, 0x03, 0xE3, 0xE0, 0x03,
  0xFC, 0x00, 0x3C, 0x3E, 0x00, 0x3F, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xFC,
  0x00, 0x7C, 0x1E, 0x00, 0x3D, 0xE0, 0x07, 0xC1, 0xE0, 0x07, 0x9E, 0x00,
  0x7C, 0x1F, 0x00, 0x79, 0xE0, 0x07, 0x81, 0xF0, 0x07, 0x9E, 0x00, 0xF8,
  0x0F, 0x00, 0x79, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0x0F,
  0x80, 0xF0, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x0F, 0x01, 0xF0, 0x07, 0x81,
  0xF0, 0x78, 0x1F, 0x00, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x07, 0xC1, 0xE0,
  0x78, 0x1E, 0x00, 0x7C, 0x1E, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xE0, 0x3C,
  0x3E, 0x00, 0x3C, 0x3C, 0x03, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x00, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x03, 0xE7, 0xC0, 0x1E, 0x7C, 0x00,
  0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x01, 0xE7, 0x80, 0x01, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x01,
  0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x78,
  0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0x8F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3C,
  0x3E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x3C, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x03, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1E, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xEF,
  0x00, 0x03, 0xC7, 0x00, 0x03, 0xC7, 0x80, 0x07, 0x83, 0xC0, 0x07, 0x83,
  0xC0, 0x0F, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1E, 0x00,
  0xF0, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x1F, 0x07, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0x0F, 0xC0, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7F,
  0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xE3, 0xE7, 0xC0, 0x1F, 0x7C,
  0x00, 0xFB, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x7F, 0x7E, 0x0F, 0x79, 0xFF,
  0xF3, 0xCF, 0xFF, 0x1E, 0x1F, 0xF0, 0xF0, 0x08, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0xFF, 0x03, 0xCF, 0xFF,
  0x0F, 0x7F, 0xFE, 0x3D, 0xFB, 0xFC, 0xFE, 0x01, 0xFB, 0xF0, 0x03, 0xEF,
  0xC0, 0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xEF, 0xC0, 0x0F, 0xBF, 0x80,
  0x7E, 0xFF, 0x87, 0xF3, 0xDF, 0xFF, 0x8F, 0x3F, 0xFC, 0x3C, 0x3F, 0xE0,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE,
  0x3F, 0x00, 0x9F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0x3F, 0xC7, 0xC7,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xFC, 0x3C, 0x3F, 0xFC, 0xF1,
  0xFF, 0xFB, 0xCF, 0xE3, 0xEF, 0x3E, 0x01, 0xFD, 0xF0, 0x03, 0xF7, 0xC0,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x7F,
  0x3F, 0x87, 0xBC, 0x7F, 0xFE, 0xF0, 0xFF, 0xF3, 0xC1, 0xFF, 0x0F, 0x00,
  0x60, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x1F,
  0xC3, 0xE0, 0x3E, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x06, 0x1F, 0xC3, 0xF0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7C, 0x10, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xFF, 0xE7, 0xFF,
  0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x3C, 0x3F,
  0xFC, 0xF1, 0xFF, 0xFB, 0xCF, 0xF7, 0xEF, 0x3E, 0x01, 0xFD, 0xF0, 0x03,
  0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0xDF,
  0x80, 0x7F, 0x3F, 0x87, 0xBC, 0x7F, 0xFE, 0xF0, 0xFF, 0xF3, 0xC1, 0xFF,
  0x0F, 0x00, 0x60, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x98, 0x00, 0x7E, 0x7F,
  0x0F, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x0F, 0xF8, 0x78, 0xFF, 0xE3, 0xDF,
  0xFF, 0x9E, 0xFD, 0xFE, 0xFE, 0x01, 0xF7, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF7, 0xFF, 0xFF, 0x10, 0x00,
  0x00, 0x3D, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x78, 0x03, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0xA3, 0xF7,
  0xFC, 0xFF, 0x9F, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x1F, 0x78, 0x01, 0xF3, 0xC0, 0x1F, 0x1E, 0x01, 0xF0, 0xF0, 0x0F,
  0x87, 0x80, 0xF8, 0x3C, 0x0F, 0x81, 0xE0, 0xF8, 0x0F, 0x0F, 0x80, 0x78,
  0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF7, 0xE0, 0x07, 0xBF, 0x80,
  0x3F, 0xFC, 0x01, 0xFD, 0xF0, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xC0,
  0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1F, 0x07, 0x80, 0x7C, 0x3C, 0x03, 0xE1,
  0xE0, 0x0F, 0x8F, 0x00, 0x7E, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0xDE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x01,
  0xFF, 0x0F, 0x3F, 0xFC, 0x3F, 0xF8, 0xF7, 0xFF, 0xC7, 0xFF, 0xCF, 0x7C,
  0xFE, 0xFD, 0xFE, 0xFE, 0x03, 0xFE, 0x03, 0xEF, 0xC0, 0x1F, 0xC0, 0x1E,
  0xFC, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x1F, 0xF8, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x00, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0x00, 0x0F, 0xF0, 0xFF, 0x87, 0x8F, 0xFE, 0x3D, 0xFF, 0xF9, 0xEF,
  0x9F, 0xEF, 0xE0, 0x1F, 0x7E, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0xFE, 0x7F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xF7,
  0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x1F,
  0x00, 0xFC, 0x1F, 0x87, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0xF0, 0xFF, 0x03, 0xCF, 0xFF, 0x0F, 0x7F,
  0xFE, 0x3D, 0xF1, 0xFC, 0xFE, 0x01, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F,
  0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x80, 0x7E, 0xF7,
  0x87, 0xF3, 0xDF, 0xFF, 0x8F, 0x3F, 0xFC, 0x3C, 0x3F, 0xE0, 0xF0, 0x18,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x3C, 0x3F, 0xFC,
  0xF1, 0xFF, 0xFB, 0xCF, 0xE3, 0xEF, 0x3E, 0x01, 0xFD, 0xF0, 0x03, 0xF7,
  0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x80,
  0x7F, 0x3F, 0x87, 0xBC, 0x7F, 0xFE, 0xF0, 0xFF, 0xF3, 0xC1, 0xFF, 0x0F,
  0x00, 0x40, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0xE3,
  0xFF, 0xCF, 0xF7, 0xBF, 0xEF, 0x78, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFC, 0x7E, 0x7C,
  0x01, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x1F, 0xBF, 0xFF,
  0xCF, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xFC,
  0x00, 0x80, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xEF, 0x80, 0x7F, 0x7F, 0x1F, 0x79, 0xFF, 0xFB, 0xC7, 0xFF,
  0x9E, 0x1F, 0xF0, 0xF0, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3,
  0xC0, 0x03, 0xC7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xEF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0xEF, 0x80, 0x3F, 0x80,
  0x1E, 0x78, 0x03, 0xF8, 0x03, 0xE7, 0x80, 0x3F, 0xC0, 0x3E, 0x7C, 0x03,
  0xBC, 0x03, 0xC7, 0xC0, 0x7B, 0xC0, 0x3C, 0x3C, 0x07, 0x9C, 0x07, 0xC3,
  0xC0, 0x79, 0xE0, 0x78, 0x3E, 0x0F, 0x1E, 0x07, 0x83, 0xE0, 0xF1, 0xE0,
  0x78, 0x1E, 0x0F, 0x1F, 0x0F, 0x81, 0xE0, 0xF0, 0xF0, 0xF0, 0x1F, 0x1E,
  0x0F, 0x0F, 0x01, 0xF1, 0xE0, 0xF0, 0xF0, 0x0F, 0x1E, 0x07, 0x9F, 0x00,
  0xF1, 0xE0, 0x79, 0xE0, 0x0F, 0x3C, 0x07, 0x9E, 0x00, 0xFB, 0xC0, 0x79,
  0xE0, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0x7B, 0x80, 0x3F, 0xC0, 0x07, 0xB8,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F,
  0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xCF, 0x80, 0x07, 0xDE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xF0, 0xF8, 0x00,
  0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3C, 0x00,
  0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x81,
  0xF0, 0x07, 0x81, 0xE0, 0x07, 0xC1, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xC3,
  0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x87, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0xFF, 0x01, 0xFC, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x02, 0x7F, 0xC0, 0x05, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0x20, 0x00, 0xFC, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 38, 13, 4, -37 },
  { 30, 14, 13, 21, 3, -37 },
  { 53, 28, 37, 30, 1, -37 },
  { 183, 21, 42, 27, 3, -39 },
  { 294, 36, 39, 40, 2, -38 },
  { 470, 31, 39, 33, 2, -38 },
  { 622, 5, 13, 11, 3, -37 },
  { 631, 12, 45, 15, 2, -37 },
  { 699, 11, 45, 15, 2, -37 },
  { 761, 22, 22, 26, 2, -40 },
  { 822, 23, 25, 27, 2, -31 },
  { 894, 8, 13, 13, 2, -6 },
  { 907, 12, 4, 16, 2, -16 },
  { 913, 7, 7, 13, 3, -6 },
  { 920, 18, 37, 19, 1, -37 },
  { 1004, 23, 39, 27, 2, -38 },
  { 1117, 13, 37, 27, 4, -37 },
  { 1178, 22, 38, 27, 2, -38 },
  { 1283, 22, 39, 27, 2, -38 },
  { 1391, 25, 37, 27, 1, -37 },
  { 1507, 21, 38, 27, 3, -37 },
  { 1607, 22, 39, 27, 3, -38 },
  { 1715, 23, 37, 27, 2, -37 },
  { 1822, 23, 39, 27, 2, -38 },
  { 1935, 22, 39, 27, 2, -38 },
  { 2043, 6, 29, 13, 4, -28 },
  { 2065, 8, 35, 13, 2, -28 },
  { 2100, 23, 25, 27, 2, -31 },
  { 2172, 22, 14, 27, 2, -25 },
  { 2211, 23, 25, 27, 2, -31 },
  { 2283, 18, 39, 20, 1, -38 },
  { 2371, 36, 42, 42, 3, -37 },
  { 2560, 30, 37, 30, 0, -37 },
  { 2699, 23, 37, 31, 5, -37 },
  { 2806, 25, 39, 29, 3, -38 },
  { 2928, 26, 37, 34, 5, -37 },
  { 3049, 18, 37, 26, 5, -37 },
  { 3133, 18, 37, 24, 5, -37 },
  { 3217, 28, 39, 34, 3, -38 },
  { 3354, 25, 37, 35, 5, -37 },
  { 3470, 13, 37, 17, 2, -37 },
  { 3531, 12, 47, 13, -3, -37 },
  { 3602, 24, 37, 29, 5, -37 },
  { 3713, 18, 37, 24, 5, -37 },
  { 3797, 34, 37, 44, 5, -37 },
  { 3955, 26, 37, 36, 5, -37 },
  { 4076, 30, 39, 36, 3, -38 },
  { 4223, 21, 37, 28, 5, -37 },
  { 4321, 30, 47, 36, 3, -38 },
  { 4498, 24, 37, 29, 5, -37 },
  { 4609, 22, 39, 26, 2, -38 },
  { 4717, 24, 37, 26, 1, -37 },
  { 4828, 26, 38, 34, 4, -37 },
  { 4952, 28, 37, 28, 0, -37 },
  { 5082, 44, 37, 44, 0, -37 },
  { 5286, 27, 37, 27, 0, -37 },
  { 5411, 26, 37, 26, 0, -37 },
  { 5532, 22, 37, 26, 2, -37 },
  { 5634, 11, 45, 17, 4, -37 },
  { 5696, 18, 37, 19, 1, -37 },
  { 5780, 12, 45, 17, 1, -37 },
  { 5848, 24, 22, 27, 2, -37 },
  { 5914, 23, 3, 23, 0, 5 },
  { 5923, 10, 8, 14, 2, -40 },
  { 5933, 21, 29, 26, 2, -28 },
  { 6010, 22, 41, 29, 4, -40 },
  { 6123, 18, 29, 22, 3, -28 },
  { 6189, 22, 41, 29, 3, -40 },
  { 6302, 21, 29, 27, 3, -28 },
  { 6379, 17, 40, 16, 1, -40 },
  { 6464, 22, 40, 29, 3, -28 },
  { 6574, 21, 40, 29, 4, -40 },
  { 6679, 5, 38, 13, 4, -38 },
  { 6703, 11, 50, 13, -2, -38 },
  { 6772, 21, 40, 25, 4, -40 },
  { 6877, 4, 40, 12, 4, -40 },
  { 6897, 36, 28, 44, 4, -28 },
  { 7023, 21, 28, 29, 4, -28 },
  { 7097, 23, 29, 28, 3, -28 },
  { 7181, 22, 40, 29, 4, -28 },
  { 7291, 22, 40, 29, 3, -28 },
  { 7401, 15, 28, 19, 4, -28 },
  { 7454, 18, 29, 22, 2, -28 },
  { 7520, 15, 35, 17, 1, -34 },
  { 7586, 21, 29, 29, 4, -28 },
  { 7663, 24, 28, 24, 0, -28 },
  { 7747, 36, 28, 37, 1, -28 },
  { 7873, 23, 28, 25, 1, -28 },
  { 7954, 24, 40, 24, 0, -28 },
  { 8074, 18, 28, 21, 2, -28 },
  { 8137, 16, 45, 19, 2, -37 },
  { 8227, 4, 52, 26, 11, -40 },
  { 8253, 16, 45, 19, 2, -37 },
  { 8343, 23, 7, 27, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_Regular52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR52PT7B_H_
