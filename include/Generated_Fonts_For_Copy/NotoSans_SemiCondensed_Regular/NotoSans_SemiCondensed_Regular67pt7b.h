#ifndef _NOTOSANS_SEMICONDENSED_REGULAR67PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular67pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE,
  0xFE, 0x38, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01,
  0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x79,
  0xE0, 0x1E, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x3F, 0xCF, 0x07, 0xCF, 0xE1, 0xE0, 0x19, 0xF8, 0x3C, 0x00, 0x3E, 0x07,
  0x80, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x03,
  0xE0, 0x78, 0x00, 0x7E, 0x0F, 0x00, 0x0F, 0xC1, 0xE0, 0x01, 0xFE, 0x3C,
  0x00, 0x1F, 0xF7, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xBF, 0xF0, 0x00, 0xF0, 0xFE, 0x00,
  0x1E, 0x0F, 0xE0, 0x03, 0xC0, 0xFC, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x01,
  0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0xF8, 0x00,
  0xF0, 0x3F, 0x80, 0x1E, 0x0F, 0xFE, 0x03, 0xC3, 0xFB, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x7E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xE0, 0x1F, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x07, 0xC3, 0xE0, 0x7F, 0x01, 0xE0, 0x1F, 0x0F, 0x87, 0xFE, 0x07,
  0xC0, 0x7C, 0x3C, 0x3F, 0xFC, 0x1F, 0x03, 0xE1, 0xF1, 0xFF, 0xF8, 0x7C,
  0x0F, 0x87, 0x87, 0xC3, 0xF0, 0xF8, 0x7E, 0x3E, 0x1E, 0x07, 0xC3, 0xFF,
  0xF0, 0xF8, 0xF8, 0x0F, 0x07, 0xFF, 0x87, 0xC3, 0xE0, 0x3E, 0x0F, 0xFE,
  0x1F, 0x0F, 0x00, 0xF8, 0x1F, 0xE0, 0xF8, 0x3C, 0x03, 0xE0, 0x04, 0x03,
  0xE1, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x00, 0x0F, 0x81,
  0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x00, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x78, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xF8, 0x0F, 0xF7, 0xF0, 0x01, 0xF8, 0x1F, 0xE7, 0xF8, 0x01,
  0xF8, 0x3F, 0xC3, 0xF8, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x7F,
  0x00, 0xFE, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xE0, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0xFC, 0x00, 0x0F, 0xEF, 0xC0,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x7F,
  0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF,
  0xEF, 0xF0, 0x1F, 0xFF, 0xFF, 0x87, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFC,
  0x07, 0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFF, 0xFB, 0xF7, 0xEF, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0x78, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x40, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x7F, 0xFE, 0x78,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x7F,
  0x00, 0xF8, 0x07, 0x80, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x8F, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xE0, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3E, 0x7F, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x7E, 0x1C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC1,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3E, 0xFC,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xDF, 0x1F, 0xCF,
  0xBF, 0xC7, 0xFF, 0xC3, 0xEF, 0x81, 0xF3, 0x80, 0xF8, 0x80, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x04, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0x00, 0x7F, 0x83,
  0xC0, 0x01, 0xFC, 0x38, 0x00, 0x0F, 0xC1, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0xF8,
  0x7E, 0x00, 0x3F, 0xC3, 0x80, 0x01, 0xFC, 0x30, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x80, 0x00, 0x1F, 0xEF, 0x00, 0x03,
  0xFC, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x10, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xD0, 0x00,
  0x07, 0xF3, 0xC0, 0x03, 0xFE, 0x7F, 0x83, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xF1, 0xE0,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x1F, 0xE0, 0x07, 0xC3, 0xFF, 0xE0, 0x3E, 0x3F, 0xFF, 0x81, 0xF3, 0xFF,
  0xFE, 0x0F, 0xBF, 0xFF, 0xF8, 0x7F, 0xE0, 0x1F, 0xE7, 0xFE, 0x00, 0x7F,
  0x3F, 0xE0, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0x7C, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0x00, 0x7F, 0x07,
  0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F,
  0x8F, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xE1, 0xFF, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFC,
  0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xFC, 0xFF, 0x00,
  0x1F, 0xC3, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xB8, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFF,
  0x3F, 0x00, 0x1F, 0xF3, 0xFC, 0x03, 0xFF, 0x1F, 0xFF, 0xFD, 0xF0, 0xFF,
  0xFF, 0x9F, 0x07, 0xFF, 0xF3, 0xF0, 0x3F, 0xFE, 0x3F, 0x00, 0xFF, 0x83,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x18, 0x1F,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0x00, 0x06, 0x07, 0xE1, 0xFC, 0x7F, 0x3F, 0xCF,
  0xF1, 0xFC, 0x7F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1,
  0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xE0,
  0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7C, 0x01,
  0xFE, 0x20, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0xFF,
  0xE0, 0x3E, 0x1F, 0x00, 0x3F, 0xFF, 0xC0, 0x3C, 0x3E, 0x00, 0xFF, 0xFF,
  0x80, 0x7C, 0xF8, 0x03, 0xF8, 0x1F, 0x00, 0xF9, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF3, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xEF, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xDF, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xBE, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0xF8, 0x0F, 0x80, 0x0F, 0x80,
  0x3F, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x3E, 0x00,
  0xF7, 0x80, 0x7C, 0x00, 0x7C, 0x01, 0xEF, 0x00, 0xF8, 0x00, 0xF8, 0x03,
  0xDE, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xBC, 0x03, 0xE0, 0x07, 0xE0, 0x1F,
  0x78, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x79,
  0xF0, 0x0F, 0x80, 0x7F, 0x01, 0xF3, 0xE0, 0x1F, 0x00, 0xFE, 0x03, 0xE7,
  0xC0, 0x3F, 0x03, 0xDE, 0x0F, 0x8F, 0x80, 0x3F, 0xFF, 0x3F, 0xFE, 0x0F,
  0x00, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x3E,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x7E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF,
  0xE1, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0,
  0x03, 0xFF, 0x8F, 0xC0, 0x01, 0xFF, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x01, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x83, 0xF0, 0x0F, 0xFF, 0x0F, 0xC0, 0x01, 0xFE, 0x3F, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x3F, 0xCF, 0xC0, 0x03, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x3C, 0x07, 0xF8, 0x00, 0x0C,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1C,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x7F,
  0xFC, 0x0F, 0xC0, 0x01, 0xFF, 0x83, 0xF0, 0x00, 0x1F, 0xE0, 0xFC, 0x00,
  0x03, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x1F, 0xE3, 0xF0, 0x00,
  0x0F, 0xF0, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x07, 0xFC, 0x0F, 0xC0,
  0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x7F, 0xC0, 0x00, 0x18,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x3F,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x01, 0xFF, 0xFB, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFC, 0xE7, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x3F, 0x7F, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x7F,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xDF, 0xFB, 0xE0, 0x00, 0x00, 0x7D,
  0xFF, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0xFB, 0xF0, 0x00, 0x00, 0xF9, 0xFF,
  0x9F, 0x00, 0x00, 0x0F, 0x9F, 0xF9, 0xF8, 0x00, 0x01, 0xF9, 0xFF, 0x8F,
  0x80, 0x00, 0x1F, 0x1F, 0xF8, 0xF8, 0x00, 0x01, 0xF3, 0xFF, 0x8F, 0xC0,
  0x00, 0x3F, 0x3F, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xFF, 0x87, 0xC0, 0x00,
  0x3E, 0x3F, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xFF, 0x83, 0xE0, 0x00, 0x7C,
  0x3F, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xFF, 0x83, 0xF0, 0x00, 0xFC, 0x3F,
  0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xFF, 0x81, 0xF0, 0x00, 0xF8, 0x3F, 0xF8,
  0x1F, 0x80, 0x1F, 0x03, 0xFF, 0x80, 0xF8, 0x01, 0xF0, 0x3F, 0xF8, 0x0F,
  0x80, 0x1F, 0x03, 0xFF, 0x80, 0xFC, 0x03, 0xE0, 0x3F, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xFF, 0x80, 0x7E, 0x03, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x7C,
  0x03, 0xFF, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0xF8, 0x03, 0xF0, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0x9F, 0x80, 0x3F, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0x9F, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0x80, 0x00, 0x7F, 0xE7, 0xE0,
  0x00, 0x1F, 0xF9, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0x00, 0x01, 0xFF, 0x87,
  0xE0, 0x00, 0x7F, 0xE1, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0x00, 0x07, 0xFE,
  0x0F, 0xE0, 0x01, 0xFF, 0x81, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0x00, 0x1F,
  0xF8, 0x0F, 0xC0, 0x07, 0xFE, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x7E, 0x00,
  0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0x7E,
  0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x7F, 0xE0, 0x03, 0xF0, 0x1F, 0xF8, 0x00,
  0xFE, 0x07, 0xFE, 0x00, 0x1F, 0x81, 0xFF, 0x80, 0x03, 0xF0, 0x7F, 0xE0,
  0x00, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0x87, 0xFE, 0x00, 0x07, 0xF1, 0xFF,
  0x80, 0x00, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0x9F, 0xF8, 0x00, 0x07, 0xE7,
  0xFE, 0x00, 0x01, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x74, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0xF8,
  0xFC, 0x00, 0x7F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xCF,
  0xC0, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x7F, 0xF0, 0x3F, 0x00, 0x0F, 0xF0, 0x7E,
  0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF8, 0x3F, 0x00, 0x3F,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07,
  0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x3F,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xF8,
  0x03, 0xE1, 0xFC, 0x00, 0x0C, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00,
  0x1F, 0xBE, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x1F, 0x00,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xE0,
  0x3E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x03, 0xE0,
  0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x00, 0x7E,
  0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xC0,
  0x01, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x01,
  0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xF8, 0x3F, 0xE0, 0x70, 0x03,
  0xF8, 0x10, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x3F, 0xC0, 0x0F, 0xDF, 0xC0,
  0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFD, 0xF8, 0x01, 0xFF, 0x7F, 0x81,
  0xF7, 0xDF, 0xFF, 0xF9, 0xF3, 0xFF, 0xFC, 0x7C, 0x7F, 0xFE, 0x0F, 0x07,
  0xFF, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x06, 0x00,
  0x1F, 0x83, 0xFF, 0x00, 0xFC, 0x7F, 0xFE, 0x07, 0xE7, 0xFF, 0xF8, 0x3F,
  0x7F, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0x8F, 0xFC, 0x01, 0xFC, 0x7F, 0xC0,
  0x07, 0xF3, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xFE, 0x00, 0x0F, 0xCF, 0xF8, 0x00,
  0xFE, 0x7F, 0xE0, 0x0F, 0xF3, 0xFF, 0xC1, 0xFF, 0x1F, 0x3F, 0xFF, 0xF0,
  0xF8, 0xFF, 0xFF, 0x07, 0xC3, 0xFF, 0xF0, 0x3E, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFE, 0xFE, 0x1F, 0xE0, 0x04,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x02, 0x0F, 0xFC, 0x3E, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x18, 0x03, 0xE0, 0x1F, 0xFC, 0x1F, 0x01, 0xFF, 0xF8, 0xF8, 0x3F,
  0xFF, 0xE7, 0xC3, 0xFF, 0xFF, 0xBE, 0x1F, 0xE0, 0xFD, 0xF1, 0xFC, 0x01,
  0xFF, 0x9F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x7F,
  0x7F, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0xFB, 0xE1,
  0xFF, 0xFF, 0xDF, 0x07, 0xFF, 0xFC, 0xF8, 0x1F, 0xFF, 0xC7, 0xC0, 0x3F,
  0xF8, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x20, 0xFE, 0x00, 0x0E, 0x0F, 0xFC,
  0x0F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xC0,
  0x7F, 0xFC, 0x3E, 0x0F, 0xFF, 0xF9, 0xF0, 0x7F, 0xFF, 0xEF, 0x87, 0xFC,
  0x7F, 0x7C, 0x7F, 0x80, 0x7F, 0xE3, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07,
  0xF9, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x3F, 0x9F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x01, 0xFF,
  0x0F, 0xF0, 0x3E, 0xF8, 0x7F, 0xFF, 0xF7, 0xC1, 0xFF, 0xFF, 0x3E, 0x07,
  0xFF, 0xF1, 0xF0, 0x0F, 0xFE, 0x0F, 0x80, 0x07, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x60, 0x00, 0x3F, 0x83, 0xE0, 0x07, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x60, 0x07, 0xE0, 0xFF, 0xE0, 0xFC,
  0x7F, 0xFE, 0x1F, 0x9F, 0xFF, 0xE3, 0xF7, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F,
  0xEF, 0xFC, 0x01, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF,
  0xFF, 0x3F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0xFC,
  0x00, 0x3F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xFE, 0x00,
  0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x7F,
  0x00, 0x07, 0xEF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFE, 0xFE, 0x00, 0x7F, 0x8F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xE1, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xFC, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x03, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE,
  0x0F, 0x87, 0xFF, 0xC0, 0x7F, 0xFE, 0x3E, 0x3F, 0xFF, 0x83, 0xFF, 0xFC,
  0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF, 0xE3, 0xFE, 0xFE, 0x3F, 0xEF,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xBF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x01,
  0xC0, 0x1F, 0x03, 0xFF, 0x83, 0xE1, 0xFF, 0xF8, 0x7C, 0x7F, 0xFF, 0xCF,
  0x9F, 0xFF, 0xF9, 0xFF, 0xF0, 0xFF, 0xBF, 0xF0, 0x07, 0xF7, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xE1,
  0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E,
  0x3F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0xFF, 0xC0, 0x3E, 0x1F, 0xFF,
  0x81, 0xF1, 0xFF, 0xFE, 0x0F, 0x9F, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xE3,
  0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0x7F,
  0x80, 0x03, 0xF3, 0xFE, 0x00, 0x3F, 0x9F, 0xF8, 0x03, 0xF8, 0xFF, 0xF0,
  0x7F, 0xC7, 0xEF, 0xFF, 0xFC, 0x3F, 0x3F, 0xFF, 0xC1, 0xF8, 0xFF, 0xFC,
  0x0F, 0xC3, 0xFF, 0x80, 0x7E, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xC0, 0x7F,
  0xFC, 0x3E, 0x0F, 0xFF, 0xF9, 0xF0, 0x7F, 0xFF, 0xEF, 0x87, 0xF8, 0x3F,
  0x7C, 0x7F, 0x00, 0x7F, 0xE3, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF9,
  0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F,
  0x9F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x01, 0xFF, 0x0F,
  0xF0, 0x3E, 0xF8, 0x7F, 0xFF, 0xF7, 0xC1, 0xFF, 0xFF, 0x3E, 0x07, 0xFF,
  0xE1, 0xF0, 0x0F, 0xFE, 0x0F, 0x80, 0x07, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x9F, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xF0,
  0x3F, 0x1F, 0x80, 0x0E, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x70, 0x00, 0x7E, 0xFE, 0x07, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC1, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xF0, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0xFC,
  0x00, 0x3F, 0xDF, 0xC0, 0x1F, 0xFB, 0xFE, 0x0F, 0xDF, 0x3F, 0xFF, 0xFB,
  0xE3, 0xFF, 0xFE, 0x7C, 0x3F, 0xFF, 0x8F, 0x81, 0xFF, 0xC0, 0xF0, 0x03,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0xFC, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xE7, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3E,
  0xF8, 0x01, 0xF0, 0x7E, 0x00, 0xF9, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF3,
  0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xC7,
  0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x1F,
  0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x3E,
  0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0xF8,
  0x3F, 0x00, 0x3E, 0x0F, 0x81, 0xF8, 0x7E, 0x00, 0x7C, 0x3F, 0x01, 0xF0,
  0xF8, 0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0xF8, 0x07, 0xC7,
  0xE0, 0x01, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x0F, 0xDF, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x3F, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x09, 0xFF,
  0xE0, 0x00, 0xDF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xD0, 0x00, 0x3F, 0xF8,
  0x80, 0x00, 0x0F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 8, 49, 17, 5, -48 },
  { 50, 18, 17, 27, 4, -48 },
  { 89, 35, 48, 39, 2, -48 },
  { 299, 27, 55, 35, 4, -51 },
  { 485, 46, 50, 52, 3, -49 },
  { 773, 40, 50, 43, 3, -49 },
  { 1023, 7, 17, 15, 4, -48 },
  { 1038, 15, 59, 20, 3, -48 },
  { 1149, 15, 59, 20, 2, -48 },
  { 1260, 27, 27, 33, 3, -51 },
  { 1352, 29, 32, 35, 3, -40 },
  { 1468, 9, 17, 17, 3, -8 },
  { 1488, 16, 6, 20, 2, -21 },
  { 1500, 8, 9, 17, 4, -8 },
  { 1509, 23, 48, 25, 1, -48 },
  { 1647, 29, 50, 35, 3, -49 },
  { 1829, 17, 48, 35, 5, -48 },
  { 1931, 28, 49, 35, 3, -49 },
  { 2103, 28, 50, 35, 3, -49 },
  { 2278, 33, 48, 35, 1, -48 },
  { 2476, 27, 49, 35, 4, -48 },
  { 2642, 29, 50, 35, 3, -49 },
  { 2824, 29, 48, 35, 3, -48 },
  { 2998, 29, 50, 35, 3, -49 },
  { 3180, 28, 50, 35, 3, -49 },
  { 3355, 7, 38, 17, 5, -37 },
  { 3389, 10, 46, 17, 2, -37 },
  { 3447, 29, 32, 35, 3, -40 },
  { 3563, 29, 19, 35, 3, -33 },
  { 3632, 29, 32, 35, 3, -40 },
  { 3748, 24, 50, 26, 1, -49 },
  { 3898, 47, 54, 54, 4, -48 },
  { 4216, 38, 48, 38, 0, -48 },
  { 4444, 30, 48, 39, 6, -48 },
  { 4624, 32, 50, 38, 4, -49 },
  { 4824, 34, 48, 44, 6, -48 },
  { 5028, 24, 48, 34, 6, -48 },
  { 5172, 24, 48, 31, 6, -48 },
  { 5316, 36, 50, 44, 4, -49 },
  { 5541, 33, 48, 45, 6, -48 },
  { 5739, 16, 48, 21, 3, -48 },
  { 5835, 16, 61, 17, -4, -48 },
  { 5957, 31, 48, 37, 6, -48 },
  { 6143, 24, 48, 31, 6, -48 },
  { 6287, 44, 48, 56, 6, -48 },
  { 6551, 34, 48, 46, 6, -48 },
  { 6755, 39, 50, 47, 4, -49 },
  { 6999, 28, 48, 37, 6, -48 },
  { 7167, 39, 60, 47, 4, -49 },
  { 7460, 31, 48, 38, 6, -48 },
  { 7646, 27, 50, 33, 3, -49 },
  { 7815, 31, 48, 33, 1, -48 },
  { 8001, 33, 49, 44, 5, -48 },
  { 8204, 36, 48, 36, 0, -48 },
  { 8420, 55, 48, 57, 1, -48 },
  { 8750, 34, 48, 35, 0, -48 },
  { 8954, 34, 48, 34, 0, -48 },
  { 9158, 29, 48, 33, 2, -48 },
  { 9332, 15, 59, 22, 5, -48 },
  { 9443, 23, 48, 25, 1, -48 },
  { 9581, 14, 59, 22, 2, -48 },
  { 9685, 31, 29, 35, 2, -48 },
  { 9798, 30, 4, 30, 0, 6 },
  { 9813, 13, 10, 18, 3, -51 },
  { 9830, 26, 38, 34, 3, -37 },
  { 9954, 29, 52, 37, 5, -51 },
  { 10143, 24, 38, 29, 3, -37 },
  { 10257, 29, 52, 37, 3, -51 },
  { 10446, 28, 38, 34, 3, -37 },
  { 10579, 22, 51, 21, 1, -51 },
  { 10720, 29, 53, 37, 3, -37 },
  { 10913, 27, 51, 37, 5, -51 },
  { 11086, 6, 49, 16, 5, -49 },
  { 11123, 14, 65, 16, -3, -49 },
  { 11237, 27, 51, 33, 5, -51 },
  { 11410, 6, 51, 16, 5, -51 },
  { 11449, 46, 37, 56, 5, -37 },
  { 11662, 27, 37, 37, 5, -37 },
  { 11787, 30, 38, 37, 3, -37 },
  { 11930, 29, 53, 37, 5, -37 },
  { 12123, 29, 53, 37, 3, -37 },
  { 12316, 19, 37, 25, 5, -37 },
  { 12404, 23, 38, 29, 3, -37 },
  { 12514, 19, 45, 22, 1, -44 },
  { 12621, 27, 37, 37, 5, -36 },
  { 12746, 31, 36, 31, 0, -36 },
  { 12886, 47, 36, 48, 1, -36 },
  { 13098, 30, 36, 32, 1, -36 },
  { 13233, 31, 52, 31, 0, -36 },
  { 13435, 23, 36, 27, 2, -36 },
  { 13539, 21, 59, 25, 2, -48 },
  { 13694, 5, 67, 33, 14, -51 },
  { 13736, 21, 59, 25, 2, -48 },
  { 13891, 29, 9, 35, 3, -28 },
};

const GFXfont NotoSans_SemiCondensed_Regular67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular67pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR67PT7B_H_
