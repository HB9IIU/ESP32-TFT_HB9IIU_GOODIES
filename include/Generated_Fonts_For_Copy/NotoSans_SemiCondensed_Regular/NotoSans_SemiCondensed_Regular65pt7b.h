#ifndef _NOTOSANS_SEMICONDENSED_REGULAR65PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular65pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x7E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x7E, 0x1C,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF,
  0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0x80,
  0xF9, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x78,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x1F, 0x00,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFE, 0x78, 0xFC, 0x7F,
  0x0F, 0x01, 0x8F, 0xC1, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80,
  0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0,
  0x78, 0x00, 0x7E, 0x0F, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0xFF, 0xBC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3C, 0xFF, 0x00, 0x07, 0x87, 0xF0, 0x00, 0xF0, 0x7E, 0x00, 0x1E,
  0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x1F, 0x80, 0x0F, 0x03, 0xF0,
  0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0xA0, 0x07, 0x83, 0xF7, 0x00, 0xF0,
  0xFC, 0xFE, 0x1E, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0x80, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0x0F, 0x80,
  0x78, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x07,
  0x80, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x0F, 0x00,
  0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x1E, 0x00, 0x00,
  0xF8, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x3C, 0x1F, 0xE0, 0x78,
  0x07, 0x87, 0xC3, 0xFF, 0x07, 0x80, 0xF8, 0x78, 0x7F, 0xF8, 0x7C, 0x0F,
  0x8F, 0x8F, 0xFF, 0xC7, 0xC1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3F, 0x1F,
  0x1F, 0x03, 0xE3, 0xFF, 0xE1, 0xF1, 0xF0, 0x3E, 0x1F, 0xFE, 0x3E, 0x1F,
  0x01, 0xE0, 0xFF, 0xC3, 0xE1, 0xE0, 0x1F, 0x03, 0xF0, 0x7C, 0x1E, 0x01,
  0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x00, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x00,
  0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x3E,
  0x03, 0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x00, 0x7C, 0x01,
  0xE0, 0x1F, 0x00, 0x07, 0x80, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0,
  0x1E, 0x00, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0x00, 0xFE, 0xFC, 0x00,
  0x3C, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7C,
  0x00, 0x01, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0x3F, 0xBF, 0x80, 0x0F,
  0xC1, 0xFC, 0x7F, 0x00, 0x3E, 0x0F, 0xE0, 0xFE, 0x00, 0xF8, 0x7F, 0x01,
  0xFC, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0x7C,
  0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0xFC, 0x00, 0x1F, 0xCF, 0xC3, 0xF0, 0x00,
  0x7F, 0x7E, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x3F, 0x00, 0x01, 0xFF, 0xC0,
  0xFC, 0x00, 0x03, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x0F, 0xFF, 0x81,
  0xFE, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0x1F, 0xFD, 0xFC, 0x07, 0xFF, 0xFF,
  0xE3, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xE0,
  0x3F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x03, 0xDF,
  0xC3, 0xC3, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x40, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7C,
  0x03, 0xE0, 0x07, 0x80, 0x78, 0x00, 0x30, 0x04, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x9F,
  0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x0F,
  0x87, 0xC3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1C, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x1C, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFE,
  0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x7E,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xBF, 0x7F, 0x1F,
  0xFF, 0x0F, 0xDF, 0x07, 0xE7, 0x03, 0xF1, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1,
  0xFF, 0x01, 0xFE, 0x1F, 0x00, 0x0F, 0xE1, 0xC0, 0x00, 0xFC, 0x10, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0x1F, 0x00, 0x0F, 0xE1, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x80, 0x00, 0x1F, 0xDC, 0x00, 0x07, 0xF3, 0xF8, 0x07, 0xFE, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xEF, 0xC0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0,
  0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0,
  0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xF0, 0x7F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFA, 0x00, 0x01, 0xFC, 0xE0, 0x00,
  0xFF, 0x3F, 0x80, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x0F, 0xF0, 0x07, 0xC3, 0xFF, 0xC0, 0x7C, 0xFF, 0xFE, 0x07, 0xDF,
  0xFF, 0xF0, 0xFD, 0xFD, 0xFF, 0x8F, 0xFC, 0x01, 0xFC, 0xFF, 0x80, 0x0F,
  0xCF, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3E, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x01, 0xFC,
  0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFC, 0x03, 0xF8, 0x3F,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x7C, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x80,
  0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x9F, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x01, 0xF8, 0x07, 0xF8, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x7E,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xE7, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xFB,
  0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF9, 0xF8, 0x01, 0xFF, 0x3F,
  0xC0, 0x7F, 0xE3, 0xFF, 0xFF, 0x7C, 0x3F, 0xFF, 0xCF, 0x83, 0xFF, 0xF1,
  0xF0, 0x3F, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x40, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x7F, 0x7F, 0xFF,
  0xFF, 0x7F, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x1C, 0x1F, 0x87, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF1, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1E,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0x80, 0x7F,
  0x9C, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xFF, 0xFC,
  0x07, 0xC7, 0xC0, 0x1F, 0xFF, 0xE0, 0x3E, 0x7C, 0x01, 0xFF, 0xFF, 0x00,
  0xF3, 0xE0, 0x1F, 0xC0, 0xF8, 0x07, 0x9F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xFC,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0xE0, 0x3E, 0x00, 0x7C, 0x01, 0xFE, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xF0, 0x0F, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0xF8,
  0x00, 0xF8, 0x03, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0xE0, 0x3E, 0x00,
  0x3E, 0x01, 0xFF, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xF8, 0x0F, 0x80, 0x1F,
  0x80, 0x7F, 0xC0, 0x3C, 0x00, 0xFC, 0x03, 0xDE, 0x01, 0xF0, 0x07, 0xE0,
  0x1E, 0xF0, 0x0F, 0x80, 0x3F, 0x01, 0xF7, 0x80, 0x7C, 0x03, 0xF8, 0x0F,
  0x3E, 0x01, 0xF0, 0x3D, 0xC0, 0xF9, 0xF0, 0x0F, 0xE3, 0xEF, 0x9F, 0x8F,
  0x80, 0x3F, 0xFE, 0x7F, 0xFC, 0x3C, 0x00, 0xFF, 0xE1, 0xFF, 0xC1, 0xF0,
  0x03, 0xFE, 0x07, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0xFF, 0xFC, 0x7C, 0x00, 0x1F, 0xF3,
  0xE0, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x3F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x3F, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xE1, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0xC7, 0xC0, 0x00, 0xFF,
  0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0xDF,
  0x00, 0x01, 0xFC, 0xF8, 0x00, 0x3F, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0x01, 0xFE, 0x00, 0x06, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x30, 0x0F, 0xFF, 0x9F, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7D, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x01, 0xFF, 0x03, 0xE0, 0x00, 0x3F, 0xC1,
  0xF0, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x03, 0xFC, 0x7C, 0x00, 0x00, 0xFE,
  0x3E, 0x00, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0x3F, 0x8F,
  0x80, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x3F, 0xC1,
  0xF0, 0x00, 0x3F, 0xE0, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00,
  0x01, 0xC0, 0x7F, 0x80, 0x00, 0x08, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x3F, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0xFF, 0x80, 0x00, 0xFC, 0x0F,
  0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xDF,
  0xFF, 0xBF, 0xFE, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF8,
  0xF8, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x3E,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFE, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x1F,
  0x80, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00,
  0x03, 0xE1, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x00,
  0xF9, 0xFC, 0x00, 0x03, 0xEF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0x80, 0x03, 0xFC, 0x7E, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xE0, 0x03, 0xE0, 0x1F,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xFC,
  0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xE0, 0x3E, 0x00, 0x1F, 0xC0,
  0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFE, 0x0F, 0x80, 0x01, 0xF8, 0x3E,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x7F, 0x3E, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x07, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFB, 0xE0,
  0x00, 0x01, 0xF7, 0xFF, 0x7C, 0x00, 0x00, 0x3E, 0xFF, 0xEF, 0xC0, 0x00,
  0x07, 0xDF, 0xFC, 0xF8, 0x00, 0x01, 0xF3, 0xFF, 0x9F, 0x00, 0x00, 0x3E,
  0x7F, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0xFE, 0x3E, 0x00, 0x01, 0xF1, 0xFF,
  0xC7, 0xC0, 0x00, 0x3E, 0x3F, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xFF, 0x0F,
  0x80, 0x01, 0xF0, 0xFF, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0xFC, 0x1F, 0x00,
  0x07, 0xC3, 0xFF, 0x83, 0xE0, 0x01, 0xF0, 0x7F, 0xF0, 0x7E, 0x00, 0x3E,
  0x0F, 0xFE, 0x07, 0xC0, 0x07, 0xC1, 0xFF, 0xC0, 0xF8, 0x01, 0xF0, 0x3F,
  0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xFF, 0x01, 0xF0, 0x0F, 0xC0, 0xFF, 0xE0,
  0x3E, 0x01, 0xF0, 0x1F, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xFF, 0x80, 0x7C,
  0x0F, 0xC0, 0x7F, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x3E,
  0x01, 0xFF, 0xC0, 0x1F, 0x0F, 0x80, 0x3F, 0xF8, 0x03, 0xE1, 0xF0, 0x07,
  0xFF, 0x00, 0x7E, 0x3E, 0x00, 0xFF, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xFC,
  0x00, 0xF9, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xBE, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFD, 0xF8, 0x00, 0x07, 0xFE, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0x00, 0x01,
  0xFF, 0x8F, 0xC0, 0x00, 0xFF, 0xC7, 0xE0, 0x00, 0x7F, 0xE1, 0xF8, 0x00,
  0x3F, 0xF0, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0x00, 0x0F, 0xFC, 0x1F, 0xC0,
  0x07, 0xFE, 0x07, 0xE0, 0x03, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0xFC,
  0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x3F, 0xF0, 0x07,
  0xE0, 0x1F, 0xF8, 0x03, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x07, 0xFE, 0x00,
  0x7F, 0x03, 0xFF, 0x00, 0x1F, 0x81, 0xFF, 0x80, 0x07, 0xE0, 0xFF, 0xC0,
  0x03, 0xF0, 0x7F, 0xE0, 0x00, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0x1F, 0xF8,
  0x00, 0x1F, 0x8F, 0xFC, 0x00, 0x0F, 0xE7, 0xFE, 0x00, 0x03, 0xF3, 0xFF,
  0x00, 0x01, 0xFD, 0xFF, 0x80, 0x00, 0x7E, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF1, 0xF0, 0x01, 0xFF, 0x3E, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0xFE,
  0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x3F, 0x7C, 0x00, 0x0F, 0xEF, 0x80, 0x03, 0xF9, 0xF0, 0x00, 0xFF, 0x3E,
  0x00, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x5F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xFE, 0x0F, 0x80, 0x03, 0xF8, 0x3E,
  0x00, 0x07, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xFC, 0x3E, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x7F, 0x03, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x0F,
  0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xFC,
  0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xFC, 0x3E,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x7F, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xFB, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x00, 0xC3, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x80, 0x00, 0x3F, 0x9E, 0x00, 0x0F, 0xF3,
  0xFF, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xD0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xFE, 0x7F,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF7, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01,
  0xF7, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xCF, 0x80, 0x07, 0xE0, 0x7E,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC,
  0x07, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x87, 0xC0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0x07, 0xC0,
  0x3F, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x00,
  0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x0F,
  0xC0, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x07,
  0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x07,
  0xC3, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x7C,
  0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xE3, 0xE0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x01,
  0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xF0, 0x70, 0x01, 0xF8, 0x20, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xCF,
  0xFC, 0x03, 0xEF, 0xF0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07,
  0xFD, 0xFC, 0x07, 0xFE, 0xFF, 0xFF, 0xDF, 0x3F, 0xFF, 0xC7, 0x8F, 0xFF,
  0xC3, 0xC3, 0xFF, 0x81, 0xE0, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0xF0,
  0x0F, 0xC7, 0xFF, 0xC0, 0xF9, 0xFF, 0xFE, 0x0F, 0x9F, 0xFF, 0xF0, 0xFB,
  0xF0, 0xFF, 0x8F, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0xFC, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0xFF,
  0x00, 0x0F, 0xCF, 0xF8, 0x01, 0xFC, 0xFF, 0xE0, 0x7F, 0x8F, 0xBF, 0xFF,
  0xF0, 0xF9, 0xFF, 0xFE, 0x0F, 0x8F, 0xFF, 0xC0, 0xF0, 0x3F, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xCF, 0xC3, 0xFC, 0x01, 0x87, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0xC3, 0xFC, 0x0F, 0x87, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0xFF, 0xC1, 0xF0, 0x3F, 0xFF, 0x1F, 0x07, 0xFF, 0xF9, 0xF0, 0xFF,
  0xFF, 0xDF, 0x1F, 0xF0, 0x7F, 0xF1, 0xFC, 0x01, 0xFF, 0x3F, 0x80, 0x0F,
  0xF3, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x7F,
  0xF0, 0xFF, 0xFF, 0xDF, 0x07, 0xFF, 0xF9, 0xF0, 0x3F, 0xFF, 0x0F, 0x00,
  0xFF, 0xC0, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x3F,
  0x80, 0x7F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x04, 0x3F, 0x80, 0x03, 0x83,
  0xFE, 0x03, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFC, 0x08,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x80, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xF0,
  0x3F, 0xFF, 0x0F, 0x07, 0xFF, 0xF9, 0xF0, 0xFF, 0xFF, 0xDF, 0x1F, 0xF0,
  0xFF, 0xF1, 0xFC, 0x01, 0xFF, 0x3F, 0x80, 0x0F, 0xF3, 0xF0, 0x00, 0x7F,
  0x3F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xF1, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0xFF, 0xDF,
  0x07, 0xFF, 0xF9, 0xF0, 0x3F, 0xFF, 0x1F, 0x00, 0xFF, 0xC1, 0xF0, 0x01,
  0xC0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE2, 0x00, 0x00, 0xFE, 0x18, 0x00, 0x1F, 0xC1, 0xFC, 0x07,
  0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xFF, 0x83, 0xF1, 0xFF, 0xF0, 0xFD,
  0xFF, 0xFF, 0x3E, 0x7F, 0xFF, 0xCF, 0xBF, 0x0F, 0xFB, 0xFF, 0x00, 0x7E,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x7B,
  0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xE8, 0x3F, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F,
  0xFC, 0x03, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x80,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x00, 0xF9, 0xF8,
  0x00, 0x3E, 0x7F, 0x00, 0x0F, 0xBF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xCF, 0xC0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0x7F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF3,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x3F, 0xF0, 0x03,
  0xFF, 0x07, 0xC7, 0xFF, 0xE0, 0x7F, 0xFC, 0x3E, 0x7F, 0xFF, 0x87, 0xFF,
  0xF1, 0xF7, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xBF, 0x0F, 0xF7, 0xE1, 0xFF,
  0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFB, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xDF,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0xF8, 0x3F, 0xF8, 0x3E, 0x1F, 0xFF, 0x8F, 0x9F, 0xFF, 0xF3, 0xE7,
  0xFF, 0xFC, 0xFB, 0xF0, 0xFF, 0xBF, 0xE0, 0x07, 0xEF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x07,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7C, 0xFC,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x3F, 0xF0, 0x0F, 0x87, 0xFF,
  0xC0, 0xF9, 0xFF, 0xFE, 0x0F, 0x9F, 0xFF, 0xF0, 0xFB, 0xF0, 0xFF, 0x8F,
  0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xE0, 0x00,
  0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFC, 0xFF, 0x00, 0x0F, 0xCF,
  0xF8, 0x01, 0xFC, 0xFF, 0xE0, 0x7F, 0x8F, 0xBF, 0xFF, 0xF0, 0xF9, 0xFF,
  0xFE, 0x0F, 0xCF, 0xFF, 0xC0, 0xFC, 0x3F, 0xF8, 0x0F, 0xC0, 0x78, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xF0, 0x3F, 0xFF, 0x0F,
  0x07, 0xFF, 0xF9, 0xF0, 0xFF, 0xFF, 0xDF, 0x0F, 0xF0, 0x7F, 0xF1, 0xFC,
  0x01, 0xFF, 0x3F, 0x80, 0x0F, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7C,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF1, 0xFC,
  0x01, 0xFF, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0xFF, 0xDF, 0x07, 0xFF, 0xF9,
  0xF0, 0x3F, 0xFF, 0x1F, 0x00, 0xFF, 0xC1, 0xF0, 0x01, 0xC0, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFE, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x81,
  0xFB, 0xF8, 0x00, 0xCF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x7F,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xCF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x08, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0x00, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x1F,
  0xF7, 0xF8, 0x1F, 0xFC, 0xFF, 0xFF, 0xDF, 0x1F, 0xFF, 0xE7, 0xC3, 0xFF,
  0xF0, 0xF0, 0x7F, 0xF0, 0x3C, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x3E,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x87,
  0xC0, 0x0F, 0xBE, 0x00, 0x7C, 0x3E, 0x00, 0x7D, 0xF0, 0x07, 0xE1, 0xF8,
  0x03, 0xEF, 0x80, 0x3F, 0x0F, 0xC0, 0x3E, 0x7C, 0x01, 0xF0, 0x3E, 0x01,
  0xF1, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C,
  0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x01, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x83, 0xE0,
  0xFC, 0x03, 0xF0, 0xF8, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x80,
  0x1F, 0x9F, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0xFB, 0xF0, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x3E,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x7C, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3F,
  0x1F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x02, 0x07, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x13, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0xC0, 0x07, 0xFF, 0xC8, 0x00, 0x0F, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Regular65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 8, 47, 17, 4, -46 },
  { 48, 18, 16, 26, 4, -46 },
  { 84, 35, 46, 38, 1, -46 },
  { 286, 27, 53, 34, 4, -49 },
  { 465, 44, 48, 50, 3, -47 },
  { 729, 38, 48, 42, 3, -47 },
  { 957, 6, 16, 14, 4, -46 },
  { 969, 14, 57, 19, 3, -47 },
  { 1069, 14, 57, 19, 2, -47 },
  { 1169, 27, 26, 32, 3, -49 },
  { 1257, 28, 31, 34, 3, -38 },
  { 1366, 9, 15, 16, 3, -7 },
  { 1383, 15, 5, 20, 2, -20 },
  { 1393, 8, 9, 16, 4, -8 },
  { 1402, 22, 46, 24, 1, -46 },
  { 1529, 28, 48, 34, 3, -47 },
  { 1697, 17, 46, 34, 5, -46 },
  { 1795, 27, 47, 34, 3, -47 },
  { 1954, 27, 48, 34, 3, -47 },
  { 2116, 32, 47, 34, 1, -47 },
  { 2304, 26, 47, 34, 4, -46 },
  { 2457, 28, 48, 34, 3, -47 },
  { 2625, 28, 46, 34, 3, -46 },
  { 2786, 28, 48, 34, 3, -47 },
  { 2954, 27, 48, 34, 3, -47 },
  { 3116, 8, 36, 16, 4, -35 },
  { 3152, 10, 43, 16, 2, -35 },
  { 3206, 28, 31, 34, 3, -39 },
  { 3315, 28, 18, 34, 3, -32 },
  { 3378, 28, 31, 34, 3, -39 },
  { 3487, 23, 48, 25, 1, -47 },
  { 3625, 45, 53, 53, 4, -47 },
  { 3924, 37, 47, 37, 0, -47 },
  { 4142, 29, 46, 38, 6, -46 },
  { 4309, 31, 48, 37, 4, -47 },
  { 4495, 33, 46, 42, 6, -46 },
  { 4685, 23, 46, 33, 6, -46 },
  { 4818, 23, 46, 30, 6, -46 },
  { 4951, 35, 48, 43, 4, -47 },
  { 5161, 31, 46, 43, 6, -46 },
  { 5340, 16, 46, 21, 2, -46 },
  { 5432, 15, 58, 17, -4, -46 },
  { 5541, 30, 46, 36, 6, -46 },
  { 5714, 23, 46, 30, 6, -46 },
  { 5847, 43, 46, 54, 6, -46 },
  { 6095, 33, 46, 45, 6, -46 },
  { 6285, 38, 48, 45, 4, -47 },
  { 6513, 27, 46, 35, 6, -46 },
  { 6669, 38, 58, 45, 4, -47 },
  { 6945, 30, 46, 37, 6, -46 },
  { 7118, 27, 48, 32, 3, -47 },
  { 7280, 30, 46, 32, 1, -46 },
  { 7453, 32, 47, 43, 5, -46 },
  { 7641, 35, 46, 35, 0, -46 },
  { 7843, 54, 46, 55, 1, -46 },
  { 8154, 33, 46, 34, 0, -46 },
  { 8344, 33, 46, 33, 0, -46 },
  { 8534, 28, 46, 32, 2, -46 },
  { 8695, 14, 57, 21, 5, -47 },
  { 8795, 22, 46, 24, 1, -46 },
  { 8922, 14, 57, 21, 2, -47 },
  { 9022, 30, 28, 34, 2, -47 },
  { 9127, 29, 4, 29, 0, 6 },
  { 9142, 12, 11, 18, 3, -50 },
  { 9159, 25, 36, 33, 3, -35 },
  { 9272, 28, 50, 36, 5, -49 },
  { 9447, 23, 36, 28, 3, -35 },
  { 9551, 28, 50, 36, 3, -49 },
  { 9726, 27, 36, 33, 3, -35 },
  { 9848, 21, 50, 20, 1, -50 },
  { 9980, 28, 51, 36, 3, -35 },
  { 10159, 26, 49, 36, 5, -49 },
  { 10319, 6, 48, 16, 5, -48 },
  { 10355, 14, 64, 16, -3, -48 },
  { 10467, 26, 49, 32, 5, -49 },
  { 10627, 6, 49, 16, 5, -49 },
  { 10664, 45, 35, 55, 5, -35 },
  { 10861, 26, 35, 36, 5, -35 },
  { 10975, 29, 36, 35, 3, -35 },
  { 11106, 28, 51, 36, 5, -35 },
  { 11285, 28, 51, 36, 3, -35 },
  { 11464, 18, 35, 24, 5, -35 },
  { 11543, 22, 36, 28, 3, -35 },
  { 11642, 19, 44, 21, 1, -43 },
  { 11747, 26, 36, 36, 5, -35 },
  { 11864, 30, 35, 30, 0, -35 },
  { 11996, 45, 35, 47, 1, -35 },
  { 12193, 29, 35, 31, 1, -35 },
  { 12320, 30, 51, 30, 0, -35 },
  { 12512, 22, 35, 27, 2, -35 },
  { 12609, 20, 56, 24, 2, -46 },
  { 12749, 5, 65, 32, 14, -49 },
  { 12790, 20, 56, 24, 2, -46 },
  { 12930, 28, 8, 34, 3, -27 },
};

const GFXfont NotoSans_SemiCondensed_Regular65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular65pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR65PT7B_H_
