#ifndef _NOTOSANS_SEMICONDENSED_REGULAR39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x66, 0x66, 0x66, 0x66, 0x00,
  0x06, 0xFF, 0xFF, 0xF1, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC,
  0x3B, 0x87, 0x70, 0xCC, 0x18, 0x01, 0xC1, 0xC0, 0x0E, 0x0C, 0x00, 0x70,
  0x60, 0x03, 0x83, 0x00, 0x18, 0x38, 0x00, 0xC1, 0xC0, 0x0E, 0x0E, 0x00,
  0x70, 0x60, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x06, 0x0E,
  0x00, 0x70, 0x70, 0x03, 0x83, 0x00, 0x1C, 0x18, 0x00, 0xE1, 0xC0, 0x06,
  0x0E, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0xE0, 0xC0,
  0x07, 0x0E, 0x00, 0x30, 0x70, 0x01, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0,
  0xC0, 0x07, 0x06, 0x00, 0x38, 0x70, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x0F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFE, 0x71, 0x82, 0xF1,
  0x80, 0xE1, 0x80, 0xE1, 0x80, 0xF1, 0x80, 0xF1, 0x80, 0x7D, 0x80, 0x3F,
  0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0x9F, 0x01, 0x8F, 0x01,
  0x87, 0x01, 0x87, 0x01, 0x87, 0x01, 0x87, 0xE1, 0x9E, 0xFF, 0xFE, 0xFF,
  0xFC, 0x3F, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3F,
  0x00, 0x38, 0x1F, 0xE0, 0x0C, 0x07, 0x38, 0x07, 0x03, 0x87, 0x01, 0x80,
  0xE1, 0xC0, 0xE0, 0x38, 0x70, 0x38, 0x0E, 0x0C, 0x1C, 0x03, 0x83, 0x07,
  0x00, 0xE0, 0xC3, 0x80, 0x38, 0x30, 0xE0, 0x0E, 0x0C, 0x70, 0x03, 0x87,
  0x1C, 0x78, 0xE1, 0xCE, 0x7F, 0x38, 0x73, 0x9D, 0xE7, 0x39, 0xCE, 0x18,
  0xFE, 0x73, 0x87, 0x1F, 0x38, 0xE1, 0xC0, 0x0E, 0x30, 0x70, 0x07, 0x0C,
  0x1C, 0x01, 0xC3, 0x07, 0x00, 0xE0, 0xC1, 0xC0, 0x38, 0x30, 0x70, 0x0C,
  0x0E, 0x1C, 0x07, 0x03, 0x87, 0x01, 0x80, 0xE1, 0xC0, 0xE0, 0x1C, 0xE0,
  0x30, 0x07, 0xF8, 0x1C, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x7D, 0xF0, 0x01, 0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0x39,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8,
  0x0E, 0x1E, 0x78, 0x1C, 0x78, 0xF8, 0x39, 0xE0, 0xF8, 0xF3, 0xC0, 0xF1,
  0xC7, 0x00, 0xF7, 0x8E, 0x00, 0xFE, 0x1C, 0x00, 0xFC, 0x38, 0x00, 0xF0,
  0x78, 0x03, 0xF0, 0xF8, 0x1F, 0xF0, 0xFF, 0xFD, 0xF0, 0xFF, 0xF1, 0xF0,
  0xFF, 0x81, 0xF0, 0xF7, 0x77, 0x77, 0x77, 0x76, 0x07, 0x0E, 0x0E, 0x1C,
  0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x70, 0x78, 0x78,
  0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0,
  0xF0, 0x38, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83,
  0x81, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x78, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x83, 0x82, 0xFB, 0xBE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x06, 0xE0, 0x0E, 0xE0, 0x1E, 0x70, 0x3C,
  0x78, 0x3C, 0x3C, 0x18, 0x30, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7B, 0xDC,
  0xE7, 0x73, 0x9C, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x6F, 0xFF, 0xF0, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x0E,
  0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x78, 0x1E,
  0x3C, 0x1E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xC0, 0xF0, 0xFC,
  0x7F, 0x3D, 0xDE, 0x7F, 0x1D, 0x87, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x0F, 0xE0, 0x3F, 0xF8, 0xFF,
  0xFC, 0xF0, 0x3E, 0x40, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0x40,
  0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x7C, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0xF8, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x1E, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x06, 0xE0, 0x01,
  0xDC, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1C,
  0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0,
  0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0xC0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8,
  0x7F, 0xE0, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xE0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x10, 0x1C, 0x7F, 0x0E, 0xFF, 0xC7, 0x71, 0xF3, 0xE0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x73, 0x80,
  0x39, 0xC0, 0x1C, 0xF0, 0x1E, 0x3C, 0x1E, 0x1F, 0xFF, 0x07, 0xFF, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x03, 0xC7, 0x00,
  0xF3, 0x80, 0x7B, 0xC0, 0x3C, 0xE0, 0x1E, 0x70, 0x0E, 0x3C, 0x0F, 0x0F,
  0x0F, 0x03, 0xCF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x7C, 0xF8,
  0x78, 0x1E, 0x38, 0x07, 0xBC, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1D, 0xE0, 0x0E, 0xF0, 0x0F, 0x3F, 0x3F, 0x0F, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x3C, 0x70, 0x1E,
  0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0x70, 0x1F, 0x7C, 0x3F, 0x3F, 0xF7, 0x1F, 0xE7,
  0x03, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x78, 0x37, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFF, 0xF0, 0x3C, 0xF3, 0xCF,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCE,
  0x79, 0xE7, 0x1C, 0x63, 0x80, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xE3, 0xFF,
  0xC7, 0xFF, 0x98, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0xF0, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x0E, 0x38, 0x1F, 0xF0, 0xEE, 0x07, 0xFE, 0x1D, 0xC1, 0xE1, 0xC3, 0xB8,
  0x70, 0x38, 0x36, 0x0E, 0x07, 0x07, 0xC1, 0xC0, 0xE0, 0xF8, 0x70, 0x1C,
  0x1F, 0x0E, 0x03, 0x03, 0xE1, 0xC0, 0xE0, 0x7C, 0x38, 0x1C, 0x1F, 0x87,
  0x03, 0x83, 0xF0, 0x70, 0x70, 0x7E, 0x0E, 0x1B, 0x1C, 0xC1, 0xFF, 0x7F,
  0x1C, 0x1F, 0xC7, 0xE3, 0x80, 0x60, 0x70, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x80, 0x04, 0x00, 0xFC, 0x07, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xB8, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCF, 0x00, 0x0E, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0xE1, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x3C,
  0x03, 0xC0, 0x70, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0x00, 0x38, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0x80, 0x07, 0x1E, 0x00,
  0x1E, 0x78, 0x00, 0x79, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xC0, 0x7C, 0xF0, 0x07, 0xBC,
  0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x01, 0xEF, 0x00,
  0x73, 0xC0, 0x7C, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xC0, 0x3E,
  0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1E, 0xF0, 0x0F, 0xBF, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xC0,
  0x61, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x41, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0x01, 0xF8, 0xF0, 0x07, 0xCF, 0x00,
  0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x1F,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0x00, 0xE1, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xDC, 0x00, 0x0E,
  0xF0, 0x00, 0x77, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xF0, 0x00, 0xE3, 0xC0,
  0x07, 0x1F, 0x80, 0x38, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x70, 0xFF, 0xFF, 0xF3, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0xCF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0xFF, 0xBF,
  0xCF, 0xE0, 0xF0, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x8F,
  0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x1E,
  0x3C, 0x03, 0xC7, 0x00, 0x79, 0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xEF, 0x00, 0xF9, 0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x78,
  0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0x78, 0xF0,
  0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xEE,
  0x00, 0x0F, 0xFB, 0x80, 0x07, 0x7E, 0xF0, 0x01, 0xDF, 0xDC, 0x00, 0x77,
  0xF7, 0x00, 0x39, 0xFD, 0xE0, 0x0E, 0x7F, 0x38, 0x03, 0x9F, 0xCE, 0x01,
  0xC7, 0xF3, 0xC0, 0x71, 0xFC, 0x70, 0x1C, 0x7F, 0x1C, 0x0E, 0x1F, 0xC7,
  0x83, 0x87, 0xF0, 0xE0, 0xE1, 0xFC, 0x38, 0x70, 0x7F, 0x07, 0x1C, 0x1F,
  0xC1, 0xC7, 0x07, 0xF0, 0x73, 0x81, 0xFC, 0x0E, 0xE0, 0x7F, 0x03, 0xB8,
  0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0x01, 0xFC, 0x07, 0xC0, 0x7F, 0x01,
  0xE0, 0x1F, 0xC0, 0x38, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7E, 0xE0, 0x07, 0xEF, 0x00, 0x7E, 0x78,
  0x07, 0xF7, 0x80, 0x7F, 0x3C, 0x07, 0xF1, 0xC0, 0x7F, 0x1E, 0x07, 0xF0,
  0xE0, 0x7F, 0x0F, 0x07, 0xF0, 0x78, 0x7F, 0x07, 0x87, 0xF0, 0x3C, 0x7F,
  0x01, 0xC7, 0xF0, 0x1E, 0x7F, 0x00, 0xE7, 0xF0, 0x0F, 0x7F, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00,
  0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x8F, 0x00, 0x1E, 0x1F, 0x00, 0x3C,
  0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9E, 0x07, 0xCF, 0x00, 0xF7, 0x80,
  0x7B, 0xC0, 0x1D, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xDE,
  0x01, 0xEF, 0x00, 0xF7, 0x81, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xE0,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xF8, 0x0F, 0x83,
  0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xE7, 0x80, 0x03,
  0xCF, 0x00, 0x07, 0x8F, 0x00, 0x1E, 0x1F, 0x00, 0x3C, 0x1F, 0x01, 0xF0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3,
  0xC0, 0xF8, 0xF0, 0x0F, 0x3C, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x1E, 0xF0,
  0x07, 0xBC, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x3F,
  0x8F, 0xFF, 0x83, 0xFF, 0xC0, 0xF0, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0xF0, 0xF0, 0x1C, 0x3C, 0x07, 0x8F, 0x00, 0xE3, 0xC0, 0x3C, 0xF0,
  0x07, 0x3C, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0x0F, 0xF8, 0x1F, 0xFE,
  0x3F, 0xFE, 0x78, 0x0C, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0xC0, 0x3E, 0xFF, 0xFC,
  0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xDC, 0x00, 0x7B, 0xC0, 0x1E, 0x3C, 0x07, 0xC7, 0xFF,
  0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDC,
  0x00, 0x1C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x1C, 0x00, 0x70, 0xF0, 0x03,
  0x87, 0x80, 0x3C, 0x1C, 0x01, 0xE0, 0xE0, 0x0E, 0x07, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xE0, 0x38, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x00, 0xE0, 0xE0,
  0x07, 0x87, 0x00, 0x3C, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x3D,
  0xE0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0xB8, 0x01, 0xF0, 0x03, 0xDC, 0x00, 0xF8, 0x01, 0xCF, 0x00, 0x7C, 0x00,
  0xE7, 0x80, 0x3E, 0x00, 0xF1, 0xC0, 0x3B, 0x80, 0x78, 0xE0, 0x1D, 0xC0,
  0x38, 0x78, 0x0E, 0xE0, 0x1C, 0x3C, 0x07, 0x70, 0x1E, 0x0E, 0x07, 0x9C,
  0x0F, 0x07, 0x03, 0x8E, 0x07, 0x03, 0xC1, 0xC7, 0x03, 0x81, 0xE0, 0xE3,
  0xC3, 0xC0, 0x70, 0xF0, 0xE1, 0xE0, 0x38, 0x70, 0x70, 0xE0, 0x1C, 0x38,
  0x38, 0x70, 0x0F, 0x1C, 0x1E, 0x38, 0x03, 0x9E, 0x07, 0x3C, 0x01, 0xCE,
  0x03, 0x9C, 0x00, 0xE7, 0x01, 0xCE, 0x00, 0x7B, 0x80, 0xF7, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03,
  0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF3, 0x80, 0x1E, 0x3C, 0x01, 0xC1,
  0xC0, 0x3C, 0x1E, 0x03, 0x80, 0xE0, 0x78, 0x0F, 0x0F, 0x00, 0x70, 0xE0,
  0x07, 0x9E, 0x00, 0x39, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x39,
  0xC0, 0x07, 0x9E, 0x00, 0x70, 0xE0, 0x0F, 0x0F, 0x00, 0xE0, 0x70, 0x1E,
  0x07, 0x81, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0x80, 0x1E, 0x78, 0x01, 0xEF,
  0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x1E, 0x78, 0x01, 0xC3, 0x80, 0x3C,
  0x3C, 0x03, 0xC1, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x0E, 0x0F,
  0x00, 0xF0, 0xE0, 0x07, 0x1E, 0x00, 0x79, 0xC0, 0x03, 0xBC, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x38,
  0x70, 0x0E, 0x1C, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x38, 0x07,
  0x0E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1, 0xE1, 0xE1, 0xC1, 0xC1, 0xC0, 0x0F,
  0xF0, 0x7F, 0xF0, 0xFB, 0xF0, 0x80, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0xFE, 0x3F, 0xFC, 0xFF, 0xFB, 0xC0, 0x7F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xE3, 0xBB, 0xFF,
  0x73, 0xF8, 0xE0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x71, 0xF8,
  0x3B, 0xFF, 0x1D, 0xFF, 0xCF, 0x81, 0xE7, 0xC0, 0x7B, 0xC0, 0x1D, 0xE0,
  0x0E, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0E, 0xF0, 0x07, 0x78, 0x07, 0xBE, 0x07,
  0x9F, 0xEF, 0xCE, 0xFF, 0xC7, 0x1F, 0xC0, 0x07, 0xFC, 0x7F, 0xE3, 0xFF,
  0x8F, 0x02, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xF0, 0x13, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x87, 0xF3, 0xC7, 0xFC, 0xE7, 0xFF, 0x77, 0x81, 0xFB,
  0xC0, 0x7D, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0x70,
  0x07, 0xBC, 0x07, 0xDE, 0x03, 0xE7, 0xEF, 0x71, 0xFF, 0x38, 0x7F, 0x1C,
  0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0x7C, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x02,
  0x3F, 0xBE, 0x1F, 0xFE, 0x07, 0xFC, 0x01, 0xF4, 0x0F, 0xE0, 0x7F, 0x83,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0xFF, 0xCF,
  0xFF, 0x3F, 0xFC, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x0F,
  0xE3, 0x8F, 0xF9, 0xCF, 0xFE, 0xEF, 0x83, 0xF7, 0x80, 0xFB, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1E, 0xE0, 0x0F, 0x78, 0x0F, 0xBC,
  0x07, 0xCF, 0xDE, 0xE3, 0xFE, 0x70, 0xFE, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x98, 0x03, 0xCF, 0xFF, 0xC7, 0xFF,
  0xC1, 0xFF, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xF8, 0xEF,
  0xFC, 0xEF, 0xFE, 0xF8, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x6F, 0xFE, 0x60, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x03, 0x03, 0xC1, 0xE0, 0xE0, 0x30,
  0x00, 0x00, 0x00, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xDB, 0xEF, 0xE7,
  0xE0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0,
  0x78, 0xE0, 0x70, 0xE0, 0xE0, 0xE1, 0xE0, 0xE3, 0xC0, 0xE7, 0x80, 0xE7,
  0x00, 0xEF, 0x00, 0xFF, 0x80, 0xFB, 0xC0, 0xF3, 0xC0, 0xE1, 0xE0, 0xE0,
  0xF0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE3, 0xF0, 0x7F, 0x1D, 0xFF, 0x9F, 0xF3, 0xBF, 0xF7, 0xFF, 0x7C,
  0x0F, 0xC1, 0xEF, 0x01, 0xF0, 0x1F, 0xE0, 0x1E, 0x03, 0xFC, 0x03, 0x80,
  0x3F, 0x80, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80,
  0x38, 0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01,
  0xF8, 0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01,
  0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0E,
  0xE3, 0xF8, 0xEF, 0xFC, 0xEF, 0xFE, 0xF8, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x87, 0x81, 0xE7, 0x80, 0x73, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1E, 0xE0, 0x0F, 0x78, 0x07, 0x1E, 0x07, 0x8F, 0xDF, 0x83, 0xFF,
  0x80, 0x7F, 0x80, 0xE3, 0xF8, 0x77, 0xFE, 0x3B, 0xFF, 0x9F, 0x03, 0xCF,
  0x00, 0xF7, 0x80, 0x3B, 0xC0, 0x1D, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1D, 0xE0,
  0x0E, 0xF0, 0x0F, 0x7C, 0x0F, 0x3F, 0xDF, 0x9D, 0xFF, 0x8E, 0x3F, 0x87,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xE3, 0x8F, 0xF9, 0xCF,
  0xFE, 0xEF, 0x03, 0xF7, 0x80, 0xFB, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1E, 0xE0, 0x0F, 0x78, 0x0F, 0xBC, 0x07, 0xCF, 0xDE, 0xE3,
  0xFE, 0xF0, 0xFE, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0xE3,
  0xFC, 0xFF, 0xBF, 0xFE, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0x1F, 0xE3, 0xFF, 0xFF, 0x7D, 0xE0, 0x2E, 0x00,
  0x70, 0x03, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x03, 0xFE, 0xFD, 0xFF,
  0xC7, 0xFC, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xFB,
  0x1F, 0xE1, 0xFC, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x3F, 0x7F, 0xF7, 0x3F, 0xE7, 0x1F, 0xC7, 0xF0, 0x03, 0xFC,
  0x00, 0xE7, 0x00, 0x39, 0xE0, 0x1E, 0x78, 0x07, 0x0E, 0x01, 0xC3, 0xC0,
  0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x80, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x3C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00,
  0xF7, 0x00, 0xF0, 0x0E, 0x70, 0x0F, 0x80, 0xE7, 0x81, 0xF8, 0x1E, 0x38,
  0x1F, 0x81, 0xE3, 0x81, 0xF8, 0x1C, 0x38, 0x39, 0xC1, 0xC3, 0xC3, 0x9C,
  0x3C, 0x1C, 0x39, 0xC3, 0xC1, 0xC3, 0x9C, 0x38, 0x1C, 0x70, 0xE3, 0x81,
  0xE7, 0x0E, 0x38, 0x0E, 0x70, 0xE7, 0x00, 0xE7, 0x0E, 0x70, 0x0E, 0xE0,
  0x77, 0x00, 0xEE, 0x07, 0x70, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xF0,
  0x07, 0x3C, 0x07, 0x9E, 0x07, 0x87, 0x83, 0x81, 0xC3, 0xC0, 0xF1, 0xC0,
  0x39, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x7B, 0x80, 0x39, 0xE0, 0x3C, 0x70, 0x3C, 0x3C, 0x1C,
  0x0F, 0x1E, 0x03, 0x8E, 0x01, 0xEF, 0x00, 0x78, 0xF0, 0x03, 0xDC, 0x00,
  0xE7, 0x00, 0x39, 0xE0, 0x1E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0xC0, 0xF0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x87, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0F,
  0x3C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x03, 0x7C, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x1F, 0x03, 0xF0, 0x7C, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x03, 0xE0, 0xFC, 0x0F, 0x80, 0xFE, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0,
  0x0F, 0xC0, 0xFE, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0x03, 0xF0, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x0F, 0xE0, 0xFC,
  0x0F, 0x00, 0x7F, 0x00, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xE8, 0x03,
  0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Regular39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 28, 10, 3, -28 },
  { 15, 11, 10, 15, 2, -28 },
  { 29, 21, 28, 23, 1, -28 },
  { 103, 16, 32, 20, 2, -30 },
  { 167, 26, 28, 30, 2, -28 },
  { 258, 23, 28, 25, 2, -28 },
  { 339, 4, 10, 9, 2, -28 },
  { 344, 8, 34, 12, 2, -28 },
  { 378, 9, 34, 12, 1, -28 },
  { 417, 16, 16, 19, 2, -30 },
  { 449, 17, 19, 20, 2, -23 },
  { 490, 5, 9, 10, 2, -4 },
  { 496, 9, 3, 12, 1, -12 },
  { 500, 4, 5, 10, 3, -5 },
  { 503, 14, 28, 15, 0, -28 },
  { 552, 16, 28, 20, 2, -28 },
  { 608, 10, 28, 20, 3, -28 },
  { 643, 16, 28, 20, 2, -28 },
  { 699, 16, 28, 20, 2, -28 },
  { 755, 19, 28, 20, 1, -28 },
  { 822, 16, 28, 20, 2, -28 },
  { 878, 17, 28, 20, 2, -28 },
  { 938, 17, 28, 20, 2, -28 },
  { 998, 17, 28, 20, 2, -28 },
  { 1058, 16, 28, 20, 2, -28 },
  { 1114, 4, 21, 10, 3, -21 },
  { 1125, 6, 26, 10, 1, -21 },
  { 1145, 17, 18, 20, 2, -23 },
  { 1184, 16, 11, 20, 2, -19 },
  { 1206, 17, 18, 20, 2, -23 },
  { 1245, 14, 28, 15, 0, -28 },
  { 1294, 27, 31, 32, 2, -28 },
  { 1399, 22, 28, 22, 0, -28 },
  { 1476, 18, 28, 23, 3, -28 },
  { 1539, 19, 28, 22, 2, -28 },
  { 1606, 20, 28, 25, 3, -28 },
  { 1676, 14, 28, 20, 3, -28 },
  { 1725, 14, 28, 18, 3, -28 },
  { 1774, 21, 28, 26, 2, -28 },
  { 1848, 19, 28, 26, 3, -28 },
  { 1915, 10, 28, 12, 1, -28 },
  { 1950, 10, 35, 10, -3, -28 },
  { 1994, 19, 28, 22, 3, -28 },
  { 2061, 14, 28, 18, 3, -28 },
  { 2110, 26, 28, 33, 3, -28 },
  { 2201, 20, 28, 27, 3, -28 },
  { 2271, 23, 28, 27, 2, -28 },
  { 2352, 17, 28, 21, 3, -28 },
  { 2412, 23, 35, 27, 2, -28 },
  { 2513, 18, 28, 22, 3, -28 },
  { 2576, 16, 28, 19, 2, -28 },
  { 2632, 19, 28, 19, 0, -28 },
  { 2699, 19, 28, 26, 3, -28 },
  { 2766, 21, 28, 21, 0, -28 },
  { 2840, 33, 28, 33, 0, -28 },
  { 2956, 20, 28, 20, 0, -28 },
  { 3026, 20, 28, 20, 0, -28 },
  { 3096, 17, 28, 19, 1, -28 },
  { 3156, 9, 34, 13, 3, -28 },
  { 3195, 14, 28, 15, 0, -28 },
  { 3244, 9, 34, 13, 1, -28 },
  { 3283, 18, 17, 20, 1, -28 },
  { 3322, 17, 3, 17, 0, 3 },
  { 3329, 7, 6, 11, 2, -30 },
  { 3335, 15, 21, 20, 2, -21 },
  { 3375, 17, 30, 22, 3, -30 },
  { 3439, 14, 21, 17, 2, -21 },
  { 3476, 17, 30, 22, 2, -30 },
  { 3540, 16, 21, 20, 2, -21 },
  { 3582, 14, 30, 12, 0, -30 },
  { 3635, 17, 30, 22, 2, -21 },
  { 3699, 16, 30, 22, 3, -30 },
  { 3759, 4, 29, 9, 3, -29 },
  { 3774, 9, 38, 9, -2, -29 },
  { 3817, 16, 30, 19, 3, -30 },
  { 3877, 3, 30, 9, 3, -30 },
  { 3889, 27, 21, 33, 3, -21 },
  { 3960, 16, 21, 22, 3, -21 },
  { 4002, 17, 21, 21, 2, -21 },
  { 4047, 17, 30, 22, 3, -21 },
  { 4111, 17, 30, 22, 2, -21 },
  { 4175, 11, 21, 15, 3, -21 },
  { 4204, 13, 21, 17, 2, -21 },
  { 4239, 11, 26, 13, 1, -26 },
  { 4275, 16, 21, 22, 3, -21 },
  { 4317, 18, 21, 18, 0, -21 },
  { 4365, 28, 21, 28, 0, -21 },
  { 4439, 17, 21, 18, 1, -21 },
  { 4484, 18, 30, 18, 0, -21 },
  { 4552, 14, 21, 16, 1, -21 },
  { 4589, 12, 34, 15, 1, -28 },
  { 4640, 3, 39, 19, 8, -30 },
  { 4655, 12, 34, 15, 1, -28 },
  { 4706, 17, 5, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_Regular39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR39PT7B_H_
