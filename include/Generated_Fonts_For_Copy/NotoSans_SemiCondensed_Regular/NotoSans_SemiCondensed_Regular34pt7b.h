#ifndef _NOTOSANS_SEMICONDENSED_REGULAR34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular34pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x76, 0x60, 0x00, 0x7F,
  0xF7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x1B, 0x0D, 0x86, 0xC3, 0x61, 0x80,
  0x03, 0x86, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x38, 0x03, 0x0E, 0x01,
  0xC3, 0x00, 0x70, 0xC1, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0x87, 0x00, 0x61,
  0x80, 0x38, 0x60, 0x0E, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x83, 0xFF, 0xFE,
  0xFF, 0xFF, 0x87, 0x0C, 0x01, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x70, 0x06,
  0x1C, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03,
  0xF8, 0x3F, 0xF9, 0xFF, 0xEE, 0x30, 0xB8, 0xC0, 0xE3, 0x03, 0x8C, 0x0E,
  0x30, 0x1E, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0x3C,
  0x0C, 0x70, 0x31, 0xC0, 0xC7, 0x83, 0x3F, 0xCF, 0xEF, 0xFF, 0x1F, 0xF0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xFC, 0x03,
  0x81, 0xFC, 0x06, 0x07, 0x18, 0x1C, 0x0C, 0x30, 0x30, 0x18, 0x70, 0xE0,
  0x30, 0xE1, 0x80, 0x61, 0xC7, 0x00, 0xC3, 0x8C, 0x01, 0x87, 0x38, 0x03,
  0x0E, 0x63, 0xC6, 0x19, 0xCF, 0xCE, 0x33, 0x39, 0xCF, 0xE6, 0x61, 0x9F,
  0x9C, 0xC3, 0x0C, 0x33, 0x86, 0x00, 0xE7, 0x0E, 0x01, 0x8E, 0x1C, 0x07,
  0x1C, 0x38, 0x0C, 0x38, 0x70, 0x38, 0x30, 0xC0, 0x60, 0x61, 0x81, 0xC0,
  0xE7, 0x03, 0x00, 0xFC, 0x0E, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x7F, 0x80,
  0x07, 0xFE, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0C, 0x0C, 0x00, 0x70,
  0xE0, 0x03, 0x87, 0x00, 0x1C, 0x78, 0x00, 0x77, 0x80, 0x03, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x70, 0xE3, 0x83, 0x8F, 0x0E,
  0x1C, 0x70, 0x79, 0xC3, 0x81, 0xEE, 0x3C, 0x07, 0xF0, 0xE0, 0x1F, 0x07,
  0x00, 0x78, 0x38, 0x0F, 0xE1, 0xF1, 0xF7, 0x07, 0xFF, 0x1C, 0x0F, 0xE0,
  0xF8, 0xFF, 0xFE, 0xDB, 0x60, 0x06, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x43, 0x05,
  0xEC, 0xFF, 0xFF, 0xC7, 0xF8, 0x07, 0xC0, 0x3B, 0x00, 0xEE, 0x07, 0x1C,
  0x3C, 0x78, 0x20, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x39, 0xCE,
  0xE7, 0x39, 0x9C, 0xFF, 0xFF, 0x7F, 0xF7, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x00, 0x7F, 0x83, 0xFF,
  0x1E, 0x1C, 0x70, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0E, 0x70, 0x39, 0xC1, 0xE7, 0x8F, 0x0F,
  0xF8, 0x1F, 0xC0, 0x07, 0x0F, 0x1F, 0x7B, 0xF7, 0xE7, 0x47, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x01, 0x80, 0x3F, 0xE1, 0xFF, 0xE3, 0xC3, 0xC2, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0x00, 0x7F, 0xE3, 0xFF, 0xE3, 0x81, 0xE2, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x7F,
  0x00, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xF0, 0x03, 0xBC, 0x1F, 0x7F, 0xFC, 0x7F,
  0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xB8, 0x03,
  0xB8, 0x03, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x70, 0x38, 0x60, 0x38, 0xE0, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x7F, 0xF1, 0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x80, 0x7B, 0x83, 0xCF, 0xFE, 0x1F, 0xF0, 0x00, 0xE0, 0x1F, 0xC1, 0xFF,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x7E, 0x3B, 0xFC, 0xF8, 0x7B, 0xC0, 0xEE, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x70, 0x1D, 0xC0, 0xE3, 0xC7, 0x87,
  0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x03, 0x80, 0x1F, 0xE0, 0xFF, 0xE1, 0xC1, 0xE7, 0x01, 0xCE, 0x03, 0x9C,
  0x03, 0x38, 0x0E, 0x38, 0x1C, 0x78, 0x70, 0x79, 0xE0, 0x7F, 0x00, 0x7E,
  0x03, 0xFE, 0x0F, 0x1E, 0x3C, 0x0E, 0x70, 0x0E, 0xE0, 0x1F, 0x80, 0x3B,
  0x00, 0x77, 0x00, 0xEE, 0x03, 0xDF, 0x0F, 0x1F, 0xFC, 0x0F, 0xF0, 0x03,
  0x00, 0x7F, 0x03, 0xFE, 0x1C, 0x1C, 0xE0, 0x3B, 0x80, 0xEE, 0x01, 0xB0,
  0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xF0, 0x7D, 0xF7, 0xF3,
  0xFD, 0xC7, 0xC7, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0xC4, 0x3E, 0x1F, 0xF0, 0x7F, 0x00, 0x2F, 0xFF, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x70, 0x13, 0xDE, 0xF3, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x3B, 0xDC, 0xE7, 0x33, 0x80, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x38, 0x00,
  0x40, 0x00, 0x02, 0x07, 0xFC, 0xFF, 0xE6, 0x0F, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x0E, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0x80,
  0xF0, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x70, 0x1E,
  0x0E, 0x70, 0x7F, 0x86, 0x60, 0xE3, 0x86, 0xE1, 0xC3, 0x87, 0xE1, 0x83,
  0x87, 0xC3, 0x83, 0x87, 0xC3, 0x83, 0x87, 0xC3, 0x83, 0x87, 0xC3, 0x83,
  0x86, 0xC3, 0x83, 0x86, 0xC3, 0x87, 0x86, 0xE1, 0xC7, 0x8C, 0xE1, 0xFD,
  0xFC, 0x60, 0xF8, 0xF8, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x40, 0x0F, 0x83, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x1B,
  0x80, 0x07, 0x70, 0x00, 0xE6, 0x00, 0x18, 0xE0, 0x07, 0x1C, 0x00, 0xE1,
  0x80, 0x18, 0x38, 0x07, 0x07, 0x00, 0xE0, 0x60, 0x18, 0x0E, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1C, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0F, 0x3C, 0x00,
  0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xE1,
  0xFF, 0xF3, 0x81, 0xF7, 0x00, 0xEE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0E, 0xE0, 0x1D, 0xC0, 0x73, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0x9C, 0x03,
  0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xFF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF0, 0x00, 0x60, 0x07, 0xFF, 0x0F,
  0xFF, 0x1F, 0x06, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1F, 0x8E, 0x0F, 0xFE, 0x03, 0xFE, 0xFF, 0xE0, 0x7F,
  0xFC, 0x38, 0x3F, 0x1C, 0x03, 0xCE, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xB8,
  0x03, 0xDC, 0x01, 0xCE, 0x03, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x0E, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x1D, 0xE0, 0x07, 0x38, 0x01, 0xCF,
  0x00, 0x71, 0xF8, 0x3C, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xFF, 0xFF, 0x87, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE3, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x9E, 0xFE, 0xFC, 0x60, 0xE0, 0x0F,
  0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0x70, 0xE0, 0xE0, 0xE1, 0xC0,
  0xE3, 0xC0, 0xE3, 0x80, 0xE7, 0x00, 0xEE, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0xF3, 0x80, 0xE3, 0xC0, 0xE1, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0x70,
  0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x06,
  0xFD, 0x80, 0x1D, 0xFB, 0x80, 0x33, 0xF7, 0x00, 0xE7, 0xE6, 0x01, 0xCF,
  0xCE, 0x03, 0x1F, 0x9C, 0x0E, 0x3F, 0x18, 0x1C, 0x7E, 0x38, 0x30, 0xFC,
  0x70, 0xE1, 0xF8, 0x61, 0xC3, 0xF0, 0xE3, 0x07, 0xE1, 0xCE, 0x0F, 0xC1,
  0x9C, 0x1F, 0x83, 0xB0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F,
  0x01, 0xF8, 0x1E, 0x03, 0xF0, 0x1C, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0x70, 0x0F, 0xB8, 0x07, 0xCE, 0x03,
  0xE7, 0x01, 0xF1, 0xC0, 0xF8, 0xF0, 0x7C, 0x38, 0x3E, 0x1E, 0x1F, 0x07,
  0x0F, 0x81, 0xC7, 0xC0, 0xE3, 0xE0, 0x39, 0xF0, 0x1E, 0xF8, 0x07, 0x7C,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0x00, 0x60,
  0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xE0, 0xF8, 0x3C, 0x03, 0xC7, 0x80,
  0x1C, 0x70, 0x01, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xEF, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1E,
  0x78, 0x01, 0xC3, 0xC0, 0x3C, 0x1F, 0x9F, 0x80, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xC3, 0xFF, 0xCE, 0x1F, 0xB8, 0x0E, 0xE0, 0x3F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xB8, 0x3E, 0xFF, 0xF3,
  0xFF, 0x8F, 0xE0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0,
  0x1F, 0xFF, 0x03, 0xE0, 0xF8, 0x3C, 0x03, 0xC7, 0x80, 0x1C, 0x70, 0x01,
  0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xEF, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1E, 0x78, 0x01, 0xC3,
  0xC0, 0x3C, 0x1F, 0x9F, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xE1, 0xF8, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x78, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0,
  0x70, 0xE0, 0x78, 0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0,
  0x0F, 0x03, 0x00, 0xFF, 0xDF, 0xFE, 0xF0, 0x6E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x3F, 0xC7, 0xDF, 0xFC, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x0E,
  0x7E, 0x3E, 0x3F, 0xFC, 0x0F, 0xF0, 0xE0, 0x01, 0xDC, 0x00, 0x77, 0x00,
  0x3D, 0xC0, 0x0E, 0x78, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x1C,
  0x1C, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x38, 0x0E, 0x1C, 0x03,
  0x87, 0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x00, 0xCE, 0x00, 0x3B,
  0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0xF0, 0x07, 0x00, 0x7B, 0x80, 0x78, 0x03, 0x9C, 0x03, 0xE0, 0x1C, 0xE0,
  0x1F, 0x00, 0xE7, 0x80, 0xD8, 0x0F, 0x1C, 0x0E, 0xC0, 0x70, 0xE0, 0x77,
  0x03, 0x87, 0x03, 0xB8, 0x1C, 0x38, 0x18, 0xC0, 0xE0, 0xE1, 0xC6, 0x0E,
  0x07, 0x0E, 0x38, 0x70, 0x38, 0x71, 0xC3, 0x81, 0xC3, 0x06, 0x1C, 0x07,
  0x38, 0x39, 0xC0, 0x39, 0xC1, 0xCE, 0x01, 0xCE, 0x0E, 0x70, 0x0E, 0x60,
  0x33, 0x80, 0x37, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0x7C, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x78, 0x03, 0xC0, 0x70, 0x07, 0x9C, 0x03, 0x8E, 0x03, 0x83, 0x81, 0xC1,
  0xC1, 0xC0, 0x70, 0xE0, 0x3C, 0xE0, 0x0E, 0x70, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1D, 0xC0, 0x0E,
  0x70, 0x0E, 0x38, 0x07, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC3, 0x80, 0xF1,
  0xC0, 0x39, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03, 0x9C, 0x01,
  0xC7, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x1C, 0x70, 0x0E,
  0x38, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFD, 0xFF,
  0xF8, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xFF, 0xE0, 0xF0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0xFF, 0xFC, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xFF, 0xE0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xE0, 0x0E, 0x60, 0x0C, 0x70,
  0x1C, 0x30, 0x18, 0x38, 0x38, 0x1C, 0x30, 0x1C, 0x70, 0x0E, 0x60, 0x0E,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x01,
  0x00, 0x7F, 0xC3, 0xFF, 0x84, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x07, 0xFC, 0x7F, 0xF3, 0xC1, 0xDC, 0x07, 0x70, 0x1F, 0x80, 0x7F,
  0x03, 0xDC, 0x0F, 0x78, 0xFD, 0xFF, 0x71, 0xF9, 0xC0, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x40, 0xEF,
  0xE3, 0x7F, 0xCF, 0x87, 0xBC, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F,
  0x03, 0xBE, 0x1E, 0xDF, 0xF3, 0x3F, 0x80, 0x01, 0x81, 0xFF, 0x3F, 0xE7,
  0x82, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x7C, 0x23, 0xFE, 0x0F, 0xE0,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x87, 0x1F, 0xCC, 0xFF, 0xB7, 0x87, 0xDC, 0x0F, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x77, 0x03, 0xDE, 0x1F, 0x3F, 0xEC, 0x7F, 0x30, 0x02, 0x00,
  0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0x80, 0xEE, 0x01, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x3C, 0x18, 0xFF, 0xE0, 0xFF, 0x00, 0x03, 0xF0, 0x7E, 0x0F,
  0x60, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x7F, 0xCF, 0xFC, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x06,
  0x00, 0x7F, 0x33, 0xFE, 0xDE, 0x1F, 0x70, 0x3F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xDC, 0x0F, 0x78, 0x7C, 0xFF, 0xB1, 0xFD, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xD0, 0x0F, 0x78, 0xF9, 0xFF, 0xC3, 0xFC, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x20,
  0xEF, 0xE6, 0xFF, 0xBE, 0x1F, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xC0, 0x6F, 0xF6, 0x00, 0x07, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x0C, 0x3C, 0x78, 0x60, 0x00,
  0x00, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xAF, 0x7E, 0xF8,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x77, 0x07, 0x38, 0x79, 0xC7, 0x8E, 0x38, 0x73, 0x83, 0x38,
  0x1B, 0xC0, 0xDE, 0x07, 0xB8, 0x39, 0xE1, 0xC7, 0x0E, 0x3C, 0x70, 0xE3,
  0x83, 0x9C, 0x1E, 0xE0, 0x77, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x41, 0x9F, 0xC7, 0xF3, 0x7F,
  0xDF, 0xF7, 0xC3, 0xF0, 0xFF, 0x07, 0xC0, 0xFC, 0x07, 0x01, 0xF8, 0x0E,
  0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0xE0,
  0x3F, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x03,
  0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0xE0, 0x38,
  0x01, 0x06, 0x7F, 0x37, 0xFD, 0xF0, 0xFF, 0x03, 0xF0, 0x1F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x06, 0x03, 0x00, 0x3F, 0xC0, 0xFF,
  0xC3, 0xC1, 0xC7, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xBC, 0x07, 0x38,
  0x1E, 0x78, 0x78, 0x7F, 0xE0, 0x3F, 0x80, 0x01, 0x83, 0x3F, 0x8D, 0xFF,
  0x3E, 0x1E, 0xF0, 0x3B, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xFC, 0x0E, 0xF8,
  0x7B, 0x7F, 0xCE, 0xFE, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x7F, 0x33, 0xFE,
  0xDE, 0x1F, 0x70, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xDC, 0x0F, 0x78,
  0x7C, 0xFF, 0xB1, 0xFD, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xE7, 0xF7, 0xFB, 0x8F,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x00, 0x02, 0x01, 0xFF, 0x7F, 0xF7, 0x02, 0x60,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x07, 0x60, 0xF7, 0xFE, 0x7F, 0xC0, 0x18, 0x1C,
  0x0E, 0x07, 0x0F, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x81, 0xF8, 0x7C, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0x77,
  0x03, 0xDE, 0x1F, 0x3F, 0xEC, 0x7F, 0x30, 0xE0, 0x0F, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x18, 0x38, 0x1C,
  0x38, 0x1C, 0x70, 0x0C, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x06, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x70, 0x3C,
  0x07, 0x70, 0x3E, 0x06, 0x70, 0x3E, 0x0E, 0x30, 0x76, 0x0E, 0x38, 0x76,
  0x0E, 0x38, 0x67, 0x0C, 0x38, 0xE7, 0x1C, 0x18, 0xE3, 0x1C, 0x1C, 0xE3,
  0x1C, 0x1C, 0xC3, 0x98, 0x1D, 0xC3, 0xB8, 0x0D, 0xC1, 0xB8, 0x0D, 0xC1,
  0xB8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x00,
  0xF0, 0xF0, 0x1C, 0xE0, 0x70, 0xE1, 0xE1, 0xC3, 0x81, 0xCE, 0x03, 0x9C,
  0x03, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x01,
  0xCE, 0x07, 0x0E, 0x0E, 0x1C, 0x38, 0x1C, 0xF0, 0x3D, 0xC0, 0x3C, 0xE0,
  0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38,
  0x38, 0x1C, 0x38, 0x1C, 0x38, 0x0C, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x06,
  0x60, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x9E, 0x00, 0xFE,
  0x00, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xC1, 0xF0, 0x70, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x3F, 0x0E,
  0x03, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xF0, 0x1F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xF0, 0x0F, 0xC0, 0x78, 0x3F, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0xF0, 0x7E, 0x0F, 0x00,
  0x3E, 0x03, 0xFF, 0x8F, 0x8F, 0xFC, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Regular34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 24, 9, 2, -24 },
  { 13, 9, 9, 14, 2, -24 },
  { 24, 18, 24, 20, 1, -24 },
  { 78, 14, 28, 18, 2, -26 },
  { 127, 23, 25, 26, 2, -25 },
  { 199, 21, 25, 22, 1, -25 },
  { 265, 3, 9, 7, 2, -24 },
  { 269, 8, 29, 10, 1, -24 },
  { 298, 8, 29, 10, 1, -24 },
  { 327, 14, 14, 17, 1, -26 },
  { 352, 15, 16, 18, 1, -20 },
  { 382, 5, 8, 9, 1, -4 },
  { 387, 8, 2, 10, 1, -10 },
  { 389, 4, 4, 9, 2, -4 },
  { 391, 12, 24, 13, 0, -24 },
  { 427, 14, 25, 18, 2, -25 },
  { 471, 8, 24, 18, 3, -24 },
  { 495, 15, 25, 18, 1, -25 },
  { 542, 15, 25, 18, 1, -25 },
  { 589, 16, 24, 18, 1, -24 },
  { 637, 14, 24, 18, 2, -24 },
  { 679, 14, 25, 18, 2, -25 },
  { 723, 15, 24, 18, 1, -24 },
  { 768, 15, 25, 18, 1, -25 },
  { 815, 14, 25, 18, 2, -25 },
  { 859, 4, 19, 9, 2, -19 },
  { 869, 5, 23, 9, 1, -19 },
  { 884, 15, 16, 18, 1, -20 },
  { 914, 14, 10, 18, 2, -17 },
  { 932, 15, 16, 18, 1, -20 },
  { 962, 12, 25, 13, 0, -25 },
  { 1000, 24, 27, 27, 2, -24 },
  { 1081, 19, 24, 19, 0, -24 },
  { 1138, 15, 24, 20, 3, -24 },
  { 1183, 16, 25, 19, 2, -25 },
  { 1233, 17, 24, 22, 3, -24 },
  { 1284, 12, 24, 17, 3, -24 },
  { 1320, 12, 24, 16, 3, -24 },
  { 1356, 18, 25, 22, 2, -25 },
  { 1413, 17, 24, 23, 3, -24 },
  { 1464, 9, 24, 11, 1, -24 },
  { 1491, 8, 31, 9, -2, -24 },
  { 1522, 16, 24, 19, 3, -24 },
  { 1570, 12, 24, 16, 3, -24 },
  { 1606, 23, 24, 28, 3, -24 },
  { 1675, 17, 24, 23, 3, -24 },
  { 1726, 20, 25, 24, 2, -25 },
  { 1789, 14, 24, 19, 3, -24 },
  { 1831, 20, 31, 24, 2, -25 },
  { 1909, 16, 24, 19, 3, -24 },
  { 1957, 13, 25, 17, 2, -25 },
  { 1998, 16, 24, 17, 0, -24 },
  { 2046, 16, 24, 22, 3, -24 },
  { 2094, 18, 24, 18, 0, -24 },
  { 2148, 29, 24, 29, 0, -24 },
  { 2235, 17, 24, 18, 0, -24 },
  { 2286, 17, 24, 17, 0, -24 },
  { 2337, 15, 24, 17, 1, -24 },
  { 2382, 7, 29, 11, 3, -24 },
  { 2408, 12, 24, 13, 0, -24 },
  { 2444, 7, 29, 11, 1, -24 },
  { 2470, 16, 14, 18, 1, -24 },
  { 2498, 15, 2, 15, 0, 3 },
  { 2502, 7, 5, 9, 1, -26 },
  { 2507, 14, 19, 17, 1, -19 },
  { 2541, 14, 26, 19, 3, -26 },
  { 2587, 12, 19, 15, 2, -19 },
  { 2616, 14, 26, 19, 2, -26 },
  { 2662, 14, 19, 17, 2, -19 },
  { 2696, 12, 26, 11, 0, -26 },
  { 2735, 14, 27, 19, 2, -19 },
  { 2783, 13, 26, 19, 3, -26 },
  { 2826, 4, 25, 8, 2, -25 },
  { 2839, 7, 33, 8, -1, -25 },
  { 2868, 13, 26, 16, 3, -26 },
  { 2911, 3, 26, 8, 3, -26 },
  { 2921, 23, 19, 29, 3, -19 },
  { 2976, 13, 19, 19, 3, -19 },
  { 3007, 15, 19, 19, 2, -19 },
  { 3043, 14, 27, 19, 3, -19 },
  { 3091, 14, 27, 19, 2, -19 },
  { 3139, 9, 19, 13, 3, -19 },
  { 3161, 12, 19, 15, 1, -19 },
  { 3190, 9, 22, 11, 1, -22 },
  { 3215, 14, 18, 19, 2, -18 },
  { 3247, 16, 18, 16, 0, -18 },
  { 3283, 24, 18, 24, 0, -18 },
  { 3337, 15, 18, 16, 1, -18 },
  { 3371, 16, 26, 16, 0, -18 },
  { 3423, 12, 18, 14, 1, -18 },
  { 3450, 10, 29, 13, 1, -24 },
  { 3487, 3, 34, 17, 7, -26 },
  { 3500, 11, 29, 13, 1, -24 },
  { 3540, 15, 4, 18, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_Regular34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR34PT7B_H_
