#ifndef _NOTOSANS_SEMICONDENSED_REGULAR61PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular61pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFB, 0xF3, 0x80, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x78, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x78,
  0x0E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x3C, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x3C,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0xF1, 0xE0, 0xE1, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x07, 0x80,
  0x0F, 0x81, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x07,
  0x80, 0x07, 0xE1, 0xE0, 0x01, 0xFC, 0x78, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7B, 0xFC, 0x00, 0x1E,
  0x3F, 0x80, 0x07, 0x87, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x1F, 0x00,
  0x1E, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3E,
  0xC0, 0x1E, 0x1F, 0xBE, 0x07, 0x9F, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0x00, 0x03,
  0xC0, 0x07, 0xFF, 0x80, 0x03, 0xE0, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x7C,
  0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x3E, 0x00, 0x0F,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x1F, 0x00, 0x03, 0xC0, 0x3C,
  0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x07, 0x80,
  0x00, 0x78, 0x07, 0x87, 0xC0, 0xF0, 0x3C, 0x03, 0xC3, 0xC1, 0xFE, 0x1F,
  0x03, 0xE1, 0xE3, 0xFF, 0x87, 0x81, 0xF1, 0xF1, 0xFF, 0xE3, 0xC0, 0xF0,
  0xF1, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0xF0, 0x7C, 0x7F, 0xF8, 0x78, 0xF8,
  0x1E, 0x1F, 0xFC, 0x7C, 0x78, 0x0F, 0x0F, 0xFC, 0x3C, 0x3C, 0x07, 0xC1,
  0xF8, 0x3E, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0xF0, 0x00, 0x1F,
  0x07, 0x80, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x81, 0xE0,
  0x1E, 0x00, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x03, 0xE0,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x3E, 0x00,
  0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x40, 0xFF, 0xFC, 0x00,
  0xF8, 0x1F, 0x8F, 0xE0, 0x0F, 0x83, 0xF0, 0x7E, 0x00, 0xF8, 0x7E, 0x03,
  0xF0, 0x1F, 0x87, 0xE0, 0x1F, 0x81, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x0F,
  0xC0, 0x0F, 0xE3, 0xF0, 0xF8, 0x00, 0x7F, 0x3E, 0x0F, 0x80, 0x03, 0xFF,
  0xE0, 0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0xF8, 0x00,
  0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xFE, 0x07, 0xFC, 0x1F, 0xF7,
  0xF0, 0x3F, 0xFF, 0xFE, 0x3F, 0x81, 0xFF, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF,
  0xF0, 0x0F, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01,
  0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0x80, 0x78, 0x06, 0x7C, 0x1E,
  0x0F, 0x9F, 0xF7, 0xBF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87,
  0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x07, 0x80, 0x06,
  0x01, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F,
  0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x9C, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xF3, 0xFC, 0x07, 0xE0,
  0x3F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x1F,
  0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF1,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x07,
  0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x7C, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x9F, 0xDF,
  0x7F, 0x3F, 0xFC, 0x7F, 0xF0, 0xFB, 0xC1, 0xF2, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xEF, 0xFC,
  0x1F, 0x80, 0x3F, 0x87, 0x80, 0x07, 0xE0, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xE0,
  0x07, 0xF1, 0xC0, 0x01, 0xFC, 0x40, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFB, 0x00, 0x01, 0xFD, 0xF0, 0x03, 0xFC,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x20, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x80, 0x00, 0x7E, 0xC0, 0x01, 0xFC, 0xF8, 0x07,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0x06, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x0F, 0xF8, 0x0F, 0xCF, 0xFF, 0x83, 0xE7, 0xFF, 0xF0, 0xFB, 0xFF, 0xFE,
  0x3E, 0xF0, 0x1F, 0xCF, 0xF8, 0x03, 0xF3, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFC, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x3F,
  0x83, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x1F, 0xE1, 0xFE, 0x0F, 0xC0, 0x1F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xC3, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xC3, 0xFC, 0x0F, 0xE0, 0x3F,
  0x83, 0xF0, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x7C, 0x00, 0x1F, 0xBE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xFE, 0x01, 0xFC, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xE3, 0xFC, 0x0F, 0xC0, 0x3F, 0x87, 0xE0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x7C, 0x00, 0x1F, 0xDF,
  0x80, 0x0F, 0xF3, 0xF0, 0x0F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xEF,
  0x83, 0xFF, 0xF3, 0xE0, 0x7F, 0xF0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x80, 0x3F,
  0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x9C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x70,
  0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xF1, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3E, 0x1F, 0x1F, 0x8F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3C, 0x01, 0xFD, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xFE,
  0x00, 0x78, 0x3E, 0x00, 0xFF, 0xFC, 0x0F, 0x8F, 0x80, 0x3F, 0xFF, 0x80,
  0xF1, 0xF0, 0x0F, 0xFF, 0xF0, 0x1E, 0x3C, 0x03, 0xF0, 0x3E, 0x03, 0xEF,
  0x80, 0xFC, 0x07, 0xC0, 0x7D, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xBC, 0x07,
  0xC0, 0x1F, 0x00, 0xF7, 0x80, 0xF8, 0x03, 0xE0, 0x1E, 0xF0, 0x1F, 0x00,
  0x7C, 0x03, 0xFE, 0x03, 0xC0, 0x0F, 0x80, 0x7F, 0xC0, 0x78, 0x01, 0xF0,
  0x0F, 0xF8, 0x1F, 0x00, 0x3E, 0x01, 0xFF, 0x03, 0xE0, 0x07, 0xC0, 0x3F,
  0xE0, 0x7C, 0x00, 0xF0, 0x0F, 0xFC, 0x0F, 0x80, 0x1E, 0x01, 0xFF, 0x80,
  0xF0, 0x07, 0xC0, 0x3D, 0xF0, 0x1E, 0x00, 0xF8, 0x07, 0xBE, 0x03, 0xE0,
  0x1F, 0x01, 0xF3, 0xC0, 0x7C, 0x07, 0xF0, 0x3C, 0x78, 0x07, 0xC1, 0xEE,
  0x0F, 0x8F, 0x00, 0xFF, 0xF9, 0xFF, 0xE1, 0xF0, 0x0F, 0xFF, 0x3F, 0xF8,
  0x3E, 0x00, 0xFF, 0xC3, 0xFE, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x00, 0x7C, 0x78, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7C, 0x7E,
  0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xC0,
  0x0F, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xCF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0,
  0x03, 0xC0, 0x7F, 0x00, 0x01, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0x00, 0xFF, 0xC0, 0x7C, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xF4, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0x80, 0x3F, 0xF8, 0x3F, 0x00, 0x0F, 0xF8, 0x7E, 0x00, 0x07, 0xF8, 0xFC,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0xFF, 0x1F, 0x80, 0x03, 0xFC, 0x3F, 0x00, 0x1F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0xF0, 0x1F, 0xE0,
  0x00, 0x18, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0xF8, 0x00, 0x1F, 0xFF,
  0x7C, 0x00, 0x0F, 0xFF, 0xBE, 0x00, 0x07, 0xFF, 0xDF, 0x00, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00,
  0x7D, 0xF8, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xF8, 0x00,
  0x01, 0xF0, 0xFE, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x7C, 0x1F, 0xF0,
  0x00, 0x3E, 0x07, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x3F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x07, 0xF8, 0x3F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x0F,
  0x00, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xBF, 0x80, 0x07, 0xF8, 0xFC, 0x00, 0x3F,
  0x83, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xFC,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x0F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x1F, 0x80,
  0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF7, 0xC0, 0x00, 0x03, 0xDF, 0xFB,
  0xE0, 0x00, 0x03, 0xEF, 0xFD, 0xF0, 0x00, 0x01, 0xF7, 0xFE, 0x7C, 0x00,
  0x00, 0xF3, 0xFF, 0x3E, 0x00, 0x00, 0xF9, 0xFF, 0x9F, 0x00, 0x00, 0x7C,
  0xFF, 0xC7, 0xC0, 0x00, 0x7C, 0x7F, 0xE3, 0xE0, 0x00, 0x3E, 0x7F, 0xF1,
  0xF0, 0x00, 0x1F, 0x3F, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0xFC, 0x3E, 0x00,
  0x0F, 0x8F, 0xFE, 0x1F, 0x00, 0x07, 0x87, 0xFF, 0x07, 0xC0, 0x07, 0xC3,
  0xFF, 0x83, 0xE0, 0x03, 0xE1, 0xFF, 0xC1, 0xF0, 0x01, 0xE0, 0xFF, 0xE0,
  0x7C, 0x01, 0xF0, 0x7F, 0xF0, 0x3E, 0x00, 0xF8, 0x3F, 0xF8, 0x1F, 0x00,
  0x78, 0x1F, 0xFC, 0x07, 0xC0, 0x7C, 0x0F, 0xFE, 0x03, 0xE0, 0x3E, 0x07,
  0xFF, 0x01, 0xF0, 0x1E, 0x03, 0xFF, 0x80, 0x7C, 0x1F, 0x01, 0xFF, 0xC0,
  0x3E, 0x0F, 0x80, 0xFF, 0xE0, 0x1F, 0x07, 0x80, 0x7F, 0xF0, 0x07, 0xC7,
  0xC0, 0x3F, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0xFC, 0x00, 0xF9, 0xE0, 0x0F,
  0xFE, 0x00, 0x7D, 0xF0, 0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x03, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFB, 0xF0, 0x00, 0x1F, 0xF9, 0xF0, 0x00, 0x1F,
  0xF9, 0xF8, 0x00, 0x1F, 0xF8, 0xF8, 0x00, 0x1F, 0xF8, 0xFC, 0x00, 0x1F,
  0xF8, 0x7E, 0x00, 0x1F, 0xF8, 0x7E, 0x00, 0x1F, 0xF8, 0x3F, 0x00, 0x1F,
  0xF8, 0x3F, 0x00, 0x1F, 0xF8, 0x1F, 0x80, 0x1F, 0xF8, 0x0F, 0x80, 0x1F,
  0xF8, 0x0F, 0xC0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F,
  0xF8, 0x03, 0xF0, 0x1F, 0xF8, 0x03, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x1F,
  0xF8, 0x00, 0xF8, 0x1F, 0xF8, 0x00, 0xFC, 0x1F, 0xF8, 0x00, 0x7E, 0x1F,
  0xF8, 0x00, 0x7E, 0x1F, 0xF8, 0x00, 0x3F, 0x1F, 0xF8, 0x00, 0x3F, 0x1F,
  0xF8, 0x00, 0x1F, 0x9F, 0xF8, 0x00, 0x1F, 0x9F, 0xF8, 0x00, 0x0F, 0xDF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0xFF, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x00,
  0xFE, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFB, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x8F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0x3E, 0x7E, 0x00, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07,
  0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0xFF, 0xE8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x3F, 0xF0, 0xFC, 0x00,
  0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8,
  0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F,
  0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xE1, 0xFC, 0x00, 0xF1, 0xFC, 0x00, 0x10, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF4, 0x00, 0x01, 0xFB, 0x80, 0x03,
  0xF9, 0xFC, 0x07, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xFC, 0x0F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x03,
  0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x7C, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x3E,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xCF, 0x80, 0x0F,
  0x81, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x7C, 0x01,
  0xF8, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xC1, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x3E,
  0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x1F, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x0F, 0x87, 0xC0, 0x03, 0xF1, 0xF0, 0x03, 0xE3, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x01, 0xF7, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x7C, 0x00,
  0x03, 0xEF, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x07,
  0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xF9, 0xE0,
  0x00, 0x0F, 0x1F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x03,
  0xE0, 0x78, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x7C, 0x3C, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xF8, 0x1F, 0xC1, 0x80, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xC0, 0x7D, 0xFC, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x3D, 0xEF, 0xFF, 0xFB, 0xCF, 0xFF, 0xE7, 0x8F, 0xFF,
  0x8F, 0x0F, 0xFC, 0x1E, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x0F, 0xF0, 0x0F, 0x8F, 0xFF, 0x03, 0xE7, 0xFF, 0xE0, 0xFB,
  0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0x8F, 0xF0, 0x07, 0xF3, 0xF8, 0x00, 0xFC,
  0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0,
  0x01, 0xFB, 0xF8, 0x00, 0x7C, 0xFF, 0x00, 0x3F, 0x3F, 0xE0, 0x3F, 0x8F,
  0x7F, 0xFF, 0xE3, 0xCF, 0xFF, 0xF0, 0xF1, 0xFF, 0xF8, 0x3C, 0x1F, 0xF8,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0xF0, 0xF0, 0x7E, 0x00, 0x43, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x02, 0x1F, 0xE0, 0x38,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x58, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xC1, 0xF0,
  0x3F, 0xFC, 0x7C, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0xF7, 0xC7, 0xF8, 0x3F,
  0xF3, 0xF8, 0x03, 0xFC, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x7F,
  0x3F, 0x00, 0x3F, 0xC7, 0xF0, 0x1F, 0xF1, 0xFF, 0xFF, 0xBC, 0x3F, 0xFF,
  0xCF, 0x07, 0xFF, 0xE3, 0xC0, 0x7F, 0xE0, 0xF0, 0x01, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81,
  0xFC, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x3E,
  0x7E, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x21, 0xFE, 0x00, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0x02, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x87,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x03, 0xC0,
  0xFF, 0xF0, 0xF0, 0x7F, 0xFE, 0x3C, 0x3F, 0xFF, 0xCF, 0x1F, 0xE0, 0xFF,
  0xCF, 0xE0, 0x0F, 0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3, 0xF0, 0x01, 0xFC,
  0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x7F, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0x7C, 0x1F, 0xFF, 0x9F, 0x01, 0xFF, 0x87, 0xC0, 0x06, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x8C, 0x00, 0x0F,
  0xE3, 0xE0, 0x07, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC1, 0xFF, 0x03, 0xE3, 0xFF, 0xE1, 0xF3, 0xFF, 0xF8, 0xFB, 0xFF,
  0xFE, 0x7F, 0xE0, 0xFF, 0x3F, 0xC0, 0x1F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0,
  0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x39, 0xFF, 0xFF, 0xFD,
  0xF3, 0x80, 0x00, 0x00, 0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7C, 0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x1F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x03, 0xF0, 0x3F, 0x07, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x07, 0x80,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC,
  0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x7E, 0x00,
  0xF8, 0xFC, 0x00, 0xF9, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x7C, 0x00, 0xFE, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0,
  0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0,
  0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x3C, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0x1F, 0xFF,
  0x87, 0xFF, 0xE3, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xC1, 0xFD, 0xF0,
  0x7F, 0xBF, 0xC0, 0x3F, 0xF0, 0x07, 0xEF, 0xE0, 0x07, 0xF8, 0x00, 0xFB,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x3F, 0xE0, 0x78, 0x7F, 0xFC, 0x3C,
  0x7F, 0xFF, 0x1E, 0x7F, 0xFF, 0xCF, 0xFC, 0x1F, 0xE7, 0xF8, 0x03, 0xFB,
  0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F,
  0xBE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0x7E, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC1,
  0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x3F, 0xC0, 0x3C,
  0x3F, 0xFC, 0x0F, 0x1F, 0xFF, 0xC3, 0xCF, 0xFF, 0xF0, 0xFF, 0xC1, 0xFE,
  0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xE0, 0x03, 0xF3,
  0xFC, 0x00, 0xFC, 0xFF, 0x80, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xBF, 0xFF,
  0xC3, 0xE7, 0xFF, 0xE0, 0xF8, 0x7F, 0xE0, 0x3E, 0x01, 0xC0, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xC0,
  0xFF, 0xF0, 0xF0, 0x7F, 0xFE, 0x3C, 0x3F, 0xFF, 0xCF, 0x1F, 0xE0, 0xFF,
  0xCF, 0xE0, 0x0F, 0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3, 0xF0, 0x01, 0xFC,
  0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x7F, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0x7C, 0x1F, 0xFF, 0x1F, 0x01, 0xFF, 0x87, 0xC0, 0x06, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x3F, 0xF7, 0xFE, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xF0, 0x3E, 0x7E, 0x00, 0x33, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7D, 0x00, 0x07, 0xEF, 0x00, 0x7F, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x1C, 0x00, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xF8, 0x00,
  0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0,
  0x0F, 0xF3, 0xF8, 0x1F, 0xF9, 0xFF, 0xFF, 0xBC, 0x7F, 0xFF, 0x9E, 0x1F,
  0xFF, 0x8F, 0x07, 0xFF, 0x07, 0x80, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x00,
  0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x3E, 0x7C, 0x00, 0x7F, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0xE0, 0x03,
  0xE7, 0xC0, 0x0F, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x3E,
  0x00, 0xF3, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0xF0, 0x07, 0xC3, 0xE0, 0x1F,
  0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xCF, 0x80, 0xF8, 0x1F, 0x01, 0xE3, 0xE0,
  0x3E, 0x07, 0xC0, 0xF8, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x1F, 0x03, 0xE0,
  0x7E, 0x0F, 0x87, 0xC1, 0xF0, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x03, 0xE1,
  0xF0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0x3F, 0x1F, 0x03,
  0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x78, 0xF8, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x00, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x0F, 0x3C, 0x01, 0xF3, 0xC0, 0x03,
  0xEF, 0x00, 0x3D, 0xF0, 0x00, 0xFB, 0xC0, 0x0F, 0x7C, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x03,
  0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF9, 0xF8, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x01, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFE,
  0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xF8,
  0x00, 0x17, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFA, 0x00, 0x0F, 0xF8, 0x80, 0x00, 0x00,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 45, 16, 4, -44 },
  { 41, 16, 16, 24, 4, -44 },
  { 73, 33, 44, 35, 1, -44 },
  { 255, 26, 50, 32, 3, -46 },
  { 418, 41, 45, 47, 3, -44 },
  { 649, 36, 45, 39, 3, -44 },
  { 852, 6, 16, 13, 4, -44 },
  { 864, 13, 54, 18, 3, -44 },
  { 952, 13, 54, 18, 2, -44 },
  { 1040, 26, 24, 30, 2, -46 },
  { 1118, 26, 29, 32, 3, -36 },
  { 1213, 9, 15, 15, 2, -7 },
  { 1230, 14, 5, 19, 2, -19 },
  { 1239, 7, 8, 15, 4, -7 },
  { 1246, 21, 44, 23, 1, -44 },
  { 1362, 26, 45, 32, 3, -44 },
  { 1509, 15, 44, 32, 5, -44 },
  { 1592, 26, 44, 32, 3, -44 },
  { 1735, 25, 45, 32, 3, -44 },
  { 1876, 30, 44, 32, 1, -44 },
  { 2041, 24, 45, 32, 4, -44 },
  { 2176, 26, 45, 32, 3, -44 },
  { 2323, 27, 44, 32, 2, -44 },
  { 2472, 26, 45, 32, 3, -44 },
  { 2619, 26, 45, 32, 3, -44 },
  { 2766, 7, 34, 15, 4, -33 },
  { 2796, 9, 41, 15, 2, -33 },
  { 2843, 26, 29, 32, 3, -36 },
  { 2938, 26, 17, 32, 3, -30 },
  { 2994, 26, 29, 32, 3, -36 },
  { 3089, 21, 45, 24, 1, -44 },
  { 3208, 43, 49, 49, 3, -44 },
  { 3472, 35, 44, 35, 0, -44 },
  { 3665, 28, 44, 36, 5, -44 },
  { 3819, 30, 45, 34, 3, -44 },
  { 3988, 31, 44, 40, 5, -44 },
  { 4159, 22, 44, 31, 5, -44 },
  { 4280, 22, 44, 29, 5, -44 },
  { 4401, 33, 45, 40, 3, -44 },
  { 4587, 30, 44, 41, 5, -44 },
  { 4752, 15, 44, 19, 2, -44 },
  { 4835, 14, 56, 16, -4, -44 },
  { 4933, 29, 44, 34, 5, -44 },
  { 5093, 22, 44, 29, 5, -44 },
  { 5214, 41, 44, 51, 5, -44 },
  { 5440, 32, 44, 42, 5, -44 },
  { 5616, 36, 45, 42, 3, -44 },
  { 5819, 26, 44, 33, 5, -44 },
  { 5962, 36, 54, 42, 3, -44 },
  { 6205, 28, 44, 34, 5, -44 },
  { 6359, 25, 45, 30, 3, -44 },
  { 6500, 28, 44, 30, 1, -44 },
  { 6654, 30, 45, 40, 5, -44 },
  { 6823, 33, 44, 33, 0, -44 },
  { 7005, 50, 44, 52, 1, -44 },
  { 7280, 31, 44, 32, 0, -44 },
  { 7451, 31, 44, 31, 0, -44 },
  { 7622, 26, 44, 30, 2, -44 },
  { 7765, 13, 54, 20, 5, -44 },
  { 7853, 21, 44, 23, 1, -44 },
  { 7969, 13, 54, 20, 2, -44 },
  { 8057, 28, 26, 32, 2, -44 },
  { 8148, 27, 4, 27, 0, 5 },
  { 8162, 12, 10, 17, 2, -47 },
  { 8177, 23, 34, 31, 3, -33 },
  { 8275, 26, 47, 34, 5, -46 },
  { 8428, 22, 34, 26, 3, -33 },
  { 8522, 26, 47, 34, 3, -46 },
  { 8675, 25, 34, 31, 3, -33 },
  { 8782, 20, 47, 19, 1, -47 },
  { 8900, 26, 48, 34, 3, -33 },
  { 9056, 25, 46, 34, 5, -46 },
  { 9200, 6, 45, 15, 4, -45 },
  { 9234, 12, 60, 15, -2, -45 },
  { 9324, 24, 46, 30, 5, -46 },
  { 9462, 5, 46, 15, 5, -46 },
  { 9491, 42, 33, 51, 5, -33 },
  { 9665, 25, 33, 34, 5, -33 },
  { 9769, 27, 34, 33, 3, -33 },
  { 9884, 26, 48, 34, 5, -33 },
  { 10040, 26, 48, 34, 3, -33 },
  { 10196, 17, 33, 23, 5, -33 },
  { 10267, 21, 34, 26, 3, -33 },
  { 10357, 18, 41, 20, 1, -40 },
  { 10450, 25, 34, 34, 4, -33 },
  { 10557, 28, 33, 28, 0, -33 },
  { 10673, 42, 33, 44, 1, -33 },
  { 10847, 27, 33, 29, 1, -33 },
  { 10959, 28, 48, 28, 0, -33 },
  { 11127, 21, 33, 25, 2, -33 },
  { 11214, 19, 54, 23, 2, -44 },
  { 11343, 4, 61, 30, 13, -46 },
  { 11374, 19, 54, 23, 2, -44 },
  { 11503, 26, 9, 32, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_Regular61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular61pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR61PT7B_H_
