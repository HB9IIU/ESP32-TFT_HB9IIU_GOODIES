#ifndef _NOTOSANS_SEMICONDENSED_REGULAR64PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular64pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x1C,
  0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xEF,
  0x01, 0xF7, 0x80, 0xFB, 0xC0, 0x7D, 0xE0, 0x3C, 0xF0, 0x0E, 0x78, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x78,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x7C, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x1F, 0xC7, 0x03, 0xC7, 0xE0, 0xE0, 0x10, 0xF8, 0x1C, 0x00, 0x1F, 0x03,
  0x80, 0x07, 0xE0, 0x70, 0x00, 0xFC, 0x0E, 0x00, 0x1F, 0x81, 0xC0, 0x01,
  0xF0, 0x38, 0x00, 0x3F, 0x07, 0x00, 0x07, 0xF0, 0xE0, 0x00, 0x7F, 0x1C,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1D, 0xFF, 0x80, 0x03, 0x87, 0xF0, 0x00, 0x70, 0x7F, 0x00,
  0x0E, 0x07, 0xE0, 0x01, 0xC0, 0x7C, 0x00, 0x38, 0x0F, 0x80, 0x07, 0x01,
  0xF0, 0x00, 0xE0, 0x3E, 0x00, 0x1C, 0x0F, 0xE0, 0x03, 0x81, 0xF7, 0x00,
  0x70, 0x7E, 0xFE, 0x0E, 0x7F, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00,
  0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xC0,
  0x3E, 0x00, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x01, 0xF0,
  0x00, 0x3C, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0x83, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0x1E, 0x1F, 0x03, 0xF0, 0x7C, 0x07, 0xC3, 0xE1, 0xFF, 0x07, 0x80, 0xF8,
  0x78, 0x7F, 0xF0, 0xF0, 0x1E, 0x1F, 0x1F, 0xFF, 0x1F, 0x07, 0xC3, 0xC3,
  0xE3, 0xF1, 0xE0, 0xF8, 0xF8, 0xF8, 0x3E, 0x3F, 0xFE, 0x1E, 0x1E, 0x03,
  0xC3, 0xFF, 0xC7, 0xC3, 0xC0, 0x7C, 0x3F, 0xF0, 0xF0, 0xF8, 0x0F, 0x83,
  0xF8, 0x3E, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x1E, 0x00, 0x01,
  0xF0, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x81,
  0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80,
  0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x00, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x03,
  0xE0, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x7F, 0xF0,
  0x01, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xE0, 0x7F, 0x1F,
  0xC0, 0x1F, 0x83, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0xFE, 0x01, 0xF0,
  0x7E, 0x01, 0xFC, 0x07, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x0F, 0xC0, 0x07,
  0xF0, 0xF8, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0xFC, 0x00, 0x1F, 0xDF, 0x83,
  0xF0, 0x00, 0x3F, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x3F, 0x00, 0x01,
  0xFF, 0x80, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0x1F,
  0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x7F, 0x03, 0xFF, 0xFF, 0xF0, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0x80,
  0x0F, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x60, 0x0F, 0x00, 0x4F, 0x81, 0xE0, 0xF9, 0xFF, 0x3C,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x0F,
  0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x03, 0xC0, 0x3C,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xFC, 0x3E,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x18, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0x7E, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xBF, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x7C, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x1F, 0xC0, 0x3F, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0x1F, 0xDF, 0x3F, 0x9F, 0x7F, 0x1F, 0xFE, 0x1F, 0x7C,
  0x1F, 0x30, 0x1F, 0x10, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0x7F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0x00, 0x0F, 0xE1, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0x7F, 0xF0, 0xFC, 0x00, 0xFE, 0x1E, 0x00, 0x0F, 0xE1, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF4, 0x00, 0x00, 0xFC,
  0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x3F, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x07, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x40, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xFA, 0x00, 0x01, 0xFC, 0xE0, 0x00, 0xFE,
  0x3F, 0x01, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFC,
  0x70, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0xFF, 0xE0,
  0x3E, 0x3F, 0xFF, 0x07, 0xCF, 0xFF, 0xF1, 0xFB, 0xFF, 0xFF, 0x3F, 0xF8,
  0x0F, 0xE7, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0xC0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xA0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x7E, 0x01, 0xFC, 0x1F,
  0x80, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xC7, 0xF8,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x3F, 0xE0,
  0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0x0F,
  0xF9, 0xFC, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0xFC, 0x3F,
  0xFF, 0x9F, 0x81, 0xFF, 0xE3, 0xF0, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x02, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x7E,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x1C, 0x0F, 0x07,
  0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xF8, 0x7E, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xE1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0,
  0x78, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xE0, 0x07,
  0xF6, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0xFF, 0x00,
  0xF8, 0x7C, 0x00, 0xFF, 0xFE, 0x07, 0xC3, 0xC0, 0x1F, 0xFF, 0xF0, 0x1E,
  0x3E, 0x01, 0xFF, 0x7F, 0x80, 0xF9, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xCF,
  0x00, 0xF8, 0x03, 0xE0, 0x1E, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF7, 0xC0,
  0x7C, 0x00, 0xF0, 0x07, 0xBC, 0x03, 0xE0, 0x07, 0x80, 0x3D, 0xE0, 0x1E,
  0x00, 0x3C, 0x01, 0xEF, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x78, 0x0F, 0x80,
  0x1F, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0xF8, 0x03, 0xFE, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0xF0, 0x1F, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0xF8, 0x01, 0xF0,
  0x0F, 0xFC, 0x07, 0xC0, 0x0F, 0x80, 0x7D, 0xE0, 0x3E, 0x00, 0x7C, 0x03,
  0xCF, 0x00, 0xF0, 0x07, 0xE0, 0x1E, 0x78, 0x07, 0xC0, 0x3F, 0x01, 0xF3,
  0xC0, 0x3F, 0x03, 0xFC, 0x1F, 0x1F, 0x00, 0xFC, 0x3D, 0xF1, 0xF8, 0xF8,
  0x07, 0xFF, 0xE7, 0xFF, 0x87, 0xC0, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0x00,
  0x7F, 0xE0, 0xFF, 0x80, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xBF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0x80, 0x0F, 0xFC, 0xF8,
  0x00, 0x1F, 0xCF, 0x80, 0x00, 0xFE, 0xF8, 0x00, 0x0F, 0xEF, 0x80, 0x00,
  0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0x80, 0x03, 0xFC, 0xF8, 0x00, 0x0F,
  0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFE, 0xF8, 0x00,
  0x3F, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF0, 0x01, 0xE0, 0xFF, 0x00, 0x01, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x18, 0x1F, 0xFE, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x03, 0xFF, 0xC0, 0xF8, 0x00, 0x3F, 0xE0, 0xF8, 0x00, 0x0F, 0xF0,
  0xF8, 0x00, 0x07, 0xF8, 0xF8, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x01, 0xFC,
  0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x07, 0xF8,
  0xF8, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xC0,
  0x7F, 0x80, 0x00, 0x30, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x3F,
  0x07, 0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xDF, 0xFF, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE1,
  0xFF, 0x00, 0xF8, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x7E, 0x3E, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x7E,
  0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFE, 0x03,
  0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0xF8,
  0x07, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xEF, 0xF0, 0x00,
  0x0F, 0xBF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xF8,
  0x0F, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x7F, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0x80, 0x0F,
  0xC0, 0x3E, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0xFC,
  0x0F, 0x80, 0x03, 0xF8, 0x3E, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x3F, 0x8F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x03, 0xFB, 0xE0, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xDF, 0x00, 0x00,
  0x07, 0xDF, 0xFF, 0xE0, 0x00, 0x01, 0xF7, 0xFE, 0xF8, 0x00, 0x00, 0x7D,
  0xFF, 0xBE, 0x00, 0x00, 0x3E, 0x7F, 0xEF, 0xC0, 0x00, 0x0F, 0x9F, 0xF9,
  0xF0, 0x00, 0x03, 0xE7, 0xFE, 0x7C, 0x00, 0x01, 0xF1, 0xFF, 0x9F, 0x80,
  0x00, 0x7C, 0x7F, 0xE3, 0xE0, 0x00, 0x1F, 0x3F, 0xF8, 0xF8, 0x00, 0x0F,
  0x8F, 0xFE, 0x3F, 0x00, 0x03, 0xE3, 0xFF, 0x87, 0xC0, 0x00, 0xF8, 0xFF,
  0xE1, 0xF0, 0x00, 0x7C, 0x3F, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xFE, 0x0F,
  0x80, 0x0F, 0x83, 0xFF, 0x83, 0xE0, 0x03, 0xE0, 0xFF, 0xE0, 0x7C, 0x00,
  0xF8, 0x3F, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0xFE, 0x07, 0xC0, 0x1F, 0x03,
  0xFF, 0x80, 0xF8, 0x07, 0xC0, 0xFF, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xFE, 0x01, 0xF0, 0x3E, 0x03, 0xFF, 0x80, 0x7C,
  0x1F, 0x00, 0xFF, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0xF8, 0x03, 0xE1, 0xF0,
  0x0F, 0xFE, 0x00, 0xF8, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x3E, 0x00, 0xFF,
  0xE0, 0x07, 0xCF, 0x80, 0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0xFC, 0x00, 0x07, 0xFF, 0x7F, 0x00, 0x03, 0xFF,
  0x9F, 0x80, 0x01, 0xFF, 0xC7, 0xE0, 0x00, 0xFF, 0xE3, 0xF0, 0x00, 0x7F,
  0xF0, 0xFC, 0x00, 0x3F, 0xF8, 0x7E, 0x00, 0x1F, 0xFC, 0x1F, 0x80, 0x0F,
  0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0xFC, 0x01,
  0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xF0, 0x0F, 0xC0,
  0x3F, 0xF8, 0x03, 0xF0, 0x1F, 0xFC, 0x01, 0xFC, 0x0F, 0xFE, 0x00, 0x7E,
  0x07, 0xFF, 0x00, 0x3F, 0x83, 0xFF, 0x80, 0x0F, 0xC1, 0xFF, 0xC0, 0x03,
  0xF0, 0xFF, 0xE0, 0x01, 0xF8, 0x7F, 0xF0, 0x00, 0x7E, 0x3F, 0xF8, 0x00,
  0x3F, 0x1F, 0xFC, 0x00, 0x0F, 0xCF, 0xFE, 0x00, 0x07, 0xF3, 0xFF, 0x00,
  0x01, 0xF9, 0xFF, 0x80, 0x00, 0x7E, 0xFF, 0xC0, 0x00, 0x3F, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x05, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x3E, 0x00, 0xFF, 0xCF, 0x80, 0x07, 0xF3, 0xE0, 0x00, 0xFE,
  0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xBE, 0x00, 0x1F, 0xCF, 0x80, 0x1F,
  0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7C, 0x01,
  0xFF, 0x83, 0xE0, 0x01, 0xFE, 0x1F, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x7F, 0x83,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x7E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x7E, 0x1F, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7F,
  0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0x3F, 0x7C,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xF0, 0x07, 0xC7, 0xF0,
  0x00, 0x31, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFA, 0x00, 0x00,
  0xFE, 0xF0, 0x00, 0x7F, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xF0,
  0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF9, 0xF0, 0x00,
  0xFC, 0x0F, 0x80, 0x07, 0xCF, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x3E,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC1, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3E, 0x00,
  0xFC, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xE0,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE1,
  0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0,
  0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x1F, 0x7E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF0,
  0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0xC0,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x78, 0x03, 0xF8, 0x30, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0xFE, 0x07, 0xEF, 0xF0, 0x03, 0xF7,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFD, 0xFC, 0x0F, 0xBE, 0xFF, 0xFF,
  0xDF, 0x3F, 0xFF, 0xCF, 0x8F, 0xFF, 0xC7, 0xC3, 0xFF, 0x81, 0xE0, 0x1C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x87, 0xFF, 0x80, 0xF8, 0xFF,
  0xFC, 0x0F, 0x9F, 0xFF, 0xE0, 0xFB, 0xFF, 0xFF, 0x0F, 0xFC, 0x07, 0xF8,
  0xFF, 0x80, 0x1F, 0x8F, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFE, 0x00,
  0x07, 0xCF, 0xE0, 0x00, 0xFC, 0xFF, 0x00, 0x1F, 0xCF, 0xF8, 0x01, 0xF8,
  0xFF, 0xE0, 0x7F, 0x8F, 0xBF, 0xFF, 0xF0, 0xF9, 0xFF, 0xFE, 0x0F, 0x0F,
  0xFF, 0xC0, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFC, 0x03, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x87,
  0xFC, 0x0F, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x1F, 0xFE,
  0x3F, 0x03, 0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0x9F, 0x0F, 0xFF, 0xFD, 0xF1,
  0xFC, 0x03, 0xFF, 0x3F, 0x80, 0x1F, 0xF3, 0xF0, 0x00, 0xFF, 0x3F, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F,
  0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xF3,
  0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x7D, 0xF0, 0xFF, 0xFF, 0xDF, 0x07, 0xFF,
  0xF9, 0xF0, 0x3F, 0xFF, 0x1F, 0x00, 0xFF, 0xC1, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0x03, 0xFC, 0x03, 0xE0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xFE, 0x1F, 0x03, 0xFF, 0xF1, 0xF0, 0x7F, 0xFF,
  0x9F, 0x0F, 0xFF, 0xFD, 0xF1, 0xFE, 0x03, 0xFF, 0x3F, 0x80, 0x1F, 0xF3,
  0xF0, 0x00, 0xFF, 0x3F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x7F, 0x3F, 0x00, 0x0F, 0xF1, 0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x7D, 0xF0,
  0xFF, 0xFF, 0xDF, 0x07, 0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0x3F, 0x01, 0xFF,
  0xC3, 0xF0, 0x01, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE2, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0xFE, 0x03, 0xE1, 0xFF, 0xE0, 0xF8, 0xFF,
  0xFE, 0x3E, 0x7F, 0xFF, 0xCF, 0xBF, 0xFF, 0xF3, 0xFF, 0x00, 0xFE, 0xFF,
  0x80, 0x1F, 0xBF, 0xC0, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0x7B, 0xFF,
  0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x03, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x00, 0x78,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xFB, 0x1F, 0xEF, 0xFF, 0x3F, 0xFC, 0xFF, 0xE3, 0xFE, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0B,
  0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x1F,
  0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0x80,
  0xFC, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x0F,
  0x87, 0xE0, 0x03, 0xE3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7E, 0x00,
  0x0F, 0xBF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xCF,
  0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0xC0, 0x3E,
  0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0xC0, 0xF8, 0x03, 0xF0,
  0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0xF8, 0x00,
  0xFE, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0xFE, 0xF8,
  0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x0F, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFF, 0x8F, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFB, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFC, 0x07, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xEF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x0F, 0xE0, 0x3C, 0x1F, 0xFE, 0x0F, 0x8F, 0xFF, 0xE3, 0xE7, 0xFF, 0xFC,
  0xFB, 0xFF, 0xFF, 0x3F, 0xF0, 0x1F, 0xEF, 0xF8, 0x01, 0xFB, 0xFC, 0x00,
  0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x87, 0xFF, 0x80, 0xF8,
  0xFF, 0xFC, 0x0F, 0x9F, 0xFF, 0xE0, 0xFB, 0xFF, 0xFF, 0x0F, 0xFC, 0x07,
  0xF8, 0xFF, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFE,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFC, 0xFF, 0x00, 0x1F, 0xCF, 0xF8, 0x03,
  0xF8, 0xFF, 0xE0, 0x7F, 0x8F, 0xBF, 0xFF, 0xF0, 0xF9, 0xFF, 0xFE, 0x0F,
  0x8F, 0xFF, 0xC0, 0xF8, 0x3F, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xFE, 0x1F, 0x03, 0xFF, 0xF1, 0xF0, 0x7F, 0xFF,
  0x9F, 0x0F, 0xFF, 0xFD, 0xF1, 0xFC, 0x03, 0xFF, 0x3F, 0x80, 0x1F, 0xF3,
  0xF0, 0x00, 0xFF, 0x3F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x7F, 0x3F, 0x00, 0x0F, 0xF3, 0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x7D, 0xF0,
  0xFF, 0xFF, 0xDF, 0x07, 0xFF, 0xFB, 0xF0, 0x3F, 0xFE, 0x3F, 0x00, 0xFF,
  0xC3, 0xF0, 0x01, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFC, 0x2F, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF1, 0xF8, 0x01, 0xCF, 0xC0, 0x01, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFB, 0x00, 0x07, 0xEF,
  0x80, 0x7F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3F,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x41, 0xFF,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x38, 0x00, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0xDF, 0xE0, 0x7D,
  0xF3, 0xFF, 0xFF, 0x7C, 0xFF, 0xFF, 0x9F, 0x1F, 0xFF, 0xC7, 0xC1, 0xFF,
  0xC1, 0xF0, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x1F,
  0x80, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xFC,
  0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x3E,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF7, 0xC0, 0x03, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xC0, 0x03,
  0xE7, 0xE0, 0x07, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xE0, 0x07, 0xE3,
  0xE0, 0x07, 0xFE, 0x00, 0x7C, 0x3E, 0x00, 0x79, 0xE0, 0x07, 0xC3, 0xF0,
  0x0F, 0x9F, 0x00, 0xFC, 0x3F, 0x00, 0xF9, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F,
  0x9F, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x0F,
  0x80, 0xF8, 0x1F, 0x81, 0xF0, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x00, 0xFC, 0x3E, 0x07, 0xC1, 0xF0,
  0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x07, 0xE7,
  0xC0, 0x3E, 0x7E, 0x00, 0x3E, 0x78, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x1F,
  0x7C, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x0F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x7C, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC0,
  0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x03,
  0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80,
  0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x04, 0x3F, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x13, 0xFF, 0x80, 0x03, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0xC0, 0x07, 0xFF, 0xC8,
  0x00, 0x1F, 0xF8, 0x80, 0x00, 0x0C, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 8, 47, 16, 4, -46 },
  { 48, 17, 17, 25, 4, -46 },
  { 85, 35, 46, 37, 1, -46 },
  { 287, 27, 53, 33, 3, -49 },
  { 466, 43, 47, 49, 3, -46 },
  { 719, 38, 47, 41, 3, -46 },
  { 943, 6, 17, 14, 4, -46 },
  { 956, 14, 56, 19, 3, -46 },
  { 1054, 14, 56, 19, 2, -46 },
  { 1152, 27, 26, 32, 2, -49 },
  { 1240, 27, 31, 33, 3, -38 },
  { 1345, 10, 15, 16, 2, -7 },
  { 1364, 15, 5, 19, 2, -20 },
  { 1374, 8, 9, 16, 4, -8 },
  { 1383, 22, 46, 24, 1, -46 },
  { 1510, 27, 47, 33, 3, -46 },
  { 1669, 16, 46, 33, 5, -46 },
  { 1761, 27, 46, 33, 3, -46 },
  { 1917, 27, 47, 33, 3, -46 },
  { 2076, 31, 46, 33, 1, -46 },
  { 2255, 26, 47, 33, 4, -46 },
  { 2408, 27, 47, 33, 3, -46 },
  { 2567, 28, 46, 33, 2, -46 },
  { 2728, 27, 47, 33, 3, -46 },
  { 2887, 27, 47, 33, 3, -46 },
  { 3046, 8, 36, 16, 4, -35 },
  { 3082, 10, 43, 16, 2, -35 },
  { 3136, 28, 30, 33, 3, -38 },
  { 3241, 27, 17, 33, 3, -31 },
  { 3299, 28, 30, 33, 3, -38 },
  { 3404, 22, 47, 25, 1, -46 },
  { 3534, 45, 52, 52, 3, -46 },
  { 3827, 36, 46, 36, 0, -46 },
  { 4034, 28, 46, 38, 6, -46 },
  { 4195, 30, 47, 36, 4, -46 },
  { 4372, 32, 46, 42, 6, -46 },
  { 4556, 22, 46, 32, 6, -46 },
  { 4683, 22, 46, 30, 6, -46 },
  { 4810, 34, 47, 42, 4, -46 },
  { 5010, 31, 46, 43, 6, -46 },
  { 5189, 16, 46, 20, 2, -46 },
  { 5281, 15, 58, 16, -4, -46 },
  { 5390, 30, 46, 36, 6, -46 },
  { 5563, 23, 46, 30, 6, -46 },
  { 5696, 42, 46, 54, 6, -46 },
  { 5938, 33, 46, 44, 6, -46 },
  { 6128, 37, 47, 45, 4, -46 },
  { 6346, 26, 46, 35, 6, -46 },
  { 6496, 37, 57, 45, 4, -46 },
  { 6760, 29, 46, 36, 6, -46 },
  { 6927, 26, 47, 32, 3, -46 },
  { 7080, 30, 46, 31, 1, -46 },
  { 7253, 32, 47, 42, 5, -46 },
  { 7441, 35, 46, 35, 0, -46 },
  { 7643, 53, 46, 55, 1, -46 },
  { 7948, 33, 46, 33, 0, -46 },
  { 8138, 32, 46, 32, 0, -46 },
  { 8322, 28, 46, 32, 2, -46 },
  { 8483, 14, 56, 21, 5, -46 },
  { 8581, 22, 46, 24, 1, -46 },
  { 8708, 14, 56, 21, 2, -46 },
  { 8806, 30, 27, 34, 2, -46 },
  { 8908, 28, 4, 28, 0, 6 },
  { 8922, 12, 10, 18, 3, -49 },
  { 8937, 25, 36, 33, 3, -35 },
  { 9050, 28, 50, 36, 5, -49 },
  { 9225, 23, 36, 28, 3, -35 },
  { 9329, 28, 50, 36, 3, -49 },
  { 9504, 27, 36, 33, 3, -35 },
  { 9626, 21, 49, 20, 1, -49 },
  { 9755, 28, 50, 36, 3, -35 },
  { 9930, 26, 49, 36, 5, -49 },
  { 10090, 6, 47, 15, 5, -47 },
  { 10126, 14, 62, 15, -3, -47 },
  { 10235, 26, 49, 31, 5, -49 },
  { 10395, 5, 49, 15, 5, -49 },
  { 10426, 44, 35, 54, 5, -35 },
  { 10619, 26, 35, 36, 5, -35 },
  { 10733, 29, 36, 35, 3, -35 },
  { 10864, 28, 50, 36, 5, -35 },
  { 11039, 28, 50, 36, 3, -35 },
  { 11214, 18, 35, 24, 5, -35 },
  { 11293, 22, 36, 27, 3, -35 },
  { 11392, 19, 43, 21, 1, -42 },
  { 11495, 26, 35, 36, 5, -34 },
  { 11609, 29, 34, 29, 0, -34 },
  { 11733, 44, 34, 46, 1, -34 },
  { 11920, 28, 34, 30, 1, -34 },
  { 12039, 29, 49, 29, 0, -34 },
  { 12217, 22, 34, 26, 2, -34 },
  { 12311, 20, 56, 24, 2, -46 },
  { 12451, 4, 64, 32, 14, -49 },
  { 12483, 20, 56, 24, 2, -46 },
  { 12623, 28, 9, 33, 3, -27 },
};

const GFXfont NotoSans_SemiCondensed_Regular64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular64pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR64PT7B_H_
