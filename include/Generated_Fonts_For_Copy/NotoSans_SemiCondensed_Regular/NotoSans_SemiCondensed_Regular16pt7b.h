#ifndef _NOTOSANS_SEMICONDENSED_REGULAR16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF5, 0x3C, 0xD9, 0x99, 0x1B, 0x09, 0x04, 0x8F, 0xF1, 0x21,
  0x90, 0x99, 0xFE, 0x24, 0x12, 0x09, 0x00, 0x10, 0xF3, 0x74, 0x89, 0x1E,
  0x0E, 0x0A, 0x17, 0x2B, 0xE0, 0x81, 0x00, 0x40, 0x16, 0x22, 0x4C, 0x49,
  0x09, 0x61, 0x2B, 0xBF, 0x52, 0x53, 0x0A, 0x62, 0x4C, 0x4D, 0x10, 0xE0,
  0x30, 0x3C, 0x13, 0x09, 0x86, 0x81, 0x81, 0xC7, 0xB2, 0x8D, 0x43, 0x31,
  0xCF, 0x30, 0xEA, 0x6B, 0x49, 0x24, 0x93, 0x26, 0x40, 0xC2, 0x23, 0x11,
  0x11, 0x13, 0x22, 0x4C, 0x30, 0x8E, 0xCC, 0x7B, 0x20, 0x10, 0x20, 0x47,
  0xF1, 0x02, 0x04, 0x00, 0xFA, 0xE0, 0xF0, 0x0C, 0x21, 0x84, 0x10, 0xC2,
  0x08, 0x41, 0x0C, 0x00, 0x30, 0xF3, 0x14, 0x28, 0x50, 0xE1, 0xC3, 0x85,
  0x0B, 0x33, 0xC0, 0x37, 0xD1, 0x11, 0x11, 0x11, 0x10, 0x31, 0xFA, 0x10,
  0x20, 0x41, 0x86, 0x08, 0x20, 0x83, 0x07, 0xF0, 0x33, 0xF8, 0x41, 0x0D,
  0xE7, 0x81, 0x04, 0x18, 0xFE, 0x06, 0x0E, 0x0E, 0x1E, 0x16, 0x26, 0x66,
  0x46, 0xFF, 0x06, 0x06, 0x06, 0xFF, 0x0C, 0x30, 0xF8, 0x30, 0x41, 0x06,
  0x3F, 0x80, 0x0C, 0xF9, 0x06, 0x08, 0x17, 0xB1, 0x43, 0x87, 0x09, 0x13,
  0xC0, 0xFE, 0x08, 0x30, 0x40, 0x83, 0x04, 0x18, 0x20, 0x41, 0x80, 0x30,
  0xFA, 0x14, 0x2C, 0xCF, 0x1E, 0x66, 0x87, 0x0F, 0x13, 0xC0, 0x30, 0xF2,
  0x14, 0x28, 0x50, 0xF3, 0x3A, 0x04, 0x18, 0x27, 0x80, 0xF0, 0x03, 0xC0,
  0xF0, 0x03, 0xE8, 0x02, 0x0C, 0x63, 0x08, 0x0E, 0x07, 0x03, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x81, 0x81, 0xC0, 0xE0, 0x63, 0x38, 0x40, 0x33, 0xE0,
  0xC1, 0x0C, 0x63, 0x08, 0x20, 0x02, 0x0C, 0x1F, 0x8C, 0x09, 0x01, 0xE7,
  0x99, 0x13, 0x22, 0x64, 0x4C, 0x99, 0x9F, 0xD8, 0x01, 0x80, 0x1F, 0x80,
  0x0C, 0x0A, 0x05, 0x02, 0xC3, 0x21, 0x10, 0xFC, 0xC6, 0x41, 0x20, 0xF0,
  0x60, 0xFE, 0xC2, 0xC2, 0xC2, 0xFC, 0xFE, 0xC2, 0xC3, 0xC3, 0xC6, 0xFC,
  0x0C, 0x3F, 0x60, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x61, 0x3E,
  0xFE, 0x61, 0xB0, 0x58, 0x2C, 0x16, 0x0F, 0x05, 0x82, 0xC3, 0x63, 0x3F,
  0x00, 0xFF, 0x0C, 0x30, 0xFF, 0xFC, 0x30, 0xC3, 0x0F, 0xC0, 0xFF, 0x0C,
  0x30, 0xC3, 0xFC, 0x30, 0xC3, 0x0C, 0x00, 0x0C, 0x1F, 0x98, 0x18, 0x0C,
  0x04, 0x02, 0x1F, 0x03, 0xC1, 0xA0, 0xD8, 0x67, 0xF0, 0xC1, 0xC1, 0xC1,
  0xC1, 0xFF, 0xFF, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xE9, 0x24, 0x92, 0x4B,
  0x80, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3E, 0xC7, 0xC4, 0xC8, 0xD8,
  0xF0, 0xF0, 0xD8, 0xCC, 0xC4, 0xC6, 0xC3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0F, 0xC0, 0xE0, 0x7C, 0x1F, 0x82, 0xF8, 0x5D, 0x13, 0xA2,
  0x72, 0x4E, 0x51, 0xCE, 0x38, 0xC7, 0x10, 0x80, 0xE1, 0xF0, 0xFC, 0x7A,
  0x3D, 0x9E, 0x4F, 0x37, 0x8F, 0xC3, 0xE1, 0xF0, 0x60, 0x0C, 0x3F, 0x90,
  0x58, 0x3C, 0x0C, 0x06, 0x03, 0x01, 0xC1, 0xE0, 0xD8, 0xC7, 0xC0, 0xFD,
  0x8F, 0x0E, 0x1C, 0x7F, 0xBC, 0x60, 0xC1, 0x83, 0x00, 0x0C, 0x3F, 0x90,
  0x58, 0x3C, 0x0C, 0x06, 0x03, 0x01, 0xC1, 0xE0, 0xD8, 0xC7, 0xC0, 0x60,
  0x18, 0x06, 0xFC, 0xC6, 0xC2, 0xC2, 0xC6, 0xFC, 0xC8, 0xCC, 0xC4, 0xC6,
  0xC3, 0x31, 0xF8, 0x20, 0xC1, 0x83, 0x83, 0x04, 0x18, 0xFE, 0xFF, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x63, 0x3E, 0xC1, 0xA0, 0x90, 0xCC,
  0x42, 0x21, 0x30, 0xD0, 0x68, 0x14, 0x0E, 0x06, 0x00, 0xC3, 0x0A, 0x18,
  0x51, 0xC6, 0xCB, 0x36, 0x49, 0x12, 0x48, 0xB2, 0xC5, 0x1E, 0x38, 0x60,
  0xC3, 0x06, 0x18, 0xC3, 0x66, 0x24, 0x1C, 0x18, 0x18, 0x1C, 0x24, 0x66,
  0x42, 0xC3, 0xC3, 0x42, 0x66, 0x24, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFC, 0x30, 0x86, 0x10, 0xC6, 0x10, 0xC2, 0x0F, 0xC0, 0xFC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC1, 0x06, 0x08, 0x20, 0xC1, 0x04, 0x08,
  0x20, 0xC0, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0xFF, 0x18, 0x18, 0x24,
  0x24, 0x62, 0xC3, 0xFE, 0xCC, 0xB9, 0x30, 0x41, 0x7E, 0x18, 0xE3, 0xF4,
  0xC1, 0x83, 0x06, 0xCE, 0xD8, 0xF0, 0xE1, 0xC3, 0x87, 0x1D, 0xE0, 0x3B,
  0x71, 0x08, 0x42, 0x18, 0x78, 0x06, 0x0C, 0x19, 0xB6, 0xF8, 0xE1, 0xC3,
  0x87, 0x0F, 0x1B, 0xD0, 0x31, 0xBC, 0x61, 0xFE, 0x08, 0x31, 0x7C, 0x3C,
  0x82, 0x1E, 0xF8, 0x82, 0x08, 0x20, 0x82, 0x08, 0x32, 0xDF, 0x1C, 0x38,
  0x70, 0xE1, 0xE3, 0x7E, 0x0C, 0x1E, 0x67, 0x80, 0xC1, 0x83, 0x06, 0xCE,
  0xD8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x30, 0xF3, 0xFF, 0xFF, 0x33, 0x03,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x2E, 0xC1, 0x83, 0x06, 0x2C, 0xDB, 0x3C,
  0x78, 0xD1, 0x93, 0x36, 0x30, 0xFF, 0xFF, 0xFF, 0x98, 0xDD, 0xEF, 0x18,
  0xE2, 0x1C, 0x43, 0x88, 0x71, 0x0E, 0x21, 0xC4, 0x20, 0x99, 0xDB, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x38, 0xDB, 0x1C, 0x38, 0x30, 0x61, 0xE2,
  0x78, 0x99, 0xDB, 0x1E, 0x1C, 0x38, 0x71, 0xE3, 0xFD, 0x83, 0x06, 0x0C,
  0x00, 0x32, 0xDF, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0x7E, 0x0C, 0x18, 0x30,
  0x60, 0x9D, 0xF1, 0x8C, 0x63, 0x18, 0xC0, 0x76, 0xE1, 0x87, 0x0C, 0x31,
  0xF0, 0x21, 0x1F, 0xF6, 0x31, 0x8C, 0x63, 0x0E, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0x7A, 0x83, 0x85, 0x1A, 0x26, 0x45, 0x8A, 0x1C, 0x18,
  0xC6, 0x38, 0xC5, 0x39, 0xA5, 0x36, 0xB4, 0xD2, 0x8E, 0x51, 0x8E, 0x31,
  0x80, 0xC2, 0xC8, 0xB1, 0xC1, 0x87, 0x0B, 0x32, 0xC6, 0x83, 0x85, 0x1A,
  0x26, 0x45, 0x8A, 0x0C, 0x18, 0x20, 0x41, 0x0E, 0x00, 0xFF, 0xC4, 0x62,
  0x33, 0x10, 0xF8, 0x36, 0x66, 0x66, 0x84, 0x66, 0x66, 0x31, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC6, 0x66, 0x66, 0x16, 0x66, 0x66, 0xC8, 0x63, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_Regular16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 6, 1, -11 },
  { 6, 9, 11, 9, 0, -11 },
  { 19, 7, 13, 8, 1, -12 },
  { 31, 11, 12, 12, 1, -12 },
  { 48, 9, 12, 10, 1, -12 },
  { 62, 2, 4, 4, 1, -11 },
  { 63, 3, 14, 5, 1, -11 },
  { 69, 4, 14, 5, 0, -11 },
  { 76, 6, 6, 8, 1, -12 },
  { 81, 7, 7, 8, 1, -9 },
  { 88, 2, 4, 4, 1, -2 },
  { 89, 3, 1, 5, 1, -5 },
  { 90, 2, 2, 4, 1, -2 },
  { 91, 6, 11, 6, 0, -11 },
  { 100, 7, 12, 8, 1, -12 },
  { 111, 4, 11, 8, 1, -11 },
  { 117, 7, 12, 8, 1, -12 },
  { 128, 6, 12, 8, 1, -12 },
  { 137, 8, 12, 8, 0, -12 },
  { 149, 6, 11, 8, 1, -11 },
  { 158, 7, 12, 8, 1, -12 },
  { 169, 7, 11, 8, 1, -11 },
  { 179, 7, 12, 8, 1, -12 },
  { 190, 7, 12, 8, 1, -12 },
  { 201, 2, 9, 4, 1, -9 },
  { 204, 2, 11, 4, 1, -9 },
  { 207, 7, 8, 8, 1, -10 },
  { 214, 7, 5, 8, 1, -8 },
  { 219, 7, 8, 8, 1, -10 },
  { 226, 6, 12, 6, 0, -12 },
  { 235, 11, 12, 13, 1, -11 },
  { 252, 9, 11, 9, 0, -11 },
  { 265, 8, 11, 9, 1, -11 },
  { 276, 8, 12, 9, 1, -12 },
  { 288, 9, 11, 10, 1, -11 },
  { 301, 6, 11, 8, 1, -11 },
  { 310, 6, 11, 7, 1, -11 },
  { 319, 9, 12, 11, 1, -12 },
  { 333, 8, 11, 11, 1, -11 },
  { 344, 3, 11, 5, 1, -11 },
  { 349, 4, 14, 4, -1, -11 },
  { 356, 8, 11, 9, 1, -11 },
  { 367, 6, 11, 7, 1, -11 },
  { 376, 11, 11, 13, 1, -11 },
  { 392, 9, 11, 11, 1, -11 },
  { 405, 9, 12, 11, 1, -12 },
  { 419, 7, 11, 9, 1, -11 },
  { 429, 9, 15, 11, 1, -12 },
  { 446, 8, 11, 9, 1, -11 },
  { 457, 6, 12, 8, 1, -12 },
  { 466, 8, 11, 8, 0, -11 },
  { 477, 8, 11, 10, 1, -11 },
  { 488, 9, 11, 9, 0, -11 },
  { 501, 13, 11, 14, 0, -11 },
  { 519, 8, 11, 8, 0, -11 },
  { 530, 8, 11, 8, 0, -11 },
  { 541, 6, 11, 8, 1, -11 },
  { 550, 4, 14, 5, 1, -11 },
  { 557, 6, 11, 6, 0, -11 },
  { 566, 4, 14, 5, 0, -11 },
  { 573, 8, 6, 8, 0, -11 },
  { 579, 7, 1, 7, 0, 1 },
  { 580, 3, 2, 4, 1, -12 },
  { 581, 6, 9, 8, 1, -9 },
  { 588, 7, 12, 9, 1, -12 },
  { 599, 5, 9, 7, 1, -9 },
  { 605, 7, 12, 9, 1, -12 },
  { 616, 6, 9, 8, 1, -9 },
  { 623, 6, 12, 5, 0, -12 },
  { 632, 7, 13, 9, 1, -9 },
  { 644, 7, 12, 9, 1, -12 },
  { 655, 2, 12, 4, 1, -12 },
  { 658, 4, 16, 4, -1, -12 },
  { 666, 7, 12, 8, 1, -12 },
  { 677, 2, 12, 4, 1, -12 },
  { 680, 11, 9, 13, 1, -9 },
  { 693, 7, 9, 9, 1, -9 },
  { 701, 7, 9, 9, 1, -9 },
  { 709, 7, 13, 9, 1, -9 },
  { 721, 7, 13, 9, 1, -9 },
  { 733, 5, 9, 6, 1, -9 },
  { 739, 5, 9, 7, 1, -9 },
  { 745, 5, 11, 5, 0, -11 },
  { 752, 7, 9, 9, 1, -9 },
  { 760, 7, 9, 7, 0, -9 },
  { 768, 11, 9, 12, 0, -9 },
  { 781, 7, 9, 8, 0, -9 },
  { 789, 7, 13, 7, 0, -9 },
  { 801, 5, 9, 7, 1, -9 },
  { 807, 4, 14, 6, 1, -11 },
  { 814, 2, 16, 8, 3, -12 },
  { 818, 4, 14, 6, 1, -11 },
  { 825, 7, 2, 8, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_Regular16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR16PT7B_H_
