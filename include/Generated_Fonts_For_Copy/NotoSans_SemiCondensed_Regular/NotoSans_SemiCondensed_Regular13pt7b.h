#ifndef _NOTOSANS_SEMICONDENSED_REGULAR13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xB6, 0x80, 0x14, 0x49, 0xF9, 0x22, 0x9F, 0xCA, 0x24,
  0x48, 0x23, 0xAB, 0x4E, 0x38, 0xA5, 0xF9, 0x08, 0xE6, 0xA4, 0xA8, 0xAA,
  0xB5, 0x55, 0x25, 0x25, 0x67, 0x71, 0x21, 0x43, 0x86, 0x32, 0xE3, 0x46,
  0xF6, 0xE0, 0x6A, 0xAA, 0xB4, 0xCC, 0x92, 0x49, 0x2B, 0x00, 0x10, 0x4F,
  0xCC, 0x68, 0x21, 0x09, 0xF2, 0x10, 0x80, 0x56, 0xF0, 0xC0, 0x18, 0x84,
  0x42, 0x31, 0x08, 0x80, 0xF4, 0x63, 0x18, 0xC6, 0x33, 0x70, 0x7C, 0x92,
  0x49, 0x20, 0xF0, 0x42, 0x21, 0x11, 0x10, 0xF8, 0xF0, 0x42, 0x27, 0x04,
  0x21, 0xF0, 0x08, 0x30, 0xA1, 0x44, 0x89, 0x3F, 0x84, 0x08, 0xF4, 0x21,
  0xC1, 0x84, 0x23, 0xF0, 0x7C, 0x21, 0xE8, 0xC6, 0x31, 0x70, 0xFC, 0x10,
  0x82, 0x18, 0x41, 0x08, 0x20, 0xFC, 0x62, 0xA7, 0x46, 0x31, 0xF0, 0xF4,
  0x63, 0x1D, 0xB4, 0x22, 0xE0, 0xC6, 0x50, 0x15, 0x80, 0x08, 0xD9, 0x06,
  0x0C, 0xF8, 0x3E, 0x86, 0x0C, 0x13, 0x60, 0xF0, 0x42, 0x22, 0x10, 0x04,
  0x60, 0x3E, 0x20, 0xA7, 0x34, 0x9A, 0x4D, 0x26, 0x95, 0x34, 0x40, 0x1F,
  0x00, 0x18, 0x30, 0xA1, 0x62, 0x4F, 0x91, 0xA1, 0x82, 0xFA, 0x38, 0x62,
  0xFA, 0x18, 0x63, 0xF8, 0x7F, 0x08, 0x20, 0x82, 0x08, 0x30, 0x7C, 0xF9,
  0x0A, 0x1C, 0x38, 0x30, 0xE1, 0x46, 0xF8, 0xFC, 0x21, 0x0F, 0xC2, 0x10,
  0xF8, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x80, 0x7F, 0x82, 0x04, 0x08, 0xF0,
  0x60, 0xA1, 0x3E, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x84, 0xF6, 0x66,
  0x66, 0x66, 0xF0, 0x24, 0x92, 0x49, 0x27, 0x80, 0x8E, 0x69, 0x28, 0xE2,
  0x49, 0xA2, 0x84, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0xC1, 0xE1, 0x68,
  0xB4, 0x5A, 0x4C, 0xA6, 0x53, 0x31, 0x88, 0x80, 0xC3, 0x86, 0x8D, 0x99,
  0x31, 0x62, 0xC3, 0x86, 0x7D, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xE3, 0x7C,
  0xFA, 0x28, 0xE2, 0xFA, 0x08, 0x20, 0x80, 0x7D, 0x8E, 0x0C, 0x18, 0x30,
  0x60, 0xE3, 0x7C, 0x10, 0x18, 0xFA, 0x28, 0xE2, 0xF2, 0x48, 0xA2, 0x84,
  0xFC, 0x21, 0x87, 0x0C, 0x23, 0xF0, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x86, 0x18, 0x61, 0x86, 0x18, 0x71, 0x78, 0x82, 0x89, 0x12, 0x26,
  0xC5, 0x0A, 0x14, 0x10, 0x84, 0x29, 0x4D, 0x29, 0x25, 0x24, 0xA4, 0x63,
  0x8C, 0x61, 0x8C, 0x31, 0x80, 0xC6, 0x98, 0xA1, 0x81, 0x05, 0x1A, 0x22,
  0xC6, 0xC6, 0x89, 0x21, 0x43, 0x02, 0x04, 0x08, 0x10, 0x7C, 0x20, 0x84,
  0x30, 0x86, 0x10, 0xFC, 0xF2, 0x49, 0x24, 0x93, 0x80, 0xC2, 0x10, 0x42,
  0x10, 0x42, 0x18, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x10, 0xA2, 0x91, 0xC4,
  0xFC, 0x90, 0xF0, 0xC3, 0xF8, 0xCF, 0xA0, 0x82, 0x08, 0x3E, 0xCA, 0x38,
  0xE3, 0x8B, 0xE0, 0x78, 0x88, 0x88, 0x70, 0x08, 0x42, 0xF8, 0xC6, 0x31,
  0x8B, 0xC0, 0x74, 0x63, 0xF8, 0x41, 0xE0, 0x3B, 0x11, 0xE4, 0x21, 0x08,
  0x42, 0x00, 0x7C, 0x63, 0x18, 0xC5, 0xE1, 0x0F, 0x80, 0x84, 0x21, 0xFC,
  0xC6, 0x31, 0x8C, 0x40, 0xDF, 0xC0, 0x24, 0x12, 0x49, 0x24, 0x9E, 0x84,
  0x21, 0x39, 0x53, 0x96, 0x94, 0x40, 0xFF, 0xC0, 0xFF, 0x44, 0x62, 0x31,
  0x18, 0x8C, 0x46, 0x22, 0xFE, 0x63, 0x18, 0xC6, 0x20, 0x74, 0x63, 0x18,
  0xC5, 0xC0, 0xFA, 0x28, 0xE3, 0x8E, 0x2F, 0xA0, 0x82, 0x00, 0x7C, 0x63,
  0x18, 0xC5, 0xE1, 0x08, 0x40, 0xBC, 0x88, 0x88, 0x80, 0xF8, 0x86, 0x11,
  0xE0, 0x44, 0xF4, 0x44, 0x44, 0x70, 0x8C, 0x63, 0x18, 0xC5, 0xE0, 0x85,
  0x24, 0x92, 0x30, 0xC3, 0x00, 0x88, 0xA6, 0x55, 0x6A, 0xA5, 0x51, 0x98,
  0x8C, 0xCD, 0x23, 0x0C, 0x31, 0x2C, 0xC0, 0x85, 0x24, 0x92, 0x30, 0xC3,
  0x08, 0x23, 0x00, 0x78, 0x84, 0x46, 0x23, 0xE0, 0x32, 0x22, 0x2C, 0x22,
  0x22, 0x10, 0xFF, 0xF8, 0xE2, 0x22, 0x21, 0x22, 0x22, 0xC0, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Regular13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 3, 5, 1, -9 },
  { 5, 7, 9, 8, 0, -9 },
  { 13, 5, 11, 7, 1, -10 },
  { 20, 8, 9, 10, 1, -9 },
  { 29, 7, 9, 8, 1, -9 },
  { 37, 1, 3, 3, 1, -9 },
  { 38, 2, 11, 4, 1, -9 },
  { 41, 3, 11, 4, 0, -9 },
  { 46, 6, 5, 6, 0, -10 },
  { 50, 5, 7, 7, 1, -8 },
  { 55, 2, 4, 3, 0, -2 },
  { 56, 4, 1, 4, 0, -4 },
  { 57, 1, 2, 3, 1, -2 },
  { 58, 5, 9, 5, 0, -9 },
  { 64, 5, 9, 7, 1, -9 },
  { 70, 3, 9, 7, 1, -9 },
  { 74, 5, 9, 7, 1, -9 },
  { 80, 5, 9, 7, 1, -9 },
  { 86, 7, 9, 7, 0, -9 },
  { 94, 5, 9, 7, 1, -9 },
  { 100, 5, 9, 7, 1, -9 },
  { 106, 6, 9, 7, 0, -9 },
  { 113, 5, 9, 7, 1, -9 },
  { 119, 5, 9, 7, 1, -9 },
  { 125, 1, 7, 3, 1, -7 },
  { 126, 2, 9, 3, 0, -7 },
  { 129, 5, 6, 7, 1, -8 },
  { 133, 5, 3, 7, 1, -6 },
  { 135, 5, 6, 7, 1, -8 },
  { 139, 5, 9, 5, 0, -9 },
  { 145, 9, 10, 11, 1, -9 },
  { 157, 7, 9, 7, 0, -9 },
  { 165, 6, 9, 8, 1, -9 },
  { 172, 6, 9, 7, 1, -9 },
  { 179, 7, 9, 8, 1, -9 },
  { 187, 5, 9, 7, 1, -9 },
  { 193, 5, 9, 6, 1, -9 },
  { 199, 7, 9, 9, 1, -9 },
  { 207, 6, 9, 9, 1, -9 },
  { 214, 4, 9, 4, 0, -9 },
  { 219, 3, 11, 3, -1, -9 },
  { 224, 6, 9, 7, 1, -9 },
  { 231, 5, 9, 6, 1, -9 },
  { 237, 9, 9, 11, 1, -9 },
  { 248, 7, 9, 9, 1, -9 },
  { 256, 7, 9, 9, 1, -9 },
  { 264, 6, 9, 7, 1, -9 },
  { 271, 7, 11, 9, 1, -9 },
  { 281, 6, 9, 7, 1, -9 },
  { 288, 5, 9, 6, 1, -9 },
  { 294, 6, 9, 6, 0, -9 },
  { 301, 6, 9, 9, 1, -9 },
  { 308, 7, 9, 7, 0, -9 },
  { 316, 11, 9, 11, 0, -9 },
  { 329, 7, 9, 7, 0, -9 },
  { 337, 7, 9, 7, 0, -9 },
  { 345, 6, 9, 6, 0, -9 },
  { 352, 3, 11, 4, 1, -9 },
  { 357, 5, 9, 5, 0, -9 },
  { 363, 3, 11, 4, 0, -9 },
  { 368, 6, 5, 7, 0, -9 },
  { 372, 6, 1, 6, 0, 1 },
  { 373, 2, 2, 4, 1, -10 },
  { 374, 5, 7, 7, 1, -7 },
  { 379, 6, 10, 7, 1, -10 },
  { 387, 4, 7, 6, 1, -7 },
  { 391, 5, 10, 7, 1, -10 },
  { 398, 5, 7, 7, 1, -7 },
  { 403, 5, 10, 4, 0, -10 },
  { 410, 5, 10, 7, 1, -7 },
  { 417, 5, 10, 7, 1, -10 },
  { 424, 1, 10, 3, 1, -10 },
  { 426, 3, 13, 3, -1, -10 },
  { 431, 5, 10, 6, 1, -10 },
  { 438, 1, 10, 3, 1, -10 },
  { 440, 9, 7, 11, 1, -7 },
  { 448, 5, 7, 7, 1, -7 },
  { 453, 5, 7, 7, 1, -7 },
  { 458, 6, 10, 7, 1, -7 },
  { 466, 5, 10, 7, 1, -7 },
  { 473, 4, 7, 5, 1, -7 },
  { 477, 4, 7, 6, 1, -7 },
  { 481, 4, 9, 4, 0, -9 },
  { 486, 5, 7, 7, 1, -7 },
  { 491, 6, 7, 6, 0, -7 },
  { 497, 9, 7, 9, 0, -7 },
  { 505, 6, 7, 6, 0, -7 },
  { 511, 6, 10, 6, 0, -7 },
  { 519, 5, 7, 5, 0, -7 },
  { 524, 4, 11, 5, 0, -9 },
  { 530, 1, 13, 6, 3, -10 },
  { 532, 4, 11, 5, 0, -9 },
  { 538, 5, 1, 7, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_Regular13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR13PT7B_H_
