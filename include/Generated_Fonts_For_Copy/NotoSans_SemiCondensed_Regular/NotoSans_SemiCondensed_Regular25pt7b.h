#ifndef _NOTOSANS_SEMICONDENSED_REGULAR25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0x6D, 0xB6, 0xDB, 0x6C, 0x06, 0xFC, 0xCF, 0x3C, 0xF3, 0xCF,
  0x38, 0xC0, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x18, 0x80, 0x84, 0x7F, 0xFF,
  0xFF, 0xE3, 0x18, 0x18, 0xC0, 0xC4, 0x04, 0x21, 0xFF, 0xEF, 0xFF, 0x18,
  0xC0, 0xC6, 0x06, 0x20, 0x21, 0x03, 0x18, 0x00, 0x04, 0x00, 0x80, 0x7E,
  0x3F, 0xE6, 0x45, 0x88, 0x31, 0x07, 0x20, 0x74, 0x07, 0xC0, 0x3E, 0x02,
  0xE0, 0x4E, 0x08, 0xC1, 0x3E, 0x2E, 0xFF, 0x87, 0xC0, 0x10, 0x02, 0x00,
  0x38, 0x0C, 0x36, 0x0C, 0x31, 0x86, 0x18, 0xC6, 0x0C, 0x63, 0x06, 0x33,
  0x03, 0x19, 0x81, 0x8D, 0x9C, 0x46, 0xDF, 0x36, 0xC8, 0xCE, 0x6C, 0x60,
  0x26, 0x30, 0x33, 0x18, 0x11, 0x8C, 0x18, 0xC6, 0x08, 0x23, 0x0C, 0x1B,
  0x0C, 0x07, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xC6, 0x01, 0x8E, 0x03, 0x18,
  0x06, 0x30, 0x0E, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x19, 0xCC, 0x37,
  0x1C, 0xCC, 0x1D, 0x98, 0x1F, 0x30, 0x1C, 0x70, 0x7C, 0x7F, 0xDC, 0x7E,
  0x1C, 0xFF, 0xF8, 0x1C, 0x63, 0x0C, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x30,
  0xC3, 0x0E, 0x18, 0x61, 0x83, 0x0C, 0x18, 0x70, 0xC3, 0x18, 0x63, 0x1C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x39, 0x8C, 0xC6, 0x60, 0x0C, 0x03,
  0x00, 0xC3, 0x33, 0xFF, 0xC7, 0x81, 0xE0, 0xEC, 0x73, 0x8C, 0x40, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xFF, 0xF8, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x76, 0x66, 0xCC, 0xFF, 0xF0, 0xDF, 0x00, 0x01,
  0x81, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x0E, 0x06, 0x03,
  0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x00, 0x1F, 0x07, 0xF1, 0xC7,
  0x30, 0x66, 0x0D, 0xC1, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3E, 0x0E, 0xC1, 0x98, 0x33, 0x8E, 0x3F, 0x83, 0xE0, 0x0C, 0x73, 0xDB,
  0xCC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x3F,
  0x1F, 0xF1, 0x87, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80,
  0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFC,
  0x3F, 0x1F, 0xF1, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x1C, 0x3E,
  0x07, 0xF0, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x34, 0x0E, 0xFF, 0x9F,
  0xE0, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x6C, 0x03, 0x60, 0x33,
  0x03, 0x18, 0x18, 0xC1, 0x86, 0x0C, 0x30, 0xC1, 0x8F, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x7F, 0xCF, 0xF9, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0xF8, 0x7F, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x0E, 0x01, 0xC0, 0x34, 0x0E, 0xFF, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0xE0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x7C, 0xDF, 0xDC, 0x1B, 0x83, 0xE0,
  0x3E, 0x06, 0xC0, 0xD8, 0x3B, 0x86, 0x3F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFC,
  0x03, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x1F, 0x07,
  0xF9, 0x83, 0x30, 0x66, 0x0C, 0xC1, 0x9C, 0x71, 0xDC, 0x1E, 0x07, 0xF1,
  0xC7, 0x70, 0x6C, 0x07, 0x80, 0xF0, 0x1F, 0x06, 0x7F, 0xC7, 0xF0, 0x1F,
  0x07, 0xF1, 0x87, 0x70, 0x6C, 0x0D, 0x81, 0xF0, 0x1E, 0x07, 0x60, 0xEF,
  0x6C, 0xFB, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x1C, 0x7F, 0x0F, 0xC0,
  0x5F, 0xA0, 0x00, 0x00, 0x6F, 0xC0, 0x27, 0x72, 0x00, 0x00, 0x00, 0x07,
  0x66, 0xEC, 0xC0, 0x00, 0x20, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x38,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x38, 0x1E, 0x1E, 0x0F, 0x03, 0x80, 0x40, 0x00, 0x3E,
  0x7F, 0x90, 0xE0, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x06, 0x06, 0x06, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x1C, 0x0C, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0x01, 0xC0, 0x70, 0x60, 0x0C, 0x30, 0x01, 0x98, 0x7E, 0x26, 0x3B, 0x8D,
  0x8C, 0x63, 0x46, 0x18, 0xF1, 0x86, 0x3C, 0x61, 0x8F, 0x18, 0x63, 0xC6,
  0x38, 0x90, 0xDB, 0x66, 0x3C, 0xF1, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xF3, 0x80, 0x1F, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x06, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x18, 0x18, 0x60, 0x61, 0x81, 0xFF,
  0x0F, 0xFC, 0x30, 0x31, 0xC0, 0xE6, 0x01, 0x98, 0x06, 0xE0, 0x1F, 0x00,
  0x30, 0xFF, 0x1F, 0xFB, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x3E, 0x0E,
  0xFF, 0x1F, 0xFB, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xFF,
  0xDF, 0xF0, 0x07, 0xF1, 0xFF, 0x3C, 0x13, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x1F, 0xF0, 0xFF, 0xFF, 0x07, 0xFE, 0x30, 0x79, 0x80, 0xEC,
  0x03, 0x60, 0x1B, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0x60, 0x1B, 0x01, 0xD8, 0x3C, 0xFF, 0xC7, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x00, 0x07, 0xF8, 0x3F, 0xF3, 0xC0, 0x8C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x83, 0xFE, 0x0F,
  0xD8, 0x03, 0x60, 0x0D, 0xC0, 0x33, 0x00, 0xCE, 0x03, 0x1F, 0xFC, 0x1F,
  0xE0, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x7B, 0xF0, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1F, 0xEF, 0x00,
  0xC0, 0x7C, 0x0E, 0xC1, 0xCC, 0x18, 0xC3, 0x0C, 0x70, 0xCE, 0x0C, 0xC0,
  0xDC, 0x0F, 0xE0, 0xE6, 0x0C, 0x70, 0xC3, 0x0C, 0x18, 0xC1, 0xCC, 0x0C,
  0xC0, 0xEC, 0x07, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xC0,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xBD, 0x80, 0xDE, 0xC0,
  0x6F, 0x30, 0x67, 0x98, 0x33, 0xCC, 0x19, 0xE3, 0x18, 0xF1, 0x8C, 0x78,
  0xC6, 0x3C, 0x36, 0x1E, 0x1B, 0x0F, 0x0D, 0x87, 0x83, 0x83, 0xC1, 0xC1,
  0xE0, 0xE0, 0xC0, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3D, 0x81, 0xEE,
  0x0F, 0x30, 0x78, 0xC3, 0xC6, 0x1E, 0x18, 0xF0, 0xE7, 0x83, 0x3C, 0x1D,
  0xE0, 0x6F, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xC0, 0x07, 0xE0, 0x3F,
  0xE0, 0xE0, 0xE3, 0x80, 0xE7, 0x00, 0xCC, 0x01, 0xD8, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x76, 0x00, 0xEC, 0x01, 0x9C,
  0x07, 0x1C, 0x1C, 0x1F, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xF3, 0x07, 0x60,
  0x6C, 0x0D, 0x81, 0xF0, 0x36, 0x06, 0xC1, 0xDF, 0xF3, 0xF8, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x07, 0xE0, 0x3F, 0xE0,
  0xE0, 0xE3, 0x80, 0xE7, 0x00, 0xCC, 0x01, 0xD8, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x76, 0x00, 0xEC, 0x01, 0x9C, 0x07,
  0x1C, 0x1C, 0x1F, 0xF0, 0x1F, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0xFE, 0x0F, 0xF8, 0xC1, 0xCC, 0x0C, 0xC0, 0xEC, 0x0E, 0xC0,
  0xCC, 0x0C, 0xC3, 0x8F, 0xF0, 0xFF, 0x0C, 0x30, 0xC3, 0x8C, 0x18, 0xC1,
  0xCC, 0x0C, 0xC0, 0xEC, 0x07, 0x1F, 0x9F, 0xF6, 0x07, 0x80, 0xE0, 0x38,
  0x06, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0x00, 0xC0, 0x30, 0x0E,
  0x07, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x37, 0x07, 0x3F, 0xE1, 0xFC, 0xC0, 0x1F,
  0x80, 0x66, 0x03, 0x98, 0x0E, 0x70, 0x30, 0xC0, 0xC3, 0x07, 0x0E, 0x18,
  0x18, 0x60, 0x63, 0x81, 0x8C, 0x03, 0x30, 0x0D, 0xC0, 0x36, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x70, 0x1B, 0x03, 0x81, 0xD8,
  0x1C, 0x0E, 0xC0, 0xF0, 0x67, 0x0D, 0x83, 0x18, 0x6C, 0x18, 0xC3, 0x61,
  0xC6, 0x19, 0x8C, 0x31, 0x8C, 0x61, 0xCC, 0x63, 0x06, 0x63, 0x38, 0x33,
  0x0D, 0x81, 0xB0, 0x6C, 0x0F, 0x83, 0x60, 0x3C, 0x1B, 0x01, 0xE0, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x00, 0x60, 0x3B, 0x83, 0x8C, 0x18, 0x71,
  0xC1, 0x8C, 0x0E, 0xE0, 0x36, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x60,
  0x1B, 0x01, 0x8C, 0x0C, 0x60, 0xC1, 0x8E, 0x0C, 0x60, 0x37, 0x01, 0xC0,
  0xE0, 0x3B, 0x01, 0x98, 0x18, 0x60, 0xC3, 0x0E, 0x0C, 0x60, 0x67, 0x03,
  0xB0, 0x0F, 0x80, 0x78, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xF1, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFC, 0xE0, 0x30, 0x18,
  0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xFC, 0x04, 0x01, 0xC0, 0x38,
  0x0D, 0x81, 0xB0, 0x63, 0x0C, 0x63, 0x06, 0x60, 0xD8, 0x0F, 0x01, 0x80,
  0xFF, 0xFF, 0xFC, 0xE3, 0x0C, 0x30, 0x0E, 0x1F, 0xE2, 0x18, 0x07, 0x00,
  0xC0, 0x31, 0xFD, 0xF3, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x77, 0xDF, 0x30,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x88, 0x37, 0xE7, 0x8E, 0xE0,
  0xD8, 0x1B, 0x03, 0xE0, 0x7C, 0x07, 0x81, 0xF0, 0x3F, 0x06, 0xE0, 0xDF,
  0xF3, 0x7C, 0x00, 0x07, 0x1F, 0xDE, 0x6C, 0x06, 0x07, 0x03, 0x81, 0x80,
  0xE0, 0x70, 0x18, 0x0E, 0x03, 0xF8, 0xFC, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x18, 0xCF, 0xDB, 0x8F, 0x60, 0xEC, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0xC0, 0xF8, 0x1B, 0x03, 0x70, 0xE7, 0xFC, 0x7D, 0x80, 0x0E, 0x07,
  0xF1, 0xC7, 0x30, 0x66, 0x0D, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x13, 0xFC, 0x3F, 0x80, 0x0F, 0x8F, 0x86, 0x07, 0x03, 0x81,
  0xC3, 0xF8, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x00, 0x0C, 0x07, 0xED, 0xC7, 0xB0, 0x76, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0D, 0x81, 0xB0, 0x73, 0xFE, 0x3E, 0xC0,
  0x18, 0x03, 0x00, 0xE8, 0x19, 0xFF, 0x1F, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x31, 0x8D, 0xFB, 0xC7, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x18, 0xC0, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8F, 0xFE, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x3B, 0x0C, 0xC6, 0x33, 0x0D, 0xC3, 0xE0, 0xFC, 0x3B, 0x0C, 0x63, 0x1C,
  0xC3, 0x30, 0x6C, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x0E, 0x6F,
  0xDF, 0xBC, 0xF8, 0xFC, 0x38, 0x3C, 0x1C, 0x1E, 0x06, 0x0F, 0x03, 0x07,
  0x81, 0x83, 0xC0, 0xC1, 0xE0, 0x60, 0xF0, 0x30, 0x78, 0x18, 0x3C, 0x0C,
  0x1E, 0x06, 0x0C, 0x06, 0x37, 0xEF, 0x1F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30, 0x0E, 0x07, 0xF1,
  0xC7, 0x30, 0x76, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0D, 0x81,
  0xB8, 0x73, 0xFC, 0x3F, 0x00, 0x06, 0x1B, 0xF3, 0xC7, 0x70, 0x6C, 0x0D,
  0x81, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0x70, 0xEF, 0xF9, 0xBE,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x0E, 0x07, 0xED,
  0xC7, 0xB0, 0x76, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0D, 0x81,
  0xB0, 0x73, 0xFE, 0x3E, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x07, 0xBF, 0xEF, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x00, 0x1C, 0x3F, 0xF8, 0x58, 0x0C, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0x01, 0xC0, 0x70, 0x7F, 0xF7, 0xF0, 0x10, 0x30, 0x30, 0xFE, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3F, 0x1F, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7E, 0x1D,
  0xFF, 0x7E, 0xC0, 0xE0, 0x6C, 0x0D, 0x83, 0x38, 0x63, 0x0C, 0x63, 0x0C,
  0x60, 0xCC, 0x1B, 0x03, 0x60, 0x3C, 0x07, 0x00, 0xE0, 0xE0, 0xC1, 0xD8,
  0x78, 0x66, 0x1E, 0x19, 0x87, 0x86, 0x73, 0x33, 0x0C, 0xCC, 0xC3, 0x33,
  0x30, 0xCC, 0xCC, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78,
  0x0C, 0x0C, 0x00, 0x70, 0xE6, 0x18, 0xE6, 0x0C, 0xC0, 0xF0, 0x1E, 0x03,
  0x80, 0x78, 0x1B, 0x83, 0x30, 0xC3, 0x38, 0x6E, 0x06, 0xE0, 0x6C, 0x0D,
  0x83, 0x38, 0x63, 0x0C, 0x63, 0x0E, 0x60, 0xCC, 0x1B, 0x01, 0x60, 0x3C,
  0x07, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x1C, 0x1F, 0x03, 0xC0, 0x00,
  0xFF, 0x03, 0x06, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x60, 0xE0, 0xFF,
  0xFF, 0x06, 0x1C, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x63, 0xC7, 0x03,
  0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xF0, 0x30, 0x38, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x0F, 0x0F, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30,
  0xF0, 0xE0, 0xFC, 0x39, 0xFE, 0x0E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 18, 6, 2, -18 },
  { 8, 6, 7, 10, 2, -18 },
  { 14, 13, 18, 14, 1, -18 },
  { 44, 11, 20, 13, 1, -19 },
  { 72, 17, 18, 19, 1, -18 },
  { 111, 15, 18, 16, 1, -18 },
  { 145, 2, 7, 5, 2, -18 },
  { 147, 6, 22, 7, 1, -18 },
  { 164, 5, 22, 7, 1, -18 },
  { 178, 10, 10, 12, 1, -19 },
  { 191, 11, 12, 13, 1, -15 },
  { 208, 4, 6, 6, 1, -3 },
  { 211, 6, 2, 8, 1, -8 },
  { 213, 3, 3, 6, 2, -3 },
  { 215, 9, 18, 9, 0, -18 },
  { 236, 11, 18, 13, 1, -18 },
  { 261, 6, 18, 13, 2, -18 },
  { 275, 11, 18, 13, 1, -18 },
  { 300, 11, 18, 13, 1, -18 },
  { 325, 13, 18, 13, 0, -18 },
  { 355, 11, 18, 13, 1, -18 },
  { 380, 11, 18, 13, 1, -18 },
  { 405, 11, 18, 13, 1, -18 },
  { 430, 11, 18, 13, 1, -18 },
  { 455, 11, 18, 13, 1, -18 },
  { 480, 3, 14, 6, 2, -14 },
  { 486, 4, 17, 6, 1, -14 },
  { 495, 11, 12, 13, 1, -15 },
  { 512, 11, 7, 13, 1, -12 },
  { 522, 11, 12, 13, 1, -15 },
  { 539, 9, 18, 10, 0, -18 },
  { 560, 18, 20, 20, 1, -18 },
  { 605, 14, 18, 14, 0, -18 },
  { 637, 11, 18, 15, 2, -18 },
  { 662, 12, 18, 14, 1, -18 },
  { 689, 13, 18, 16, 2, -18 },
  { 719, 9, 18, 13, 2, -18 },
  { 740, 9, 18, 12, 2, -18 },
  { 761, 14, 18, 17, 1, -18 },
  { 793, 12, 18, 17, 2, -18 },
  { 820, 6, 18, 8, 1, -18 },
  { 834, 6, 23, 6, -2, -18 },
  { 852, 12, 18, 14, 2, -18 },
  { 879, 9, 18, 12, 2, -18 },
  { 900, 17, 18, 21, 2, -18 },
  { 939, 13, 18, 17, 2, -18 },
  { 969, 15, 18, 17, 1, -18 },
  { 1003, 11, 18, 14, 2, -18 },
  { 1028, 15, 22, 17, 1, -18 },
  { 1070, 12, 18, 14, 2, -18 },
  { 1097, 10, 18, 12, 1, -18 },
  { 1120, 12, 18, 12, 0, -18 },
  { 1147, 12, 18, 16, 2, -18 },
  { 1174, 14, 18, 14, 0, -18 },
  { 1206, 21, 18, 21, 0, -18 },
  { 1254, 13, 18, 13, 0, -18 },
  { 1284, 13, 18, 13, 0, -18 },
  { 1314, 11, 18, 12, 1, -18 },
  { 1339, 5, 22, 8, 2, -18 },
  { 1353, 9, 18, 9, 0, -18 },
  { 1374, 5, 22, 8, 1, -18 },
  { 1388, 11, 11, 13, 1, -18 },
  { 1404, 11, 2, 11, 0, 2 },
  { 1407, 5, 4, 7, 1, -19 },
  { 1410, 10, 14, 13, 1, -14 },
  { 1428, 11, 19, 14, 2, -19 },
  { 1455, 9, 14, 11, 1, -14 },
  { 1471, 11, 19, 14, 1, -19 },
  { 1498, 11, 14, 13, 1, -14 },
  { 1518, 9, 19, 8, 0, -19 },
  { 1540, 11, 20, 14, 1, -14 },
  { 1568, 10, 19, 14, 2, -19 },
  { 1592, 2, 18, 6, 2, -18 },
  { 1597, 5, 24, 6, -1, -18 },
  { 1612, 10, 19, 12, 2, -19 },
  { 1636, 2, 19, 6, 2, -19 },
  { 1641, 17, 14, 21, 2, -14 },
  { 1671, 10, 14, 14, 2, -14 },
  { 1689, 11, 14, 14, 1, -14 },
  { 1709, 11, 20, 14, 2, -14 },
  { 1737, 11, 20, 14, 1, -14 },
  { 1765, 7, 14, 9, 2, -14 },
  { 1778, 9, 14, 11, 1, -14 },
  { 1794, 8, 16, 8, 0, -16 },
  { 1810, 10, 13, 14, 2, -13 },
  { 1827, 11, 13, 11, 0, -13 },
  { 1845, 18, 13, 18, 0, -13 },
  { 1875, 11, 13, 12, 0, -13 },
  { 1893, 11, 19, 11, 0, -13 },
  { 1920, 8, 13, 10, 1, -13 },
  { 1933, 7, 22, 9, 1, -18 },
  { 1953, 2, 25, 12, 5, -19 },
  { 1960, 8, 22, 9, 1, -18 },
  { 1982, 11, 3, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Regular25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR25PT7B_H_
