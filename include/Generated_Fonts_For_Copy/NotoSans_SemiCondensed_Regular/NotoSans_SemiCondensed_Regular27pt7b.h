#ifndef _NOTOSANS_SEMICONDENSED_REGULAR27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF9, 0x24, 0x80, 0xFF, 0x80, 0xCF, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0x80, 0x06, 0x30, 0x10, 0xC0, 0xC2, 0x03, 0x18, 0x0C,
  0x63, 0xFF, 0xFF, 0xFF, 0xC2, 0x18, 0x18, 0x40, 0x63, 0x01, 0x8C, 0x3F,
  0xFE, 0xFF, 0xF8, 0x43, 0x03, 0x08, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03,
  0x18, 0x00, 0x06, 0x00, 0x60, 0x06, 0x01, 0xFC, 0x7F, 0xE6, 0x62, 0xE6,
  0x0E, 0x60, 0x66, 0x07, 0x60, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x66, 0x06,
  0x70, 0x67, 0x06, 0x6F, 0x7E, 0xFF, 0xC0, 0xE0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x10, 0x00, 0x0F, 0x80, 0xC1, 0x98, 0x30, 0x23, 0x06, 0x0C, 0x21,
  0x81, 0x86, 0x30, 0x30, 0xCC, 0x06, 0x19, 0x80, 0xC2, 0x67, 0x08, 0xCD,
  0xF1, 0x9B, 0x33, 0x1E, 0x6C, 0x61, 0x99, 0x84, 0x03, 0x30, 0xC0, 0xC6,
  0x18, 0x18, 0xC3, 0x06, 0x18, 0xC0, 0xC1, 0x98, 0x30, 0x3F, 0x06, 0x03,
  0xC0, 0x06, 0x00, 0x1F, 0x80, 0x39, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30,
  0xC0, 0x38, 0xC0, 0x19, 0x80, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0x73,
  0x86, 0x61, 0xCE, 0xE0, 0xCC, 0xE0, 0xFC, 0xE0, 0x78, 0xE0, 0x38, 0x70,
  0xFC, 0x7F, 0xEE, 0x3F, 0x87, 0xFF, 0xFC, 0x1C, 0x63, 0x8C, 0x71, 0x86,
  0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x61, 0x87, 0x0C, 0x38, 0x61,
  0xC0, 0xE1, 0x87, 0x0C, 0x38, 0x61, 0x86, 0x1C, 0x71, 0xC3, 0x1C, 0x71,
  0xC6, 0x18, 0x63, 0x8C, 0x71, 0x8E, 0x00, 0x0E, 0x01, 0xC0, 0x18, 0x03,
  0x0E, 0x4F, 0xFF, 0xC3, 0x80, 0x78, 0x1B, 0x07, 0x30, 0xC7, 0x00, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xF0, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x77, 0x66, 0x6C, 0xC0, 0xFF,
  0xF0, 0xFF, 0x80, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x18, 0x0E, 0x00, 0x04, 0x01, 0xF8, 0x3F, 0xC7, 0x0E, 0x60, 0x66, 0x06,
  0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0x60, 0x66, 0x06, 0x60, 0xE7, 0x0E, 0x3F, 0xC1, 0xF8, 0x0E, 0x3C, 0xFF,
  0xB4, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x06, 0x03, 0xF8, 0xFF, 0xC4, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x06, 0x07, 0xF8, 0xFB,
  0xC4, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x01, 0xC1, 0xF0, 0x1F,
  0x80, 0x1E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x68, 0x0E, 0xFF,
  0xCF, 0xF8, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0D, 0x80, 0x6C, 0x06, 0x60,
  0x63, 0x03, 0x18, 0x30, 0xC1, 0x86, 0x18, 0x31, 0x81, 0x8C, 0x0C, 0x7F,
  0xFF, 0xFF, 0xE0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0x9F, 0xF3,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xF0, 0xFF, 0x88, 0x78, 0x07,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x81, 0xDF, 0xF3, 0xFC, 0x00,
  0x01, 0x80, 0xFE, 0x1F, 0x63, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x6F, 0x8F, 0xFC, 0xF0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0x76, 0x07,
  0x70, 0x63, 0x0E, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x00, 0x02,
  0x03, 0xFC, 0x79, 0xE6, 0x06, 0x60, 0x66, 0x06, 0x60, 0x67, 0x0E, 0x39,
  0xC1, 0xF0, 0x1F, 0x83, 0x9C, 0x60, 0xEE, 0x07, 0xE0, 0x3C, 0x03, 0xE0,
  0x76, 0x06, 0x7F, 0xE1, 0xF8, 0x06, 0x03, 0xF8, 0x7F, 0xC6, 0x0E, 0xE0,
  0x6E, 0x06, 0xE0, 0x6E, 0x07, 0xE0, 0x76, 0x07, 0x71, 0xF3, 0xFF, 0x1E,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x7F, 0x87, 0xE0, 0x5F,
  0xA0, 0x00, 0x00, 0x0F, 0xF8, 0x27, 0x76, 0x00, 0x00, 0x00, 0x00, 0x77,
  0x66, 0xCC, 0xC0, 0x00, 0x10, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x1E, 0x07, 0x81,
  0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x04, 0x3F, 0xC7, 0xF9, 0x07, 0x00,
  0xC0, 0x30, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x06, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x70, 0x03, 0xFC, 0x00, 0xF1, 0xE0,
  0x30, 0x0E, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0x61, 0xF8, 0xD8, 0x7F, 0x1B,
  0x18, 0x63, 0x63, 0x0C, 0x68, 0xE1, 0x8F, 0x18, 0x31, 0xE3, 0x06, 0x3C,
  0x31, 0xC6, 0xC6, 0x38, 0xD8, 0xFD, 0xF3, 0x0F, 0x1C, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x8F, 0x00, 0x7F, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xCC, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0x30, 0x30, 0x60, 0x60, 0xE0, 0xFF, 0xC3, 0xFF, 0x86, 0x03, 0x9C,
  0x07, 0x38, 0x06, 0x60, 0x0F, 0xC0, 0x1F, 0x80, 0x18, 0xFF, 0xC7, 0xFF,
  0x38, 0x1D, 0xC0, 0xEE, 0x03, 0x70, 0x3B, 0x81, 0xDC, 0x1C, 0xFF, 0x87,
  0xFE, 0x38, 0x1D, 0xC0, 0x6E, 0x03, 0x70, 0x1F, 0x80, 0xDC, 0x0E, 0xE0,
  0xF7, 0xFF, 0x3F, 0xE0, 0x01, 0x00, 0xFF, 0x3F, 0xF7, 0x81, 0x70, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x81, 0x3F, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0x8E, 0x07, 0x38, 0x0E, 0xE0, 0x1B, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x6E, 0x03,
  0xB8, 0x1E, 0xE0, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0x3F, 0xF1,
  0xFF, 0x8E, 0x02, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0x70, 0x0C, 0xE0, 0x31, 0xFF, 0xC3, 0xFE, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xC0, 0xFE, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xFB, 0xF8, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xBF, 0x7C, 0xE0, 0x7F, 0x03, 0x38, 0x39,
  0xC3, 0x8E, 0x38, 0x71, 0x83, 0x9C, 0x1D, 0xC0, 0xFC, 0x07, 0xF0, 0x3D,
  0xC1, 0xC6, 0x0E, 0x38, 0x70, 0xE3, 0x87, 0x1C, 0x1C, 0xE0, 0x67, 0x03,
  0xB8, 0x0E, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F,
  0xFF, 0xFC, 0xF0, 0x01, 0xFC, 0x00, 0xFD, 0x80, 0x3F, 0x60, 0x1F, 0xF8,
  0x06, 0xFB, 0x01, 0xBE, 0xC0, 0xEF, 0xB8, 0x33, 0xE6, 0x0C, 0xF9, 0x87,
  0x3E, 0x71, 0x8F, 0x8C, 0x63, 0xE3, 0x38, 0xF8, 0xEC, 0x3E, 0x1B, 0x0F,
  0x87, 0x83, 0xE1, 0xE0, 0xF8, 0x38, 0x3E, 0x0C, 0x0C, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0xF6, 0x03, 0xDC, 0x0F, 0xB0, 0x3E, 0xE0, 0xF9, 0xC3, 0xE3,
  0x0F, 0x8E, 0x3E, 0x18, 0xF8, 0x73, 0xE0, 0xCF, 0x83, 0xBE, 0x07, 0xF8,
  0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xC0, 0x01, 0x00, 0x3F, 0xE0, 0xFF,
  0xE3, 0x81, 0xE6, 0x01, 0xDC, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0,
  0x06, 0x70, 0x1C, 0xF0, 0x70, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0x8F, 0xFC,
  0xE0, 0xEE, 0x06, 0xE0, 0x6E, 0x07, 0xE0, 0x6E, 0x06, 0xE0, 0xEF, 0xFC,
  0xFF, 0x8F, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x00, 0x01, 0x00, 0x3F, 0xE0, 0xFF, 0xE3, 0x81, 0xE6, 0x01, 0xDC,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0, 0x06, 0x70, 0x1C, 0xF0, 0x70,
  0xFF, 0xC0, 0x7F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0xFF, 0x87, 0xFE, 0x38, 0x39, 0xC0, 0xCE, 0x07, 0x70, 0x3B, 0x81,
  0x9C, 0x0C, 0xE0, 0xE7, 0xFE, 0x3F, 0xC1, 0xC7, 0x0E, 0x18, 0x70, 0xE3,
  0x83, 0x1C, 0x1C, 0xE0, 0x67, 0x03, 0xB8, 0x0E, 0x06, 0x07, 0xFD, 0xFF,
  0xB8, 0x1E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x1F, 0xFF, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x6C, 0x07, 0x70, 0x71, 0xFF,
  0x87, 0xF0, 0xE0, 0x0E, 0xC0, 0x19, 0x80, 0x73, 0x80, 0xC7, 0x01, 0x86,
  0x07, 0x0E, 0x0E, 0x1C, 0x18, 0x18, 0x70, 0x30, 0xE0, 0x71, 0x80, 0x63,
  0x00, 0xCE, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0xE0, 0x38, 0x0E, 0xC0, 0x70, 0x19, 0x80, 0xE0, 0x33, 0x83,
  0x60, 0xE7, 0x06, 0xC1, 0xC6, 0x0D, 0x83, 0x0C, 0x1B, 0x06, 0x1C, 0x63,
  0x1C, 0x38, 0xC6, 0x38, 0x31, 0x8C, 0x60, 0x67, 0x18, 0xC0, 0xCC, 0x19,
  0x81, 0xD8, 0x37, 0x01, 0xB0, 0x6C, 0x03, 0x60, 0xD8, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0xC0,
  0xE3, 0x87, 0x06, 0x18, 0x1C, 0xE0, 0x33, 0x00, 0xFC, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0C, 0xC0, 0x73, 0x81, 0x86, 0x0E,
  0x1C, 0x30, 0x31, 0x80, 0xEE, 0x01, 0xC0, 0xE0, 0x1D, 0x80, 0xE7, 0x03,
  0x0C, 0x1C, 0x38, 0x60, 0x63, 0x81, 0xCC, 0x03, 0x70, 0x0F, 0x80, 0x1E,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0xFF, 0xC0, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x1C, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x06, 0x00,
  0xF0, 0x0F, 0x01, 0x98, 0x19, 0x83, 0x1C, 0x30, 0xC3, 0x0E, 0x60, 0x66,
  0x07, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xE3, 0x0C, 0x30, 0x80, 0x0F, 0x07,
  0xF8, 0xC7, 0x00, 0x70, 0x0E, 0x01, 0xC1, 0xF9, 0xFF, 0x70, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x1E, 0xFE, 0xCF, 0x98, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC6, 0x0D, 0xFC, 0xF9, 0xEE, 0x0E, 0xE0, 0x6E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x06, 0xF0, 0xED,
  0xFC, 0xCF, 0x80, 0x07, 0x87, 0xF3, 0x89, 0xC0, 0x60, 0x18, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x4F, 0xF1, 0xFC, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x06, 0x33, 0xFB, 0x39, 0xF7,
  0x07, 0x60, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x76,
  0x07, 0x70, 0x73, 0xFB, 0x1F, 0x30, 0x0F, 0x01, 0xFC, 0x39, 0xC7, 0x06,
  0x60, 0x66, 0x06, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0x70, 0x23, 0xFE, 0x0F, 0xE0, 0x07, 0x07, 0xC7, 0x23, 0x01, 0x80, 0xC0,
  0xE1, 0xFE, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x0E, 0x03, 0xFB, 0x39, 0xF7, 0x07, 0x60,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x36, 0x07, 0x70,
  0x73, 0xFB, 0x1F, 0x30, 0x03, 0x00, 0x30, 0x07, 0x40, 0x67, 0xFE, 0x7F,
  0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x31, 0xC6, 0xFE,
  0xF9, 0xFC, 0x1F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06, 0xDF, 0x00, 0x36, 0xDB, 0x6D, 0xB6,
  0xDB, 0x60, 0x18, 0x71, 0x80, 0x00, 0x01, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0xFB, 0xC0, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x0E, 0xC3, 0x98, 0xE3,
  0x18, 0x66, 0x0D, 0xC1, 0xF8, 0x3F, 0x87, 0x30, 0xC7, 0x18, 0x73, 0x06,
  0x60, 0xEC, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x07, 0x1B,
  0xF3, 0xFB, 0xC7, 0xE7, 0x70, 0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF0,
  0x38, 0x3E, 0x07, 0x07, 0xC0, 0xE0, 0xF8, 0x1C, 0x1F, 0x03, 0x83, 0xE0,
  0x70, 0x7C, 0x0E, 0x0F, 0x81, 0xC1, 0xF0, 0x38, 0x38, 0x07, 0x1B, 0xFB,
  0xE7, 0xF0, 0x7E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x18, 0x07, 0x01, 0xFC, 0x38, 0xE7, 0x07,
  0x60, 0x36, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x36, 0x07,
  0x70, 0x63, 0xFE, 0x1F, 0x80, 0x07, 0x0D, 0xFC, 0xF9, 0xEE, 0x0E, 0xE0,
  0x6E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x6E, 0x06, 0xF0,
  0xED, 0xFC, 0xCF, 0x8C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x00, 0x0E, 0x03, 0xFB, 0x39, 0xF7, 0x07, 0x60, 0x7E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0x60, 0x76, 0x07, 0x70, 0xF3, 0xFB, 0x1F, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0xDF, 0xDD,
  0xF0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x1E, 0x3F, 0xFC, 0x78, 0x0C, 0x07, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xC0,
  0x60, 0x38, 0x1F, 0xFF, 0xFC, 0x18, 0x18, 0x18, 0x38, 0xFF, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F, 0x1F, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x83, 0xF0, 0xF7, 0xF6, 0x7C, 0xC0, 0xE0, 0x36, 0x07, 0x60, 0x67,
  0x06, 0x30, 0xE3, 0x0C, 0x38, 0xC1, 0x9C, 0x19, 0x81, 0xD8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0x70, 0xE0, 0xE0, 0x6C, 0x1C, 0x0D, 0x83, 0xC3, 0xB0,
  0x78, 0x67, 0x1B, 0x0C, 0x63, 0x61, 0x8C, 0x66, 0x71, 0x8C, 0xCC, 0x3B,
  0x19, 0x83, 0x63, 0x30, 0x6C, 0x3E, 0x0D, 0x87, 0x81, 0xE0, 0xF0, 0x1C,
  0x1E, 0x03, 0x81, 0xC0, 0x70, 0x73, 0x0E, 0x38, 0xC1, 0xDC, 0x0D, 0x80,
  0xF0, 0x07, 0x00, 0xF0, 0x0F, 0x81, 0xDC, 0x18, 0xC3, 0x0E, 0x70, 0x6E,
  0x07, 0xE0, 0x36, 0x07, 0x60, 0x67, 0x06, 0x30, 0xE3, 0x0C, 0x18, 0xC1,
  0x9C, 0x19, 0x80, 0xD8, 0x0D, 0x80, 0xF0, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0xBC, 0x0F, 0x80, 0xFF, 0x81, 0xC0, 0xC0, 0xE0,
  0x60, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x0F, 0xFF, 0xFC, 0x07,
  0x0F, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xF0, 0xC0, 0xF0,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x0F, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xF0, 0x38, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x0F, 0x03, 0x0F, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x38, 0xF0, 0xE0, 0x7C, 0x1F, 0xFF, 0x83, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Regular27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 7, 7, 11, 2, -19 },
  { 16, 14, 19, 16, 1, -19 },
  { 50, 12, 23, 14, 1, -21 },
  { 85, 19, 20, 21, 1, -20 },
  { 133, 16, 20, 17, 1, -20 },
  { 173, 2, 7, 6, 2, -19 },
  { 175, 6, 23, 8, 1, -19 },
  { 193, 6, 23, 8, 1, -19 },
  { 211, 11, 11, 13, 1, -21 },
  { 227, 12, 13, 14, 1, -16 },
  { 247, 4, 7, 7, 1, -3 },
  { 251, 6, 2, 8, 1, -8 },
  { 253, 3, 3, 7, 2, -3 },
  { 255, 10, 19, 10, 0, -19 },
  { 279, 12, 20, 14, 1, -20 },
  { 309, 7, 19, 14, 2, -19 },
  { 326, 12, 20, 14, 1, -20 },
  { 356, 12, 20, 14, 1, -20 },
  { 386, 13, 19, 14, 1, -19 },
  { 417, 11, 19, 14, 2, -19 },
  { 444, 12, 20, 14, 1, -20 },
  { 474, 12, 19, 14, 1, -19 },
  { 503, 12, 20, 14, 1, -20 },
  { 533, 12, 20, 14, 1, -20 },
  { 563, 3, 15, 7, 2, -15 },
  { 569, 4, 19, 7, 1, -15 },
  { 579, 12, 13, 14, 1, -16 },
  { 599, 12, 7, 14, 1, -13 },
  { 610, 12, 13, 14, 1, -16 },
  { 630, 10, 20, 11, 0, -20 },
  { 655, 19, 21, 22, 1, -19 },
  { 705, 15, 19, 15, 0, -19 },
  { 741, 13, 19, 16, 2, -19 },
  { 772, 12, 20, 15, 2, -20 },
  { 802, 14, 19, 18, 2, -19 },
  { 836, 10, 19, 14, 2, -19 },
  { 860, 10, 19, 13, 2, -19 },
  { 884, 14, 20, 18, 2, -20 },
  { 919, 14, 19, 18, 2, -19 },
  { 953, 7, 19, 9, 1, -19 },
  { 970, 7, 24, 7, -2, -19 },
  { 991, 13, 19, 15, 2, -19 },
  { 1022, 10, 19, 13, 2, -19 },
  { 1046, 18, 19, 23, 2, -19 },
  { 1089, 14, 19, 19, 2, -19 },
  { 1123, 15, 20, 19, 2, -20 },
  { 1161, 12, 19, 15, 2, -19 },
  { 1190, 15, 25, 19, 2, -20 },
  { 1237, 13, 19, 15, 2, -19 },
  { 1268, 11, 20, 13, 1, -20 },
  { 1296, 13, 19, 13, 0, -19 },
  { 1327, 13, 19, 18, 2, -19 },
  { 1358, 15, 19, 15, 0, -19 },
  { 1394, 23, 19, 23, 0, -19 },
  { 1449, 14, 19, 14, 0, -19 },
  { 1483, 14, 19, 14, 0, -19 },
  { 1517, 12, 19, 13, 1, -19 },
  { 1546, 6, 23, 9, 2, -19 },
  { 1564, 10, 19, 10, 0, -19 },
  { 1588, 6, 23, 9, 1, -19 },
  { 1606, 12, 11, 14, 1, -19 },
  { 1623, 12, 2, 12, 0, 2 },
  { 1626, 5, 5, 7, 1, -21 },
  { 1630, 11, 15, 14, 1, -15 },
  { 1651, 12, 21, 15, 2, -21 },
  { 1683, 10, 15, 12, 1, -15 },
  { 1702, 12, 21, 15, 1, -21 },
  { 1734, 12, 15, 14, 1, -15 },
  { 1757, 9, 21, 8, 0, -21 },
  { 1781, 12, 21, 15, 1, -15 },
  { 1813, 11, 21, 15, 2, -21 },
  { 1842, 3, 20, 7, 2, -20 },
  { 1850, 6, 26, 7, -1, -20 },
  { 1870, 11, 21, 13, 2, -21 },
  { 1899, 2, 21, 6, 2, -21 },
  { 1905, 19, 15, 23, 2, -15 },
  { 1941, 11, 15, 15, 2, -15 },
  { 1962, 12, 15, 15, 1, -15 },
  { 1985, 12, 21, 15, 2, -15 },
  { 2017, 12, 21, 15, 1, -15 },
  { 2049, 8, 15, 10, 2, -15 },
  { 2064, 9, 15, 12, 1, -15 },
  { 2081, 8, 18, 9, 0, -18 },
  { 2099, 11, 14, 15, 2, -14 },
  { 2119, 12, 14, 12, 0, -14 },
  { 2140, 19, 15, 19, 0, -15 },
  { 2176, 12, 14, 13, 0, -14 },
  { 2197, 12, 20, 12, 0, -14 },
  { 2227, 9, 14, 11, 1, -14 },
  { 2243, 8, 23, 10, 1, -19 },
  { 2266, 2, 27, 13, 6, -21 },
  { 2273, 8, 23, 10, 1, -19 },
  { 2296, 12, 3, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_Regular27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR27PT7B_H_
