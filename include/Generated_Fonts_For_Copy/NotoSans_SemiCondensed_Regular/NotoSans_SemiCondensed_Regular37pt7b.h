#ifndef _NOTOSANS_SEMICONDENSED_REGULAR37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x60, 0x00,
  0xFF, 0xFF, 0xF1, 0xFC, 0x77, 0x1D, 0xC7, 0x61, 0xD8, 0x76, 0x1D, 0x83,
  0x60, 0xC0, 0x01, 0xC3, 0x80, 0x18, 0x30, 0x03, 0x83, 0x00, 0x38, 0x30,
  0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x07, 0x07, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00, 0x60,
  0xC0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x0C,
  0x1C, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0xC1, 0x80, 0x1C, 0x38, 0x01,
  0xC3, 0x80, 0x18, 0x38, 0x01, 0x83, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x7F, 0x83, 0xFF, 0xEF, 0xFF, 0x9C, 0x63, 0x70, 0xC0, 0xE1, 0x81,
  0xC3, 0x03, 0x86, 0x07, 0x8C, 0x07, 0xD8, 0x07, 0xF0, 0x07, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0x3C, 0x06, 0x38, 0x0C, 0x70, 0x18, 0xE0, 0x31,
  0xF0, 0x67, 0xFF, 0xFE, 0xFF, 0xF8, 0x7F, 0xC0, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x38, 0x1F, 0xE0,
  0x38, 0x1C, 0x70, 0x1C, 0x0E, 0x18, 0x1C, 0x07, 0x0E, 0x0E, 0x03, 0x07,
  0x0E, 0x01, 0x83, 0x87, 0x00, 0xC1, 0xC7, 0x00, 0x60, 0xE3, 0x80, 0x30,
  0x73, 0x80, 0x1C, 0x39, 0xCF, 0x8E, 0x19, 0xCF, 0xE7, 0x1C, 0xE7, 0x39,
  0xFE, 0x67, 0x1C, 0x7E, 0x73, 0x86, 0x1C, 0x31, 0x83, 0x80, 0x38, 0xC1,
  0xC0, 0x18, 0x60, 0xE0, 0x1C, 0x30, 0x70, 0x0C, 0x18, 0x38, 0x0E, 0x0C,
  0x1C, 0x06, 0x07, 0x0C, 0x07, 0x03, 0x86, 0x03, 0x00, 0xC7, 0x03, 0x80,
  0x7F, 0x01, 0xC0, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x70, 0x03, 0x83, 0xC0,
  0x0E, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0x71, 0xE0, 0x01, 0xEF, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0x1E, 0x78,
  0x1C, 0xF0, 0xF0, 0xF3, 0xC1, 0xE3, 0x8E, 0x03, 0xCE, 0x38, 0x07, 0xF0,
  0xE0, 0x0F, 0xC3, 0x80, 0x1E, 0x0E, 0x00, 0xFC, 0x3C, 0x07, 0xF0, 0x7F,
  0xFD, 0xE0, 0xFF, 0xE3, 0xC1, 0xFE, 0x07, 0xC0, 0xFF, 0x77, 0x66, 0x66,
  0x60, 0x0F, 0x0E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xF0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0,
  0x70, 0x70, 0x78, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0xF0, 0x70, 0x38,
  0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C,
  0x1C, 0x38, 0x38, 0x70, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x41, 0x81, 0x79, 0x9E, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x07,
  0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x38, 0x3C, 0x3C, 0x04, 0x10, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x3C,
  0xF3, 0x8E, 0x79, 0xC7, 0x18, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xDE,
  0xF0, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x1F, 0xF0,
  0x3F, 0xF8, 0x3C, 0x78, 0x78, 0x1C, 0x70, 0x1C, 0xF0, 0x1E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xF0, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x3E, 0xF8, 0x1F, 0xF0,
  0x0F, 0xE0, 0x03, 0x87, 0xC7, 0xE7, 0xF7, 0xBF, 0x9D, 0x8E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x07, 0xC0, 0x7F, 0xE1,
  0xFF, 0xE7, 0x83, 0xE6, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x80, 0x7F, 0xE3, 0xFF, 0xE7, 0x83, 0xE4, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x07, 0xC1, 0xFE, 0x03,
  0xFC, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x1E, 0xF9, 0xFD, 0xFF, 0xF3,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x37, 0x00, 0x1D, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x38, 0x70, 0x1C, 0x1C, 0x07, 0x07, 0x03, 0x81, 0xC0,
  0xC0, 0x70, 0x70, 0x1C, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xFF, 0x83,
  0xFF, 0xC7, 0xFF, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x7C, 0xFC,
  0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE1, 0xC0, 0xE7, 0xF8, 0xEF, 0xFC, 0xFC, 0x3C, 0xF0, 0x1E, 0xF0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x38, 0x1E, 0x3E, 0x7C, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8,
  0x78, 0x3C, 0x70, 0x1E, 0xF0, 0x0E, 0xE0, 0x0E, 0xF0, 0x0E, 0x70, 0x1E,
  0x70, 0x1C, 0x3C, 0x38, 0x1E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0,
  0x3C, 0x7C, 0x70, 0x3C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1E, 0x7C, 0x7C, 0x3F, 0xF8, 0x1F, 0xF0,
  0x07, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xC7, 0x03, 0xDC, 0x03, 0xB8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x01,
  0xEE, 0x07, 0xDF, 0xBF, 0x9F, 0xF7, 0x1F, 0xCE, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x63, 0xF0, 0xFF,
  0xC1, 0xFE, 0x00, 0xEF, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x39, 0xF7, 0xCF, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0xE3, 0x9E, 0x71, 0xC7, 0x18, 0xE0, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x07,
  0x81, 0xFF, 0x8F, 0xFF, 0x1C, 0x1E, 0x40, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x0E, 0x30, 0x3F, 0xE3, 0x9C, 0x1F, 0xF8, 0x67, 0x0F, 0x0E, 0x1D, 0x83,
  0x83, 0x87, 0xE1, 0xC0, 0xC1, 0xF8, 0x70, 0x30, 0x7E, 0x1C, 0x0C, 0x1F,
  0x87, 0x03, 0x07, 0xE1, 0xC1, 0xC1, 0xF8, 0x70, 0x70, 0x7E, 0x1C, 0x1C,
  0x1B, 0x87, 0x07, 0x8E, 0xE0, 0xF7, 0x77, 0x18, 0x3F, 0x9F, 0xC7, 0x03,
  0xC3, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x01, 0x00, 0x3E, 0x03, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00,
  0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x71, 0xC0, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x78, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0x00, 0x78, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x79, 0xE0,
  0x01, 0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3C, 0x1F, 0x9E, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x3B, 0xC0,
  0x1D, 0xE0, 0x0E, 0xF0, 0x0F, 0x78, 0x07, 0x3C, 0x0F, 0x9F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFF, 0xF3, 0xC0, 0x3D, 0xE0, 0x0E, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3B, 0xC0, 0x7D, 0xFF,
  0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7E, 0x0E, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x02,
  0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xC3, 0xFC, 0x78, 0x07, 0x8F, 0x00, 0x79, 0xE0, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0x0E, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3B, 0xC0, 0x07, 0x78, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x1F, 0x3C,
  0x07, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFC, 0x1E, 0x1E, 0x00, 0x23,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00,
  0x07, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x3C, 0x00, 0x71, 0xF0, 0x07, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x70, 0xFF, 0xFF, 0xC7, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0xFF, 0xFF, 0xC0,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0xFE, 0xFE, 0xF8, 0xF0, 0x07, 0xBC,
  0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x70, 0xF0, 0x38, 0x3C, 0x1E, 0x0F, 0x0F,
  0x03, 0xC3, 0x80, 0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0x9C, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x3C,
  0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x00,
  0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xF0, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0xE0, 0x03, 0xBF, 0x70, 0x01,
  0xDF, 0xB8, 0x00, 0xEF, 0xCE, 0x00, 0xE7, 0xE7, 0x00, 0x73, 0xF3, 0x80,
  0x31, 0xF8, 0xE0, 0x38, 0xFC, 0x70, 0x1C, 0x7E, 0x38, 0x0C, 0x3F, 0x0E,
  0x0E, 0x1F, 0x87, 0x07, 0x0F, 0xC3, 0x83, 0x07, 0xE0, 0xE3, 0x83, 0xF0,
  0x71, 0xC1, 0xF8, 0x39, 0xC0, 0xFC, 0x0E, 0xE0, 0x7E, 0x07, 0x70, 0x3F,
  0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3C, 0x03,
  0xF0, 0x0E, 0x01, 0xC0, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xDC, 0x01, 0xFB, 0xC0, 0x3F, 0x3C, 0x07, 0xE3,
  0x80, 0xFC, 0x78, 0x1F, 0x87, 0x03, 0xF0, 0xF0, 0x7E, 0x0E, 0x0F, 0xC1,
  0xE1, 0xF8, 0x1E, 0x3F, 0x01, 0xC7, 0xE0, 0x3C, 0xFC, 0x03, 0x9F, 0x80,
  0x7B, 0xF0, 0x07, 0x7E, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x03, 0xC7, 0x80,
  0x07, 0x1C, 0x00, 0x1E, 0x70, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03,
  0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00,
  0x1E, 0x78, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x78,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0xFF,
  0xF8, 0xF1, 0xFC, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x7C, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8,
  0x3E, 0x01, 0xE0, 0xF0, 0x03, 0xC7, 0x80, 0x07, 0x1C, 0x00, 0x1E, 0x70,
  0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xE0,
  0x01, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x78, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3C, 0x7F, 0x1E, 0x03, 0xCF, 0x00, 0xE7, 0x80, 0x73, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x0E, 0x78, 0x07, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0xFF, 0xC7,
  0xFF, 0x83, 0xFF, 0x81, 0xE1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x3C, 0x0E,
  0x1E, 0x07, 0x8F, 0x01, 0xC7, 0x80, 0xF3, 0xC0, 0x39, 0xE0, 0x1E, 0xF0,
  0x07, 0x78, 0x03, 0xC0, 0x07, 0xC0, 0x3F, 0xF8, 0xFF, 0xF3, 0xE0, 0xEF,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x40,
  0x1E, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xDC, 0x00, 0xE7, 0x80, 0x78, 0xFF, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x70, 0x00,
  0xE7, 0x80, 0x1E, 0x38, 0x01, 0xE3, 0x80, 0x1C, 0x3C, 0x03, 0xC3, 0xC0,
  0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x1E, 0x07, 0x80, 0xE0, 0x70, 0x0E,
  0x07, 0x00, 0xF0, 0xF0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x9E, 0x00,
  0x39, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0xE0, 0x07, 0x80, 0x3D, 0xC0, 0x1F, 0x00, 0x73, 0xC0, 0x3E,
  0x00, 0xE3, 0x80, 0x7E, 0x01, 0xC7, 0x00, 0xDC, 0x07, 0x8E, 0x03, 0xB8,
  0x0F, 0x1E, 0x07, 0x70, 0x1C, 0x3C, 0x0E, 0x70, 0x38, 0x38, 0x38, 0xE0,
  0x70, 0x70, 0x71, 0xC1, 0xE0, 0xE0, 0xE3, 0x83, 0x81, 0xE1, 0xC3, 0x87,
  0x01, 0xC7, 0x07, 0x0E, 0x03, 0x8E, 0x0E, 0x3C, 0x07, 0x1C, 0x0E, 0x70,
  0x0F, 0x38, 0x1C, 0xE0, 0x0E, 0xE0, 0x39, 0xC0, 0x1D, 0xC0, 0x77, 0x80,
  0x3B, 0x80, 0x6E, 0x00, 0x77, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x03,
  0x80, 0x0F, 0x00, 0x78, 0x01, 0xE7, 0x00, 0x70, 0xF0, 0x0E, 0x0E, 0x03,
  0x80, 0xE0, 0xF0, 0x1C, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x03, 0xBC,
  0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x07, 0xBC, 0x00, 0xE3, 0x80, 0x3C, 0x38,
  0x07, 0x07, 0x01, 0xE0, 0x70, 0x38, 0x0F, 0x0E, 0x00, 0xE1, 0xC0, 0x1E,
  0x70, 0x01, 0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xEE, 0x00, 0x79, 0xE0, 0x0E,
  0x1C, 0x03, 0xC3, 0xC0, 0x70, 0x38, 0x1E, 0x07, 0x83, 0x80, 0x70, 0x70,
  0x0F, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x3B, 0x80, 0x18,
  0xC0, 0x1C, 0x70, 0x0C, 0x18, 0x0E, 0x0E, 0x07, 0x03, 0x07, 0x01, 0xC3,
  0x80, 0x63, 0x80, 0x39, 0xC0, 0x0D, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x38, 0x3C, 0x1E, 0x0E, 0x03, 0x0F, 0xE1, 0xFF, 0xE3,
  0xEF, 0x88, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x07, 0xFC,
  0xFF, 0xF7, 0xE1, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F,
  0xE0, 0x7F, 0xC3, 0xF7, 0xFD, 0xCF, 0xE3, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE7,
  0xF0, 0xEF, 0xF8, 0xFF, 0xFC, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0xF8, 0x1E, 0xFE, 0x7C, 0xEF,
  0xF8, 0xC7, 0xF0, 0x07, 0xF0, 0xFF, 0xCF, 0xFC, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xF3, 0xC7, 0xFE, 0x1F, 0xE0,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x0F, 0xC7, 0x1F, 0xF7, 0x3E, 0xFF, 0x78, 0x1F,
  0x70, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F,
  0x78, 0x1F, 0x3C, 0x7F, 0x3F, 0xF7, 0x0F, 0xE7, 0x0F, 0xE0, 0x3F, 0xE0,
  0xFB, 0xE3, 0xC1, 0xE7, 0x01, 0xDE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x02, 0x7E, 0x78, 0x7F, 0xF0, 0x7F, 0xC0, 0x03, 0xF8,
  0x3F, 0x83, 0xE4, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x3F,
  0xE7, 0xFF, 0x3F, 0xF8, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x0F, 0xC7, 0x1F, 0xF7,
  0x3F, 0xF7, 0x78, 0x1F, 0x70, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1F, 0x3E, 0x7F, 0x3F, 0xF7, 0x0F, 0xE7,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x60, 0x3E,
  0x7F, 0xFC, 0x7F, 0xF8, 0x0F, 0xE0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE3, 0xF1, 0xDF,
  0xF3, 0xFF, 0xF7, 0xC0, 0xEF, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x70, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x1C,
  0x38, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x1F, 0xFB, 0xF7, 0x80, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x3D, 0xC0,
  0xF3, 0x81, 0xC7, 0x07, 0x0E, 0x1E, 0x1C, 0x78, 0x39, 0xE0, 0x73, 0x80,
  0xEE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0x9C, 0x0E, 0x3C, 0x1C, 0x3C, 0x38,
  0x38, 0x70, 0x78, 0xE0, 0x71, 0xC0, 0xF3, 0x80, 0xF7, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC7, 0xE0,
  0xFE, 0x77, 0xFC, 0xFF, 0xBF, 0xFE, 0xFF, 0xFF, 0x07, 0xE0, 0xFF, 0x01,
  0xE0, 0x3F, 0x80, 0xF0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0,
  0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x7E,
  0x01, 0xC0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07,
  0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80,
  0x70, 0xC3, 0xF1, 0xDF, 0xF3, 0xFF, 0xF7, 0xC0, 0xEF, 0x01, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x70, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x1E, 0x70,
  0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x70, 0x0E, 0x78,
  0x1E, 0x3E, 0x3C, 0x1F, 0xF8, 0x0F, 0xF0, 0xE7, 0xF0, 0xEF, 0xF8, 0xFF,
  0xFC, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0E, 0xF0, 0x1E, 0xF8, 0x1E, 0xFC, 0x7C, 0xEF, 0xF8, 0xE7, 0xF0, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xC7, 0x1F, 0xF7, 0x3E, 0xF7, 0x78,
  0x1F, 0x70, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0x70,
  0x0F, 0x78, 0x1F, 0x3E, 0x7F, 0x3F, 0xF7, 0x0F, 0xC7, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0xC3, 0xFB, 0xFE, 0xFF, 0xF0, 0xF8, 0x3C, 0x0F, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0x1F, 0xE7, 0xFF, 0xFD, 0xEE, 0x02, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x7F, 0x1F, 0xFF, 0xEF, 0xFC, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C,
  0x07, 0x91, 0xFC, 0x3F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x3E,
  0xF9, 0xFD, 0xFF, 0xB9, 0xFE, 0x70, 0xE0, 0x07, 0xF8, 0x03, 0x9C, 0x01,
  0xCE, 0x01, 0xE7, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x78, 0x38, 0x1C,
  0x1C, 0x0E, 0x0E, 0x07, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x7B, 0x80,
  0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0xF0, 0x0E, 0x01, 0xDC, 0x07, 0x80, 0x77, 0x01, 0xF0, 0x3D, 0xC0,
  0x7C, 0x0E, 0x78, 0x3B, 0x03, 0x8E, 0x0E, 0xE0, 0xE3, 0x83, 0xB8, 0x38,
  0xE0, 0xCE, 0x1C, 0x3C, 0x73, 0x87, 0x07, 0x1C, 0x71, 0xC1, 0xC7, 0x1C,
  0x70, 0x73, 0x87, 0x38, 0x0E, 0xE0, 0xCE, 0x03, 0xB8, 0x3B, 0x80, 0xEE,
  0x0E, 0xE0, 0x3B, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00,
  0x78, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x70, 0x1E, 0x78, 0x1C,
  0x38, 0x3C, 0x1C, 0x38, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0x70, 0x1C, 0x70,
  0x3C, 0x38, 0x38, 0x3C, 0x78, 0x1C, 0x70, 0x1E, 0xE0, 0x0F, 0xF0, 0x07,
  0xB8, 0x03, 0x9C, 0x01, 0xCF, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xF0,
  0x38, 0x38, 0x38, 0x1C, 0x1C, 0x0F, 0x0E, 0x03, 0x8E, 0x01, 0xC7, 0x00,
  0xE3, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x00,
  0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x3F,
  0x07, 0xC0, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0xFC, 0x0F, 0x00, 0xFC, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8,
  0x0F, 0xC0, 0x3E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0xF0, 0x1F, 0x03,
  0xF0, 0x78, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x0F, 0xC0, 0xF8, 0x0E, 0x00, 0x7F,
  0x01, 0xFF, 0xC7, 0xC7, 0xFF, 0x80, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_Regular37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 26, 10, 3, -26 },
  { 14, 10, 9, 15, 2, -26 },
  { 26, 20, 26, 21, 1, -26 },
  { 91, 15, 30, 19, 2, -28 },
  { 148, 25, 27, 28, 2, -27 },
  { 233, 22, 27, 24, 2, -27 },
  { 308, 4, 9, 8, 2, -26 },
  { 313, 8, 32, 11, 2, -26 },
  { 345, 8, 32, 11, 1, -26 },
  { 377, 16, 15, 18, 1, -28 },
  { 407, 16, 18, 19, 2, -22 },
  { 443, 6, 9, 9, 1, -4 },
  { 450, 9, 3, 11, 1, -11 },
  { 454, 5, 4, 9, 2, -4 },
  { 457, 13, 26, 14, 0, -26 },
  { 500, 16, 27, 19, 2, -27 },
  { 554, 9, 26, 19, 3, -26 },
  { 584, 15, 27, 19, 2, -27 },
  { 635, 15, 27, 19, 2, -27 },
  { 686, 18, 27, 19, 1, -27 },
  { 747, 15, 26, 19, 2, -26 },
  { 796, 16, 27, 19, 2, -27 },
  { 850, 17, 26, 19, 1, -26 },
  { 906, 16, 27, 19, 2, -27 },
  { 960, 15, 27, 19, 2, -27 },
  { 1011, 4, 20, 9, 3, -20 },
  { 1021, 6, 25, 9, 1, -20 },
  { 1040, 16, 17, 19, 2, -22 },
  { 1074, 15, 10, 19, 2, -18 },
  { 1093, 16, 17, 19, 2, -22 },
  { 1127, 14, 27, 14, 0, -27 },
  { 1175, 26, 30, 30, 2, -27 },
  { 1273, 21, 26, 21, 0, -26 },
  { 1342, 17, 26, 22, 3, -26 },
  { 1398, 18, 27, 21, 2, -27 },
  { 1459, 19, 26, 24, 3, -26 },
  { 1521, 13, 26, 19, 3, -26 },
  { 1564, 13, 26, 17, 3, -26 },
  { 1607, 20, 27, 24, 2, -27 },
  { 1675, 18, 26, 25, 3, -26 },
  { 1734, 9, 26, 12, 1, -26 },
  { 1764, 8, 33, 9, -2, -26 },
  { 1797, 18, 26, 21, 3, -26 },
  { 1856, 14, 26, 17, 3, -26 },
  { 1902, 25, 26, 31, 3, -26 },
  { 1984, 19, 26, 26, 3, -26 },
  { 2046, 22, 27, 26, 2, -27 },
  { 2121, 16, 26, 20, 3, -26 },
  { 2173, 22, 33, 26, 2, -27 },
  { 2264, 17, 26, 21, 3, -26 },
  { 2320, 15, 27, 18, 2, -27 },
  { 2371, 18, 26, 18, 0, -26 },
  { 2430, 18, 26, 24, 3, -26 },
  { 2489, 20, 26, 20, 0, -26 },
  { 2554, 31, 26, 32, 0, -26 },
  { 2655, 19, 26, 19, 0, -26 },
  { 2717, 19, 26, 19, 0, -26 },
  { 2779, 16, 26, 18, 1, -26 },
  { 2831, 8, 32, 12, 3, -26 },
  { 2863, 13, 26, 14, 0, -26 },
  { 2906, 8, 32, 12, 1, -26 },
  { 2938, 17, 16, 19, 1, -27 },
  { 2972, 16, 3, 16, 0, 3 },
  { 2978, 8, 6, 10, 1, -28 },
  { 2984, 14, 20, 19, 2, -20 },
  { 3019, 16, 28, 21, 3, -28 },
  { 3075, 13, 20, 16, 2, -20 },
  { 3108, 16, 28, 21, 2, -28 },
  { 3164, 15, 20, 19, 2, -20 },
  { 3202, 13, 28, 12, 0, -28 },
  { 3248, 16, 29, 21, 2, -20 },
  { 3306, 15, 28, 21, 3, -28 },
  { 3359, 3, 27, 9, 3, -27 },
  { 3370, 7, 36, 9, -1, -27 },
  { 3402, 15, 28, 18, 3, -28 },
  { 3455, 3, 28, 9, 3, -28 },
  { 3466, 25, 20, 31, 3, -20 },
  { 3529, 15, 20, 21, 3, -20 },
  { 3567, 16, 20, 20, 2, -20 },
  { 3607, 16, 29, 21, 3, -20 },
  { 3665, 16, 29, 21, 2, -20 },
  { 3723, 10, 20, 14, 3, -20 },
  { 3748, 12, 20, 16, 2, -20 },
  { 3778, 10, 24, 12, 1, -24 },
  { 3808, 15, 20, 21, 3, -20 },
  { 3846, 17, 20, 17, 0, -20 },
  { 3889, 26, 20, 27, 0, -20 },
  { 3954, 16, 20, 17, 1, -20 },
  { 3994, 17, 29, 17, 0, -20 },
  { 4056, 13, 20, 15, 1, -20 },
  { 4089, 12, 32, 14, 1, -26 },
  { 4137, 3, 37, 18, 8, -28 },
  { 4151, 12, 32, 14, 1, -26 },
  { 4199, 16, 4, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_Regular37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR37PT7B_H_
