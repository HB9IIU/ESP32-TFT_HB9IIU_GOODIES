#ifndef _NOTOSANS_SEMICONDENSED_REGULAR50PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular50pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7,
  0x9E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE0, 0x00, 0x00, 0x03,
  0x9F, 0xFF, 0xF7, 0xDF, 0x30, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7B, 0xC1, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03,
  0x9C, 0x0E, 0x70, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E,
  0x07, 0x00, 0x03, 0xC0, 0xE0, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xC0, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0,
  0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xF0,
  0x00, 0x38, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x3C,
  0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFC, 0x7E, 0xE1, 0xE7, 0xC7, 0x01, 0x3C, 0x38, 0x01, 0xE1,
  0xC0, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC3, 0x80, 0x1F, 0x1C, 0x00,
  0x7E, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1C, 0x7E, 0x00, 0xE1, 0xF0,
  0x07, 0x07, 0x80, 0x38, 0x3E, 0x01, 0xC1, 0xE0, 0x0E, 0x0F, 0x00, 0x70,
  0x7B, 0x03, 0x87, 0xDF, 0x9D, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x07, 0xF8,
  0x00, 0x78, 0x03, 0xFF, 0x00, 0x1E, 0x00, 0xE1, 0xE0, 0x0F, 0x00, 0x78,
  0x78, 0x03, 0xC0, 0x1C, 0x0E, 0x01, 0xE0, 0x07, 0x03, 0xC0, 0x78, 0x03,
  0xC0, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x03, 0x80,
  0x0F, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x70, 0x00, 0xF0, 0x3C, 0x3C,
  0x00, 0x3C, 0x0F, 0x0E, 0x00, 0x0F, 0x03, 0xC7, 0x87, 0xC1, 0xC0, 0xF1,
  0xC7, 0xF8, 0x70, 0x38, 0xF1, 0xFF, 0x1E, 0x1E, 0x38, 0xF3, 0xE3, 0xC7,
  0x9E, 0x38, 0x78, 0xFF, 0xC7, 0x1E, 0x0E, 0x1F, 0xE3, 0xC7, 0x83, 0xC3,
  0xF0, 0xE1, 0xC0, 0xF0, 0x00, 0x78, 0x70, 0x1C, 0x00, 0x1E, 0x1C, 0x07,
  0x00, 0x0F, 0x07, 0x01, 0xC0, 0x03, 0xC1, 0xC0, 0x70, 0x01, 0xE0, 0x70,
  0x1C, 0x00, 0x78, 0x1C, 0x07, 0x00, 0x3C, 0x07, 0x03, 0xC0, 0x0F, 0x01,
  0xC0, 0xF0, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xE0, 0x1E, 0x0E, 0x00, 0x70,
  0x03, 0xC7, 0x80, 0x3C, 0x00, 0xFF, 0xE0, 0x0E, 0x00, 0x1F, 0xF0, 0x07,
  0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0x07, 0xEF, 0x80, 0x7C, 0x3F,
  0x1F, 0x01, 0xF0, 0xF8, 0x3E, 0x07, 0x87, 0xC0, 0xFC, 0x1E, 0x1E, 0x01,
  0xF8, 0xF8, 0xF8, 0x03, 0xF3, 0xC3, 0xE0, 0x07, 0xFF, 0x0F, 0x80, 0x0F,
  0xF8, 0x3E, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC,
  0x07, 0xC0, 0x07, 0xF8, 0x1F, 0x80, 0x7F, 0xF0, 0x3F, 0x8F, 0xF7, 0xE0,
  0xFF, 0xFF, 0x8F, 0xC1, 0xFF, 0xFC, 0x1F, 0x81, 0xFF, 0xC0, 0x3F, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x00,
  0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E,
  0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8,
  0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x01, 0x01,
  0xC0, 0x5F, 0x8E, 0x3E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xEF, 0x00, 0x1E, 0x78, 0x00, 0xF1,
  0xE0, 0x0F, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x0C, 0x06, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xCF, 0x9F,
  0x3C, 0x78, 0xE3, 0xC7, 0x8E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x79, 0xFF, 0xFF, 0xFD, 0xF1, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0x03,
  0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x1F, 0x0F, 0x00, 0x3C, 0x7C, 0x00, 0xF9,
  0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xE0,
  0x01, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80,
  0x07, 0x9F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xE0, 0x1F,
  0x07, 0xC0, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x78, 0x07, 0xC0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x8F, 0xBC, 0xF9, 0xFF, 0x9F, 0xF8, 0xFB, 0x87, 0xC8, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xC0, 0x3E, 0x18, 0x00, 0xF8, 0x80, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC7, 0x80, 0x3F, 0x10, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xD8, 0x00, 0x7E, 0xFC, 0x1F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x79, 0xE0, 0x00,
  0x71, 0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x03,
  0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x01, 0xE0, 0x0F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x78,
  0x01, 0xE0, 0x70, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87,
  0xFF, 0xFC, 0x20, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xEC, 0x00,
  0x7E, 0xF8, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFB,
  0x80, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC7, 0xFC, 0x1E, 0x7F, 0xF0, 0xF7, 0xFF, 0xC7, 0xF8,
  0x3F, 0x3F, 0x00, 0xFD, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0x78, 0x00, 0x7B,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xF0, 0x07, 0xC7,
  0xC0, 0x7C, 0x1F, 0x8F, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xFE, 0x07, 0xF3, 0xF8, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC7,
  0xC0, 0x0F, 0x9E, 0x00, 0x3E, 0x78, 0x00, 0xF9, 0xE0, 0x03, 0xE7, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x3E, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0xFC, 0x7C,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF8, 0x03,
  0xF7, 0xF0, 0x1F, 0x07, 0xE0, 0xF8, 0x0F, 0xC7, 0xC0, 0x0F, 0x9E, 0x00,
  0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x3F,
  0x03, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x30,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xE0, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x00, 0x1E, 0x78, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x0F,
  0xCF, 0x80, 0xFE, 0x7F, 0xFE, 0xF1, 0xFF, 0xE7, 0x83, 0xFE, 0x3C, 0x03,
  0xC1, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x30, 0x3F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x20, 0x00, 0x00, 0x79, 0xFF, 0xFF, 0x7D, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7, 0xFF, 0xFD, 0xF7, 0xC4,
  0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xCF, 0x9F, 0x3C, 0xF9, 0xF3,
  0xC7, 0x8F, 0x3C, 0x78, 0xE1, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xE6, 0x01, 0xFA, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x07, 0xF8,
  0x0E, 0x1C, 0x03, 0xFF, 0xC1, 0xE7, 0x80, 0xFF, 0xF8, 0x1C, 0xF0, 0x3E,
  0x0F, 0x03, 0x9C, 0x0F, 0x81, 0xE0, 0x77, 0x81, 0xE0, 0x3C, 0x0F, 0xF0,
  0x78, 0x07, 0x81, 0xFE, 0x0F, 0x00, 0xF0, 0x3F, 0x81, 0xE0, 0x1E, 0x07,
  0xF0, 0x3C, 0x03, 0xC0, 0xFE, 0x07, 0x80, 0x78, 0x1F, 0xC0, 0xF0, 0x0E,
  0x03, 0xF8, 0x1E, 0x03, 0xC0, 0x77, 0x03, 0xC0, 0x78, 0x0E, 0xE0, 0x78,
  0x0F, 0x03, 0xDC, 0x0F, 0x03, 0xF0, 0x73, 0xC0, 0xF0, 0x7E, 0x1E, 0x78,
  0x1F, 0xFD, 0xFF, 0x8F, 0x01, 0xFF, 0x1F, 0xE0, 0xF0, 0x1F, 0xC1, 0xF8,
  0x1E, 0x00, 0x40, 0x08, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x20, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0xC0, 0x3E, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x1E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x8F, 0x80, 0x3F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03,
  0xEF, 0x80, 0x07, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x0F, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xC0, 0x3F, 0xCF,
  0x80, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE0,
  0x0E, 0x1F, 0x80, 0x02, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x02, 0x0F, 0xFE,
  0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0xF8, 0x07, 0xF8, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE3,
  0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E,
  0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC3, 0xE0, 0x0F, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBE, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x78, 0x1F, 0x80, 0x01,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0x78, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0xF8, 0x7F, 0x00, 0x1F, 0x07, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE8, 0xFC, 0xFF,
  0xCF, 0xF8, 0xFF, 0x01, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8,
  0x1E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x78, 0x00, 0x07, 0xFF, 0xDE, 0x00, 0x01, 0xFF,
  0xF7, 0xC0, 0x00, 0xF7, 0xFC, 0xF0, 0x00, 0x3D, 0xFF, 0x3C, 0x00, 0x0E,
  0x7F, 0xC7, 0x80, 0x07, 0x9F, 0xF1, 0xE0, 0x01, 0xE7, 0xFC, 0x78, 0x00,
  0x71, 0xFF, 0x8F, 0x00, 0x3C, 0x7F, 0xE3, 0xC0, 0x0F, 0x1F, 0xF8, 0xF0,
  0x03, 0x87, 0xFE, 0x1E, 0x01, 0xE1, 0xFF, 0x87, 0x80, 0x78, 0x7F, 0xE1,
  0xE0, 0x3C, 0x1F, 0xF8, 0x3C, 0x0F, 0x07, 0xFE, 0x0F, 0x03, 0xC1, 0xFF,
  0x83, 0xC1, 0xE0, 0x7F, 0xE0, 0x78, 0x78, 0x1F, 0xF8, 0x1E, 0x1E, 0x07,
  0xFE, 0x07, 0x8F, 0x01, 0xFF, 0x80, 0xF3, 0xC0, 0x7F, 0xE0, 0x3C, 0xF0,
  0x1F, 0xF8, 0x0F, 0x78, 0x07, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0xE0, 0x1F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00,
  0xFC, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0x80, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0x00,
  0x0F, 0xF7, 0xC0, 0x03, 0xFC, 0xF8, 0x00, 0xFF, 0x1E, 0x00, 0x3F, 0xC7,
  0xC0, 0x0F, 0xF0, 0xF0, 0x03, 0xFC, 0x3E, 0x00, 0xFF, 0x07, 0xC0, 0x3F,
  0xE1, 0xF0, 0x0F, 0xF8, 0x3E, 0x03, 0xFE, 0x0F, 0x80, 0xFF, 0x81, 0xF0,
  0x3F, 0xE0, 0x3C, 0x0F, 0xF8, 0x0F, 0x83, 0xFE, 0x01, 0xF0, 0xFF, 0x80,
  0x7C, 0x3F, 0xE0, 0x0F, 0x8F, 0xF8, 0x03, 0xE3, 0xFE, 0x00, 0x7C, 0xFF,
  0x80, 0x0F, 0x3F, 0xE0, 0x03, 0xEF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x1F,
  0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x80, 0xFE,
  0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x3F, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x1F, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x6F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x80, 0xFF, 0x1F, 0x00, 0x7E, 0x3E,
  0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xF3, 0xE0,
  0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00,
  0x3C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0x03, 0xC0, 0x3E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC3, 0xF0, 0x0E, 0x3E, 0x00, 0x11, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xDC,
  0x00, 0x7C, 0xFF, 0x3F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x7F, 0xFC,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0xF9, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xE7, 0xFC, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x3E, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0x7C, 0x00,
  0x7C, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF8, 0x0F,
  0x80, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xC0, 0x01,
  0xF7, 0xC0, 0x03, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x7C,
  0x00, 0x3F, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0xE0, 0x03, 0xE3, 0xC0, 0x07,
  0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xFE, 0x00, 0x3C, 0x3E, 0x00, 0x7B, 0xC0,
  0x0F, 0x07, 0x80, 0x1E, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x3C, 0x01, 0xF0,
  0x7C, 0x03, 0xCF, 0x00, 0x78, 0x1F, 0x00, 0xF1, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x1E, 0x03, 0xE0, 0x3E, 0x07, 0x87,
  0x80, 0xF0, 0x0F, 0x81, 0xE0, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x3C, 0x0F,
  0x00, 0x78, 0x3C, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x07,
  0xC3, 0xC0, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x1E, 0x1E, 0x00, 0x3C, 0x78,
  0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0x80, 0x3C,
  0xF0, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00,
  0x07, 0xBC, 0x00, 0x77, 0xC0, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x00, 0x3B,
  0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x0F, 0x8F, 0x00, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x01,
  0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0x3C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x7C, 0x00,
  0x7C, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1F,
  0x01, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xBC,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xE1,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1E,
  0x00, 0x1F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF7,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xE7, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xC3, 0x80, 0x03, 0xC3,
  0xC0, 0x03, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x03,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x03, 0xFF, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC1, 0xF0, 0xFE, 0x08, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x1F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0x01, 0xF7, 0xC0, 0x1F, 0x78,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xF7, 0xC0, 0xEF, 0x7F, 0xFE, 0xF3, 0xFF, 0xCF,
  0x0F, 0xF0, 0xF0, 0x10, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE1, 0xFC,
  0x0F, 0x3F, 0xF8, 0x7B, 0xFF, 0xE3, 0xFF, 0x3F, 0x9F, 0xC0, 0x7E, 0xFC,
  0x01, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xF7, 0xF0, 0x0F, 0xBF, 0xC1,
  0xF9, 0xEF, 0xFF, 0x8E, 0x3F, 0xF8, 0x70, 0xFF, 0x80, 0x00, 0x40, 0x00,
  0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xE3, 0xE0, 0x13, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x02, 0x7F, 0x0F, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0x04, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0xFF, 0x0F, 0x07, 0xFF, 0x3C,
  0x3F, 0xFE, 0xF1, 0xFC, 0x7F, 0xCF, 0xC0, 0x7F, 0x3E, 0x00, 0xFD, 0xF0,
  0x01, 0xF7, 0xC0, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x00,
  0xF7, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF7,
  0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0xC0,
  0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xF1, 0xF8, 0x3F,
  0xC3, 0xFF, 0xEF, 0x07, 0xFF, 0x3C, 0x0F, 0xF8, 0x70, 0x02, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF0, 0xFC, 0x3E, 0x03,
  0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x23, 0xF8, 0x1E,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x00, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xE6, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x01, 0xFC, 0x1C, 0x1F, 0xFC, 0xF0, 0xFF, 0xFB, 0xC7, 0xF3,
  0xFF, 0x3F, 0x01, 0xFC, 0xF8, 0x03, 0xF3, 0xC0, 0x07, 0xDF, 0x00, 0x1F,
  0x78, 0x00, 0x7D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7C,
  0xF8, 0x03, 0xF3, 0xE0, 0x1F, 0xC7, 0xE0, 0xFF, 0x0F, 0xFF, 0xBC, 0x1F,
  0xFC, 0xF0, 0x3F, 0xE3, 0xC0, 0x08, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x80, 0x03, 0xE3,
  0x80, 0x1F, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x0F, 0xF0, 0xF3, 0xFF, 0x8F, 0x7F,
  0xFC, 0xFF, 0xCF, 0xEF, 0xE0, 0x3E, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0x67, 0xBF, 0xFF, 0x30, 0x00, 0x00, 0x3D, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x00, 0x01, 0x80, 0x78, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x7D, 0xFF, 0x3F, 0xE7, 0xF8, 0xFC, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x3E, 0xF0, 0x07, 0xCF, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x01,
  0xF0, 0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF1,
  0xE0, 0x0F, 0x3E, 0x00, 0xF7, 0xC0, 0x0F, 0x7E, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFC, 0xF8, 0x0F, 0x8F, 0x80, 0xF0, 0x7C, 0x0F, 0x03, 0xE0,
  0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0xF0, 0x07,
  0xCF, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x01, 0xFC, 0x3C, 0xFF, 0xE1, 0xFF, 0xCF,
  0x7F, 0xFC, 0xFF, 0xFB, 0xFE, 0x3F, 0x7C, 0xFE, 0xFE, 0x03, 0xFC, 0x07,
  0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xE0, 0x07, 0xC0,
  0x0F, 0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E,
  0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00,
  0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0,
  0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F,
  0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00,
  0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0,
  0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0xE0, 0xFF,
  0x0F, 0x3F, 0xFC, 0xF7, 0xFF, 0xCF, 0xF8, 0xFE, 0xFE, 0x03, 0xEF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFE, 0x3F, 0x81, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F,
  0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xFB, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xDE, 0x00,
  0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00,
  0xF3, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0x07, 0xC0, 0x3E,
  0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x00, 0x80, 0x00, 0xE0, 0xFF, 0x07, 0x9F, 0xFC, 0x3D, 0xFF, 0xF1, 0xFF,
  0x1F, 0xCF, 0xE0, 0x3F, 0x7E, 0x00, 0xFB, 0xE0, 0x03, 0xDF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0xFB, 0xF8, 0x0F, 0xDF, 0xE0, 0xFC, 0xF7, 0xFF, 0xC7, 0x9F, 0xFC, 0x3C,
  0x7F, 0xC1, 0xE0, 0x20, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x1C, 0x1F, 0xFC, 0xF0, 0xFF, 0xFB, 0xC7, 0xF1, 0xFF, 0x3F, 0x01, 0xFC,
  0xF8, 0x03, 0xF3, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0,
  0x01, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7,
  0x80, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0,
  0x1F, 0xC7, 0xE0, 0xFF, 0x0F, 0xFF, 0xBC, 0x1F, 0xFC, 0xF0, 0x3F, 0xE3,
  0xC0, 0x18, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0xE0, 0xFF,
  0x87, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xFE,
  0x0F, 0xFF, 0xCF, 0xFF, 0xEF, 0xC3, 0xE7, 0x80, 0x17, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x3F, 0xF0,
  0x3E, 0xFF, 0xFF, 0x7F, 0xFF, 0x0F, 0xFE, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x10, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x01, 0x80, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xF7, 0xE1, 0xFF, 0x7F, 0xFE,
  0xF3, 0xFF, 0xCF, 0x0F, 0xF8, 0x70, 0x08, 0x00, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x79, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0x87, 0x80,
  0x0F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x78,
  0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0xC7, 0x80, 0x07, 0x8F, 0x00,
  0x0F, 0x1E, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xEF, 0x00, 0x3F, 0x00, 0x3D, 0xE0,
  0x07, 0xE0, 0x07, 0xBE, 0x00, 0xFC, 0x01, 0xF3, 0xC0, 0x3F, 0xC0, 0x3C,
  0x78, 0x07, 0xF8, 0x07, 0x8F, 0x00, 0xFF, 0x00, 0xF1, 0xF0, 0x1C, 0xE0,
  0x3E, 0x1E, 0x07, 0x9E, 0x07, 0x83, 0xC0, 0xF3, 0xC0, 0xF0, 0x78, 0x1E,
  0x78, 0x1E, 0x0F, 0x83, 0x87, 0x07, 0xC0, 0xF0, 0xF0, 0xF0, 0xF0, 0x1E,
  0x1E, 0x1E, 0x1E, 0x03, 0xC3, 0xC3, 0xC3, 0xC0, 0x7C, 0xF0, 0x3C, 0xF8,
  0x07, 0x9E, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0xF3, 0xC0, 0x1E, 0x70, 0x1E,
  0x78, 0x03, 0xCE, 0x01, 0xCF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x0F, 0x80, 0x78,
  0x1F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xF8, 0x78, 0x01, 0xE3, 0xE0, 0x07,
  0xCF, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0x7C, 0x00, 0x7C, 0xF8, 0x03, 0xE1, 0xE0, 0x0F, 0x07, 0xC0, 0x7C,
  0x0F, 0x01, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x7C, 0x00, 0xF1, 0xE0, 0x03,
  0xEF, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x00,
  0xF3, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x80, 0x3E,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03,
  0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x0F, 0xF0, 0x1F, 0x80,
  0x3F, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xFE,
  0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0xFF, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x05, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFA, 0x00, 0x7F, 0xC8, 0x00, 0x08, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 37, 13, 3, -36 },
  { 29, 14, 13, 20, 3, -36 },
  { 52, 27, 36, 29, 1, -36 },
  { 174, 21, 41, 26, 3, -38 },
  { 282, 34, 37, 39, 2, -36 },
  { 440, 30, 37, 32, 2, -36 },
  { 579, 5, 13, 11, 3, -36 },
  { 588, 11, 44, 15, 2, -36 },
  { 649, 12, 44, 15, 1, -36 },
  { 715, 21, 20, 25, 2, -38 },
  { 768, 22, 24, 26, 2, -30 },
  { 834, 7, 13, 13, 2, -6 },
  { 846, 11, 4, 15, 2, -15 },
  { 852, 6, 7, 13, 3, -6 },
  { 858, 17, 36, 19, 1, -36 },
  { 935, 22, 37, 26, 2, -36 },
  { 1037, 13, 36, 26, 4, -36 },
  { 1096, 21, 36, 26, 2, -36 },
  { 1191, 21, 37, 26, 2, -36 },
  { 1289, 24, 36, 26, 1, -36 },
  { 1397, 20, 37, 26, 3, -36 },
  { 1490, 21, 37, 26, 3, -36 },
  { 1588, 22, 36, 26, 2, -36 },
  { 1687, 22, 37, 26, 2, -36 },
  { 1789, 21, 37, 26, 2, -36 },
  { 1887, 6, 28, 13, 3, -27 },
  { 1908, 7, 34, 13, 2, -27 },
  { 1938, 22, 24, 26, 2, -30 },
  { 2004, 22, 13, 26, 2, -24 },
  { 2040, 22, 24, 26, 2, -30 },
  { 2106, 17, 37, 20, 1, -36 },
  { 2185, 35, 40, 40, 3, -36 },
  { 2360, 28, 36, 29, 0, -36 },
  { 2486, 23, 36, 29, 4, -36 },
  { 2590, 24, 37, 28, 3, -36 },
  { 2701, 26, 36, 33, 4, -36 },
  { 2818, 18, 36, 25, 4, -36 },
  { 2899, 18, 36, 23, 4, -36 },
  { 2980, 27, 37, 33, 3, -36 },
  { 3105, 25, 36, 33, 4, -36 },
  { 3218, 12, 36, 16, 2, -36 },
  { 3272, 12, 46, 13, -3, -36 },
  { 3341, 24, 36, 28, 4, -36 },
  { 3449, 18, 36, 23, 4, -36 },
  { 3530, 34, 36, 42, 4, -36 },
  { 3683, 26, 36, 35, 4, -36 },
  { 3800, 29, 37, 35, 3, -36 },
  { 3935, 21, 36, 27, 4, -36 },
  { 4030, 29, 45, 35, 3, -36 },
  { 4194, 23, 36, 28, 4, -36 },
  { 4298, 21, 37, 25, 2, -36 },
  { 4396, 24, 36, 25, 0, -36 },
  { 4504, 25, 37, 33, 4, -36 },
  { 4620, 27, 36, 27, 0, -36 },
  { 4742, 42, 36, 43, 0, -36 },
  { 4931, 26, 36, 26, 0, -36 },
  { 5048, 25, 36, 25, 0, -36 },
  { 5161, 21, 36, 25, 2, -36 },
  { 5256, 11, 44, 16, 4, -36 },
  { 5317, 17, 36, 19, 1, -36 },
  { 5394, 11, 44, 16, 1, -36 },
  { 5455, 24, 21, 26, 1, -36 },
  { 5518, 22, 4, 22, 0, 4 },
  { 5529, 10, 8, 14, 2, -38 },
  { 5539, 20, 28, 25, 2, -27 },
  { 5609, 21, 39, 28, 4, -38 },
  { 5712, 17, 28, 22, 3, -27 },
  { 5772, 22, 39, 28, 2, -38 },
  { 5880, 20, 28, 26, 3, -27 },
  { 5950, 16, 38, 16, 1, -38 },
  { 6026, 22, 39, 28, 2, -27 },
  { 6134, 20, 38, 28, 4, -38 },
  { 6229, 5, 37, 12, 4, -37 },
  { 6253, 11, 49, 12, -2, -37 },
  { 6321, 20, 38, 24, 4, -38 },
  { 6416, 4, 38, 12, 4, -38 },
  { 6435, 34, 27, 42, 4, -27 },
  { 6550, 20, 27, 28, 4, -27 },
  { 6618, 23, 28, 27, 2, -27 },
  { 6699, 21, 39, 28, 4, -27 },
  { 6802, 22, 39, 28, 2, -27 },
  { 6910, 14, 27, 19, 4, -27 },
  { 6958, 17, 28, 21, 2, -27 },
  { 7018, 14, 34, 16, 1, -33 },
  { 7078, 20, 28, 28, 4, -27 },
  { 7148, 23, 27, 23, 0, -27 },
  { 7226, 35, 27, 36, 0, -27 },
  { 7345, 22, 27, 24, 1, -27 },
  { 7420, 23, 39, 23, 0, -27 },
  { 7533, 17, 27, 20, 2, -27 },
  { 7591, 15, 44, 19, 2, -36 },
  { 7674, 3, 50, 25, 11, -38 },
  { 7693, 15, 44, 19, 2, -36 },
  { 7776, 22, 7, 26, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_Regular50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR50PT7B_H_
