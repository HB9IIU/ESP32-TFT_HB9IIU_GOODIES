#ifndef _NOTOSANS_SEMICONDENSED_REGULAR18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x55, 0x43, 0xC0, 0xDE, 0xF3, 0x9C, 0x80, 0x09, 0x82, 0x40,
  0x90, 0x64, 0x7F, 0xC4, 0x41, 0x30, 0x48, 0xFF, 0x8C, 0x82, 0x20, 0x98,
  0x26, 0x00, 0x10, 0x21, 0xFE, 0x99, 0x1A, 0x3C, 0x1E, 0x1E, 0x24, 0x4C,
  0xBF, 0xC2, 0x04, 0x00, 0x70, 0xCD, 0x08, 0x99, 0x89, 0x90, 0x9B, 0x09,
  0xAE, 0xD6, 0xB7, 0x59, 0x0D, 0x10, 0x91, 0x19, 0x11, 0x1B, 0x30, 0xE0,
  0x3C, 0x19, 0x04, 0x61, 0x98, 0x6C, 0x0E, 0x07, 0x83, 0x33, 0xC4, 0xA1,
  0xEC, 0x33, 0x1E, 0x7C, 0xC0, 0xFF, 0xC0, 0x36, 0x44, 0xCC, 0x88, 0x88,
  0xCC, 0x44, 0x63, 0x8C, 0x46, 0x22, 0x23, 0x32, 0x22, 0x64, 0xC8, 0x10,
  0x20, 0x47, 0xF3, 0x05, 0x1B, 0x14, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0xFE, 0xFF, 0xF0, 0x06, 0x18, 0x30, 0x41, 0x83, 0x04,
  0x18, 0x20, 0x41, 0x82, 0x0C, 0x00, 0x3C, 0x6C, 0xC6, 0xC2, 0x82, 0x82,
  0x83, 0x82, 0x82, 0xC2, 0xC6, 0x66, 0x3C, 0x19, 0xFA, 0xB1, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x80, 0x7D, 0x9C, 0x18, 0x30, 0x60, 0xC3, 0x0C, 0x10,
  0x41, 0x86, 0x0F, 0xE0, 0x7D, 0x9C, 0x18, 0x30, 0x61, 0x9E, 0x03, 0x02,
  0x04, 0x0C, 0x3F, 0xC0, 0x06, 0x03, 0x03, 0x81, 0x41, 0x21, 0x90, 0x88,
  0xC4, 0x42, 0x7F, 0xC0, 0x80, 0x40, 0x20, 0x7E, 0xFD, 0x06, 0x0C, 0x1F,
  0x13, 0x83, 0x02, 0x04, 0x1C, 0x3F, 0xC0, 0x1E, 0x70, 0x60, 0xC0, 0xC0,
  0xFC, 0xE6, 0xC2, 0xC3, 0xC3, 0xC2, 0x66, 0x3C, 0xFF, 0xFE, 0x02, 0x06,
  0x04, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x20, 0x60, 0x3C, 0x66, 0xC2,
  0xC2, 0xC6, 0x7C, 0x38, 0x66, 0xC2, 0x83, 0x82, 0xC6, 0x7C, 0x38, 0xDB,
  0x1C, 0x18, 0x38, 0x71, 0xBD, 0x02, 0x0C, 0x18, 0x67, 0x80, 0xF4, 0x00,
  0xF0, 0xF4, 0x00, 0xFA, 0x01, 0x07, 0x1C, 0x70, 0xC0, 0x60, 0x1C, 0x07,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x0E,
  0x38, 0xE0, 0x80, 0x79, 0x98, 0x18, 0x30, 0x41, 0x86, 0x18, 0x30, 0x00,
  0x01, 0x83, 0x00, 0x0F, 0x80, 0xC7, 0x08, 0x08, 0x80, 0x24, 0xF9, 0x64,
  0x4E, 0x62, 0x73, 0x13, 0x99, 0x94, 0x4C, 0xB3, 0x98, 0x80, 0x06, 0x00,
  0x1F, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0xE0, 0x68, 0x12, 0x04, 0xC3,
  0x10, 0x84, 0x3F, 0x98, 0x64, 0x09, 0x03, 0xC0, 0xC0, 0xF8, 0xFE, 0x86,
  0x82, 0x82, 0x8C, 0xFC, 0x86, 0x83, 0x83, 0x83, 0x86, 0xFC, 0x1F, 0x9C,
  0x98, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0E, 0x21,
  0xF0, 0xF8, 0x7F, 0x20, 0xD0, 0x68, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1,
  0xA0, 0xD1, 0xCF, 0xC0, 0xFF, 0xF8, 0x20, 0x82, 0x0F, 0xE0, 0x82, 0x08,
  0x20, 0xFC, 0xFF, 0xF8, 0x20, 0x82, 0x0F, 0xFF, 0x82, 0x08, 0x20, 0x80,
  0x1F, 0xCE, 0x66, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0x0F, 0xC0, 0xF0,
  0x36, 0x0C, 0xC3, 0x1F, 0xC0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xF6, 0x66, 0x66, 0x66, 0x66, 0x66,
  0xF0, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13, 0x3E, 0x83, 0x86, 0x8C,
  0x88, 0x90, 0xB0, 0xF0, 0xD8, 0x98, 0x8C, 0x84, 0x86, 0x83, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0xC0, 0x7C, 0x07, 0xE0,
  0xFA, 0x0B, 0xA0, 0xBB, 0x1B, 0x91, 0x39, 0x13, 0x9B, 0x38, 0xA3, 0x8A,
  0x38, 0xE3, 0x84, 0x30, 0xC1, 0xE0, 0xF8, 0x74, 0x3B, 0x1C, 0x8E, 0x67,
  0x1B, 0x8D, 0xC3, 0xE0, 0xF0, 0x78, 0x18, 0x1F, 0x0E, 0x71, 0x83, 0x60,
  0x6C, 0x05, 0x80, 0xB0, 0x1E, 0x02, 0xC0, 0x58, 0x19, 0x83, 0x38, 0xC1,
  0xF0, 0xF9, 0xFA, 0x1C, 0x38, 0x70, 0xE3, 0x7C, 0x81, 0x02, 0x04, 0x08,
  0x00, 0x1F, 0x0E, 0x71, 0x83, 0x60, 0x6C, 0x05, 0x80, 0xB0, 0x1E, 0x02,
  0xC0, 0x58, 0x19, 0x83, 0x38, 0xC1, 0xF0, 0x06, 0x00, 0x60, 0x0E, 0xF8,
  0xFC, 0x86, 0x86, 0x86, 0x86, 0xFC, 0xF8, 0x88, 0x8C, 0x84, 0x86, 0x83,
  0x3F, 0xCF, 0x06, 0x0C, 0x0C, 0x0E, 0x07, 0x06, 0x04, 0x1C, 0x7F, 0xC0,
  0xFF, 0xFF, 0xC2, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xA0, 0x50, 0x6C, 0x73, 0xF0, 0xC0, 0xF0, 0x24, 0x19, 0x86, 0x61,
  0x08, 0xC3, 0x30, 0xC8, 0x12, 0x05, 0x81, 0xC0, 0x30, 0x0C, 0x00, 0xC1,
  0x87, 0x83, 0x0D, 0x0E, 0x1B, 0x14, 0x26, 0x2C, 0x4C, 0xD9, 0x89, 0x93,
  0x1A, 0x24, 0x34, 0x68, 0x78, 0xF0, 0x70, 0xE0, 0xC1, 0x81, 0x83, 0x00,
  0xC1, 0xB0, 0x88, 0xC6, 0x41, 0x60, 0xE0, 0x30, 0x38, 0x16, 0x19, 0x18,
  0xCC, 0x2C, 0x18, 0xC1, 0xA0, 0x98, 0xC4, 0x43, 0x60, 0xB0, 0x70, 0x38,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xFF, 0xFC, 0x18, 0x60, 0x83, 0x04,
  0x18, 0x60, 0xC3, 0x04, 0x0F, 0xE0, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCF, 0xC0, 0x81, 0x83, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x30,
  0x60, 0x60, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x10, 0x38,
  0x28, 0x2C, 0x44, 0x46, 0xC2, 0x83, 0xFF, 0xC8, 0x80, 0x38, 0xD8, 0x18,
  0x33, 0xFC, 0xE1, 0xC3, 0xCE, 0xF4, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xFE,
  0xC3, 0xC3, 0xC1, 0xC1, 0xC3, 0xC3, 0xE2, 0xDE, 0x3D, 0xFC, 0x30, 0xC3,
  0x0C, 0x30, 0x64, 0xF0, 0x03, 0x03, 0x03, 0x03, 0x3B, 0x6F, 0xC3, 0xC3,
  0xC3, 0x83, 0xC3, 0xC3, 0x67, 0x7B, 0x38, 0xDF, 0x1E, 0x1F, 0xF0, 0x30,
  0x60, 0x62, 0x7C, 0x1C, 0xF2, 0x08, 0x7B, 0xE2, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x80, 0x3B, 0x7F, 0xC3, 0xC3, 0xC3, 0x83, 0xC3, 0xC3, 0x67, 0x7B,
  0x03, 0x03, 0x86, 0x7C, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xF6, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xD3, 0xFF, 0xFF, 0xC0, 0x31, 0x03,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC6,
  0xC4, 0xCC, 0xD8, 0xF0, 0xF8, 0xC8, 0xCC, 0xC6, 0xC7, 0xFF, 0xFF, 0xFF,
  0xF0, 0xDC, 0xE7, 0xFD, 0xB0, 0xC7, 0x84, 0x3C, 0x21, 0xE1, 0x0F, 0x08,
  0x78, 0x43, 0xC2, 0x1E, 0x10, 0xC0, 0xDC, 0xF6, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x3C, 0x7E, 0xC2, 0xC3, 0xC3, 0x83, 0xC3, 0xC3,
  0x66, 0x3C, 0xDC, 0xF6, 0xC3, 0xC3, 0xC1, 0xC1, 0xC3, 0xC3, 0xE2, 0xDE,
  0xC0, 0xC0, 0xC0, 0xC0, 0x3B, 0x6F, 0xC3, 0xC3, 0xC3, 0x83, 0xC3, 0xC3,
  0x67, 0x7B, 0x03, 0x03, 0x03, 0x03, 0xDF, 0xF9, 0x8C, 0x63, 0x18, 0xC6,
  0x00, 0x7B, 0x38, 0x30, 0x60, 0xE0, 0xC3, 0x8F, 0xE0, 0x21, 0x1F, 0xF6,
  0x31, 0x8C, 0x61, 0x08, 0x70, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x67, 0x7B, 0xC1, 0xC3, 0x42, 0x62, 0x66, 0x24, 0x34, 0x3C, 0x18,
  0x18, 0xC2, 0x1E, 0x38, 0x91, 0x44, 0xCA, 0x66, 0xD3, 0x36, 0xD0, 0xA2,
  0x85, 0x14, 0x38, 0xE0, 0xC6, 0x00, 0xC3, 0x62, 0x26, 0x34, 0x18, 0x18,
  0x3C, 0x26, 0x62, 0xC3, 0xC1, 0xC3, 0x43, 0x62, 0x66, 0x26, 0x34, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x30, 0xE0, 0xFF, 0xF1, 0x84, 0x30, 0x86, 0x30,
  0xC3, 0xF0, 0x19, 0x88, 0x42, 0x11, 0x98, 0xC1, 0x08, 0x42, 0x10, 0xC3,
  0xFF, 0xFF, 0xC0, 0xC7, 0x18, 0x42, 0x10, 0x87, 0x39, 0x08, 0x42, 0x33,
  0x98, 0x41, 0xFB, 0x8E,
};

const GFXglyph NotoSans_SemiCondensed_Regular18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 13, 5, 1, -13 },
  { 5, 5, 5, 7, 1, -13 },
  { 9, 10, 13, 10, 0, -13 },
  { 26, 7, 15, 9, 1, -14 },
  { 40, 12, 13, 14, 1, -13 },
  { 60, 10, 13, 12, 1, -13 },
  { 77, 2, 5, 4, 1, -13 },
  { 79, 4, 16, 5, 1, -13 },
  { 87, 4, 16, 5, 1, -13 },
  { 95, 7, 8, 9, 1, -14 },
  { 102, 8, 9, 9, 1, -11 },
  { 111, 2, 4, 5, 1, -2 },
  { 112, 4, 2, 5, 1, -6 },
  { 113, 2, 2, 5, 1, -2 },
  { 114, 7, 13, 7, 0, -13 },
  { 126, 8, 13, 9, 1, -13 },
  { 139, 5, 13, 9, 1, -13 },
  { 148, 7, 13, 9, 1, -13 },
  { 160, 7, 13, 9, 1, -13 },
  { 172, 9, 13, 9, 0, -13 },
  { 187, 7, 13, 9, 1, -13 },
  { 199, 8, 13, 9, 1, -13 },
  { 212, 8, 13, 9, 1, -13 },
  { 225, 8, 13, 9, 1, -13 },
  { 238, 7, 13, 9, 1, -13 },
  { 250, 2, 10, 5, 1, -10 },
  { 253, 2, 12, 5, 1, -10 },
  { 256, 8, 9, 9, 1, -11 },
  { 265, 7, 5, 9, 1, -9 },
  { 270, 8, 9, 9, 1, -11 },
  { 279, 7, 13, 7, 0, -13 },
  { 291, 13, 15, 15, 1, -13 },
  { 316, 10, 13, 10, 0, -13 },
  { 333, 8, 13, 11, 2, -13 },
  { 346, 9, 13, 10, 1, -13 },
  { 361, 9, 13, 12, 2, -13 },
  { 376, 6, 13, 9, 2, -13 },
  { 386, 6, 13, 8, 2, -13 },
  { 396, 10, 13, 12, 1, -13 },
  { 413, 8, 13, 12, 2, -13 },
  { 426, 4, 13, 6, 1, -13 },
  { 433, 4, 16, 5, -1, -13 },
  { 441, 8, 13, 10, 2, -13 },
  { 454, 6, 13, 8, 2, -13 },
  { 464, 12, 13, 15, 2, -13 },
  { 484, 9, 13, 12, 2, -13 },
  { 499, 11, 13, 13, 1, -13 },
  { 517, 7, 13, 10, 2, -13 },
  { 529, 11, 16, 13, 1, -13 },
  { 551, 8, 13, 10, 2, -13 },
  { 564, 7, 13, 9, 1, -13 },
  { 576, 9, 13, 9, 0, -13 },
  { 591, 9, 13, 12, 1, -13 },
  { 606, 10, 13, 10, 0, -13 },
  { 623, 15, 13, 15, 0, -13 },
  { 648, 9, 13, 9, 0, -13 },
  { 663, 9, 13, 9, 0, -13 },
  { 678, 7, 13, 9, 1, -13 },
  { 690, 4, 16, 6, 1, -13 },
  { 698, 7, 13, 7, 0, -13 },
  { 710, 4, 16, 6, 0, -13 },
  { 718, 8, 8, 9, 1, -13 },
  { 726, 8, 1, 8, 0, 2 },
  { 727, 3, 3, 5, 1, -14 },
  { 729, 7, 10, 9, 1, -10 },
  { 738, 8, 14, 10, 1, -14 },
  { 752, 6, 10, 8, 1, -10 },
  { 760, 8, 14, 10, 1, -14 },
  { 774, 7, 10, 9, 1, -10 },
  { 783, 6, 14, 6, 0, -14 },
  { 794, 8, 14, 10, 1, -10 },
  { 808, 8, 14, 10, 1, -14 },
  { 822, 2, 13, 4, 1, -13 },
  { 826, 4, 17, 4, -1, -13 },
  { 835, 8, 14, 9, 1, -14 },
  { 849, 2, 14, 4, 1, -14 },
  { 853, 13, 10, 15, 1, -10 },
  { 870, 8, 10, 10, 1, -10 },
  { 880, 8, 10, 10, 1, -10 },
  { 890, 8, 14, 10, 1, -10 },
  { 904, 8, 14, 10, 1, -10 },
  { 918, 5, 10, 7, 1, -10 },
  { 925, 6, 10, 8, 1, -10 },
  { 933, 5, 12, 6, 0, -12 },
  { 941, 8, 10, 10, 1, -10 },
  { 951, 8, 10, 8, 0, -10 },
  { 961, 13, 10, 13, 0, -10 },
  { 978, 8, 10, 9, 0, -10 },
  { 988, 8, 14, 8, 0, -10 },
  { 1002, 6, 10, 7, 1, -10 },
  { 1010, 5, 16, 7, 1, -13 },
  { 1020, 1, 18, 9, 4, -14 },
  { 1023, 5, 16, 7, 1, -13 },
  { 1033, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Regular18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR18PT7B_H_
