#ifndef _NOTOSANS_SEMICONDENSED_REGULAR7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xF0, 0x5F, 0x6F, 0xA0, 0x79, 0xBE, 0xD6, 0xBE, 0x75, 0x80,
  0x66, 0x4B, 0x70, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0xE9, 0x80, 0x5D, 0x00,
  0xC0, 0xC0, 0x80, 0x29, 0x48, 0x76, 0xD6, 0xF8, 0xE4, 0xAE, 0xE5, 0x9E,
  0x26, 0xAF, 0x20, 0x73, 0x9E, 0x73, 0xD6, 0xE4, 0xA4, 0x75, 0xDE, 0x77,
  0x9E, 0x90, 0x98, 0x39, 0x80, 0xFC, 0xC7, 0x00, 0xC5, 0x24, 0x7D, 0xF7,
  0xF8, 0x38, 0x46, 0x69, 0x90, 0xD7, 0x5C, 0x78, 0x88, 0x70, 0xD6, 0xDC,
  0xEE, 0xC0, 0xEE, 0x80, 0x78, 0x99, 0x70, 0xB7, 0xDA, 0xD5, 0xC0, 0xFC,
  0xBA, 0x6A, 0xAA, 0xC0, 0x99, 0xBF, 0xD0, 0xB7, 0xFA, 0x79, 0x99, 0x70,
  0xD7, 0x48, 0x79, 0x99, 0x71, 0xD7, 0x6A, 0x71, 0x9E, 0xE9, 0x24, 0xB6,
  0xDE, 0x9A, 0x66, 0x40, 0xA6, 0xDB, 0x92, 0x48, 0xB6, 0x46, 0xB0, 0xB6,
  0x44, 0x40, 0xE5, 0x2E, 0xFC, 0x91, 0x22, 0xD5, 0x70, 0x4E, 0x80, 0xE0,
  0xC0, 0x67, 0xF0, 0x9A, 0xDC, 0x72, 0x30, 0x2E, 0xD6, 0x77, 0x30, 0x7A,
  0x80, 0x76, 0xB2, 0xC0, 0xBF, 0xC0, 0xF8, 0xFE, 0xBA, 0xC0, 0xF8, 0xFD,
  0xDD, 0xFF, 0x76, 0xB0, 0xD6, 0xE9, 0x00, 0x76, 0xB2, 0x40, 0xEA, 0x71,
  0xF0, 0xBA, 0x40, 0xFF, 0xB5, 0x20, 0xAD, 0x74, 0xA0, 0xA9, 0x50, 0xB5,
  0x25, 0x00, 0xE9, 0x70, 0x57, 0x50, 0xFE, 0x95, 0x70, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Regular7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 2, 2, 3, 0, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 5, 4, 0, -5 },
  { 8, 5, 5, 5, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 2, 0, -5 },
  { 16, 2, 6, 2, 0, -5 },
  { 18, 2, 6, 2, 0, -5 },
  { 20, 3, 3, 3, 0, -5 },
  { 22, 3, 3, 4, 0, -4 },
  { 24, 1, 2, 2, 0, -1 },
  { 25, 2, 1, 2, 0, -2 },
  { 26, 1, 1, 2, 0, -1 },
  { 27, 3, 5, 3, 0, -5 },
  { 29, 3, 5, 4, 0, -5 },
  { 31, 1, 5, 4, 1, -5 },
  { 32, 3, 5, 4, 0, -5 },
  { 34, 3, 5, 4, 0, -5 },
  { 36, 4, 5, 4, 0, -5 },
  { 39, 3, 5, 4, 0, -5 },
  { 41, 3, 5, 4, 0, -5 },
  { 43, 3, 5, 4, 0, -5 },
  { 45, 3, 5, 4, 0, -5 },
  { 47, 3, 5, 4, 0, -5 },
  { 49, 1, 4, 2, 0, -4 },
  { 50, 1, 5, 2, 0, -4 },
  { 51, 3, 3, 4, 0, -4 },
  { 53, 3, 2, 4, 0, -3 },
  { 54, 3, 3, 4, 0, -4 },
  { 56, 3, 5, 3, 0, -5 },
  { 58, 5, 6, 6, 0, -5 },
  { 62, 4, 5, 4, 0, -5 },
  { 65, 3, 5, 4, 1, -5 },
  { 67, 4, 5, 4, 0, -5 },
  { 70, 3, 5, 5, 1, -5 },
  { 72, 2, 5, 4, 1, -5 },
  { 74, 2, 5, 3, 1, -5 },
  { 76, 4, 5, 5, 0, -5 },
  { 79, 3, 5, 5, 1, -5 },
  { 81, 2, 5, 2, 0, -5 },
  { 83, 1, 6, 2, 0, -5 },
  { 84, 3, 5, 4, 1, -5 },
  { 86, 2, 5, 3, 1, -5 },
  { 88, 4, 5, 6, 1, -5 },
  { 91, 3, 5, 5, 1, -5 },
  { 93, 4, 5, 5, 0, -5 },
  { 96, 3, 5, 4, 1, -5 },
  { 98, 4, 6, 5, 0, -5 },
  { 101, 3, 5, 4, 1, -5 },
  { 103, 3, 5, 4, 0, -5 },
  { 105, 3, 5, 3, 0, -5 },
  { 107, 3, 5, 5, 1, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 6, 5, 6, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 3, 5, 3, 0, -5 },
  { 124, 1, 6, 2, 1, -5 },
  { 125, 3, 5, 3, 0, -5 },
  { 127, 2, 6, 2, 0, -5 },
  { 129, 3, 3, 4, 0, -5 },
  { 131, 3, 1, 3, 0, 0 },
  { 132, 2, 1, 2, 0, -5 },
  { 133, 3, 4, 4, 0, -4 },
  { 135, 3, 5, 4, 1, -5 },
  { 137, 3, 4, 3, 0, -4 },
  { 139, 3, 5, 4, 0, -5 },
  { 141, 3, 4, 4, 0, -4 },
  { 143, 2, 5, 2, 0, -5 },
  { 145, 3, 6, 4, 0, -4 },
  { 148, 2, 5, 4, 1, -5 },
  { 150, 1, 5, 2, 0, -5 },
  { 151, 1, 7, 2, 0, -5 },
  { 152, 2, 5, 3, 1, -5 },
  { 154, 1, 5, 2, 0, -5 },
  { 155, 4, 4, 6, 1, -4 },
  { 157, 2, 4, 4, 1, -4 },
  { 158, 3, 4, 4, 0, -4 },
  { 160, 3, 6, 4, 1, -4 },
  { 163, 3, 6, 4, 0, -4 },
  { 166, 2, 4, 3, 1, -4 },
  { 167, 3, 4, 3, 0, -4 },
  { 169, 2, 5, 2, 0, -5 },
  { 171, 2, 4, 4, 1, -4 },
  { 172, 3, 4, 3, 0, -4 },
  { 174, 5, 4, 5, 0, -4 },
  { 177, 3, 4, 3, 0, -4 },
  { 179, 3, 6, 3, 0, -4 },
  { 182, 3, 4, 3, 0, -4 },
  { 184, 2, 6, 3, 0, -5 },
  { 186, 1, 7, 3, 1, -5 },
  { 187, 2, 6, 3, 0, -5 },
  { 189, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Regular7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR7PT7B_H_
