#ifndef _NOTOSANS_SEMICONDENSED_REGULAR31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x6F, 0xFF,
  0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3, 0x03, 0x0C, 0x07, 0x0C,
  0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x7F, 0xFF, 0x7F, 0xFF,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0xFF, 0xFE,
  0xFF, 0xFE, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x38, 0xE0,
  0x30, 0xC0, 0x30, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x3F, 0x87, 0xFF,
  0x7F, 0x7B, 0x98, 0x18, 0xC0, 0xC6, 0x07, 0x30, 0x3D, 0x80, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xCE, 0x06, 0x38, 0x31, 0xC1, 0x8D, 0x0C,
  0xEF, 0xFE, 0x7F, 0xE0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x3E,
  0x01, 0x83, 0xB8, 0x1C, 0x18, 0xC0, 0xC0, 0xC7, 0x0E, 0x06, 0x18, 0x60,
  0x70, 0xC7, 0x03, 0x86, 0x30, 0x1C, 0x33, 0x80, 0x61, 0x98, 0xC3, 0x1D,
  0xCF, 0x98, 0xCC, 0xEC, 0xFE, 0xEE, 0x33, 0xE6, 0x61, 0x80, 0x33, 0x0C,
  0x03, 0x18, 0x60, 0x18, 0xC3, 0x01, 0x86, 0x18, 0x0C, 0x30, 0xC0, 0xC1,
  0x86, 0x06, 0x06, 0x30, 0x60, 0x3F, 0x07, 0x00, 0xF8, 0x0F, 0xC0, 0x03,
  0xFC, 0x00, 0x61, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x06,
  0x1C, 0x00, 0xE7, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1F,
  0xC0, 0xE3, 0x9C, 0x18, 0xE1, 0xC7, 0x18, 0x1C, 0xE7, 0x01, 0xF8, 0xE0,
  0x1F, 0x1C, 0x03, 0xC1, 0xC0, 0x7C, 0x3C, 0x3F, 0xC3, 0xFF, 0x38, 0x3F,
  0x83, 0xC0, 0xFF, 0xFF, 0xB6, 0x0E, 0x18, 0x71, 0xC3, 0x86, 0x1C, 0x38,
  0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xC1, 0xC3, 0x87, 0x06,
  0x0E, 0x0C, 0x1C, 0x18, 0x38, 0xE0, 0xE0, 0xC1, 0xC3, 0x83, 0x87, 0x0E,
  0x0C, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3,
  0x0E, 0x1C, 0x70, 0xC3, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x04,
  0x30, 0xFD, 0xFF, 0xFF, 0xE0, 0xE0, 0x0D, 0x80, 0xEE, 0x07, 0x38, 0x71,
  0xC1, 0x84, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x39, 0xDC, 0xE7, 0x31, 0x98, 0xFF, 0xFF, 0xF8,
  0x6F, 0xFE, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x7F,
  0x83, 0x87, 0x1C, 0x0E, 0x70, 0x39, 0xC0, 0xE6, 0x01, 0x98, 0x06, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x76, 0x01, 0x98,
  0x06, 0x70, 0x39, 0xC0, 0xE3, 0x03, 0x0E, 0x1C, 0x1F, 0xE0, 0x3F, 0x00,
  0x07, 0x0F, 0x1F, 0x3B, 0xF3, 0x63, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x1F, 0xC1,
  0xFF, 0xC7, 0x07, 0x08, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xE7, 0xFF, 0x98, 0x1C, 0x80, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0xFF, 0x07, 0xE0, 0x3F, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0F, 0xC0, 0xEF, 0xFF, 0x3F,
  0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x37, 0x00, 0xEE,
  0x01, 0x9C, 0x07, 0x38, 0x1C, 0x70, 0x30, 0xE0, 0xE1, 0xC1, 0x83, 0x86,
  0x07, 0x1C, 0x0E, 0x30, 0x1C, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x7F, 0xE7, 0xFE, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xEE, 0x0F, 0xFC, 0x7F, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x7C,
  0x1E, 0xFF, 0xCF, 0xF8, 0x0F, 0xE0, 0xFF, 0x0F, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xC7, 0x86, 0xFF, 0x3E, 0x3D, 0xC0, 0xEE,
  0x03, 0x60, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0x9C, 0x1C, 0xF1,
  0xE3, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0x87,
  0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x8E, 0x0C, 0x3C, 0xF0, 0x7F,
  0x00, 0xF8, 0x07, 0xF8, 0x38, 0xF1, 0xC0, 0xE6, 0x01, 0xB8, 0x07, 0xE0,
  0x1F, 0x80, 0x77, 0x01, 0x9E, 0x0E, 0x3F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0,
  0xFF, 0x87, 0x87, 0x1C, 0x0E, 0x60, 0x3B, 0x80, 0x6E, 0x01, 0xB8, 0x06,
  0xE0, 0x1D, 0x80, 0xF7, 0x03, 0xCF, 0x7E, 0x3F, 0xD8, 0x3C, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x78, 0x3F, 0xC0, 0xFC,
  0x00, 0x6F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0x33, 0xDE,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xCE, 0x73, 0x19, 0xCC, 0x00,
  0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x7F, 0x9F, 0xF9, 0x83,
  0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x03,
  0x80, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x01,
  0xE0, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xC0, 0x70, 0x38,
  0x01, 0xC3, 0x80, 0x07, 0x38, 0x00, 0x19, 0x83, 0xF8, 0xEC, 0x3F, 0xC3,
  0xC3, 0x86, 0x1E, 0x18, 0x30, 0xF0, 0xC1, 0x87, 0x8E, 0x0C, 0x3C, 0x70,
  0x61, 0xE3, 0x83, 0x0F, 0x1C, 0x38, 0x78, 0x61, 0xC7, 0xC3, 0x9B, 0x76,
  0x0F, 0x9F, 0x38, 0x10, 0x20, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x80, 0x7C, 0x3C, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0x70, 0x00, 0xCC, 0x00, 0x73,
  0x00, 0x18, 0xE0, 0x06, 0x38, 0x03, 0x86, 0x00, 0xC1, 0xC0, 0x30, 0x70,
  0x1C, 0x0C, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xE0, 0x18, 0x38, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x31, 0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x70, 0xFF,
  0xC3, 0xFF, 0xCC, 0x0F, 0x30, 0x0E, 0xC0, 0x3B, 0x00, 0xEC, 0x03, 0xB0,
  0x0E, 0xC0, 0x73, 0xFF, 0x8F, 0xFC, 0x3F, 0xFC, 0xC0, 0x7B, 0x00, 0xEC,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xEC, 0x03, 0xB0, 0x3E, 0xFF, 0xF3,
  0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0xF8, 0x31, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xF0, 0x61, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xE3,
  0x03, 0xE6, 0x01, 0xEC, 0x01, 0xD8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1D, 0x80, 0x3B, 0x01, 0xE6, 0x0F, 0x8F, 0xFE, 0x1F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x1F, 0xFB, 0xFF, 0x7F, 0xEC, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFF,
  0x7F, 0xEF, 0xFD, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x00, 0x07, 0xFE, 0x0F, 0xFF, 0x1E, 0x06, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0x70, 0x03, 0x70, 0x03, 0x38, 0x03, 0x3E, 0x07, 0x0F, 0xFF, 0x07, 0xFE,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xC0, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x87, 0x0F, 0xFF, 0xF7, 0x80, 0xC0, 0x3F, 0x00, 0xEC, 0x07, 0x30, 0x38,
  0xC1, 0xC3, 0x07, 0x0C, 0x38, 0x31, 0xC0, 0xCE, 0x03, 0x30, 0x0D, 0xE0,
  0x3F, 0xC0, 0xE7, 0x03, 0x0E, 0x0C, 0x3C, 0x30, 0x70, 0xC0, 0xE3, 0x03,
  0x8C, 0x07, 0x30, 0x0E, 0xC0, 0x3B, 0x00, 0x70, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F,
  0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x1B, 0xD8, 0x01, 0xBD, 0xC0, 0x3B, 0xDC, 0x03, 0x3C, 0xC0, 0x33, 0xCE,
  0x07, 0x3C, 0xE0, 0x63, 0xC6, 0x06, 0x3C, 0x70, 0xE3, 0xC7, 0x0C, 0x3C,
  0x30, 0xC3, 0xC3, 0x9C, 0x3C, 0x19, 0x83, 0xC1, 0x98, 0x3C, 0x1F, 0x83,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x06, 0x03, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xDC, 0x07, 0xDC, 0x07, 0xCE, 0x07,
  0xCE, 0x07, 0xC7, 0x07, 0xC7, 0x07, 0xC3, 0x87, 0xC1, 0xC7, 0xC1, 0xC7,
  0xC0, 0xE7, 0xC0, 0xE7, 0xC0, 0x77, 0xC0, 0x77, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xC1,
  0xE1, 0xE0, 0x1C, 0x70, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0E, 0x70, 0x03, 0x9C, 0x01, 0xE3, 0x80,
  0x70, 0xF8, 0x78, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x87, 0xFF, 0x30,
  0x7D, 0x80, 0xEC, 0x07, 0x60, 0x1F, 0x00, 0xF8, 0x06, 0xC0, 0x76, 0x03,
  0xB0, 0x39, 0xFF, 0xCF, 0xF8, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x0F, 0xF8, 0x07, 0xFF,
  0x83, 0xC1, 0xE1, 0xE0, 0x1C, 0x70, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0E, 0x70, 0x03, 0x9C, 0x01,
  0xE3, 0x80, 0x70, 0xF8, 0x78, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x78, 0xFF, 0x83, 0xFF,
  0x8C, 0x1F, 0x30, 0x1C, 0xC0, 0x73, 0x00, 0xEC, 0x03, 0xB0, 0x0C, 0xC0,
  0x73, 0x01, 0xCC, 0x7E, 0x3F, 0xF0, 0xFF, 0x83, 0x0E, 0x0C, 0x1C, 0x30,
  0x70, 0xC0, 0xE3, 0x01, 0xCC, 0x07, 0x30, 0x0E, 0xC0, 0x3B, 0x00, 0x70,
  0x1F, 0xF9, 0xFF, 0x9E, 0x0C, 0xE0, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xC1, 0xEF, 0xFE, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x3B, 0x80, 0x73, 0xC3, 0xC3, 0xFF, 0x83, 0xFC, 0x00,
  0xE0, 0x03, 0xB0, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xE1, 0xC0,
  0x70, 0xE0, 0x38, 0x70, 0x18, 0x18, 0x1C, 0x0E, 0x0E, 0x07, 0x06, 0x01,
  0x87, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x19, 0xC0, 0x0E, 0xE0, 0x07, 0x70,
  0x01, 0xB0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xD8, 0x07, 0x80, 0x77, 0x01, 0xE0, 0x1D, 0xC0, 0x78, 0x0E,
  0x70, 0x1F, 0x03, 0x8C, 0x0E, 0xC0, 0xE3, 0x83, 0xB0, 0x38, 0xE0, 0xCE,
  0x0C, 0x38, 0x33, 0x87, 0x06, 0x1C, 0x61, 0xC1, 0xC7, 0x18, 0x70, 0x71,
  0x87, 0x18, 0x1C, 0x61, 0xCE, 0x03, 0x38, 0x33, 0x80, 0xCE, 0x0C, 0xE0,
  0x3B, 0x03, 0xB0, 0x0E, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x07,
  0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x0F, 0x30, 0x0E, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x0E, 0x30, 0x0E,
  0x70, 0x07, 0x60, 0x07, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0C, 0x30, 0x1C, 0x38, 0x18, 0x18, 0x38,
  0x1C, 0x30, 0x0E, 0x70, 0x0E, 0xE0, 0x07, 0xE0, 0x0F, 0x70, 0x0E, 0x70,
  0x1C, 0x38, 0x1C, 0x38, 0x18, 0x18, 0x38, 0x1C, 0x30, 0x0C, 0x70, 0x0E,
  0x60, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xFF, 0xF8, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0xFF, 0xFC,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xF8, 0x03, 0x00,
  0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0C, 0xC0, 0x73, 0x81, 0x86, 0x06, 0x1C,
  0x30, 0x30, 0xC0, 0xE6, 0x01, 0x98, 0x07, 0xE0, 0x0C, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF1, 0xC3, 0x86, 0x0C, 0x0F, 0xC3, 0xFE, 0x38, 0xF0, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x30, 0xFF, 0x3F, 0xF7, 0x83, 0x70, 0x3E, 0x03, 0xE0,
  0x7E, 0x07, 0x70, 0xF7, 0xFB, 0x3F, 0x30, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x39, 0xF0, 0xEF, 0xE3, 0xF3,
  0xCF, 0x03, 0xBC, 0x0E, 0xE0, 0x1B, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x06, 0xF0, 0x3B, 0xE1, 0xEF, 0xFF, 0x39,
  0xF8, 0x0F, 0xA7, 0xF9, 0xF7, 0x38, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x11, 0xFE, 0x1F,
  0xC0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE1, 0xE7, 0x3F, 0xBB, 0xCF, 0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xB8,
  0x7D, 0xFF, 0x63, 0xF3, 0x0F, 0x83, 0xFC, 0x79, 0xE6, 0x07, 0xE0, 0x7E,
  0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x78, 0x33, 0xFF, 0x1F, 0xE0, 0x03, 0xC1, 0xFC, 0x3F, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xFC, 0xFF, 0x83, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1F, 0x19, 0xFC, 0xDE, 0x7F, 0xE0, 0xFE, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3D, 0xC3, 0xEF, 0xFF, 0x1F, 0xB8, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x20, 0x39, 0xFF, 0x8F, 0xF8, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0xF8, 0xEF, 0xF7, 0xE7, 0xBC, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0x7F, 0xA0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0C, 0x71, 0xC2, 0x00, 0x01, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0xFB, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x0E, 0xE0, 0xF7, 0x07, 0x38, 0x71, 0xC7,
  0x0E, 0x70, 0x77, 0x03, 0xB8, 0x1F, 0xC0, 0xF7, 0x07, 0x1C, 0x38, 0xE1,
  0xC3, 0x8E, 0x0E, 0x70, 0x73, 0x81, 0xDC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xC1, 0xE3, 0xBF, 0x9F, 0xEF, 0xDF,
  0xE7, 0xBC, 0x1E, 0x07, 0xF0, 0x38, 0x1F, 0x80, 0xE0, 0x7E, 0x03, 0x01,
  0xF8, 0x0C, 0x07, 0xE0, 0x30, 0x1F, 0x80, 0xC0, 0x7E, 0x03, 0x01, 0xF8,
  0x0C, 0x07, 0xE0, 0x30, 0x1F, 0x80, 0xC0, 0x7E, 0x03, 0x01, 0xF8, 0x0C,
  0x07, 0xE0, 0x30, 0x1C, 0xE7, 0xC7, 0x7F, 0xBF, 0x3D, 0xE0, 0x7F, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x38, 0x0F, 0x81, 0xFF, 0x1F,
  0x3C, 0xE0, 0xEE, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x19, 0xC1, 0xC7, 0xFC, 0x1F, 0xC0,
  0xE7, 0xC3, 0xBF, 0x8F, 0xCF, 0x3C, 0x0E, 0xF0, 0x3B, 0x80, 0x6E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3B, 0xC0,
  0xEF, 0x87, 0xBB, 0xFC, 0xE7, 0xE3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x1F, 0x19, 0xFC, 0xDE, 0x7E, 0xE0,
  0xFE, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3D, 0xC3, 0xEF, 0xFF, 0x1F, 0xB8, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xE3, 0xF7, 0xFF,
  0xFF, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x00, 0x1F, 0x87, 0xFD, 0xC7, 0x70, 0x0E, 0x01,
  0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x70, 0x0E, 0x01,
  0xF0, 0x7F, 0xFE, 0x7F, 0x80, 0x18, 0x0C, 0x06, 0x07, 0xFF, 0xF8, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0E, 0x07, 0xE1, 0xF0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x3D, 0xC3, 0xEF, 0xFB, 0x3F, 0x98, 0xE0, 0x1F, 0x80, 0x76,
  0x01, 0x9C, 0x0E, 0x70, 0x38, 0xC0, 0xC3, 0x87, 0x0E, 0x1C, 0x18, 0x60,
  0x73, 0x81, 0xCE, 0x03, 0x30, 0x0E, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0xE0, 0x38, 0x1D, 0x81, 0xE0, 0x77, 0x07, 0x81, 0x9C, 0x1E,
  0x06, 0x70, 0x7C, 0x38, 0xC3, 0xB0, 0xE3, 0x0C, 0xC3, 0x0E, 0x33, 0x8C,
  0x39, 0xCE, 0x70, 0x67, 0x19, 0xC1, 0x98, 0x66, 0x07, 0x61, 0xD8, 0x1D,
  0x87, 0xE0, 0x3E, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03,
  0xC0, 0xE0, 0x3F, 0x03, 0x9C, 0x1C, 0x71, 0xC3, 0x8C, 0x0E, 0xE0, 0x3E,
  0x01, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xE0, 0x3B, 0x83, 0x8C, 0x1C, 0x71,
  0xC1, 0xDC, 0x0E, 0xE0, 0x38, 0xE0, 0x1F, 0x80, 0x77, 0x01, 0x9C, 0x0E,
  0x30, 0x38, 0xE0, 0xC3, 0x87, 0x06, 0x1C, 0x1C, 0x60, 0x71, 0x80, 0xCE,
  0x03, 0x30, 0x0E, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x0F, 0xC0, 0x3E, 0x00, 0xFF,
  0xDF, 0xF8, 0x03, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0x83, 0xC3, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03,
  0x8F, 0x87, 0x03, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x1C, 0x0F, 0x03, 0xC0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x3E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x38, 0x07, 0xC0, 0xF0, 0xF8, 0x38, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x78, 0x3E, 0x0E, 0x00,
  0x3C, 0x07, 0xFE, 0x3E, 0x7F, 0xE0, 0x3C,
};

const GFXglyph NotoSans_SemiCondensed_Regular31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 8, 8, 12, 2, -22 },
  { 20, 16, 22, 18, 1, -22 },
  { 64, 13, 26, 16, 2, -24 },
  { 107, 21, 22, 24, 1, -22 },
  { 165, 19, 22, 20, 1, -22 },
  { 218, 3, 8, 7, 2, -22 },
  { 221, 7, 27, 9, 1, -22 },
  { 245, 7, 27, 9, 1, -22 },
  { 269, 13, 13, 15, 1, -24 },
  { 291, 14, 14, 16, 1, -18 },
  { 316, 5, 8, 8, 1, -4 },
  { 321, 7, 3, 9, 1, -10 },
  { 324, 4, 4, 8, 2, -4 },
  { 326, 11, 22, 12, 0, -22 },
  { 357, 14, 22, 16, 1, -22 },
  { 396, 8, 22, 16, 2, -22 },
  { 418, 14, 22, 16, 1, -22 },
  { 457, 13, 22, 16, 1, -22 },
  { 493, 15, 22, 16, 1, -22 },
  { 535, 12, 22, 16, 2, -22 },
  { 568, 13, 22, 16, 2, -22 },
  { 604, 14, 22, 16, 1, -22 },
  { 643, 14, 22, 16, 1, -22 },
  { 682, 14, 22, 16, 1, -22 },
  { 721, 4, 17, 8, 2, -17 },
  { 730, 5, 21, 8, 1, -17 },
  { 744, 14, 15, 16, 1, -19 },
  { 771, 14, 8, 16, 1, -15 },
  { 785, 14, 15, 16, 1, -19 },
  { 812, 11, 22, 12, 0, -22 },
  { 843, 21, 25, 25, 2, -22 },
  { 909, 18, 22, 18, 0, -22 },
  { 959, 14, 22, 18, 3, -22 },
  { 998, 15, 22, 17, 2, -22 },
  { 1040, 15, 22, 20, 3, -22 },
  { 1082, 11, 22, 16, 3, -22 },
  { 1113, 11, 22, 15, 3, -22 },
  { 1144, 16, 22, 20, 2, -22 },
  { 1188, 15, 22, 21, 3, -22 },
  { 1230, 8, 22, 10, 1, -22 },
  { 1252, 7, 28, 8, -2, -22 },
  { 1277, 14, 22, 17, 3, -22 },
  { 1316, 11, 22, 15, 3, -22 },
  { 1347, 20, 22, 26, 3, -22 },
  { 1402, 16, 22, 21, 3, -22 },
  { 1446, 18, 22, 22, 2, -22 },
  { 1496, 13, 22, 17, 3, -22 },
  { 1532, 18, 27, 22, 2, -22 },
  { 1593, 14, 22, 17, 3, -22 },
  { 1632, 13, 22, 15, 1, -22 },
  { 1668, 15, 22, 15, 0, -22 },
  { 1710, 15, 22, 20, 3, -22 },
  { 1752, 17, 22, 17, 0, -22 },
  { 1799, 26, 22, 26, 0, -22 },
  { 1871, 16, 22, 16, 0, -22 },
  { 1915, 16, 22, 16, 0, -22 },
  { 1959, 13, 22, 15, 1, -22 },
  { 1995, 7, 27, 10, 2, -22 },
  { 2019, 11, 22, 12, 0, -22 },
  { 2050, 7, 27, 10, 1, -22 },
  { 2074, 14, 13, 16, 1, -22 },
  { 2097, 14, 2, 14, 0, 3 },
  { 2101, 6, 5, 9, 1, -24 },
  { 2105, 12, 17, 16, 1, -17 },
  { 2131, 14, 24, 17, 2, -24 },
  { 2173, 11, 17, 13, 2, -17 },
  { 2197, 13, 24, 17, 2, -24 },
  { 2236, 12, 17, 16, 2, -17 },
  { 2262, 11, 24, 10, 0, -24 },
  { 2295, 13, 24, 17, 2, -17 },
  { 2334, 13, 24, 17, 2, -24 },
  { 2373, 3, 23, 7, 2, -23 },
  { 2382, 6, 30, 7, -1, -23 },
  { 2405, 13, 24, 15, 2, -24 },
  { 2444, 3, 24, 7, 2, -24 },
  { 2453, 22, 17, 26, 2, -17 },
  { 2500, 13, 17, 17, 2, -17 },
  { 2528, 13, 17, 17, 2, -17 },
  { 2556, 14, 24, 17, 2, -17 },
  { 2598, 13, 24, 17, 2, -17 },
  { 2637, 9, 17, 12, 2, -17 },
  { 2657, 11, 17, 13, 1, -17 },
  { 2681, 9, 20, 10, 0, -20 },
  { 2704, 13, 17, 17, 2, -17 },
  { 2732, 14, 17, 14, 0, -17 },
  { 2762, 22, 17, 22, 0, -17 },
  { 2809, 13, 17, 15, 1, -17 },
  { 2837, 14, 24, 14, 0, -17 },
  { 2879, 11, 17, 13, 1, -17 },
  { 2903, 9, 27, 12, 1, -22 },
  { 2934, 2, 31, 15, 7, -24 },
  { 2942, 10, 27, 12, 1, -22 },
  { 2976, 14, 4, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_Regular31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR31PT7B_H_
