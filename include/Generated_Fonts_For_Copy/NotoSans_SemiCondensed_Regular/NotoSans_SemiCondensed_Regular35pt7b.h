#ifndef _NOTOSANS_SEMICONDENSED_REGULAR35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular35pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x80, 0x00, 0x3B, 0xDF, 0x70, 0xF3, 0xF8, 0x7E, 0x1F, 0x86, 0xE1, 0x98,
  0x66, 0x19, 0x86, 0x61, 0x80, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x60,
  0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x70, 0xE1, 0xFF, 0xFF, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF0, 0x60, 0xC0, 0x18, 0x70, 0x0E, 0x1C, 0x03, 0x87,
  0x00, 0xE1, 0x83, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE1, 0xC3, 0x80,
  0x70, 0xE0, 0x1C, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x61, 0xC0, 0x38,
  0x70, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x1F, 0xFD, 0xFF,
  0xE7, 0x31, 0xB8, 0xC0, 0xE3, 0x03, 0x8C, 0x0E, 0x30, 0x3C, 0xC0, 0x7F,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0x7C, 0x0C, 0x70, 0x31, 0xC0,
  0xC3, 0x03, 0x1E, 0x0C, 0x7F, 0xBF, 0xBF, 0xFC, 0x7F, 0xE0, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x3E, 0x00, 0xE0, 0xFE, 0x03, 0x83, 0x8C,
  0x07, 0x07, 0x1C, 0x1C, 0x0C, 0x38, 0x38, 0x18, 0x30, 0x60, 0x30, 0x61,
  0xC0, 0x60, 0xC3, 0x00, 0xC1, 0x8E, 0x01, 0x83, 0x18, 0x03, 0x0E, 0x73,
  0xE7, 0x1C, 0xCF, 0xEE, 0x33, 0x98, 0xEF, 0xE6, 0x71, 0xCF, 0x9C, 0xC1,
  0x80, 0x31, 0x83, 0x00, 0xE3, 0x06, 0x01, 0x86, 0x0C, 0x07, 0x0C, 0x18,
  0x0C, 0x18, 0x30, 0x38, 0x30, 0x60, 0x60, 0x71, 0xC1, 0xC0, 0x63, 0x83,
  0x00, 0xFE, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3C, 0x70,
  0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x87,
  0x00, 0x1C, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x0E, 0x71, 0xE0, 0xEF, 0x0F, 0x1C, 0xE0, 0x79, 0xCE,
  0x03, 0xFC, 0xE0, 0x1F, 0x8E, 0x00, 0xF0, 0xE0, 0x0F, 0x0F, 0x01, 0xF8,
  0x7C, 0xFF, 0xC7, 0xFF, 0x1E, 0x1F, 0xE0, 0xF0, 0xFE, 0xEE, 0xE6, 0x66,
  0x60, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x70, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x78,
  0x38, 0x38, 0x3C, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0xE0, 0x70, 0x38, 0x38,
  0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38,
  0x70, 0x70, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x0E, 0x33, 0xDF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x0D, 0x80, 0x3B, 0x80,
  0xF3, 0x83, 0xC7, 0x83, 0x86, 0x01, 0x08, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x39, 0xCE, 0xF7, 0x39, 0x8C, 0xE0,
  0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x7F, 0xE0, 0xF3, 0xC3, 0x81, 0xC7, 0x03, 0x9C, 0x03, 0xB8, 0x07, 0x70,
  0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x00, 0xE7,
  0x03, 0x8E, 0x07, 0x0F, 0x3C, 0x1F, 0xF8, 0x0F, 0xC0, 0x03, 0x87, 0xC7,
  0xE7, 0xF7, 0xBF, 0x1D, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0x0F, 0xE0, 0x7F, 0xF1, 0xF1, 0xF1, 0x80, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xF0, 0xFF, 0xF1, 0xE1, 0xF1, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xE0, 0x7F, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xFE, 0x1F, 0x7F, 0xFC, 0x7F, 0xE0,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0D,
  0xC0, 0x0E, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x0E, 0x03,
  0x87, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0xC0, 0x70, 0xE0, 0x38,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x07,
  0xFE, 0x3F, 0xFC, 0x20, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3E, 0x00, 0xEF, 0x0F, 0xBF, 0xFC,
  0x7F, 0xC0, 0x03, 0xF8, 0x1F, 0xF0, 0x7C, 0x21, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC3, 0x83, 0xBF, 0xC7, 0xFF,
  0xCF, 0x83, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xE7, 0x01, 0xCF, 0x07, 0x8F, 0x1E, 0x0F, 0xF8, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xE1, 0xE3, 0x81, 0xEE, 0x01,
  0xDC, 0x03, 0xB8, 0x07, 0x78, 0x0E, 0x70, 0x38, 0x70, 0xE0, 0xFF, 0xC0,
  0x7E, 0x01, 0xFE, 0x07, 0xBE, 0x1E, 0x1E, 0x78, 0x1E, 0xE0, 0x1D, 0xC0,
  0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xDC, 0x03, 0x9E, 0x1F, 0x3F, 0xFC,
  0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0xC7, 0xCF, 0x1C, 0x0E, 0xE0, 0x3B, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0x70,
  0x7D, 0xFF, 0xF3, 0xFD, 0xC3, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x03, 0xC4, 0x3E, 0x1F, 0xF0, 0x7F, 0x80, 0x77, 0xBE,
  0xE2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xF7, 0xDC, 0x3B, 0xDE,
  0x71, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3B, 0xDC, 0xE7, 0x33,
  0x98, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80,
  0x00, 0x3F, 0xC7, 0xFF, 0x1E, 0x3C, 0x80, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x07, 0x80, 0x38, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0,
  0x07, 0xC0, 0xF0, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x06, 0x70, 0x3F, 0xC7, 0x70, 0xFF, 0xC7, 0x60, 0xE1, 0x83,
  0xE1, 0xC1, 0x83, 0xE1, 0x81, 0x83, 0xE3, 0x81, 0x83, 0xC3, 0x81, 0x83,
  0xC3, 0x81, 0x83, 0xC3, 0x83, 0x83, 0xC3, 0x83, 0x87, 0xE1, 0x83, 0x87,
  0xE1, 0xC6, 0xCE, 0xE0, 0xFE, 0xFC, 0x60, 0x78, 0x78, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x0F, 0x83, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x19, 0x80, 0x03, 0x9C, 0x00,
  0x39, 0xC0, 0x03, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x60, 0xE0,
  0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xC0, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x00,
  0x0E, 0x70, 0x00, 0xEF, 0x00, 0x0E, 0xE0, 0x00, 0x70, 0xFF, 0xE0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x78, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0,
  0x7C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x03,
  0xFF, 0x03, 0xFF, 0xC7, 0xF7, 0xC3, 0xC0, 0x23, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0x3C,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3,
  0x80, 0xF8, 0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x0E, 0xE0,
  0x03, 0xB8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x7B,
  0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xEF, 0xFF, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0xFF, 0x7F, 0xFB, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xBF, 0x0F, 0x00, 0x23, 0xC0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xBC, 0x00, 0x73,
  0xC0, 0x0E, 0x7C, 0x01, 0xC7, 0xF0, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xC0,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x71, 0xFF, 0xFF, 0x80, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x0F, 0x0E, 0xFE, 0xFC, 0xF0, 0xE0, 0x0F, 0x70, 0x07, 0x38,
  0x07, 0x1C, 0x07, 0x0E, 0x07, 0x87, 0x03, 0x83, 0x83, 0x81, 0xC3, 0x80,
  0xE3, 0xC0, 0x73, 0xC0, 0x39, 0xC0, 0x1D, 0xE0, 0x0F, 0xF8, 0x07, 0xDC,
  0x03, 0xCF, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C,
  0x0F, 0x0E, 0x03, 0xC7, 0x00, 0xE3, 0x80, 0x79, 0xC0, 0x1E, 0xE0, 0x07,
  0x80, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFD, 0x80, 0x0F, 0xFB,
  0x80, 0x1B, 0xF7, 0x00, 0x77, 0xE6, 0x00, 0xEF, 0xCE, 0x03, 0x9F, 0x9C,
  0x07, 0x3F, 0x1C, 0x0E, 0x7E, 0x38, 0x38, 0xFC, 0x70, 0x71, 0xF8, 0x70,
  0xE3, 0xF0, 0xE3, 0x87, 0xE1, 0xC7, 0x0F, 0xC1, 0xCC, 0x1F, 0x83, 0xB8,
  0x3F, 0x07, 0x70, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03,
  0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0E, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7E, 0xE0, 0x1F, 0x9C, 0x07,
  0xE7, 0x81, 0xF8, 0xE0, 0x7E, 0x3C, 0x1F, 0x87, 0x07, 0xE1, 0xE1, 0xF8,
  0x38, 0x7E, 0x07, 0x1F, 0x81, 0xC7, 0xE0, 0x39, 0xF8, 0x0F, 0x7E, 0x01,
  0xDF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x03, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0x8F, 0x83, 0xC0,
  0x3C, 0x38, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x77, 0x00, 0x07,
  0x70, 0x00, 0xF7, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0xC0, 0x3C, 0x1F, 0x9F,
  0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7,
  0x01, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3B, 0x80, 0x77, 0x01, 0xEE, 0x1F, 0x9F, 0xFE, 0x3F, 0xF0, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0x8F,
  0x83, 0xC0, 0x3C, 0x38, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x77,
  0x00, 0x07, 0x70, 0x00, 0xF7, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0xC0, 0x3C,
  0x1F, 0x9F, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x78, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0,
  0x78, 0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0,
  0x0F, 0x1F, 0xF0, 0xFF, 0xE7, 0xEF, 0xBC, 0x02, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3E, 0x00, 0xEF, 0x9F, 0xBF, 0xFC, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x73,
  0xC0, 0x78, 0xFC, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0xFE,
  0x00, 0x3D, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x80, 0x3C, 0x70, 0x07, 0x0E,
  0x00, 0xE1, 0xC0, 0x3C, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07,
  0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07,
  0x1C, 0x00, 0xF7, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x80,
  0x3D, 0xC0, 0x1E, 0x00, 0xE7, 0x00, 0x78, 0x03, 0x9C, 0x03, 0xE0, 0x0E,
  0x78, 0x0F, 0xC0, 0x70, 0xE0, 0x3F, 0x01, 0xC3, 0x80, 0xDC, 0x07, 0x0E,
  0x07, 0x30, 0x1C, 0x38, 0x1C, 0xE0, 0xE0, 0x70, 0x73, 0x83, 0x81, 0xC1,
  0x8E, 0x0E, 0x07, 0x0E, 0x18, 0x38, 0x1C, 0x38, 0x71, 0xC0, 0x38, 0xE1,
  0xC7, 0x00, 0xE3, 0x07, 0x1C, 0x03, 0x9C, 0x0C, 0x70, 0x0E, 0x70, 0x3B,
  0x80, 0x1D, 0xC0, 0xEE, 0x00, 0x76, 0x03, 0xB8, 0x01, 0xF8, 0x06, 0xE0,
  0x07, 0xE0, 0x1B, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x70, 0x03, 0xCE, 0x01, 0xE3,
  0x80, 0x70, 0x70, 0x3C, 0x1C, 0x0E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x1C,
  0xE0, 0x07, 0xB8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x87, 0x00,
  0xE1, 0xC0, 0x70, 0x38, 0x1C, 0x0F, 0x0E, 0x01, 0xC3, 0x80, 0x79, 0xC0,
  0x0E, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xDC, 0x00, 0xE7, 0x00, 0x70, 0xE0,
  0x1C, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0x38, 0x70, 0x0E, 0x3C,
  0x03, 0xCE, 0x00, 0x73, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0F, 0xFF, 0xFF, 0x80, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0xFF, 0xFF, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0,
  0x06, 0x60, 0x0E, 0x70, 0x0E, 0x30, 0x1C, 0x38, 0x1C, 0x38, 0x18, 0x1C,
  0x38, 0x1C, 0x30, 0x0E, 0x70, 0x0E, 0x60, 0x07, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xC0, 0x0F, 0xE0, 0xFF, 0xE1,
  0xE7, 0x84, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x0F, 0xFC,
  0xFF, 0xF7, 0xC1, 0xDC, 0x07, 0x70, 0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x0F,
  0x78, 0x7C, 0xFF, 0x31, 0xF8, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE7, 0xE1, 0xDF,
  0xE3, 0xFB, 0xE7, 0x81, 0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xB8,
  0x07, 0x78, 0x1E, 0xFC, 0x79, 0xBF, 0xE3, 0x1F, 0x80, 0x0F, 0xE1, 0xFF,
  0x3F, 0xE7, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x7C, 0x33, 0xFF,
  0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x0F, 0x8E, 0x7F, 0xDD, 0xFB, 0xFB, 0x81,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xB8, 0x0F, 0x7C,
  0x7E, 0x7F, 0xDC, 0x7F, 0x38, 0x0F, 0xC0, 0x7F, 0xC3, 0xCF, 0x9C, 0x0E,
  0x70, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x01, 0x3E, 0x18, 0x7F,
  0xE0, 0xFF, 0x80, 0x01, 0xE0, 0x7F, 0x0F, 0xF0, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3F, 0xCF, 0xFC, 0xFF, 0xC1, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x8E, 0x7F, 0xDC,
  0xFB, 0xFB, 0xC1, 0xF7, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x07,
  0xB8, 0x0F, 0x7C, 0x7E, 0x7F, 0xDC, 0x7F, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x20, 0x0E, 0x70, 0x7C, 0xFF, 0xF0, 0xFF, 0x80, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE7, 0xE3, 0xBF, 0xCF, 0xEF, 0xBC, 0x0F, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0, 0x67,
  0xF7, 0x00, 0x07, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x0C, 0x1C, 0x78, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x8E, 0xFD, 0xF0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x3B, 0x81, 0xCE,
  0x0E, 0x38, 0x78, 0xE3, 0xC3, 0x8E, 0x0E, 0x70, 0x3B, 0x80, 0xFE, 0x03,
  0xFC, 0x0F, 0x70, 0x38, 0xE0, 0xE3, 0xC3, 0x87, 0x0E, 0x1E, 0x38, 0x3C,
  0xE0, 0x73, 0x81, 0xEE, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC7, 0xE1, 0xF8, 0xCF, 0xF3, 0xFC, 0xDF,
  0xFF, 0xBE, 0xF0, 0x7E, 0x0E, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0,
  0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0,
  0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0,
  0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0,
  0x38, 0x07, 0xC7, 0xE3, 0x3F, 0xCD, 0xEF, 0xBC, 0x0F, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0,
  0x0F, 0xE0, 0x3F, 0xE0, 0xFB, 0xE3, 0xC1, 0xE7, 0x01, 0xDC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xDC, 0x07, 0xB8, 0x0E, 0x3C, 0x7C, 0x3F, 0xF0, 0x3F, 0x80,
  0xC7, 0xE1, 0x9F, 0xE3, 0xFB, 0xE7, 0x81, 0xEF, 0x01, 0xDC, 0x03, 0xB8,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xB8, 0x07, 0x78, 0x1E, 0xF8, 0x79, 0xFF, 0xE3, 0x9F, 0x87,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x0F, 0xCE, 0x7F, 0xDC, 0xFB, 0xFB, 0x81, 0xF7, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xB8, 0x0F, 0x7C, 0x7E, 0x7F,
  0xDC, 0x7F, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0xC7, 0xF3, 0xED, 0xFB, 0x60, 0xF0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x1F, 0xC7, 0xFE, 0xF9, 0xEE, 0x02,
  0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x0E, 0xE1, 0xEF, 0xFC, 0xFF, 0x80, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x7F, 0xBF, 0xEF, 0xF8, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x3C, 0x47, 0xF0, 0xFC, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xF8, 0xFD, 0xFF, 0x73,
  0xF9, 0xC0, 0xE0, 0x07, 0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E,
  0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x1C, 0x03, 0xB8, 0x0F, 0x03, 0x9C, 0x0F,
  0x81, 0xCE, 0x07, 0xC0, 0xE7, 0x03, 0x60, 0x71, 0xC1, 0xB8, 0x30, 0xE1,
  0xDC, 0x38, 0x70, 0xE6, 0x1C, 0x38, 0x63, 0x8E, 0x0E, 0x71, 0xC6, 0x07,
  0x38, 0xE7, 0x03, 0x9C, 0x33, 0x81, 0xCC, 0x1D, 0xC0, 0x7E, 0x0E, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xC0, 0x78,
  0x01, 0xE0, 0x3C, 0x00, 0xE0, 0x1E, 0xE0, 0x39, 0xE0, 0xE1, 0xC3, 0xC1,
  0xC7, 0x03, 0x9C, 0x03, 0xB8, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0xEE, 0x03, 0x9E, 0x0F, 0x1C, 0x1C, 0x1C, 0x70, 0x38,
  0xE0, 0x3B, 0x80, 0x78, 0xE0, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E,
  0x38, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x1C, 0x38,
  0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x7C, 0x1F, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x3E, 0x07,
  0x80, 0xFC, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x7E, 0x07, 0xC0, 0x18, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xF8, 0x0F, 0x07, 0xE1,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0E, 0x0F, 0xC1, 0xF0, 0x30, 0x00, 0x18, 0x01, 0x7F, 0x83, 0xFF,
  0xFF, 0xC1, 0xFE, 0x80, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_Regular35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 25, 9, 2, -25 },
  { 17, 10, 9, 14, 2, -25 },
  { 29, 18, 25, 20, 1, -25 },
  { 86, 14, 29, 18, 2, -27 },
  { 137, 23, 25, 27, 2, -25 },
  { 209, 20, 25, 22, 2, -25 },
  { 272, 4, 9, 8, 2, -25 },
  { 277, 8, 31, 10, 1, -25 },
  { 308, 8, 31, 10, 1, -25 },
  { 339, 15, 15, 17, 1, -27 },
  { 368, 16, 17, 18, 1, -21 },
  { 402, 5, 9, 9, 1, -4 },
  { 408, 8, 3, 11, 1, -11 },
  { 411, 4, 4, 9, 2, -4 },
  { 413, 13, 25, 13, 0, -25 },
  { 454, 15, 25, 18, 2, -25 },
  { 501, 9, 25, 18, 3, -25 },
  { 530, 15, 25, 18, 1, -25 },
  { 577, 15, 25, 18, 1, -25 },
  { 624, 17, 25, 18, 1, -25 },
  { 678, 14, 25, 18, 2, -25 },
  { 722, 15, 25, 18, 2, -25 },
  { 769, 16, 25, 18, 1, -25 },
  { 819, 15, 25, 18, 2, -25 },
  { 866, 14, 25, 18, 2, -25 },
  { 910, 5, 19, 9, 2, -19 },
  { 922, 5, 24, 9, 1, -19 },
  { 937, 16, 17, 18, 1, -21 },
  { 971, 14, 9, 18, 2, -17 },
  { 987, 16, 17, 18, 1, -21 },
  { 1021, 13, 25, 14, 0, -25 },
  { 1062, 24, 28, 28, 2, -25 },
  { 1146, 20, 25, 20, 0, -25 },
  { 1209, 16, 25, 21, 3, -25 },
  { 1259, 17, 25, 20, 2, -25 },
  { 1313, 18, 25, 23, 3, -25 },
  { 1370, 13, 25, 18, 3, -25 },
  { 1411, 13, 25, 16, 3, -25 },
  { 1452, 19, 25, 23, 2, -25 },
  { 1512, 17, 25, 23, 3, -25 },
  { 1566, 9, 25, 11, 1, -25 },
  { 1595, 8, 32, 9, -2, -25 },
  { 1627, 17, 25, 19, 3, -25 },
  { 1681, 13, 25, 16, 3, -25 },
  { 1722, 23, 25, 29, 3, -25 },
  { 1794, 18, 25, 24, 3, -25 },
  { 1851, 20, 25, 24, 2, -25 },
  { 1914, 15, 25, 19, 3, -25 },
  { 1961, 20, 31, 24, 2, -25 },
  { 2039, 16, 25, 20, 3, -25 },
  { 2089, 14, 25, 17, 2, -25 },
  { 2133, 17, 25, 17, 0, -25 },
  { 2187, 17, 25, 23, 3, -25 },
  { 2241, 19, 25, 19, 0, -25 },
  { 2301, 30, 25, 30, 0, -25 },
  { 2395, 18, 25, 18, 0, -25 },
  { 2452, 18, 25, 18, 0, -25 },
  { 2509, 15, 25, 17, 1, -25 },
  { 2556, 7, 31, 11, 3, -25 },
  { 2584, 13, 25, 13, 0, -25 },
  { 2625, 8, 31, 11, 1, -25 },
  { 2656, 16, 15, 18, 1, -25 },
  { 2686, 16, 2, 15, 0, 3 },
  { 2690, 7, 6, 10, 1, -27 },
  { 2696, 14, 19, 18, 1, -19 },
  { 2730, 15, 27, 20, 3, -27 },
  { 2781, 12, 19, 15, 2, -19 },
  { 2810, 15, 27, 20, 2, -27 },
  { 2861, 14, 19, 18, 2, -19 },
  { 2895, 12, 27, 11, 0, -27 },
  { 2936, 15, 27, 20, 2, -19 },
  { 2987, 14, 27, 20, 3, -27 },
  { 3035, 4, 26, 8, 2, -26 },
  { 3048, 7, 34, 8, -1, -26 },
  { 3078, 14, 27, 17, 3, -27 },
  { 3126, 3, 27, 8, 3, -27 },
  { 3137, 24, 19, 29, 3, -19 },
  { 3194, 14, 19, 20, 3, -19 },
  { 3228, 15, 19, 19, 2, -19 },
  { 3264, 15, 27, 20, 3, -19 },
  { 3315, 15, 27, 20, 2, -19 },
  { 3366, 10, 19, 13, 3, -19 },
  { 3390, 12, 19, 15, 2, -19 },
  { 3419, 10, 23, 11, 1, -23 },
  { 3448, 14, 19, 20, 3, -19 },
  { 3482, 16, 19, 16, 0, -19 },
  { 3520, 25, 19, 25, 0, -19 },
  { 3580, 15, 19, 17, 1, -19 },
  { 3616, 16, 27, 16, 0, -19 },
  { 3670, 12, 19, 14, 1, -19 },
  { 3699, 11, 31, 13, 1, -25 },
  { 3742, 3, 35, 17, 7, -27 },
  { 3756, 11, 31, 13, 1, -25 },
  { 3799, 16, 5, 18, 1, -15 },
};

const GFXfont NotoSans_SemiCondensed_Regular35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR35PT7B_H_
