#ifndef _NOTOSANS_SEMICONDENSED_REGULAR10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xF0, 0x28, 0xA7, 0xD4, 0xF9, 0x45, 0x00, 0x4F, 0xCC, 0x65,
  0xF4, 0x40, 0x65, 0x52, 0xA3, 0xB1, 0xA5, 0x49, 0x80, 0x71, 0x45, 0x19,
  0x96, 0x27, 0x40, 0xC0, 0x69, 0x49, 0x12, 0x20, 0xC9, 0x12, 0x92, 0x80,
  0x21, 0x3E, 0xA0, 0x21, 0x3E, 0x42, 0x00, 0x60, 0xE0, 0x80, 0x32, 0x24,
  0x44, 0x80, 0x72, 0x63, 0x18, 0xA5, 0xC0, 0x75, 0x54, 0xF0, 0x44, 0x22,
  0x23, 0xE0, 0xF0, 0x44, 0xE0, 0x87, 0xC0, 0x11, 0x94, 0xA9, 0x3C, 0x40,
  0xE8, 0xCA, 0x11, 0xE0, 0xE8, 0xCB, 0x99, 0xE0, 0xF8, 0x84, 0x22, 0x11,
  0x00, 0x72, 0x54, 0xE8, 0xC5, 0xC0, 0x74, 0x62, 0xF0, 0x89, 0xC0, 0x88,
  0x40, 0x60, 0x09, 0xB0, 0x60, 0x80, 0xF8, 0x3E, 0xC1, 0x06, 0xC8, 0x00,
  0xE1, 0x22, 0x40, 0x40, 0x79, 0x0A, 0xEE, 0x5C, 0xB7, 0xA0, 0x3C, 0x30,
  0xC5, 0x12, 0x7A, 0x28, 0x40, 0xF9, 0x9F, 0x99, 0xF0, 0x78, 0x88, 0x88,
  0x70, 0xF4, 0x63, 0x18, 0xCF, 0xC0, 0xF2, 0x79, 0x38, 0xF2, 0x79, 0x20,
  0x7C, 0x21, 0x38, 0xC5, 0xE0, 0x8C, 0x63, 0xF8, 0xC6, 0x20, 0xE9, 0x24,
  0xB8, 0x24, 0x92, 0x49, 0xC0, 0x95, 0x31, 0x8A, 0x4A, 0x60, 0x92, 0x49,
  0x38, 0x87, 0x8F, 0x2E, 0x5B, 0x36, 0x64, 0x80, 0x8E, 0x73, 0x59, 0xCE,
  0x20, 0xF4, 0x63, 0x18, 0xC5, 0xC0, 0xF9, 0x9E, 0x88, 0x80, 0xF4, 0x63,
  0x18, 0xC5, 0xC2, 0x08, 0xF9, 0x9E, 0xA9, 0x90, 0x74, 0x10, 0x61, 0x07,
  0xC0, 0xF9, 0x08, 0x42, 0x10, 0x80, 0x8C, 0x63, 0x18, 0xC5, 0xC0, 0x8C,
  0x52, 0xA5, 0x18, 0x80, 0x89, 0x99, 0x59, 0x55, 0x56, 0x66, 0x22, 0xCA,
  0x8C, 0x45, 0x2A, 0x20, 0x8A, 0x94, 0x42, 0x10, 0x80, 0xF8, 0x88, 0x44,
  0x23, 0xE0, 0xEA, 0xAA, 0xC0, 0x84, 0x44, 0x22, 0x30, 0xD5, 0x55, 0xC0,
  0x22, 0x95, 0x10, 0xF0, 0xD0, 0x71, 0x79, 0x70, 0x88, 0xE9, 0x99, 0x9E,
  0xF2, 0x4E, 0x08, 0x4A, 0xB8, 0xC5, 0x2F, 0xE9, 0xE8, 0xE0, 0x29, 0xE4,
  0x92, 0x7C, 0x62, 0x97, 0x85, 0xC0, 0x88, 0xE9, 0x99, 0x99, 0xBE, 0x45,
  0x55, 0xC0, 0x88, 0x9A, 0xCC, 0xAB, 0xFF, 0xFF, 0x26, 0x4C, 0x99, 0x20,
  0xF9, 0x99, 0x90, 0x7C, 0x62, 0x97, 0x00, 0xF9, 0x99, 0xE8, 0x80, 0x7C,
  0x62, 0x97, 0x84, 0x20, 0xF2, 0x48, 0xF4, 0x21, 0xF0, 0x4F, 0x24, 0x98,
  0x99, 0x99, 0xF0, 0x9A, 0x94, 0xC2, 0x00, 0x93, 0x55, 0xB3, 0x66, 0x40,
  0xD3, 0x08, 0xA9, 0x80, 0x9A, 0x94, 0xC2, 0x13, 0x00, 0xF2, 0x44, 0xF0,
  0x29, 0x2C, 0x92, 0x20, 0xFF, 0xC0, 0xC9, 0x22, 0x92, 0x80, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Regular10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 3, 1, -7 },
  { 2, 2, 2, 4, 1, -7 },
  { 3, 6, 7, 6, 0, -7 },
  { 9, 4, 9, 5, 1, -8 },
  { 14, 7, 7, 8, 0, -7 },
  { 21, 6, 7, 6, 0, -7 },
  { 27, 1, 2, 2, 1, -7 },
  { 28, 3, 9, 3, 0, -7 },
  { 32, 3, 9, 3, 0, -7 },
  { 36, 5, 4, 5, 0, -8 },
  { 39, 5, 5, 5, 0, -6 },
  { 43, 2, 2, 3, 0, -1 },
  { 44, 3, 1, 3, 0, -3 },
  { 45, 1, 1, 3, 1, -1 },
  { 46, 4, 7, 4, 0, -7 },
  { 50, 5, 7, 5, 0, -7 },
  { 55, 2, 7, 5, 1, -7 },
  { 57, 5, 7, 5, 0, -7 },
  { 62, 5, 7, 5, 0, -7 },
  { 67, 5, 7, 5, 0, -7 },
  { 72, 4, 7, 5, 1, -7 },
  { 76, 4, 7, 5, 1, -7 },
  { 80, 5, 7, 5, 0, -7 },
  { 85, 5, 7, 5, 0, -7 },
  { 90, 5, 7, 5, 0, -7 },
  { 95, 1, 5, 3, 1, -5 },
  { 96, 2, 6, 3, 0, -5 },
  { 98, 5, 5, 5, 0, -6 },
  { 102, 5, 3, 5, 0, -5 },
  { 104, 5, 5, 5, 0, -6 },
  { 108, 4, 7, 4, 0, -7 },
  { 112, 7, 8, 8, 1, -7 },
  { 119, 6, 7, 6, 0, -7 },
  { 125, 4, 7, 6, 1, -7 },
  { 129, 4, 7, 6, 1, -7 },
  { 133, 5, 7, 7, 1, -7 },
  { 138, 3, 7, 5, 1, -7 },
  { 141, 3, 7, 5, 1, -7 },
  { 144, 5, 7, 7, 1, -7 },
  { 149, 5, 7, 7, 1, -7 },
  { 154, 3, 7, 3, 0, -7 },
  { 157, 3, 9, 3, -1, -7 },
  { 161, 5, 7, 6, 1, -7 },
  { 166, 3, 7, 5, 1, -7 },
  { 169, 7, 7, 8, 1, -7 },
  { 176, 5, 7, 7, 1, -7 },
  { 181, 5, 7, 7, 1, -7 },
  { 186, 4, 7, 5, 1, -7 },
  { 190, 5, 9, 7, 1, -7 },
  { 196, 4, 7, 6, 1, -7 },
  { 200, 5, 7, 5, 0, -7 },
  { 205, 5, 7, 5, 0, -7 },
  { 210, 5, 7, 7, 1, -7 },
  { 215, 5, 7, 5, 0, -7 },
  { 220, 8, 7, 9, 0, -7 },
  { 227, 5, 7, 5, 0, -7 },
  { 232, 5, 7, 5, 0, -7 },
  { 237, 5, 7, 5, 0, -7 },
  { 242, 2, 9, 3, 1, -7 },
  { 245, 4, 7, 4, 0, -7 },
  { 249, 2, 9, 3, 0, -7 },
  { 252, 5, 4, 5, 0, -7 },
  { 255, 4, 1, 4, 0, 1 },
  { 256, 2, 2, 3, 0, -8 },
  { 257, 4, 5, 5, 0, -5 },
  { 260, 4, 8, 6, 1, -8 },
  { 264, 3, 5, 4, 1, -5 },
  { 266, 5, 8, 6, 0, -8 },
  { 271, 4, 5, 5, 1, -5 },
  { 274, 3, 8, 3, 0, -8 },
  { 277, 5, 7, 6, 0, -5 },
  { 282, 4, 8, 6, 1, -8 },
  { 286, 1, 7, 2, 1, -7 },
  { 287, 2, 9, 2, 0, -7 },
  { 290, 4, 8, 5, 1, -8 },
  { 294, 1, 8, 2, 1, -8 },
  { 295, 7, 5, 8, 1, -5 },
  { 300, 4, 5, 6, 1, -5 },
  { 303, 5, 5, 5, 0, -5 },
  { 307, 4, 7, 6, 1, -5 },
  { 311, 5, 7, 6, 0, -5 },
  { 316, 3, 5, 4, 1, -5 },
  { 318, 4, 5, 4, 0, -5 },
  { 321, 3, 7, 3, 0, -7 },
  { 324, 4, 5, 6, 1, -5 },
  { 327, 5, 5, 5, 0, -5 },
  { 331, 7, 5, 7, 0, -5 },
  { 336, 5, 5, 5, 0, -5 },
  { 340, 5, 7, 5, 0, -5 },
  { 345, 4, 5, 4, 0, -5 },
  { 348, 3, 9, 4, 0, -7 },
  { 352, 1, 10, 5, 2, -8 },
  { 354, 3, 9, 4, 0, -7 },
  { 358, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_Regular10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR10PT7B_H_
