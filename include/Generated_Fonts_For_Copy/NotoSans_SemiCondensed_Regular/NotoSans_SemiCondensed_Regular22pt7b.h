#ifndef _NOTOSANS_SEMICONDENSED_REGULAR22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0x2F, 0xCF, 0x34, 0xD1, 0x45, 0x10, 0x04, 0x60,
  0x44, 0x0C, 0x40, 0xC4, 0x0C, 0xC7, 0xFF, 0x08, 0x80, 0x88, 0x18, 0x81,
  0x88, 0xFF, 0xF1, 0x18, 0x11, 0x01, 0x10, 0x31, 0x03, 0x30, 0x08, 0x04,
  0x07, 0xCF, 0xFC, 0x8E, 0x43, 0x20, 0xD0, 0x7C, 0x0F, 0x82, 0xE1, 0x30,
  0x8C, 0x4F, 0xFC, 0xFC, 0x08, 0x04, 0x00, 0x30, 0x30, 0xF0, 0x43, 0x31,
  0x86, 0x62, 0x0C, 0xCC, 0x19, 0x98, 0x33, 0x66, 0x66, 0xDE, 0x7B, 0x66,
  0x66, 0xCC, 0x09, 0x98, 0x32, 0x30, 0x46, 0x61, 0x8C, 0xC2, 0x19, 0x0C,
  0x1E, 0x1E, 0x01, 0xF8, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x19, 0x80, 0xF8,
  0x03, 0x80, 0x3C, 0x33, 0x31, 0xB0, 0xCD, 0x83, 0xCC, 0x0E, 0x60, 0xF1,
  0xDF, 0xC7, 0xC7, 0xF5, 0x50, 0x19, 0x8C, 0xC6, 0x23, 0x18, 0xC6, 0x31,
  0x8C, 0x61, 0x0C, 0x61, 0x8E, 0xC6, 0x18, 0xC3, 0x18, 0xC2, 0x18, 0xC6,
  0x23, 0x18, 0xC6, 0x63, 0x30, 0x18, 0x04, 0x02, 0x19, 0x3F, 0xF8, 0xE0,
  0xD0, 0x6C, 0x63, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xFF, 0xFC, 0x20,
  0x10, 0x08, 0x04, 0x00, 0x6D, 0xED, 0x00, 0xFF, 0xC0, 0x5D, 0x80, 0x03,
  0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x20,
  0x60, 0x60, 0xC0, 0x1E, 0x1F, 0x98, 0xC8, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1B, 0x0D, 0xDC, 0x7C, 0x19, 0xDB, 0xB9,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x3E, 0x7F, 0x90, 0xE0, 0x30,
  0x18, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0xFF,
  0xFF, 0x3E, 0x7F, 0x90, 0xE0, 0x30, 0x18, 0x0C, 0x0C, 0x7C, 0x3F, 0x01,
  0xC0, 0x60, 0x30, 0x18, 0x0F, 0x9D, 0xFC, 0x01, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0xD8, 0x13, 0x06, 0x60, 0x8C, 0x31, 0x8C, 0x31, 0x06, 0x7F, 0xFF,
  0xFE, 0x03, 0x00, 0x60, 0x0C, 0x7F, 0x3F, 0x98, 0x0C, 0x06, 0x02, 0x01,
  0x70, 0xFE, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0x9D, 0xFC, 0x0F,
  0x1F, 0x8C, 0x0C, 0x06, 0x06, 0x03, 0x39, 0xFE, 0xE1, 0xE0, 0xF0, 0x38,
  0x14, 0x1B, 0x0D, 0xCC, 0x3C, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x30, 0x18,
  0x0C, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x1E,
  0x3F, 0x98, 0x78, 0x3C, 0x1B, 0x0D, 0xCC, 0x3C, 0x3E, 0x31, 0xF0, 0x78,
  0x1C, 0x0E, 0x0D, 0x8E, 0x7E, 0x1C, 0x3F, 0x98, 0xD8, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0x77, 0x9E, 0xC0, 0x60, 0x30, 0x10, 0x19, 0x38, 0xF8, 0x7D,
  0x80, 0x00, 0x0B, 0xB0, 0x7D, 0x80, 0x00, 0x0D, 0xED, 0xA0, 0x00, 0xC0,
  0xF0, 0xF0, 0xF0, 0xE0, 0x38, 0x07, 0x80, 0x78, 0x03, 0x80, 0x30, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x70, 0x70, 0xF0, 0xF0, 0x30, 0x00, 0x3C, 0xFE, 0x43, 0x03, 0x03,
  0x03, 0x06, 0x0C, 0x18, 0x18, 0x10, 0x10, 0x00, 0x10, 0x38, 0x38, 0x03,
  0xC0, 0x0F, 0xF8, 0x18, 0x0C, 0x30, 0x04, 0x60, 0x06, 0x63, 0xE2, 0x46,
  0x22, 0xCC, 0x23, 0xCC, 0x63, 0xCC, 0x63, 0xCC, 0x62, 0xC4, 0x66, 0xC7,
  0xBC, 0x41, 0x08, 0x60, 0x00, 0x30, 0x00, 0x1E, 0xF0, 0x07, 0xE0, 0x06,
  0x00, 0x38, 0x01, 0xC0, 0x1A, 0x00, 0xD8, 0x04, 0xC0, 0x66, 0x03, 0x18,
  0x10, 0xC1, 0xFE, 0x0F, 0xF8, 0x40, 0xC6, 0x06, 0x30, 0x19, 0x00, 0xD8,
  0x07, 0xFC, 0x3F, 0xCC, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x1B, 0xF8, 0xFF,
  0x30, 0x6C, 0x0F, 0x03, 0xC0, 0xF0, 0x6F, 0xFB, 0xFC, 0x0F, 0xC3, 0xFC,
  0xE1, 0x38, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x06, 0x00, 0x60, 0x0F, 0xF0, 0x7E, 0xFC, 0x1F, 0xE3, 0x06, 0x60,
  0x6C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C,
  0x0D, 0x83, 0xBF, 0xE7, 0xF0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x07, 0xE1, 0xFF, 0x38, 0x27, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0xC1, 0xFC, 0x03, 0xE0, 0x36, 0x03, 0x60, 0x33, 0x03, 0x3E, 0xF0,
  0xFF, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF,
  0xC8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x11, 0xDF, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFD, 0xC0, 0xC0, 0xF0,
  0x6C, 0x33, 0x1C, 0xC6, 0x33, 0x0D, 0x83, 0xE0, 0xFC, 0x33, 0x0C, 0x63,
  0x18, 0xC3, 0x30, 0xEC, 0x1B, 0x03, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xBF, 0x03, 0x7B, 0x06, 0xF6, 0x09, 0xEC,
  0x33, 0xCC, 0x67, 0x98, 0x8F, 0x33, 0x1E, 0x36, 0x3C, 0x78, 0x78, 0xF0,
  0xF0, 0xC1, 0xE1, 0x83, 0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x87, 0xB0,
  0xF3, 0x1E, 0x63, 0xC6, 0x78, 0xCF, 0x0D, 0xE1, 0xFC, 0x1B, 0x81, 0xF0,
  0x3E, 0x03, 0x0F, 0x81, 0xFF, 0x0C, 0x1C, 0xC0, 0x66, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x06, 0xC0, 0x36, 0x03, 0x18,
  0x38, 0xFF, 0x81, 0xF8, 0xFC, 0x7F, 0xB0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07,
  0x86, 0xFF, 0x7E, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x0F, 0x81,
  0xFF, 0x0C, 0x1C, 0xC0, 0x66, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x06, 0xC0, 0x36, 0x03, 0x18, 0x38, 0xFF, 0x81, 0xF8,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0xFC, 0x3F, 0xCC, 0x3B, 0x06,
  0xC1, 0xB0, 0x6C, 0x1B, 0x0C, 0xFE, 0x33, 0x0C, 0x63, 0x1C, 0xC3, 0x30,
  0x6C, 0x1B, 0x03, 0x1F, 0x3F, 0xF8, 0x38, 0x0C, 0x06, 0x01, 0xC0, 0x78,
  0x1E, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0F, 0xFD, 0xFC, 0xFF, 0xFF, 0xFC,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0D, 0xC1, 0x9F, 0xE1, 0xF8, 0xC0, 0x3C, 0x03, 0x60, 0x66, 0x06, 0x60,
  0x63, 0x0C, 0x30, 0xC3, 0x0C, 0x19, 0x81, 0x98, 0x19, 0x80, 0xB0, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0x60, 0xC0, 0xC0, 0x78, 0x1C, 0x19, 0x83, 0x83,
  0x30, 0x70, 0x66, 0x1A, 0x0C, 0xC3, 0x63, 0x0C, 0x6C, 0x61, 0x89, 0x8C,
  0x33, 0x11, 0x86, 0x63, 0x60, 0x68, 0x6C, 0x0D, 0x0D, 0x81, 0xE0, 0xB0,
  0x3C, 0x1C, 0x03, 0x03, 0x80, 0x60, 0x30, 0xE0, 0x6C, 0x18, 0xC3, 0x18,
  0xC1, 0x98, 0x36, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xE0, 0x6C, 0x0C, 0xC3,
  0x18, 0xC1, 0x98, 0x36, 0x03, 0xC0, 0x6C, 0x19, 0x83, 0x18, 0x63, 0x18,
  0x63, 0x06, 0xC0, 0xD8, 0x0E, 0x01, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0xFF, 0xFF, 0xC0, 0xE0, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xF0, 0xC0, 0x60,
  0x60, 0x60, 0x30, 0x30, 0x10, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06,
  0x02, 0x03, 0xFF, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xFF,
  0x08, 0x07, 0x01, 0xC0, 0x58, 0x32, 0x08, 0xC6, 0x11, 0x06, 0xC0, 0xA0,
  0x30, 0xFF, 0xC0, 0xC6, 0x31, 0x3E, 0x3F, 0x80, 0xC0, 0x30, 0x19, 0xFD,
  0xC7, 0x83, 0xC1, 0xE1, 0xF9, 0xEF, 0xB0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0xF3, 0xFD, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0xEE, 0x9E, 0x00, 0x1F, 0x7F, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x60, 0x73, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCF, 0x37, 0xFD,
  0x87, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x36, 0x1D, 0xCF, 0x3E,
  0xC0, 0x1E, 0x3F, 0x98, 0x78, 0x3C, 0x1F, 0xFF, 0x01, 0x80, 0xC0, 0x30,
  0x1C, 0x67, 0xF0, 0x0F, 0x1E, 0x30, 0x30, 0x30, 0x7E, 0xFE, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3C, 0xDF, 0xF6, 0x1F,
  0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8, 0x77, 0x3C, 0xFB, 0x00,
  0xC0, 0x30, 0x19, 0x8E, 0x7F, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0xF3, 0xFD, 0x86, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0x18, 0xC0, 0x01, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0x6F, 0x00, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x1B, 0x19, 0x98, 0xD8, 0x6C, 0x2C, 0x1F, 0x0C, 0xC6, 0x63,
  0x19, 0x8E, 0xC3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x9E, 0x79, 0x7F,
  0xFB, 0x0E, 0x1E, 0x18, 0x3C, 0x30, 0x78, 0x60, 0xF0, 0xC1, 0xE1, 0x83,
  0xC3, 0x07, 0x86, 0x0F, 0x0C, 0x1E, 0x18, 0x30, 0x9E, 0x5F, 0xB0, 0xD8,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x1E, 0x1F,
  0xE6, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8, 0x67, 0x38,
  0xFC, 0x9E, 0x5F, 0xB0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xED, 0xDB, 0xCC, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x3C, 0xDF, 0xF6,
  0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8, 0x77, 0x3C, 0xFB,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x9E, 0xFE, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0x3E, 0xFE, 0xC0, 0xC0, 0xE0, 0x78, 0x1E, 0x06,
  0x03, 0x02, 0xCE, 0xFC, 0x10, 0x60, 0xC3, 0xFF, 0xE6, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x07, 0x47, 0x80, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF9, 0xEF, 0xB0, 0xC0, 0xF0, 0x36, 0x19,
  0x86, 0x61, 0x8C, 0xC3, 0x30, 0xCC, 0x1E, 0x07, 0x81, 0xE0, 0x30, 0xC1,
  0x83, 0x41, 0x86, 0x63, 0xC6, 0x63, 0xC6, 0x62, 0xC4, 0x26, 0x4C, 0x36,
  0x6C, 0x36, 0x6C, 0x34, 0x68, 0x1C, 0x28, 0x1C, 0x38, 0x18, 0x38, 0x60,
  0xD8, 0x63, 0x30, 0x6C, 0x1E, 0x03, 0x80, 0xE0, 0x78, 0x1B, 0x0C, 0xC6,
  0x1B, 0x83, 0xC0, 0xD0, 0x36, 0x19, 0x86, 0x21, 0x8C, 0xC3, 0x30, 0x4C,
  0x1A, 0x07, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0xE0, 0xF0, 0x00,
  0xFF, 0xFC, 0x18, 0x61, 0x83, 0x0C, 0x18, 0x61, 0x83, 0xFF, 0xF0, 0x04,
  0x73, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0x8E, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xE1, 0xC1, 0xFF, 0xFF, 0xFC, 0xC3, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0x71, 0xCC, 0x30, 0xC3, 0x0C, 0x31, 0xCE, 0x20, 0xF8, 0x77, 0xF8, 0x30,
};

const GFXglyph NotoSans_SemiCondensed_Regular22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 16, 6, 2, -16 },
  { 5, 6, 6, 9, 1, -16 },
  { 10, 12, 16, 13, 0, -16 },
  { 34, 9, 18, 11, 1, -17 },
  { 55, 15, 16, 17, 1, -16 },
  { 85, 13, 16, 14, 1, -16 },
  { 111, 2, 6, 5, 1, -16 },
  { 113, 5, 19, 7, 1, -16 },
  { 125, 5, 19, 7, 1, -16 },
  { 137, 9, 9, 11, 1, -17 },
  { 148, 9, 10, 11, 1, -13 },
  { 160, 3, 6, 6, 1, -3 },
  { 163, 5, 2, 7, 1, -7 },
  { 165, 3, 3, 6, 1, -3 },
  { 167, 8, 16, 8, 0, -16 },
  { 183, 9, 16, 11, 1, -16 },
  { 201, 5, 16, 11, 2, -16 },
  { 211, 9, 16, 11, 1, -16 },
  { 229, 9, 16, 11, 1, -16 },
  { 247, 11, 16, 11, 0, -16 },
  { 269, 9, 16, 11, 1, -16 },
  { 287, 9, 16, 11, 1, -16 },
  { 305, 9, 16, 11, 1, -16 },
  { 323, 9, 16, 11, 1, -16 },
  { 341, 9, 16, 11, 1, -16 },
  { 359, 3, 12, 6, 1, -12 },
  { 364, 3, 15, 6, 1, -12 },
  { 370, 10, 10, 11, 1, -13 },
  { 383, 9, 6, 11, 1, -11 },
  { 390, 10, 10, 11, 1, -13 },
  { 403, 8, 16, 9, 0, -16 },
  { 419, 16, 18, 18, 1, -16 },
  { 455, 13, 16, 13, 0, -16 },
  { 481, 10, 16, 13, 2, -16 },
  { 501, 11, 16, 12, 1, -16 },
  { 523, 11, 16, 14, 2, -16 },
  { 545, 8, 16, 11, 2, -16 },
  { 561, 8, 16, 10, 2, -16 },
  { 577, 12, 16, 15, 1, -16 },
  { 601, 11, 16, 15, 2, -16 },
  { 623, 5, 16, 7, 1, -16 },
  { 633, 5, 20, 6, -1, -16 },
  { 646, 10, 16, 12, 2, -16 },
  { 666, 8, 16, 10, 2, -16 },
  { 682, 15, 16, 18, 2, -16 },
  { 712, 11, 16, 15, 2, -16 },
  { 734, 13, 16, 15, 1, -16 },
  { 760, 9, 16, 12, 2, -16 },
  { 778, 13, 20, 15, 1, -16 },
  { 811, 10, 16, 12, 2, -16 },
  { 831, 9, 16, 11, 1, -16 },
  { 849, 11, 16, 11, 0, -16 },
  { 871, 11, 16, 14, 2, -16 },
  { 893, 12, 16, 12, 0, -16 },
  { 917, 19, 16, 19, 0, -16 },
  { 955, 11, 16, 11, 0, -16 },
  { 977, 11, 16, 11, 0, -16 },
  { 999, 9, 16, 11, 1, -16 },
  { 1017, 5, 20, 7, 2, -16 },
  { 1030, 8, 16, 8, 0, -16 },
  { 1046, 4, 20, 7, 1, -16 },
  { 1056, 10, 10, 12, 1, -16 },
  { 1069, 10, 1, 10, 0, 2 },
  { 1071, 4, 4, 6, 1, -17 },
  { 1073, 9, 12, 11, 1, -12 },
  { 1087, 9, 17, 12, 2, -17 },
  { 1107, 8, 12, 9, 1, -12 },
  { 1119, 10, 17, 12, 1, -17 },
  { 1141, 9, 12, 11, 1, -12 },
  { 1155, 8, 17, 7, 0, -17 },
  { 1172, 10, 17, 12, 1, -12 },
  { 1194, 9, 17, 12, 2, -17 },
  { 1214, 2, 16, 5, 2, -16 },
  { 1218, 5, 21, 5, -1, -16 },
  { 1232, 9, 17, 11, 2, -17 },
  { 1252, 2, 17, 5, 2, -17 },
  { 1257, 15, 12, 19, 2, -12 },
  { 1280, 9, 12, 12, 2, -12 },
  { 1294, 10, 12, 12, 1, -12 },
  { 1309, 9, 17, 12, 2, -12 },
  { 1329, 10, 17, 12, 1, -12 },
  { 1351, 6, 12, 8, 2, -12 },
  { 1360, 8, 12, 9, 1, -12 },
  { 1372, 7, 15, 7, 0, -15 },
  { 1386, 9, 12, 12, 2, -12 },
  { 1400, 10, 12, 10, 0, -12 },
  { 1415, 16, 12, 16, 0, -12 },
  { 1439, 10, 12, 10, 0, -12 },
  { 1454, 10, 17, 10, 0, -12 },
  { 1476, 7, 12, 9, 1, -12 },
  { 1487, 6, 20, 8, 1, -16 },
  { 1502, 1, 22, 11, 5, -17 },
  { 1505, 6, 20, 8, 1, -16 },
  { 1520, 10, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_Regular22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR22PT7B_H_
