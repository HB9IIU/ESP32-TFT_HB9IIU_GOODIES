#ifndef _NOTOSANS_SEMICONDENSED_REGULAR53PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xC7, 0x00, 0x00, 0x00,
  0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xE3, 0x00, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFB, 0xC1, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xE0, 0x73, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x80, 0x00, 0x3C,
  0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x38, 0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x0E, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x1E,
  0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x0F, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x78,
  0x0E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0x73, 0xF1,
  0xF1, 0xC0, 0xCF, 0x87, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0xC1,
  0xC0, 0x0F, 0x07, 0x00, 0x3E, 0x1C, 0x00, 0xFC, 0x70, 0x01, 0xFD, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x71, 0xF8, 0x01, 0xC3, 0xE0, 0x07,
  0x07, 0xC0, 0x1C, 0x1F, 0x00, 0x70, 0x3C, 0x01, 0xC1, 0xF0, 0x07, 0x07,
  0xE0, 0x1C, 0x3E, 0xE0, 0x71, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x78, 0x01, 0xFF, 0x00, 0x07, 0x80, 0x3F, 0xF8, 0x00, 0xF0, 0x03,
  0xC7, 0x80, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x07, 0x83, 0xC0, 0x1E,
  0x00, 0x78, 0x1C, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x1E,
  0x07, 0x80, 0x0F, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x1E, 0x07, 0x00, 0x0F,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x1E, 0x0E, 0x00, 0x0F, 0x01, 0xE1, 0xE0,
  0x00, 0x70, 0x1E, 0x1E, 0x00, 0x07, 0x01, 0xE3, 0xC3, 0xF0, 0x78, 0x1C,
  0x3C, 0x7F, 0x87, 0x83, 0xC7, 0x8F, 0xFC, 0x78, 0x3C, 0x79, 0xF3, 0xE3,
  0xC7, 0x8F, 0x1E, 0x1E, 0x3F, 0xF8, 0xF1, 0xC0, 0xF1, 0xFF, 0x1E, 0x3C,
  0x0F, 0x0F, 0xE1, 0xE3, 0xC0, 0xF0, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x03,
  0xC3, 0xC0, 0x70, 0x00, 0x78, 0x3C, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x70,
  0x00, 0xF0, 0x3C, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x3C,
  0x0F, 0x00, 0x1E, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x3C,
  0x01, 0xC0, 0xF0, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x1E, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x7C, 0x1F, 0xDF, 0x00, 0x7C, 0x1F, 0x1F, 0x80, 0x78, 0x3E, 0x0F,
  0xC0, 0xF8, 0x7C, 0x07, 0xE0, 0xF8, 0x7C, 0x03, 0xF0, 0xF0, 0x78, 0x01,
  0xF9, 0xF0, 0xF8, 0x00, 0xFD, 0xF0, 0xF8, 0x00, 0x7F, 0xE0, 0xF8, 0x00,
  0x3F, 0xE0, 0xF8, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF9, 0xF8, 0x1F, 0xFF, 0xF0, 0xFC, 0x0F, 0xFF, 0xE0, 0x7C, 0x03, 0xFF,
  0x80, 0x7F, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0x38, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF8,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F,
  0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0,
  0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x3E,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x04, 0x07, 0x80, 0x9E,
  0x1E, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xE0,
  0x07, 0x87, 0x80, 0x3E, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xC0, 0xF0, 0x03,
  0x01, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78,
  0x70, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xE3, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0xF8, 0x00, 0x79, 0xF0, 0x00,
  0xF3, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F,
  0xBC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBC,
  0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xE0,
  0x01, 0xE7, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0xF8, 0x3F, 0x03, 0xE0, 0x3F, 0xBF, 0xC0, 0x3F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7C,
  0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x7F, 0xF3, 0xF7, 0xDF, 0x9F,
  0xFC, 0x7D, 0xE1, 0xF2, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xE0, 0x3F, 0x07, 0x00, 0x1F, 0x04, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xC0, 0x1F, 0x86, 0x00, 0x1F,
  0x08, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x80, 0x00, 0xFD, 0xC0, 0x03, 0xF3, 0xFC, 0xFF, 0xC7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0xCF, 0x80,
  0x01, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x0F,
  0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x3E, 0x00, 0xF8,
  0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x03,
  0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x80, 0x01, 0xF3, 0x80,
  0x1F, 0xCF, 0xE3, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x01, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x3C, 0x7F, 0xE0,
  0xF3, 0xFF, 0xE3, 0xDF, 0xFF, 0xCF, 0x78, 0x3F, 0x3F, 0x80, 0x3E, 0xFC,
  0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7D,
  0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0xFC,
  0x07, 0xC1, 0xFC, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x8F,
  0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x78, 0xF0,
  0x01, 0xF1, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0xE0,
  0x7C, 0x07, 0xF3, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0xFE, 0xFE, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x1F, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xBC,
  0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xFC, 0x01, 0xF8, 0xFF, 0x0F, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xF0,
  0x1F, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x78, 0x00,
  0x7C, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x7C, 0x00, 0x7E,
  0xF8, 0x00, 0xFC, 0xF8, 0x03, 0xF9, 0xF8, 0x1F, 0xF1, 0xFF, 0xFB, 0xE1,
  0xFF, 0xF7, 0xC1, 0xFF, 0x8F, 0x00, 0xFC, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xC0, 0x61, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x73, 0xEF, 0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF,
  0xFF, 0xF8, 0xC0, 0x1C, 0x3E, 0x3F, 0x7F, 0x3F, 0x3E, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78,
  0xF0, 0xF0, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x70, 0x0F, 0xD0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x0E, 0x00, 0x38,
  0x78, 0x03, 0xFF, 0xC1, 0xE3, 0xC0, 0x7F, 0xFE, 0x0F, 0x3C, 0x07, 0xFF,
  0xF0, 0x39, 0xE0, 0x3C, 0x07, 0x01, 0xEF, 0x03, 0xC0, 0x38, 0x0F, 0xF0,
  0x1E, 0x03, 0xC0, 0x7F, 0x81, 0xE0, 0x1E, 0x03, 0xFC, 0x0F, 0x00, 0xF0,
  0x1F, 0xE0, 0x78, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x3C, 0x07, 0xF8, 0x1E,
  0x01, 0xE0, 0x3F, 0xC0, 0xE0, 0x0F, 0x01, 0xFE, 0x07, 0x80, 0x78, 0x0F,
  0xF0, 0x3C, 0x03, 0xC0, 0x77, 0x81, 0xE0, 0x3E, 0x07, 0xBC, 0x0F, 0x01,
  0xF0, 0x3D, 0xE0, 0x7C, 0x1D, 0xC3, 0xCF, 0x01, 0xF1, 0xEE, 0x3E, 0x38,
  0x0F, 0xFE, 0x7F, 0xE1, 0xE0, 0x3F, 0xE1, 0xFE, 0x0F, 0x00, 0x7E, 0x07,
  0xE0, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x08, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xF0, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0xF0, 0x07, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7C,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8,
  0xF0, 0x01, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7E,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x7E, 0xF0, 0x00, 0xFC, 0xF0, 0x01, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x00,
  0x70, 0x7E, 0x00, 0x08, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x01, 0x81, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x0F, 0x00, 0xFF, 0xC1, 0xE0, 0x01, 0xFC, 0x3C, 0x00, 0x1F, 0x87, 0x80,
  0x01, 0xF8, 0xF0, 0x00, 0x1F, 0x9E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E,
  0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBC, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3F, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0xC7, 0x80, 0x03, 0xF0, 0xF0,
  0x00, 0xFE, 0x1E, 0x00, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBC, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x07, 0xF8, 0x01, 0xE0, 0xFE, 0x00, 0x04, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0xF1, 0xF8,
  0x00, 0x0F, 0x0F, 0xC0, 0x00, 0xF0, 0xFF, 0x00, 0x0F, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xA0, 0x00, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7D, 0x07, 0xEF, 0xFF, 0x7F, 0xF3,
  0xFF, 0x0F, 0xE0, 0xF0, 0x00, 0x3F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x1F,
  0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x87, 0x80, 0x0F, 0x83, 0xC0, 0x0F,
  0x81, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0xC0, 0x78, 0x07, 0xC0, 0x3C, 0x07,
  0xC0, 0x1E, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC3,
  0xE0, 0x01, 0xE3, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0x7B, 0xF8, 0x00, 0x3D,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xEF, 0x80, 0x07, 0xE3, 0xE0, 0x03,
  0xE1, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x0F, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF8, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x1F,
  0x03, 0xC0, 0x0F, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x78, 0x00,
  0x7E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xF7, 0x80,
  0x00, 0xFC, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xBC, 0x00, 0x03, 0xFF, 0xF7, 0x80, 0x00, 0x7B,
  0xFE, 0xF8, 0x00, 0x0F, 0x7F, 0xCF, 0x00, 0x03, 0xEF, 0xF9, 0xE0, 0x00,
  0x79, 0xFF, 0x3E, 0x00, 0x0F, 0x3F, 0xE3, 0xC0, 0x03, 0xE7, 0xFC, 0x78,
  0x00, 0x78, 0xFF, 0x8F, 0x80, 0x0F, 0x1F, 0xF0, 0xF0, 0x03, 0xC3, 0xFE,
  0x1E, 0x00, 0x78, 0x7F, 0xC3, 0xE0, 0x0F, 0x0F, 0xF8, 0x3C, 0x03, 0xC1,
  0xFF, 0x07, 0x80, 0x78, 0x3F, 0xE0, 0xF8, 0x0F, 0x07, 0xFC, 0x0F, 0x03,
  0xC0, 0xFF, 0x81, 0xE0, 0x78, 0x1F, 0xF0, 0x3E, 0x0F, 0x03, 0xFE, 0x03,
  0xC3, 0xC0, 0x7F, 0xC0, 0x78, 0x78, 0x0F, 0xF8, 0x0F, 0x8F, 0x01, 0xFF,
  0x00, 0xF3, 0xC0, 0x3F, 0xE0, 0x1F, 0x78, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x0F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0x00, 0x3F, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF7,
  0xC0, 0x01, 0xFE, 0xF8, 0x00, 0x3F, 0xCF, 0x80, 0x07, 0xF9, 0xF8, 0x00,
  0xFF, 0x1F, 0x00, 0x1F, 0xE1, 0xF0, 0x03, 0xFC, 0x3E, 0x00, 0x7F, 0x83,
  0xE0, 0x0F, 0xF0, 0x7C, 0x01, 0xFE, 0x07, 0xC0, 0x3F, 0xC0, 0xFC, 0x07,
  0xF8, 0x0F, 0x80, 0xFF, 0x00, 0xF8, 0x1F, 0xE0, 0x1F, 0x03, 0xFC, 0x01,
  0xF0, 0x7F, 0x80, 0x3E, 0x0F, 0xF0, 0x03, 0xE1, 0xFE, 0x00, 0x7E, 0x3F,
  0xC0, 0x07, 0xC7, 0xF8, 0x00, 0xFC, 0xFF, 0x00, 0x0F, 0x9F, 0xE0, 0x00,
  0xFB, 0xFC, 0x00, 0x1F, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0xF0, 0x1F, 0xF3, 0xC0, 0x0F, 0xCF, 0x00, 0x1F, 0xBC, 0x00, 0x3E, 0xF0,
  0x00, 0xFB, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0xF0, 0x01, 0xFB,
  0xC0, 0x0F, 0xCF, 0x00, 0x7F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x5F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xF0, 0x1F, 0xF0, 0xF0, 0x03, 0xF8, 0xF0, 0x01, 0xF8, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00,
  0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x07,
  0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x01,
  0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x7E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x00, 0x70, 0xF8, 0x00, 0x47,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0xFB, 0xC0, 0x0F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF8,
  0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xC1, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x60,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8,
  0x07, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0xC0,
  0x7C, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xE3, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x77, 0x00, 0x0F, 0x87, 0xC0,
  0x07, 0xBC, 0x00, 0x7C, 0x1E, 0x00, 0x3D, 0xE0, 0x03, 0xE0, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0x07, 0xC0, 0x1F, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF1,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0x8F, 0x00, 0x7C, 0x07, 0x80, 0x3C, 0x78,
  0x03, 0xC0, 0x3E, 0x03, 0xE3, 0xE0, 0x1E, 0x01, 0xF0, 0x1E, 0x0F, 0x01,
  0xF0, 0x0F, 0x80, 0xF0, 0x78, 0x0F, 0x80, 0x3C, 0x07, 0x83, 0xC0, 0x78,
  0x01, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0x0F, 0x83, 0xC0, 0x78, 0x3E, 0x00,
  0x7C, 0x1E, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0x0F,
  0x8F, 0x80, 0xF8, 0x78, 0x00, 0x7C, 0x78, 0x03, 0xC7, 0xC0, 0x03, 0xE3,
  0xC0, 0x1E, 0x3E, 0x00, 0x0F, 0x1E, 0x00, 0xF1, 0xF0, 0x00, 0x79, 0xF0,
  0x07, 0xCF, 0x00, 0x03, 0xEF, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x78, 0x00,
  0xF7, 0xC0, 0x00, 0x7B, 0xC0, 0x07, 0xBE, 0x00, 0x03, 0xDE, 0x00, 0x1D,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x3E, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x7C, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83, 0xE0,
  0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1,
  0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x1F, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xEF, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xE7, 0x80, 0x03, 0xC7, 0x80,
  0x03, 0xC3, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x0F, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xE0, 0x3F, 0x04, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x0F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFC, 0x1F, 0x7E, 0x00,
  0xFB, 0xE0, 0x07, 0xDE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0x7C, 0x03, 0xFB, 0xF0, 0x7B,
  0xCF, 0xFF, 0x9E, 0x3F, 0xF8, 0xF0, 0xFF, 0x83, 0x80, 0x40, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x0F, 0x9F, 0xFC,
  0x1F, 0x7F, 0xFC, 0x3D, 0xFF, 0xFC, 0x7F, 0xC1, 0xFC, 0xFE, 0x00, 0xF9,
  0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0xFC, 0x00, 0x7D, 0xF8, 0x00,
  0xFB, 0xF8, 0x03, 0xE7, 0xF8, 0x0F, 0xCF, 0x7C, 0x7F, 0x1E, 0xFF, 0xFE,
  0x3C, 0xFF, 0xF8, 0x78, 0x7F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x81, 0x8F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x4F, 0xFB, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x03, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x0F, 0xC1, 0xF0, 0x7F, 0xE3, 0xE1, 0xFF, 0xF7, 0xC7, 0xFF, 0xEF,
  0x9F, 0x81, 0xFF, 0x7E, 0x00, 0xFE, 0xF8, 0x01, 0xFD, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xF9, 0xF0, 0x0F,
  0xF3, 0xF8, 0x7F, 0xE3, 0xFF, 0xF7, 0xC3, 0xFF, 0xC7, 0x81, 0xFF, 0x0F,
  0x00, 0x20, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x07, 0xC7, 0xC0, 0x0F, 0x1E, 0x00,
  0x3E, 0x78, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x10,
  0x7F, 0x8F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7E,
  0x30, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x3C,
  0x3F, 0xFC, 0x78, 0xFF, 0xFD, 0xF3, 0xF0, 0x3F, 0xE7, 0xC0, 0x3F, 0xDF,
  0x00, 0x3F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xDF, 0x00, 0x1F,
  0xBE, 0x00, 0x7F, 0x3E, 0x01, 0xFE, 0x7F, 0x0F, 0xFC, 0x7F, 0xFE, 0xF8,
  0x7F, 0xF9, 0xF0, 0x3F, 0xE3, 0xE0, 0x04, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE2, 0x00, 0x1F, 0x87, 0xC0, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0xC0, 0xF9, 0xFF, 0xC3, 0xEF, 0xFF, 0x8F, 0x7F, 0xFF,
  0x3F, 0xE0, 0xFE, 0xFE, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x07, 0xBE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x77, 0xFF, 0xFF,
  0xB8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xC0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x81, 0xF4, 0x7E, 0xFF, 0xDF, 0xF3, 0xFC, 0x3C, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x7C, 0x01, 0xF3, 0xE0,
  0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x81,
  0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x03, 0xE7, 0x80, 0x1E, 0x7C,
  0x00, 0xF7, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFD, 0xF0, 0x0F,
  0xC7, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x87, 0xC0, 0x7C, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x7C,
  0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x7E,
  0x07, 0x8F, 0xFC, 0x0F, 0xFC, 0x3C, 0xFF, 0xF8, 0xFF, 0xF9, 0xEF, 0xFF,
  0xCF, 0xFF, 0xCF, 0xF0, 0x3F, 0xF0, 0x3F, 0x7F, 0x00, 0xFF, 0x00, 0xFB,
  0xF0, 0x07, 0xF0, 0x07, 0xDF, 0x80, 0x1F, 0x80, 0x1F, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0xF0,
  0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x7C, 0x00,
  0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3F,
  0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x7C,
  0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00,
  0x3F, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x00,
  0x3F, 0x03, 0xC7, 0xFF, 0x0F, 0x3F, 0xFE, 0x3D, 0xFF, 0xFC, 0xFF, 0x83,
  0xFB, 0xF8, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x1E, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x87, 0xC0, 0x1F,
  0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x00, 0x07, 0x9F, 0x00,
  0x1F, 0x1F, 0x00, 0x7E, 0x3F, 0x01, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F,
  0x01, 0xE3, 0xFF, 0x83, 0xCF, 0xFF, 0x87, 0xBF, 0xFF, 0x8F, 0xF8, 0x3F,
  0x9F, 0xC0, 0x1F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xDF, 0x80,
  0x0F, 0xBF, 0x00, 0x1F, 0x7F, 0x00, 0x7C, 0xFF, 0x01, 0xF9, 0xEF, 0x8F,
  0xE3, 0xCF, 0xFF, 0xC7, 0xCF, 0xFF, 0x0F, 0x8F, 0xF8, 0x1F, 0x03, 0x80,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xFC, 0x3C, 0x3F, 0xFC, 0x78, 0xFF, 0xFD, 0xF3, 0xF0,
  0x3F, 0xEF, 0xC0, 0x1F, 0xDF, 0x00, 0x3F, 0xBE, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x7F, 0x3E, 0x01, 0xFE, 0x7F,
  0x0F, 0xFC, 0x7F, 0xFE, 0xF8, 0x7F, 0xF9, 0xF0, 0x3F, 0xE3, 0xE0, 0x08,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x7E, 0x7E, 0xE0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC7, 0xE0, 0x38, 0xF0, 0x01, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF4, 0x00, 0x1E, 0xC0, 0x07, 0xDF, 0x87, 0xF3, 0xFF, 0xFE, 0x7F,
  0xFF, 0x83, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE1, 0x07, 0xFE, 0x0F, 0xFC, 0x0F,
  0xF8, 0x01, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xDF, 0x00, 0xFF, 0x7F, 0x9F, 0xFC,
  0xFF, 0xFD, 0xF1, 0xFF, 0xE3, 0xC3, 0xFF, 0x0F, 0x00, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3C,
  0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x1F,
  0x00, 0x78, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x81, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0xC3, 0xE0, 0x03,
  0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xE3, 0xC0, 0x01, 0xE7, 0xC0, 0x01,
  0xE7, 0x80, 0x01, 0xF7, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF0,
  0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xBE, 0x00, 0x7E, 0x00,
  0x7C, 0xF0, 0x03, 0xF8, 0x03, 0xE7, 0x80, 0x3F, 0xC0, 0x1E, 0x3E, 0x01,
  0xFE, 0x00, 0xF1, 0xF0, 0x0F, 0x70, 0x0F, 0x87, 0x80, 0xF3, 0xC0, 0x7C,
  0x3C, 0x07, 0x9E, 0x03, 0xC1, 0xF0, 0x3C, 0xF0, 0x1E, 0x0F, 0x81, 0xE7,
  0xC1, 0xF0, 0x3C, 0x1E, 0x1E, 0x0F, 0x81, 0xE0, 0xF0, 0xF0, 0x78, 0x0F,
  0x07, 0x87, 0x83, 0xC0, 0x7C, 0x7C, 0x3E, 0x3E, 0x01, 0xE3, 0xC0, 0xF1,
  0xF0, 0x0F, 0x1E, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x3C, 0x78, 0x03, 0xEF,
  0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x07, 0xBC, 0x00, 0x7B, 0xC0, 0x3D, 0xE0,
  0x03, 0xDE, 0x01, 0xEF, 0x00, 0x1E, 0xE0, 0x07, 0x78, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0xF8, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0x80, 0x07,
  0xDF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xDF,
  0x00, 0x0F, 0x9E, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7C,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0xF8, 0xF8, 0x00, 0xF9,
  0xF0, 0x01, 0xF7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C,
  0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0xF8,
  0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0x81, 0xF0,
  0x07, 0xC1, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xE3, 0xC0,
  0x01, 0xE3, 0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xF7, 0x80, 0x00, 0xF7, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xF8, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0xFF, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xA0, 0x00, 0x78, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 39, 14, 4, -38 },
  { 31, 15, 14, 21, 3, -38 },
  { 58, 28, 38, 31, 1, -38 },
  { 191, 22, 43, 28, 3, -40 },
  { 310, 36, 39, 41, 2, -38 },
  { 486, 32, 39, 34, 2, -38 },
  { 642, 5, 14, 12, 3, -38 },
  { 651, 12, 46, 16, 2, -38 },
  { 720, 11, 46, 16, 2, -38 },
  { 784, 22, 21, 26, 2, -40 },
  { 842, 23, 25, 28, 2, -31 },
  { 914, 8, 13, 13, 2, -6 },
  { 927, 12, 4, 16, 2, -16 },
  { 933, 6, 7, 13, 4, -6 },
  { 939, 18, 38, 20, 1, -38 },
  { 1025, 23, 39, 28, 2, -38 },
  { 1138, 14, 38, 28, 4, -38 },
  { 1205, 23, 38, 28, 2, -38 },
  { 1315, 23, 39, 28, 2, -38 },
  { 1428, 26, 38, 28, 1, -38 },
  { 1552, 22, 39, 28, 3, -38 },
  { 1660, 22, 39, 28, 3, -38 },
  { 1768, 23, 38, 28, 2, -38 },
  { 1878, 23, 39, 28, 2, -38 },
  { 1991, 23, 39, 28, 2, -38 },
  { 2104, 6, 30, 13, 4, -29 },
  { 2127, 8, 36, 13, 2, -29 },
  { 2163, 23, 26, 28, 2, -32 },
  { 2238, 23, 15, 28, 2, -26 },
  { 2282, 23, 26, 28, 2, -32 },
  { 2357, 18, 39, 21, 1, -38 },
  { 2445, 37, 43, 43, 3, -38 },
  { 2644, 30, 38, 30, 0, -38 },
  { 2787, 24, 38, 31, 5, -38 },
  { 2901, 25, 39, 30, 3, -38 },
  { 3023, 27, 38, 35, 5, -38 },
  { 3152, 19, 38, 27, 5, -38 },
  { 3243, 19, 38, 25, 5, -38 },
  { 3334, 28, 39, 35, 3, -38 },
  { 3471, 26, 38, 35, 5, -38 },
  { 3595, 13, 38, 17, 2, -38 },
  { 3657, 13, 48, 14, -4, -38 },
  { 3735, 25, 38, 29, 5, -38 },
  { 3854, 19, 38, 25, 5, -38 },
  { 3945, 35, 38, 44, 5, -38 },
  { 4112, 27, 38, 37, 5, -38 },
  { 4241, 31, 39, 37, 3, -38 },
  { 4393, 22, 38, 29, 5, -38 },
  { 4498, 31, 47, 37, 3, -38 },
  { 4681, 24, 38, 30, 5, -38 },
  { 4795, 22, 39, 26, 2, -38 },
  { 4903, 25, 38, 26, 1, -38 },
  { 5022, 26, 39, 35, 4, -38 },
  { 5149, 29, 38, 29, 0, -38 },
  { 5287, 45, 38, 45, 0, -38 },
  { 5501, 27, 38, 27, 0, -38 },
  { 5630, 27, 38, 27, 0, -38 },
  { 5759, 23, 38, 26, 2, -38 },
  { 5869, 12, 46, 17, 4, -38 },
  { 5938, 18, 38, 20, 1, -38 },
  { 6024, 12, 46, 17, 1, -38 },
  { 6093, 24, 23, 28, 2, -38 },
  { 6162, 23, 3, 23, 0, 5 },
  { 6171, 11, 9, 15, 2, -41 },
  { 6184, 21, 30, 27, 2, -29 },
  { 6263, 23, 41, 30, 4, -40 },
  { 6381, 18, 30, 23, 3, -29 },
  { 6449, 23, 41, 30, 3, -40 },
  { 6567, 22, 30, 27, 3, -29 },
  { 6650, 17, 41, 16, 1, -41 },
  { 6738, 23, 42, 30, 3, -29 },
  { 6859, 22, 40, 30, 4, -40 },
  { 6969, 5, 39, 13, 4, -39 },
  { 6994, 11, 52, 13, -2, -39 },
  { 7066, 21, 40, 26, 4, -40 },
  { 7171, 5, 40, 13, 4, -40 },
  { 7196, 37, 29, 45, 4, -29 },
  { 7331, 22, 29, 30, 4, -29 },
  { 7411, 23, 30, 29, 3, -29 },
  { 7498, 23, 42, 30, 4, -29 },
  { 7619, 23, 42, 30, 3, -29 },
  { 7740, 15, 29, 20, 4, -29 },
  { 7795, 19, 30, 23, 2, -29 },
  { 7867, 15, 36, 17, 1, -35 },
  { 7935, 22, 29, 30, 4, -28 },
  { 8015, 24, 28, 24, 0, -28 },
  { 8099, 37, 28, 38, 1, -28 },
  { 8229, 23, 28, 25, 1, -28 },
  { 8310, 24, 41, 24, 0, -28 },
  { 8433, 18, 28, 22, 2, -28 },
  { 8496, 16, 46, 20, 2, -38 },
  { 8588, 4, 53, 26, 11, -40 },
  { 8615, 16, 46, 20, 2, -38 },
  { 8707, 23, 7, 28, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_Regular53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR53PT7B_H_
