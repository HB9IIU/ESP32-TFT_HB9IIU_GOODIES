#ifndef _NOTOSANS_SEMICONDENSED_REGULAR19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular19pt7bBitmaps[] PROGMEM = {
  0x00, 0xD9, 0x24, 0x92, 0x48, 0x0F, 0x80, 0xCE, 0x73, 0x9C, 0x80, 0x08,
  0x81, 0x10, 0x22, 0x04, 0xC7, 0xFE, 0xFF, 0xC4, 0x40, 0x88, 0x13, 0x1F,
  0xF8, 0xC8, 0x19, 0x02, 0x20, 0x44, 0x00, 0x10, 0x3D, 0x7E, 0xD0, 0xD0,
  0xD0, 0x70, 0x1E, 0x13, 0x13, 0x13, 0xD6, 0xFC, 0x10, 0x10, 0x70, 0x46,
  0x86, 0x26, 0x21, 0x13, 0x08, 0x90, 0x45, 0x82, 0x6B, 0xDA, 0xD2, 0x74,
  0x98, 0x24, 0xC2, 0x26, 0x11, 0x31, 0x09, 0x18, 0x38, 0x1C, 0x0F, 0xC1,
  0x98, 0x33, 0x06, 0x60, 0x78, 0x0E, 0x03, 0xC2, 0xCC, 0xD8, 0xDB, 0x0E,
  0x60, 0xCE, 0x7C, 0xF8, 0xC0, 0xFF, 0xC0, 0x32, 0x64, 0xCC, 0xCC, 0x88,
  0xCC, 0xC4, 0x62, 0x30, 0x8C, 0x46, 0x22, 0x33, 0x33, 0x33, 0x26, 0x64,
  0x80, 0x18, 0x10, 0xD6, 0xFF, 0x38, 0x6C, 0x66, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x7B, 0x40, 0xFF, 0xF8, 0x06, 0x08, 0x10,
  0x60, 0x83, 0x06, 0x08, 0x30, 0x40, 0x83, 0x04, 0x18, 0x00, 0x38, 0x7E,
  0x46, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0x66, 0x3C,
  0x08, 0xDF, 0x90, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x38, 0xFE, 0x86,
  0x02, 0x02, 0x02, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x60, 0xC0, 0xFF, 0x38,
  0xFE, 0x82, 0x03, 0x02, 0x06, 0x3C, 0x3E, 0x02, 0x03, 0x03, 0x03, 0x86,
  0xFC, 0x03, 0x01, 0xC0, 0x70, 0x3C, 0x0B, 0x04, 0xC3, 0x30, 0x8C, 0x63,
  0x30, 0xCF, 0xFC, 0x0C, 0x03, 0x00, 0xC0, 0x7E, 0x7E, 0x40, 0x40, 0x40,
  0xC0, 0xFE, 0x06, 0x03, 0x03, 0x03, 0x03, 0x86, 0xFC, 0x0E, 0x3E, 0x60,
  0x40, 0xC0, 0xC8, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0xFF,
  0xFF, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x30,
  0x60, 0x3C, 0x7E, 0xC3, 0xC3, 0xC2, 0x66, 0x3C, 0x7C, 0xC6, 0xC3, 0x83,
  0xC3, 0xC7, 0x7E, 0x38, 0x7E, 0xC6, 0xC3, 0x83, 0xC3, 0xC3, 0x67, 0x3B,
  0x03, 0x02, 0x06, 0x0C, 0x78, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0xDB, 0x40, 0x03, 0x0E, 0x38, 0x60, 0xC0, 0x70, 0x1C, 0x03, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x03, 0x0E, 0x70, 0xC0,
  0x80, 0x39, 0xF8, 0x18, 0x30, 0x60, 0x83, 0x0C, 0x30, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x00, 0xFF, 0x0C, 0x0C, 0xC0, 0x24, 0x7C, 0xE6, 0x67,
  0x23, 0x31, 0x11, 0x98, 0x8C, 0x44, 0x73, 0x57, 0x8E, 0xE4, 0x00, 0x30,
  0x00, 0xFF, 0x00, 0xE0, 0x04, 0x01, 0xC0, 0x38, 0x05, 0x01, 0xB0, 0x26,
  0x04, 0x41, 0x8C, 0x3F, 0x87, 0xF1, 0x83, 0x30, 0x64, 0x05, 0x80, 0xC0,
  0xF0, 0xFE, 0x83, 0x83, 0x83, 0x82, 0xFC, 0xFE, 0x83, 0x83, 0x83, 0x83,
  0x87, 0xFC, 0x0F, 0x1F, 0xDC, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x10, 0x0C, 0x03, 0x88, 0xFC, 0xF0, 0x7F, 0x20, 0xD0, 0x38, 0x1C,
  0x0E, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x68, 0xE7, 0xE0, 0xFF, 0xF8,
  0x20, 0x82, 0x0F, 0xFF, 0x82, 0x08, 0x20, 0x83, 0xF0, 0xFF, 0xF8, 0x20,
  0x82, 0x08, 0x3F, 0x82, 0x08, 0x20, 0x82, 0x00, 0x0F, 0x8F, 0xF7, 0x05,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xC0, 0x70, 0x14, 0x05, 0x81, 0x38,
  0xC7, 0xF0, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0xFF, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x6F, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13, 0xFC, 0x83, 0x41,
  0xA1, 0x91, 0x89, 0x84, 0x82, 0xC1, 0xE0, 0xD8, 0x46, 0x23, 0x10, 0xC8,
  0x34, 0x1C, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFF,
  0xF0, 0xC0, 0x3C, 0x07, 0xE0, 0x7A, 0x05, 0xA0, 0xDB, 0x0D, 0x90, 0x99,
  0x99, 0x99, 0x98, 0x91, 0x8F, 0x18, 0xE1, 0x86, 0x18, 0x61, 0xC0, 0xE0,
  0x78, 0x34, 0x1B, 0x0C, 0x86, 0x63, 0x19, 0x8C, 0xC3, 0x61, 0xB0, 0x78,
  0x1C, 0x0C, 0x0F, 0x07, 0xF1, 0x83, 0x30, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0D, 0x01, 0xB0, 0x63, 0x1C, 0x3E, 0x00, 0xF0, 0xFC,
  0x86, 0x82, 0x83, 0x82, 0x86, 0xFC, 0xF8, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x0F, 0x07, 0xF1, 0x83, 0x30, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0D, 0x01, 0xB0, 0x63, 0x1C, 0x3E, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0xF0, 0xFE, 0x86, 0x82, 0x83, 0x82, 0x86, 0xFC, 0x88, 0x8C, 0x84, 0x86,
  0x83, 0x83, 0x3C, 0x7E, 0xC0, 0xC0, 0xC0, 0xE0, 0x70, 0x1C, 0x06, 0x03,
  0x03, 0x02, 0xC6, 0xFC, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x3E, 0x33, 0xF0,
  0xC0, 0x70, 0x34, 0x0D, 0x82, 0x61, 0x88, 0x63, 0x10, 0xCC, 0x13, 0x04,
  0x81, 0xA0, 0x78, 0x0C, 0x03, 0x00, 0xC1, 0x83, 0xC1, 0x83, 0x41, 0x83,
  0x63, 0xC2, 0x63, 0xC6, 0x62, 0x46, 0x22, 0x46, 0x36, 0x64, 0x36, 0x6C,
  0x34, 0x2C, 0x14, 0x2C, 0x14, 0x38, 0x1C, 0x18, 0x18, 0x18, 0xC0, 0xD8,
  0x62, 0x10, 0xCC, 0x12, 0x07, 0x80, 0xC0, 0x30, 0x1E, 0x04, 0x83, 0x31,
  0x84, 0x61, 0xB0, 0x30, 0xC0, 0xD0, 0x66, 0x19, 0x8C, 0x33, 0x0D, 0x81,
  0xE0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF,
  0x06, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x60, 0x60, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xF8, 0xC0,
  0x81, 0x83, 0x02, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x60, 0x40, 0xC0,
  0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x10, 0x18, 0x38,
  0x2C, 0x64, 0x46, 0xC2, 0x83, 0xFF, 0xD9, 0x80, 0x7C, 0x8C, 0x08, 0x17,
  0xF8, 0x70, 0xC3, 0xCE, 0xF4, 0xC0, 0x60, 0x30, 0x18, 0x0D, 0xE7, 0x1B,
  0x05, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x2E, 0x36, 0xF0, 0x3E, 0xC3, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0x62, 0x7C, 0x01, 0x01, 0x01, 0x01, 0x7D, 0x63,
  0xC3, 0xC3, 0xC1, 0xC1, 0xC3, 0xC3, 0x67, 0x3D, 0x3C, 0x66, 0xC3, 0xC3,
  0xFF, 0xC0, 0xC0, 0xC0, 0x62, 0x3E, 0x0A, 0x78, 0xC1, 0x02, 0x1F, 0x88,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x00, 0x7D, 0x63, 0xC3, 0xC3,
  0xC1, 0xC1, 0xC3, 0xC3, 0x67, 0x3D, 0x01, 0x03, 0x83, 0x7E, 0x18, 0xC0,
  0xC0, 0xC0, 0xC0, 0xDE, 0xE3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xF0, 0xFF, 0xFF, 0xF0, 0x33, 0x00, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x3F, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC7, 0xC4, 0xCC, 0xD8, 0xF8,
  0xF8, 0xCC, 0xC4, 0xC6, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xDE, 0xFB, 0x8E,
  0x6C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3,
  0x0F, 0x0C, 0x30, 0xDE, 0xE3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0x3E, 0x63, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0x67, 0x3E, 0xDE,
  0x71, 0xB0, 0x58, 0x3C, 0x1E, 0x0F, 0x07, 0x82, 0xE3, 0x6F, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x7D, 0x63, 0xC3, 0xC3, 0xC1, 0xC1, 0xC3, 0xC3,
  0x67, 0x3D, 0x01, 0x01, 0x01, 0x01, 0x01, 0xDF, 0xCE, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x00, 0x7F, 0x18, 0x30, 0x70, 0x70, 0xC1, 0x8F, 0xE0, 0x20,
  0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x3C, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC3, 0xC3, 0x67, 0x7D, 0xC1, 0xA1, 0x98, 0xCC, 0x42,
  0x61, 0xB0, 0xD0, 0x28, 0x1C, 0x0C, 0x00, 0xC3, 0x0A, 0x38, 0xD1, 0xC6,
  0xCB, 0x36, 0x49, 0x16, 0x58, 0xB3, 0xC7, 0x1E, 0x38, 0x60, 0xC3, 0x00,
  0xE3, 0x91, 0x0D, 0x82, 0x81, 0xC0, 0xE0, 0xD0, 0x6C, 0x63, 0x60, 0xC0,
  0xC1, 0xA1, 0x98, 0xCC, 0x42, 0x21, 0xB0, 0xD0, 0x28, 0x1C, 0x0C, 0x06,
  0x03, 0x01, 0x07, 0x81, 0x00, 0xFC, 0x31, 0x86, 0x30, 0x86, 0x30, 0xC3,
  0xF0, 0x09, 0xCC, 0x42, 0x10, 0x8C, 0xC3, 0x08, 0x42, 0x10, 0x86, 0x18,
  0xFF, 0xFF, 0xE0, 0x87, 0x18, 0x42, 0x10, 0x86, 0x19, 0x88, 0x42, 0x10,
  0x8C, 0xC0, 0xF1, 0xBF, 0x84,
};

const GFXglyph NotoSans_SemiCondensed_Regular19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 5, 5, 8, 1, -14 },
  { 11, 11, 14, 11, 0, -14 },
  { 31, 8, 15, 10, 1, -14 },
  { 46, 13, 14, 15, 1, -14 },
  { 69, 11, 14, 12, 1, -14 },
  { 89, 2, 5, 4, 1, -14 },
  { 91, 4, 17, 6, 1, -14 },
  { 100, 4, 17, 6, 1, -14 },
  { 109, 8, 7, 9, 1, -14 },
  { 116, 8, 9, 10, 1, -11 },
  { 125, 3, 4, 5, 1, -2 },
  { 127, 4, 2, 6, 1, -6 },
  { 128, 3, 2, 5, 1, -2 },
  { 129, 7, 14, 7, 0, -14 },
  { 142, 8, 14, 10, 1, -14 },
  { 156, 5, 14, 10, 1, -14 },
  { 165, 8, 14, 10, 1, -14 },
  { 179, 8, 14, 10, 1, -14 },
  { 193, 10, 14, 10, 0, -14 },
  { 211, 8, 14, 10, 1, -14 },
  { 225, 8, 14, 10, 1, -14 },
  { 239, 8, 14, 10, 1, -14 },
  { 253, 8, 14, 10, 1, -14 },
  { 267, 8, 14, 10, 1, -14 },
  { 281, 3, 10, 5, 1, -10 },
  { 285, 3, 12, 5, 1, -10 },
  { 290, 8, 9, 10, 1, -11 },
  { 299, 8, 5, 10, 1, -9 },
  { 304, 8, 9, 10, 1, -11 },
  { 313, 7, 14, 7, 0, -14 },
  { 326, 13, 16, 15, 1, -14 },
  { 352, 11, 14, 11, 0, -14 },
  { 372, 8, 14, 11, 2, -14 },
  { 386, 9, 14, 11, 1, -14 },
  { 402, 9, 14, 12, 2, -14 },
  { 418, 6, 14, 10, 2, -14 },
  { 429, 6, 14, 9, 2, -14 },
  { 440, 10, 14, 13, 1, -14 },
  { 458, 9, 14, 13, 2, -14 },
  { 474, 4, 14, 6, 1, -14 },
  { 481, 4, 18, 5, -1, -14 },
  { 490, 9, 14, 11, 2, -14 },
  { 506, 6, 14, 9, 2, -14 },
  { 517, 12, 14, 16, 2, -14 },
  { 538, 9, 14, 13, 2, -14 },
  { 554, 11, 14, 13, 1, -14 },
  { 574, 8, 14, 10, 2, -14 },
  { 588, 11, 17, 13, 1, -14 },
  { 612, 8, 14, 11, 2, -14 },
  { 626, 8, 14, 9, 1, -14 },
  { 640, 9, 14, 9, 0, -14 },
  { 656, 9, 14, 12, 2, -14 },
  { 672, 10, 14, 10, 0, -14 },
  { 690, 16, 14, 16, 0, -14 },
  { 718, 10, 14, 10, 0, -14 },
  { 736, 10, 14, 10, 0, -14 },
  { 754, 8, 14, 9, 1, -14 },
  { 768, 5, 17, 6, 1, -14 },
  { 779, 7, 14, 7, 0, -14 },
  { 792, 4, 17, 6, 1, -14 },
  { 801, 8, 8, 10, 1, -14 },
  { 809, 8, 1, 8, 0, 2 },
  { 810, 3, 3, 5, 1, -15 },
  { 812, 7, 10, 10, 1, -10 },
  { 821, 9, 14, 11, 1, -14 },
  { 837, 7, 10, 8, 1, -10 },
  { 846, 8, 14, 11, 1, -14 },
  { 860, 8, 10, 10, 1, -10 },
  { 870, 7, 15, 6, 0, -15 },
  { 884, 8, 15, 11, 1, -10 },
  { 899, 8, 14, 11, 1, -14 },
  { 913, 2, 14, 5, 1, -14 },
  { 917, 4, 19, 5, -1, -14 },
  { 927, 8, 14, 9, 1, -14 },
  { 941, 2, 14, 5, 1, -14 },
  { 945, 14, 10, 16, 1, -10 },
  { 963, 8, 10, 11, 1, -10 },
  { 973, 8, 10, 10, 1, -10 },
  { 983, 9, 15, 11, 1, -10 },
  { 1000, 8, 15, 11, 1, -10 },
  { 1015, 6, 10, 7, 1, -10 },
  { 1023, 6, 10, 8, 1, -10 },
  { 1031, 6, 13, 6, 0, -13 },
  { 1041, 8, 10, 11, 1, -10 },
  { 1051, 9, 10, 9, 0, -10 },
  { 1063, 13, 10, 14, 0, -10 },
  { 1080, 9, 10, 9, 0, -10 },
  { 1092, 9, 15, 9, 0, -10 },
  { 1109, 6, 10, 8, 1, -10 },
  { 1117, 5, 17, 7, 1, -14 },
  { 1128, 1, 19, 9, 4, -14 },
  { 1131, 5, 17, 7, 1, -14 },
  { 1142, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Regular19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR19PT7B_H_
