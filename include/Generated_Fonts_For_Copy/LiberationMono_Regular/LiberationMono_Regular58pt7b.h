#ifndef _LIBERATIONMONO_REGULAR58PT7B_H_
#define _LIBERATIONMONO_REGULAR58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x80,
  0xF9, 0xF0, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x9E, 0x01,
  0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x01,
  0xC0, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x38, 0x01, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x07,
  0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80,
  0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0xE0, 0x03, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xE3, 0x8F, 0xF0, 0x7F,
  0x07, 0x07, 0xE0, 0xFC, 0x0E, 0x07, 0xE1, 0xF0, 0x1C, 0x07, 0xC3, 0xE0,
  0x38, 0x0F, 0xC7, 0xC0, 0x70, 0x0C, 0x0F, 0x80, 0xE0, 0x00, 0x1F, 0x01,
  0xC0, 0x00, 0x3E, 0x03, 0x80, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x7E, 0x0E,
  0x00, 0x00, 0x7F, 0x9C, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0x0F, 0xE0, 0x00, 0x0E, 0x07, 0xE0, 0x00, 0x1C, 0x07,
  0xE0, 0x00, 0x38, 0x07, 0xC0, 0x00, 0x70, 0x0F, 0x80, 0x00, 0xE0, 0x0F,
  0x1C, 0x01, 0xC0, 0x1F, 0xF8, 0x03, 0x80, 0x3F, 0xF8, 0x07, 0x00, 0xF9,
  0xF0, 0x0E, 0x01, 0xF3, 0xF0, 0x1C, 0x07, 0xE3, 0xF0, 0x38, 0x1F, 0x87,
  0xFC, 0x70, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xE0,
  0xFF, 0xF0, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0x0F, 0x07, 0x81, 0xE0, 0x03,
  0xC1, 0xF0, 0x1E, 0x00, 0xF8, 0x3C, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x0F, 0x00, 0x78, 0x07, 0x83, 0xC0, 0x0F, 0x00, 0xF0, 0x78, 0x01,
  0xF0, 0x1E, 0x1E, 0x00, 0x1E, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xF1, 0xF0,
  0x00, 0x3F, 0xFC, 0x3C, 0x00, 0x03, 0xFF, 0x0F, 0x00, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x83, 0xF8, 0x00, 0x00, 0xF1, 0xFF, 0xC0, 0x00, 0x3C, 0x7F, 0xFC,
  0x00, 0x0F, 0x0F, 0x87, 0xC0, 0x01, 0xE3, 0xE0, 0x78, 0x00, 0x78, 0x78,
  0x0F, 0x00, 0x1E, 0x0F, 0x01, 0xF0, 0x07, 0xC1, 0xE0, 0x1E, 0x00, 0xF0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x7C, 0x1E, 0x00, 0x78, 0x0F,
  0x03, 0xC0, 0x0F, 0x81, 0xE0, 0xF0, 0x00, 0xF8, 0x78, 0x3C, 0x00, 0x0F,
  0xFF, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x03, 0xDF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x30,
  0x01, 0xFF, 0x00, 0x1E, 0x01, 0xFF, 0xC0, 0x0F, 0x01, 0xF9, 0xE0, 0x07,
  0x81, 0xF8, 0xF8, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xC0, 0xF8, 0x1F, 0x01,
  0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x7C, 0x01, 0xF0, 0xF0, 0x3E, 0x00, 0xFC,
  0x78, 0x1F, 0x00, 0x3F, 0x7C, 0x0F, 0x80, 0x0F, 0xBC, 0x07, 0xC0, 0x03,
  0xFE, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x7C, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0xF0, 0x0F, 0xE0, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0x1F, 0xF8, 0x3F, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x7C, 0xFF, 0xFB, 0xF7, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x20, 0x38, 0x19, 0xE1,
  0xC3, 0xDF, 0xCE, 0x7E, 0xFF, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0xFF, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xEF, 0x00, 0x1E, 0x78, 0x00, 0xF1,
  0xE0, 0x0F, 0x07, 0x80, 0xF8, 0x3E, 0x07, 0x80, 0xE0, 0x08, 0x06, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFB,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x3F, 0x83, 0xFF,
  0x07, 0xF0, 0x7F, 0xE0, 0xFE, 0x0F, 0xFC, 0x1F, 0xC1, 0xFF, 0x83, 0xF8,
  0x3F, 0xF0, 0x7F, 0x07, 0xFE, 0x0F, 0xE0, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF7, 0xC0, 0x0F, 0xFC, 0x7C, 0x00, 0xFF, 0x07, 0xC0,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x7E,
  0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x7E,
  0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x01,
  0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xF7, 0xE0, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x78, 0x7E, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x80,
  0x07, 0xC0, 0xFC, 0x00, 0x3C, 0x07, 0xE0, 0x03, 0xC0, 0x3F, 0x00, 0x3E,
  0x01, 0xF8, 0x01, 0xE0, 0x0F, 0xC0, 0x1E, 0x00, 0x7E, 0x01, 0xF0, 0x03,
  0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x07, 0xF0, 0x03, 0xE7, 0xFF, 0xC0, 0x7D, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x03, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x07, 0xF0, 0xFF, 0x03,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x07, 0xF8, 0x03, 0xE3, 0xFF, 0xC0, 0xF8, 0xFF, 0xFE,
  0x1F, 0x3F, 0xFF, 0xE3, 0xEF, 0x81, 0xFE, 0x7F, 0xC0, 0x0F, 0xCF, 0xF0,
  0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF9,
  0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7F, 0x00,
  0x7E, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFC, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0x7E, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE1, 0xF8, 0x00, 0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE,
  0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xCF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x1F, 0xE0, 0x3F, 0xC1,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x07,
  0xC3, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xFB, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F,
  0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xE0, 0x01, 0xFE,
  0x7E, 0x00, 0x7F, 0xC7, 0xF0, 0x3E, 0xF8, 0xFF, 0xFF, 0x9F, 0x0F, 0xFF,
  0xE3, 0xC0, 0x7F, 0xF8, 0xF8, 0x03, 0xF8, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x1F,
  0xE0, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC1, 0xFE, 0x07,
  0xFC, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x03, 0x83, 0xC0, 0x3E, 0x01, 0xE1, 0xC0, 0x7F,
  0x9E, 0xF1, 0xE0, 0x7F, 0xEE, 0x38, 0xF0, 0x7C, 0x77, 0x1C, 0x70, 0x78,
  0x1B, 0x8E, 0x78, 0x78, 0x0F, 0xC7, 0x3C, 0x3C, 0x03, 0xE3, 0xDE, 0x1C,
  0x01, 0xE1, 0xEE, 0x1E, 0x00, 0xF0, 0xF7, 0x0F, 0x00, 0x78, 0x7B, 0x87,
  0x00, 0x3C, 0x3F, 0xC7, 0x80, 0x1E, 0x1F, 0xE3, 0xC0, 0x0E, 0x0F, 0xF1,
  0xE0, 0x0F, 0x07, 0x78, 0xF0, 0x07, 0x83, 0xBC, 0x78, 0x03, 0xC1, 0xDE,
  0x3C, 0x01, 0xE0, 0xEF, 0x1E, 0x01, 0xE0, 0xF7, 0x8F, 0x00, 0xF0, 0x7B,
  0xC7, 0x80, 0x78, 0x39, 0xE3, 0xC0, 0x7C, 0x1C, 0x71, 0xE0, 0x3E, 0x1E,
  0x38, 0x78, 0x37, 0x0E, 0x1E, 0x3C, 0x3B, 0x8F, 0x0F, 0x0F, 0xF9, 0xFF,
  0x07, 0x87, 0xF8, 0x7F, 0x01, 0xC0, 0xF8, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00,
  0x7D, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0xFF, 0x0F,
  0x80, 0x03, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80,
  0x1F, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x7F, 0x8F, 0x80, 0x01, 0xFC, 0xF8,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00,
  0x1F, 0xCF, 0x80, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x03,
  0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x20, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x04, 0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x03, 0xF8,
  0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0x80, 0x7F,
  0xC1, 0xF0, 0x01, 0xFC, 0x3E, 0x00, 0x1F, 0xC7, 0xC0, 0x01, 0xF8, 0xF8,
  0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x3F, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xF8, 0xF8, 0x00, 0xFE, 0x1F,
  0x00, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x8F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x3F, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0x87, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x1F, 0x80,
  0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x81, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF3,
  0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xBE, 0x00, 0x3E, 0x7E,
  0x00, 0xFC, 0xFE, 0x01, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x7F, 0x03, 0xE0, 0x03, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0xFC,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF9, 0xFC, 0x00, 0x03,
  0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xBF, 0x80, 0x03, 0xFC, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x3E, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xFE, 0x03, 0xE0, 0x01, 0xF8,
  0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x1F, 0xC3,
  0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xFC, 0xF8,
  0x00, 0x03, 0xFB, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0x7F, 0xBC, 0x01, 0xEF, 0xF7, 0xC0, 0x3D, 0xFE, 0xF8, 0x0F, 0x3F, 0xCF,
  0x01, 0xE7, 0xF9, 0xF0, 0x7C, 0xFF, 0x3E, 0x0F, 0x1F, 0xE3, 0xC1, 0xE3,
  0xFC, 0x7C, 0x7C, 0x7F, 0x87, 0x8F, 0x0F, 0xF0, 0xF1, 0xE1, 0xFE, 0x1F,
  0x7C, 0x3F, 0xC1, 0xEF, 0x07, 0xF8, 0x3D, 0xE0, 0xFF, 0x07, 0xB8, 0x1F,
  0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0xF8, 0x0F, 0xF0, 0x1F,
  0x01, 0xFE, 0x03, 0xE0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xEF, 0x00, 0x1F, 0xF7,
  0xC0, 0x0F, 0xFB, 0xE0, 0x07, 0xFC, 0xF8, 0x03, 0xFE, 0x7C, 0x01, 0xFF,
  0x1F, 0x00, 0xFF, 0x8F, 0x80, 0x7F, 0xC3, 0xE0, 0x3F, 0xE1, 0xF0, 0x1F,
  0xF0, 0x7C, 0x0F, 0xF8, 0x3E, 0x07, 0xFC, 0x0F, 0x83, 0xFE, 0x07, 0xC1,
  0xFF, 0x01, 0xE0, 0xFF, 0x80, 0xF8, 0x7F, 0xC0, 0x7C, 0x3F, 0xE0, 0x1F,
  0x1F, 0xF0, 0x0F, 0x8F, 0xF8, 0x03, 0xE7, 0xFC, 0x01, 0xF3, 0xFE, 0x00,
  0x7D, 0xFF, 0x00, 0x3E, 0xFF, 0x80, 0x0F, 0xBF, 0xC0, 0x07, 0xDF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0xFC, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x7E,
  0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F,
  0x80, 0x0F, 0xF9, 0xF0, 0x00, 0x7F, 0x3E, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x7E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xF3, 0xE0,
  0x03, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x07,
  0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC,
  0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xFC, 0xF8,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xF0,
  0x07, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0x7F, 0x8F, 0x80, 0x01, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x7C, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xF8,
  0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0xFE, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0x83,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x70,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0xF9, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x07, 0xF8, 0x07,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7D, 0xF8, 0x00,
  0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0x87,
  0xE0, 0x03, 0xF0, 0xFF, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x07, 0xC3,
  0xE0, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x1F, 0x0F, 0x80, 0xFE, 0x03,
  0xE1, 0xF0, 0x1F, 0xC0, 0xF8, 0x1F, 0x03, 0xF8, 0x1F, 0x03, 0xE0, 0xF7,
  0x03, 0xE0, 0x7C, 0x1E, 0xF0, 0x7C, 0x0F, 0x83, 0xDE, 0x0F, 0x81, 0xF0,
  0x7B, 0xC1, 0xF0, 0x3E, 0x1E, 0x3C, 0x3C, 0x03, 0xC3, 0xC7, 0x87, 0x80,
  0x78, 0x78, 0xF1, 0xF0, 0x0F, 0x9F, 0x1E, 0x3E, 0x01, 0xF3, 0xC1, 0xE7,
  0xC0, 0x3E, 0x78, 0x3C, 0xF8, 0x07, 0xCF, 0x07, 0x9E, 0x00, 0xFB, 0xE0,
  0xF3, 0xC0, 0x0F, 0x78, 0x0F, 0x78, 0x01, 0xEF, 0x01, 0xEF, 0x00, 0x3D,
  0xE0, 0x3D, 0xE0, 0x07, 0xB8, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3C, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x03,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x78,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0xF8, 0x1F, 0x80,
  0x07, 0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x07,
  0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0xE1, 0xF8, 0x03, 0xFF, 0x07, 0xF0,
  0x7C, 0xFC, 0x3F, 0xFF, 0xC7, 0xFC, 0xFF, 0xFC, 0x3F, 0xE3, 0xFF, 0xC0,
  0xFF, 0x07, 0xF8, 0x03, 0xF8, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x81, 0xFC, 0x03, 0xE1, 0xFF, 0xC0, 0xF8, 0xFF, 0xFC, 0x3E,
  0x7F, 0xFF, 0x8F, 0xBE, 0x0F, 0xE3, 0xFE, 0x00, 0xFC, 0xFF, 0x00, 0x1F,
  0x3F, 0x80, 0x07, 0xEF, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00,
  0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF8,
  0x00, 0x7E, 0xFF, 0x00, 0x1F, 0x3F, 0xC0, 0x0F, 0xCF, 0xBC, 0x0F, 0xE3,
  0xEF, 0xFF, 0xF8, 0xF9, 0xFF, 0xFC, 0x3E, 0x1F, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x0F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x7C, 0x00,
  0x07, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC1,
  0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x1F, 0xFE, 0x3F, 0x0F, 0xFF, 0xEF, 0xC7,
  0xFF, 0xFB, 0xF3, 0xFC, 0x1F, 0xFC, 0xFC, 0x01, 0xFF, 0x7E, 0x00, 0x3F,
  0xDF, 0x80, 0x07, 0xF7, 0xC0, 0x01, 0xFD, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x01, 0xFD, 0xF8,
  0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xCF, 0xC0, 0x1D, 0xF3, 0xFC, 0x1F, 0x7C,
  0x7F, 0xFF, 0x9F, 0x0F, 0xFF, 0xC7, 0xC1, 0xFF, 0xE1, 0xF0, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFB, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x06, 0x0F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC1,
  0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xE1, 0xF0, 0xFF, 0xFC,
  0x7C, 0x7F, 0xFF, 0x9F, 0x3F, 0xC1, 0xF7, 0xCF, 0xC0, 0x1D, 0xF7, 0xE0,
  0x03, 0xFD, 0xF8, 0x00, 0x7F, 0x7C, 0x00, 0x1F, 0xDF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x1F,
  0xDF, 0x80, 0x0F, 0xF3, 0xF0, 0x07, 0x7C, 0xFF, 0x07, 0xDF, 0x1F, 0xFF,
  0xE7, 0xC3, 0xFF, 0xF1, 0xF0, 0x7F, 0xF8, 0x7C, 0x07, 0xF0, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x0E, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7F, 0x81,
  0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xF8,
  0x1F, 0x0F, 0xFF, 0x0F, 0x8F, 0xFF, 0xC7, 0xCF, 0xFF, 0xF3, 0xEF, 0x83,
  0xF9, 0xFF, 0x00, 0x7E, 0xFF, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xBF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE7, 0x00, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xEF, 0x80, 0x07, 0xE7, 0xC0, 0x07, 0xE3, 0xE0,
  0x07, 0xE1, 0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x3E,
  0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03,
  0xE3, 0xF0, 0x01, 0xF3, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE7, 0xE0, 0x07, 0xE1, 0xF8,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03,
  0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xC0,
  0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x7C,
  0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0x87, 0x9F, 0xE1,
  0xFF, 0x3C, 0xFF, 0x9F, 0xF9, 0xEF, 0xFC, 0xFF, 0xEF, 0x63, 0xFE, 0x3F,
  0x7F, 0x0F, 0xE0, 0xFB, 0xF0, 0x3F, 0x03, 0xFF, 0x81, 0xF0, 0x1F, 0xF8,
  0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F,
  0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03,
  0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE,
  0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07,
  0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80,
  0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF,
  0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0xE0, 0x7C, 0x3F, 0xFC, 0x3E, 0x3F, 0xFF, 0x1F,
  0x3F, 0xFF, 0xCF, 0xBE, 0x0F, 0xE7, 0xFC, 0x01, 0xFB, 0xFC, 0x00, 0xFD,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x3E, 0x1F, 0xFE, 0x0F, 0x8F, 0xFF, 0xC3, 0xE7, 0xFF, 0xF8, 0xFB,
  0xC0, 0xFE, 0x3F, 0xE0, 0x0F, 0xCF, 0xF0, 0x01, 0xF3, 0xF8, 0x00, 0x7E,
  0xFE, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x80, 0x07, 0xEF, 0xF0,
  0x01, 0xF3, 0xFC, 0x00, 0xFC, 0xFB, 0xC0, 0xFE, 0x3E, 0xFF, 0xFF, 0x8F,
  0x9F, 0xFF, 0xC3, 0xE1, 0xFF, 0xC0, 0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x07,
  0xC1, 0xFF, 0xE1, 0xF0, 0xFF, 0xFC, 0x7C, 0x7F, 0xFF, 0xBF, 0x3F, 0xC1,
  0xFF, 0xCF, 0xC0, 0x1F, 0xF7, 0xE0, 0x03, 0xFD, 0xF8, 0x00, 0x7F, 0x7C,
  0x00, 0x1F, 0xDF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFD,
  0xF0, 0x00, 0x7F, 0x7C, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x03,
  0xFC, 0xFC, 0x01, 0xDF, 0x3F, 0xC1, 0xFF, 0xC7, 0xFF, 0xFB, 0xF0, 0xFF,
  0xFC, 0xFC, 0x1F, 0xFE, 0x3F, 0x01, 0xFE, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xF7, 0xCF, 0xFF, 0xEF, 0xBF,
  0x80, 0x5F, 0x78, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xE1, 0xF0, 0x01, 0xF9, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x98, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xE7, 0xF0, 0x07, 0xF1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x07,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xF0,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xBE, 0x00, 0x3F, 0xDF, 0x80, 0x3F,
  0xEF, 0xE0, 0x3D, 0xF3, 0xFF, 0xFC, 0xF8, 0xFF, 0xFC, 0x7C, 0x3F, 0xFC,
  0x3E, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xF8,
  0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x3E, 0x7C, 0x07, 0xE0, 0x1F, 0x3E, 0x03, 0xF8, 0x0F, 0x9F, 0x01,
  0xFC, 0x07, 0x87, 0x80, 0xFE, 0x07, 0xC3, 0xE0, 0xF7, 0x03, 0xE1, 0xF0,
  0x7B, 0xC1, 0xF0, 0xF8, 0x3D, 0xE0, 0xF8, 0x7C, 0x3C, 0x70, 0x7C, 0x3E,
  0x1E, 0x3C, 0x3C, 0x0F, 0x0F, 0x1E, 0x3E, 0x07, 0x8F, 0x0F, 0x1F, 0x03,
  0xE7, 0x83, 0xCF, 0x81, 0xF3, 0xC1, 0xE7, 0xC0, 0xF9, 0xC0, 0xF3, 0xC0,
  0x7D, 0xE0, 0x39, 0xE0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0xF8,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8,
  0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x07,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x3E, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFE, 0x00,
};

const GFXglyph LiberationMono_Regular58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 5, 38, 35, 15, -38 },
  { 25, 19, 18, 35, 8, -42 },
  { 68, 31, 38, 35, 2, -38 },
  { 216, 31, 47, 35, 2, -42 },
  { 399, 35, 40, 35, 0, -39 },
  { 574, 33, 39, 35, 1, -38 },
  { 735, 7, 18, 35, 14, -42 },
  { 751, 15, 54, 35, 10, -42 },
  { 853, 15, 54, 35, 10, -42 },
  { 955, 21, 20, 35, 7, -42 },
  { 1008, 28, 28, 35, 3, -33 },
  { 1106, 13, 19, 35, 7, -8 },
  { 1137, 16, 5, 35, 9, -18 },
  { 1147, 7, 8, 35, 14, -8 },
  { 1154, 29, 43, 35, 3, -42 },
  { 1310, 27, 40, 35, 4, -39 },
  { 1445, 28, 38, 35, 4, -38 },
  { 1578, 27, 39, 35, 4, -39 },
  { 1710, 27, 40, 35, 4, -39 },
  { 1845, 29, 38, 35, 3, -38 },
  { 1983, 27, 39, 35, 4, -38 },
  { 2115, 27, 40, 35, 4, -39 },
  { 2250, 26, 38, 35, 4, -38 },
  { 2374, 27, 40, 35, 4, -39 },
  { 2509, 27, 40, 35, 4, -39 },
  { 2644, 7, 31, 35, 14, -31 },
  { 2672, 12, 42, 35, 10, -31 },
  { 2735, 28, 30, 35, 3, -34 },
  { 2840, 28, 18, 35, 3, -28 },
  { 2903, 28, 30, 35, 3, -34 },
  { 3008, 27, 39, 35, 3, -39 },
  { 3140, 33, 49, 35, 1, -42 },
  { 3343, 35, 38, 35, 0, -38 },
  { 3510, 28, 38, 35, 5, -38 },
  { 3643, 29, 40, 35, 3, -39 },
  { 3788, 27, 38, 35, 5, -38 },
  { 3917, 27, 38, 35, 5, -38 },
  { 4046, 26, 38, 35, 5, -38 },
  { 4170, 28, 40, 35, 3, -39 },
  { 4310, 25, 38, 35, 5, -38 },
  { 4429, 23, 38, 35, 6, -38 },
  { 4539, 23, 39, 35, 5, -38 },
  { 4652, 30, 38, 35, 5, -38 },
  { 4795, 24, 38, 35, 7, -38 },
  { 4909, 27, 38, 35, 4, -38 },
  { 5038, 25, 38, 35, 5, -38 },
  { 5157, 29, 40, 35, 3, -39 },
  { 5302, 27, 38, 35, 5, -38 },
  { 5431, 29, 50, 35, 3, -39 },
  { 5613, 28, 38, 35, 5, -38 },
  { 5746, 30, 40, 35, 2, -39 },
  { 5896, 31, 38, 35, 2, -38 },
  { 6044, 27, 39, 35, 4, -38 },
  { 6176, 35, 38, 35, 0, -38 },
  { 6343, 35, 38, 35, 0, -38 },
  { 6510, 33, 38, 35, 1, -38 },
  { 6667, 33, 38, 35, 1, -38 },
  { 6824, 31, 38, 35, 2, -38 },
  { 6972, 15, 54, 35, 12, -42 },
  { 7074, 29, 43, 35, 3, -42 },
  { 7230, 15, 54, 35, 8, -42 },
  { 7332, 27, 26, 35, 4, -38 },
  { 7420, 35, 3, 35, 0, 4 },
  { 7434, 12, 7, 35, 11, -41 },
  { 7445, 29, 33, 35, 4, -32 },
  { 7565, 26, 43, 35, 5, -42 },
  { 7705, 27, 33, 35, 4, -32 },
  { 7817, 26, 43, 35, 4, -42 },
  { 7957, 27, 33, 35, 4, -32 },
  { 8069, 27, 42, 35, 4, -42 },
  { 8211, 26, 44, 35, 4, -32 },
  { 8354, 25, 42, 35, 5, -42 },
  { 8486, 28, 42, 35, 4, -42 },
  { 8633, 21, 54, 35, 3, -42 },
  { 8775, 25, 42, 35, 7, -42 },
  { 8907, 28, 42, 35, 4, -42 },
  { 9054, 29, 32, 35, 3, -32 },
  { 9170, 25, 32, 35, 5, -32 },
  { 9270, 27, 33, 35, 4, -32 },
  { 9382, 26, 44, 35, 5, -32 },
  { 9525, 26, 44, 35, 4, -32 },
  { 9668, 23, 32, 35, 7, -32 },
  { 9760, 25, 33, 35, 5, -32 },
  { 9864, 24, 40, 35, 5, -39 },
  { 9984, 25, 32, 35, 5, -31 },
  { 10084, 31, 31, 35, 2, -31 },
  { 10205, 33, 31, 35, 1, -31 },
  { 10333, 29, 31, 35, 3, -31 },
  { 10446, 31, 43, 35, 2, -31 },
  { 10613, 26, 31, 35, 4, -31 },
  { 10714, 24, 54, 35, 6, -42 },
  { 10876, 5, 54, 35, 15, -42 },
  { 10910, 23, 54, 35, 5, -42 },
  { 11066, 29, 7, 35, 3, -23 },
};

const GFXfont LiberationMono_Regular58pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular58pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular58pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _LIBERATIONMONO_REGULAR58PT7B_H_
