#ifndef _LIBERATIONMONO_REGULAR51PT7B_H_
#define _LIBERATIONMONO_REGULAR51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB,
  0xE0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0x9E, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x1E, 0x00, 0x38, 0x03,
  0x80, 0x03, 0x80, 0x38, 0x00, 0x38, 0x03, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x70, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x06, 0x00, 0x06, 0x00,
  0x60, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x01, 0xC0,
  0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x80,
  0x03, 0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x38, 0x0F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x70,
  0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0C,
  0x00, 0x0C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFC, 0x71, 0xF8, 0x3E,
  0x0E, 0x1F, 0x8F, 0x81, 0xC1, 0xF1, 0xF0, 0x38, 0x1F, 0x3E, 0x07, 0x03,
  0x87, 0xC0, 0xE0, 0x00, 0xF8, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xF8,
  0x70, 0x00, 0x1F, 0xCE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0x8F, 0xE0, 0x00, 0x70, 0x7E, 0x00, 0x0E, 0x07, 0xC0, 0x01, 0xC0, 0x78,
  0x00, 0x38, 0x0F, 0x98, 0x07, 0x01, 0xFF, 0x00, 0xE0, 0x3F, 0xF0, 0x1C,
  0x07, 0xBF, 0x03, 0x81, 0xF3, 0xF0, 0x70, 0x7E, 0x3F, 0x8E, 0x3F, 0x87,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xE1, 0xFF,
  0xE0, 0x03, 0xC3, 0xC3, 0xC0, 0x0F, 0x0F, 0x03, 0xC0, 0x1C, 0x1E, 0x07,
  0x80, 0x78, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x1C,
  0x0F, 0x01, 0xE0, 0x38, 0x3C, 0x03, 0xC0, 0xF0, 0x70, 0x07, 0x81, 0xE1,
  0xE0, 0x07, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x0E, 0x00, 0x0F, 0xFE, 0x3C,
  0x00, 0x1F, 0xF8, 0xF0, 0x00, 0x0F, 0xC1, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x7F, 0x00, 0x00, 0xE1, 0xFF,
  0x00, 0x03, 0xC7, 0xFF, 0x00, 0x0F, 0x1F, 0x1F, 0x00, 0x1C, 0x3C, 0x1E,
  0x00, 0x78, 0x70, 0x1C, 0x01, 0xE1, 0xE0, 0x3C, 0x03, 0x83, 0xC0, 0x78,
  0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x70, 0x1E, 0x03, 0xC1,
  0xE0, 0x1C, 0x07, 0x07, 0x80, 0x3C, 0x1E, 0x0E, 0x00, 0x7C, 0x7C, 0x3C,
  0x00, 0x7F, 0xF0, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x1C, 0x03, 0xE0, 0x00,
  0xF0, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x7E, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x03,
  0x00, 0x7F, 0xC0, 0x1E, 0x07, 0xDE, 0x00, 0xE0, 0x7C, 0x78, 0x0F, 0x07,
  0xC3, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC3, 0xE0, 0x3C, 0x3C, 0x1F, 0x01,
  0xF1, 0xE0, 0xF0, 0x07, 0xCF, 0x07, 0x80, 0x1E, 0xF0, 0x3C, 0x00, 0xFF,
  0x81, 0xE0, 0x03, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x3C, 0x00, 0x7E, 0x01,
  0xF0, 0x07, 0xF8, 0x07, 0xE0, 0xFF, 0xFB, 0x1F, 0xFF, 0xCF, 0xF8, 0x7F,
  0xF8, 0x3F, 0xC0, 0x7F, 0x00, 0x3C, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x18,
  0x38, 0x27, 0x8E, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0xFE, 0x00, 0x1F,
  0x00, 0x0F, 0xE0, 0x07, 0xB8, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x78, 0x38,
  0x1C, 0x0F, 0x01, 0x01, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3C, 0x00,
  0x3E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7E,
  0x0F, 0xF8, 0x7E, 0x0F, 0xF8, 0x7E, 0x0F, 0xF8, 0x7E, 0x0F, 0xF8, 0x7E,
  0x0F, 0xF8, 0x7E, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0xC1,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xDE, 0x00, 0xFF, 0x9E, 0x00, 0xFF, 0x1E,
  0x00, 0xFC, 0x1E, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xF0, 0x3F, 0x8F, 0xC0, 0x1F,
  0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x3F, 0x81, 0xFC, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x78, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0x3F, 0x80, 0xFE,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x79,
  0xE0, 0x00, 0x78, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x7F, 0x80, 0x7D, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F,
  0x81, 0xFC, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xE0,
  0x1F, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x1C, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0xE0,
  0x3C, 0x7F, 0xF0, 0x79, 0xFF, 0xF8, 0xF7, 0xFF, 0xF9, 0xFF, 0x03, 0xFB,
  0xF8, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0xFB, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0xC0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3E, 0x00, 0x7E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1E,
  0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F,
  0x7E, 0x00, 0x3E, 0x3F, 0x80, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x0F, 0xC0, 0x3F, 0x3F,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xE0, 0x00, 0x7B, 0xC0,
  0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x03,
  0xFB, 0xF8, 0x1E, 0xF3, 0xFF, 0xFD, 0xE3, 0xFF, 0xF7, 0xC3, 0xFF, 0xCF,
  0x81, 0xFC, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x1F, 0x00, 0x7C, 0x3F,
  0x83, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3,
  0xFC, 0x0F, 0xE1, 0xF8, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x78, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xE0, 0xE0, 0x3C,
  0x07, 0x0F, 0x07, 0xF3, 0x9C, 0x70, 0x7F, 0xDC, 0xE3, 0x87, 0x86, 0xE7,
  0x3C, 0x78, 0x1F, 0x39, 0xC3, 0x80, 0xF1, 0xCE, 0x3C, 0x07, 0x87, 0x71,
  0xE0, 0x3C, 0x3F, 0x8E, 0x01, 0xE1, 0xFC, 0xF0, 0x0F, 0x0F, 0xC7, 0x80,
  0x70, 0x7E, 0x38, 0x03, 0x87, 0x71, 0xC0, 0x1C, 0x3B, 0x8E, 0x01, 0xE1,
  0xDC, 0x70, 0x0F, 0x0E, 0xE3, 0x80, 0x70, 0x77, 0x1C, 0x03, 0x83, 0xB8,
  0xE0, 0x3C, 0x39, 0xC7, 0x81, 0xE1, 0xCF, 0x3C, 0x1F, 0x1E, 0x38, 0xF1,
  0xF8, 0xE1, 0xC7, 0xFC, 0xFF, 0x0E, 0x1F, 0xC7, 0xF0, 0x78, 0x7C, 0x1E,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x10, 0x07, 0x80, 0x03, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xFC,
  0x0F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00,
  0x78, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x0F, 0x80, 0x3F, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x87, 0xC0, 0x1F, 0xC3, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3E, 0x00, 0x7F,
  0x1F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x3D, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x07, 0xF3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x81, 0xFC, 0x0F, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0xFC, 0x00,
  0x3E, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x06, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x03, 0x1F, 0x00, 0x01,
  0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0xF8, 0x7E, 0x00,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xF8, 0x0F, 0xF0, 0xF8, 0x01, 0xF8, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x07, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x0C, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x0F,
  0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3F, 0x00, 0x0F, 0x1F, 0x80, 0x1F,
  0x1F, 0xC0, 0x7F, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF9, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x3F, 0x01, 0xF8, 0xFC, 0x1F, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x81,
  0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xDF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFD, 0xF8, 0x00, 0x7F,
  0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0,
  0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xF7, 0x80, 0xFF, 0xF7, 0x80, 0xFF, 0xF7, 0x80, 0xEF, 0xF3,
  0xC1, 0xEF, 0xF3, 0xC1, 0xEF, 0xF3, 0xC1, 0xCF, 0xF1, 0xE3, 0xCF, 0xF1,
  0xE3, 0xCF, 0xF1, 0xE7, 0x8F, 0xF0, 0xF7, 0x8F, 0xF0, 0xF7, 0x0F, 0xF0,
  0x77, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0,
  0x3E, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFB, 0xC0,
  0x1F, 0xF7, 0x80, 0x3F, 0xE7, 0x80, 0x7F, 0xCF, 0x00, 0xFF, 0x8F, 0x01,
  0xFF, 0x1E, 0x03, 0xFE, 0x1E, 0x07, 0xFC, 0x3C, 0x0F, 0xF8, 0x7C, 0x1F,
  0xF0, 0x78, 0x3F, 0xE0, 0xF8, 0x7F, 0xC0, 0xF0, 0xFF, 0x81, 0xE1, 0xFF,
  0x01, 0xE3, 0xFE, 0x03, 0xC7, 0xFC, 0x03, 0xCF, 0xF8, 0x07, 0x9F, 0xF0,
  0x0F, 0xBF, 0xE0, 0x0F, 0x7F, 0xC0, 0x1F, 0xFF, 0x80, 0x1E, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8,
  0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xE0, 0x03, 0xE1, 0xF0,
  0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xFC,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x01, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x01,
  0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xE0, 0x03, 0xE1, 0xF0, 0x03,
  0xF0, 0xFC, 0x01, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF8,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x8F, 0x80, 0x1F, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00,
  0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF0,
  0x03, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x3E, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF3,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xE7, 0xE0, 0x01, 0xF8, 0xFF, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xEF,
  0x80, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0xC0, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3C, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E,
  0x1F, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0,
  0x3E, 0x07, 0xC3, 0xC0, 0x7C, 0x0F, 0x87, 0x81, 0xF8, 0x1F, 0x0F, 0x83,
  0xF0, 0x3C, 0x1F, 0x07, 0xF0, 0x78, 0x1E, 0x0E, 0xE0, 0xF0, 0x3C, 0x3D,
  0xC1, 0xE0, 0x78, 0x7B, 0xC3, 0xC0, 0xF0, 0xE7, 0x8F, 0x81, 0xE1, 0xC7,
  0x1E, 0x03, 0xC7, 0x8E, 0x3C, 0x07, 0xCF, 0x1E, 0x78, 0x07, 0x9C, 0x3C,
  0xF0, 0x0F, 0x78, 0x39, 0xE0, 0x1E, 0xF0, 0x73, 0xC0, 0x3D, 0xE0, 0xF7,
  0x80, 0x7B, 0x81, 0xEE, 0x00, 0xF7, 0x01, 0xDC, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xE0, 0x7C,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1E,
  0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x78, 0x1F, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE3, 0x80, 0x01, 0xC3, 0xC0,
  0x03, 0xC1, 0xC0, 0x03, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xF0,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x7E, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFE, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x3F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x06, 0xF0, 0x7C, 0x03, 0xBC, 0x1F,
  0x83, 0xCF, 0x83, 0xFF, 0xE3, 0xFC, 0x7F, 0xF0, 0x7F, 0x07, 0xF0, 0x0F,
  0xC0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x7F, 0x01, 0xE3, 0xFF, 0x83, 0xCF, 0xFF, 0x87,
  0xBC, 0x1F, 0x8F, 0xE0, 0x1F, 0x1F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7C,
  0x00, 0x3C, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80,
  0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00,
  0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03,
  0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x7C,
  0xFE, 0x01, 0xF1, 0xEE, 0x07, 0xE3, 0xDF, 0xFF, 0x8F, 0x8F, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x0F, 0xC1, 0xF8, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xF8, 0x7C, 0x1F,
  0xFC, 0xF8, 0x7F, 0xFD, 0xF1, 0xF8, 0x3D, 0xE7, 0xC0, 0x1B, 0xCF, 0x80,
  0x1F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xE0, 0x00,
  0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB,
  0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0xBE,
  0x00, 0x3F, 0x3E, 0x00, 0xFE, 0x7C, 0x01, 0xBC, 0x7E, 0x0F, 0x78, 0x7F,
  0xFC, 0xF0, 0x7F, 0xF1, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xC1, 0xF8, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x78,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x18, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x0F,
  0xC1, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0xF1, 0xFF, 0xF3, 0xCF, 0xC1,
  0xEF, 0x7E, 0x01, 0xBD, 0xF0, 0x07, 0xF7, 0x80, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xF7, 0xC0, 0x1F, 0xDF, 0x00, 0x6F, 0x3F, 0x07, 0xBC, 0xFF,
  0xFC, 0xF0, 0xFF, 0xC3, 0xC0, 0xFC, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE3,
  0xE0, 0x0F, 0x87, 0xE0, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x83, 0xF8, 0x3C, 0x7F, 0xF1, 0xE7, 0xFF, 0xCF, 0x78, 0x3F,
  0x7F, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0xC0, 0x3F,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x0F, 0xBC, 0x00, 0x7C, 0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x0F, 0x00, 0xF8,
  0x3C, 0x07, 0xC0, 0xF0, 0x3E, 0x03, 0xC1, 0xF0, 0x0F, 0x0F, 0x80, 0x3C,
  0x3E, 0x00, 0xF1, 0xF0, 0x03, 0xCF, 0x80, 0x0F, 0x7E, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x87, 0xC0, 0x3C, 0x0F, 0x80,
  0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x0F, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xF0,
  0x07, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF0, 0x00,
  0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x3E,
  0x3C, 0xFE, 0x1F, 0xC7, 0x7F, 0xCF, 0xF9, 0xD8, 0xF7, 0x3E, 0x7C, 0x1D,
  0x87, 0xDF, 0x07, 0xC1, 0xF7, 0xC1, 0xF0, 0x3D, 0xE0, 0x7C, 0x0F, 0x78,
  0x1F, 0x03, 0xDE, 0x07, 0x80, 0xF7, 0x81, 0xE0, 0x3D, 0xE0, 0x78, 0x0F,
  0x78, 0x1E, 0x03, 0xDE, 0x07, 0x80, 0xF7, 0x81, 0xE0, 0x3D, 0xE0, 0x78,
  0x0F, 0x78, 0x1E, 0x03, 0xDE, 0x07, 0x80, 0xF7, 0x81, 0xE0, 0x3D, 0xE0,
  0x78, 0x0F, 0x78, 0x1E, 0x03, 0xDE, 0x07, 0x80, 0xF7, 0x81, 0xE0, 0x3D,
  0xE0, 0x78, 0x0F, 0x78, 0x1E, 0x03, 0xDE, 0x07, 0x80, 0xF7, 0x81, 0xE0,
  0x3D, 0xE0, 0x78, 0x0F, 0x00, 0x3F, 0x83, 0xE3, 0xFF, 0x87, 0x9F, 0xFF,
  0x1E, 0xF0, 0x7E, 0x7F, 0x00, 0xF9, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF,
  0x00, 0x1F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00,
  0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F,
  0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78,
  0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x7C,
  0x0F, 0x81, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x81, 0xF1, 0xFF, 0xC1, 0xE7, 0xFF, 0xC3, 0xDC, 0x0F, 0xC7,
  0xF0, 0x0F, 0x8F, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x1E, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80,
  0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00,
  0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0xC0, 0x03,
  0xEF, 0x80, 0x07, 0x9F, 0x00, 0x1F, 0x3F, 0x00, 0x3E, 0x7F, 0x00, 0xF8,
  0xF7, 0x03, 0xF1, 0xEF, 0xFF, 0xC3, 0xC7, 0xFF, 0x07, 0x83, 0xF8, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x1E, 0x0F, 0xFE, 0x3C, 0x3F,
  0xFE, 0x78, 0xFC, 0x1F, 0xF3, 0xE0, 0x0F, 0xE7, 0xC0, 0x0F, 0xDF, 0x00,
  0x1F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00,
  0xFB, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB,
  0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0x9F,
  0x00, 0x7F, 0x3E, 0x00, 0xDE, 0x3F, 0x07, 0xBC, 0x3F, 0xFE, 0xF8, 0x3F,
  0xF9, 0xF0, 0x1F, 0xC3, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xF7, 0x9F, 0xFF, 0x79, 0xF0, 0x07, 0xBC,
  0x00, 0x7B, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xC0, 0x7C, 0x3E, 0x00, 0x78, 0xF0, 0x01,
  0xF7, 0x80, 0x03, 0xDE, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF7, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0x78, 0x00, 0x79, 0xF8, 0x07, 0xE3, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x03,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x6F, 0x7E,
  0x0F, 0x7B, 0xFF, 0xF3, 0xCF, 0xFF, 0x1E, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x3E,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x01, 0xF0, 0x3E, 0x78,
  0x1F, 0x81, 0xF3, 0xC0, 0xFC, 0x0F, 0x1F, 0x07, 0xF0, 0x78, 0xF8, 0x3B,
  0x83, 0xC3, 0xC3, 0xDC, 0x1E, 0x1E, 0x1C, 0xF1, 0xF0, 0xF0, 0xE3, 0x8F,
  0x87, 0x8F, 0x1C, 0x78, 0x3C, 0x70, 0xF3, 0xC1, 0xF3, 0x87, 0x9E, 0x07,
  0xBC, 0x1C, 0xF0, 0x3D, 0xC0, 0xE7, 0x81, 0xEE, 0x07, 0xF8, 0x0F, 0x70,
  0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x01, 0xF1,
  0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3E,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xE0,
};

const GFXglyph LiberationMono_Regular51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 5, 34, 31, 13, -34 },
  { 23, 17, 16, 31, 7, -37 },
  { 57, 28, 34, 31, 1, -34 },
  { 176, 27, 41, 31, 2, -37 },
  { 315, 31, 36, 31, 0, -35 },
  { 455, 29, 35, 31, 1, -34 },
  { 582, 6, 16, 31, 12, -37 },
  { 594, 13, 48, 31, 9, -37 },
  { 672, 14, 48, 31, 8, -37 },
  { 756, 18, 18, 31, 6, -37 },
  { 797, 25, 26, 31, 3, -30 },
  { 879, 11, 16, 31, 6, -7 },
  { 901, 14, 4, 31, 8, -16 },
  { 908, 6, 7, 31, 12, -7 },
  { 914, 25, 38, 31, 3, -37 },
  { 1033, 24, 36, 31, 3, -35 },
  { 1141, 24, 34, 31, 4, -34 },
  { 1243, 23, 35, 31, 4, -35 },
  { 1344, 24, 36, 31, 3, -35 },
  { 1452, 25, 34, 31, 3, -34 },
  { 1559, 24, 35, 31, 3, -34 },
  { 1664, 23, 36, 31, 4, -35 },
  { 1768, 23, 34, 31, 4, -34 },
  { 1866, 24, 36, 31, 3, -35 },
  { 1974, 23, 36, 31, 4, -35 },
  { 2078, 6, 27, 31, 12, -27 },
  { 2099, 11, 36, 31, 9, -27 },
  { 2149, 25, 26, 31, 3, -30 },
  { 2231, 25, 16, 31, 3, -25 },
  { 2281, 25, 26, 31, 3, -30 },
  { 2363, 25, 35, 31, 2, -35 },
  { 2473, 29, 43, 31, 1, -37 },
  { 2629, 31, 34, 31, 0, -34 },
  { 2761, 25, 34, 31, 4, -34 },
  { 2868, 25, 36, 31, 3, -35 },
  { 2981, 24, 34, 31, 4, -34 },
  { 3083, 24, 34, 31, 4, -34 },
  { 3185, 22, 34, 31, 5, -34 },
  { 3279, 24, 36, 31, 3, -35 },
  { 3387, 23, 34, 31, 4, -34 },
  { 3485, 21, 34, 31, 5, -34 },
  { 3575, 21, 35, 31, 4, -34 },
  { 3667, 27, 34, 31, 4, -34 },
  { 3782, 21, 34, 31, 6, -34 },
  { 3872, 24, 34, 31, 3, -34 },
  { 3974, 23, 34, 31, 4, -34 },
  { 4072, 25, 36, 31, 3, -35 },
  { 4185, 24, 34, 31, 4, -34 },
  { 4287, 25, 45, 31, 3, -35 },
  { 4428, 25, 34, 31, 4, -34 },
  { 4535, 26, 36, 31, 2, -35 },
  { 4652, 27, 34, 31, 2, -34 },
  { 4767, 23, 35, 31, 4, -34 },
  { 4868, 30, 34, 31, 0, -34 },
  { 4996, 31, 34, 31, 0, -34 },
  { 5128, 29, 34, 31, 1, -34 },
  { 5252, 29, 34, 31, 1, -34 },
  { 5376, 27, 34, 31, 2, -34 },
  { 5491, 14, 48, 31, 10, -37 },
  { 5575, 25, 38, 31, 3, -37 },
  { 5694, 13, 48, 31, 7, -37 },
  { 5772, 24, 23, 31, 3, -34 },
  { 5841, 31, 2, 31, 0, 3 },
  { 5849, 11, 6, 31, 10, -36 },
  { 5858, 26, 29, 31, 3, -28 },
  { 5953, 23, 38, 31, 4, -37 },
  { 6063, 24, 29, 31, 3, -28 },
  { 6150, 23, 38, 31, 3, -37 },
  { 6260, 24, 29, 31, 3, -28 },
  { 6347, 24, 37, 31, 3, -37 },
  { 6458, 22, 39, 31, 4, -28 },
  { 6566, 21, 37, 31, 5, -37 },
  { 6664, 24, 37, 31, 4, -37 },
  { 6775, 18, 48, 31, 3, -37 },
  { 6883, 22, 37, 31, 6, -37 },
  { 6985, 25, 37, 31, 3, -37 },
  { 7101, 26, 28, 31, 2, -28 },
  { 7192, 22, 28, 31, 4, -28 },
  { 7269, 24, 29, 31, 3, -28 },
  { 7356, 23, 39, 31, 4, -28 },
  { 7469, 23, 39, 31, 3, -28 },
  { 7582, 20, 28, 31, 6, -28 },
  { 7652, 22, 29, 31, 4, -28 },
  { 7732, 20, 35, 31, 5, -34 },
  { 7820, 21, 28, 31, 5, -27 },
  { 7894, 27, 27, 31, 2, -27 },
  { 7986, 29, 27, 31, 1, -27 },
  { 8084, 26, 27, 31, 2, -27 },
  { 8172, 27, 38, 31, 2, -27 },
  { 8301, 23, 27, 31, 4, -27 },
  { 8379, 20, 48, 31, 6, -37 },
  { 8499, 4, 48, 31, 13, -37 },
  { 8523, 21, 48, 31, 4, -37 },
  { 8649, 25, 6, 31, 3, -20 },
};

const GFXfont LiberationMono_Regular51pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular51pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular51pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _LIBERATIONMONO_REGULAR51PT7B_H_
