#ifndef _LIBERATIONMONO_REGULAR52PT7B_H_
#define _LIBERATIONMONO_REGULAR52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3E, 0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x00, 0x38, 0x03,
  0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x70, 0x0F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x07, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x60, 0x06, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x03,
  0x80, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0x07, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x03,
  0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC1, 0xFC, 0x71, 0xFC, 0x3E, 0x0E, 0x0F, 0x8F, 0x81, 0xC0, 0xF9, 0xF0,
  0x38, 0x1F, 0x3E, 0x07, 0x01, 0xC7, 0xC0, 0xE0, 0x00, 0xF8, 0x1C, 0x00,
  0x0F, 0x83, 0x80, 0x01, 0xF8, 0x70, 0x00, 0x1F, 0xCE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0x87, 0xF0, 0x00, 0x70, 0x3E, 0x00, 0x0E,
  0x03, 0xE0, 0x01, 0xC0, 0x7C, 0x00, 0x38, 0x07, 0x98, 0x07, 0x00, 0xFF,
  0x00, 0xE0, 0x1F, 0xF0, 0x1C, 0x07, 0xFF, 0x03, 0x80, 0xFB, 0xF0, 0x70,
  0x3E, 0x3F, 0x8E, 0x1F, 0xC7, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xF1, 0xFF, 0xE0, 0x01, 0xC3, 0xC3, 0xE0, 0x07, 0x8F,
  0x03, 0xC0, 0x1E, 0x1E, 0x03, 0x80, 0x78, 0x3C, 0x07, 0x00, 0xF0, 0x78,
  0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x3C, 0x1C, 0x03, 0xC0,
  0x70, 0x78, 0x07, 0x81, 0xE1, 0xE0, 0x07, 0x03, 0xC3, 0x80, 0x0F, 0x0F,
  0x8F, 0x00, 0x0F, 0xFE, 0x3C, 0x00, 0x1F, 0xF8, 0xF0, 0x00, 0x0F, 0xC1,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x3F, 0x00, 0x00, 0xF1, 0xFF, 0x80, 0x03, 0xC7, 0xFF, 0x80, 0x07, 0x0F,
  0x0F, 0x00, 0x1E, 0x3C, 0x0F, 0x00, 0x78, 0x78, 0x1E, 0x00, 0xE0, 0xF0,
  0x3C, 0x03, 0xC1, 0xC0, 0x78, 0x0F, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01,
  0xE0, 0x70, 0x0F, 0x03, 0xC1, 0xE0, 0x1E, 0x07, 0x87, 0x80, 0x3C, 0x0F,
  0x0E, 0x00, 0x3C, 0x3C, 0x3C, 0x00, 0x7F, 0xF8, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xE0,
  0x0F, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x70, 0x03, 0xC0, 0x03, 0x80, 0x3C,
  0x00, 0x1C, 0x01, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0x83, 0xF0, 0x00,
  0x3C, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x03, 0x00, 0x7F, 0xC0, 0x1E, 0x07, 0xDF, 0x00,
  0xF0, 0x7C, 0x78, 0x07, 0x87, 0xC3, 0xE0, 0x38, 0x3C, 0x0F, 0x83, 0xC3,
  0xE0, 0x3C, 0x1E, 0x1F, 0x01, 0xF1, 0xE0, 0xF0, 0x07, 0xCF, 0x07, 0x80,
  0x1F, 0x78, 0x3C, 0x00, 0x7F, 0x81, 0xF0, 0x01, 0xFC, 0x0F, 0x80, 0x0F,
  0xC0, 0x3C, 0x00, 0x7F, 0x01, 0xF0, 0x07, 0xFC, 0x07, 0xE0, 0xFF, 0xFF,
  0x1F, 0xFF, 0xCF, 0xF8, 0x7F, 0xFC, 0x1F, 0xC0, 0x7F, 0x00, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF7, 0xBD, 0xCE, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xC1, 0xC1, 0x9F, 0x38, 0xF3,
  0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xC0, 0x01, 0xFC, 0x00,
  0x7B, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x80, 0xF0, 0x78, 0x1E, 0x0F, 0x00,
  0x80, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xF8, 0x03, 0xF0, 0xF8,
  0x00, 0xF8, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9E,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x7E, 0x1F, 0xF8, 0x3F, 0x0F, 0xFC, 0x1F, 0x87,
  0xFE, 0x0F, 0xC3, 0xFF, 0x07, 0xE1, 0xFF, 0x83, 0xF0, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x07, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x7C, 0x01, 0xFE, 0x3E, 0x00, 0xFC, 0x1F,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x7E,
  0x00, 0xFC, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE1, 0xF8, 0x03, 0xF0,
  0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFB,
  0xE0, 0x00, 0xF9, 0xF8, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF3, 0xE0,
  0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x83,
  0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x3C,
  0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x0F, 0x81,
  0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC7, 0xF8, 0x01, 0xEF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xF0, 0x03, 0xF0, 0xFE,
  0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x38, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0xF9, 0xFF, 0xE0,
  0xF3, 0xFF, 0xF0, 0xF7, 0xFF, 0xF8, 0xFF, 0x81, 0xFC, 0xFE, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x7C,
  0x1F, 0xC1, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xE1, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x83, 0xE0, 0x03, 0xE3, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0xF9, 0xF8, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0x83,
  0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x3F, 0x83, 0xFF, 0x3F, 0xFF,
  0xDE, 0x1F, 0xFF, 0x9E, 0x07, 0xFF, 0x1E, 0x01, 0xF8, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x7C, 0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x78,
  0x1F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1,
  0xFC, 0x07, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x01, 0xE0, 0x1E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x03, 0x8F, 0x01, 0xE0, 0x1C, 0x70, 0x3F, 0xCE, 0xE3, 0x83, 0xFE, 0x73,
  0xBC, 0x3E, 0x3F, 0x1D, 0xC1, 0xE0, 0xF8, 0xEE, 0x1E, 0x07, 0xC7, 0x70,
  0xE0, 0x1E, 0x3B, 0x8F, 0x00, 0xF1, 0xFC, 0x70, 0x07, 0x0F, 0xE3, 0x80,
  0x38, 0x7E, 0x3C, 0x03, 0xC3, 0xF1, 0xE0, 0x1E, 0x1F, 0x8F, 0x00, 0xE0,
  0xFC, 0x78, 0x07, 0x07, 0xE3, 0x80, 0x38, 0x3F, 0x1C, 0x03, 0xC3, 0xB8,
  0xF0, 0x1E, 0x1D, 0xC7, 0x81, 0xF0, 0xEF, 0x3C, 0x0F, 0x0F, 0x78, 0xE0,
  0xF8, 0x71, 0xC7, 0x8E, 0xE7, 0x8E, 0x3F, 0xE7, 0xF8, 0x70, 0xFE, 0x3F,
  0x83, 0xC3, 0xE0, 0xF8, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0xF0,
  0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x07,
  0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0x80, 0x1F, 0xC7, 0xC0, 0x03, 0xF3,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x0F,
  0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x3E, 0x00, 0x3F, 0x9F, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xF7,
  0xC0, 0x07, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xE0, 0xFE, 0x07, 0xE0, 0x0F, 0xC3,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x01,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x87, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x3F, 0x83, 0xF8,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x0F, 0x80, 0xFF, 0x87, 0xC0, 0x0F, 0xE3, 0xE0, 0x03, 0xF1, 0xF0,
  0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3D,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xDF, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x9F, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0x87, 0xC0, 0x3F, 0xC3, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE1,
  0xFC, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xBE, 0x00, 0x06, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0xFF,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF9, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0,
  0x1F, 0x1F, 0x00, 0xF8, 0xFE, 0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE3,
  0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x1F,
  0x03, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFE, 0xFC, 0x00, 0x7F, 0x9F, 0x80,
  0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0,
  0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x3E, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xB8, 0x03, 0xFF, 0xDE, 0x01, 0xDF, 0xEF, 0x01, 0xEF, 0xF3,
  0xC0, 0xF7, 0xF9, 0xE0, 0x73, 0xFC, 0xF0, 0x79, 0xFE, 0x3C, 0x3C, 0xFF,
  0x1E, 0x3C, 0x7F, 0x8F, 0x1E, 0x3F, 0xC3, 0xCF, 0x1F, 0xE1, 0xEF, 0x0F,
  0xF0, 0xF7, 0x87, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x07, 0xE0,
  0xFF, 0x03, 0xE0, 0x7F, 0x81, 0xF0, 0x3F, 0xC0, 0x78, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFB, 0xC0, 0x0F, 0xF7, 0xC0, 0x1F, 0xE7,
  0x80, 0x3F, 0xCF, 0x80, 0x7F, 0x8F, 0x00, 0xFF, 0x1F, 0x01, 0xFE, 0x1E,
  0x03, 0xFC, 0x3E, 0x07, 0xF8, 0x3C, 0x0F, 0xF0, 0x78, 0x1F, 0xE0, 0x78,
  0x3F, 0xC0, 0xF0, 0x7F, 0x81, 0xF0, 0xFF, 0x01, 0xE1, 0xFE, 0x03, 0xE3,
  0xFC, 0x03, 0xC7, 0xF8, 0x07, 0xCF, 0xF0, 0x07, 0x9F, 0xE0, 0x0F, 0xBF,
  0xC0, 0x0F, 0x7F, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xE7,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x83, 0xF0, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xF8, 0x01, 0xFE, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xF8, 0x01, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x03,
  0xE1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBF,
  0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xFE, 0x3E, 0x00, 0x0F,
  0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE3, 0xE0, 0x03, 0xF8, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xF8, 0x1F,
  0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xF8,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFC, 0x07,
  0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3C,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0x9F, 0xC0, 0x03, 0xF1, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0x7F,
  0x01, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xE0,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x1E, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x07, 0x9F, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xF1, 0xE0, 0x3E, 0x03,
  0xC3, 0xC0, 0x7C, 0x07, 0x87, 0xC0, 0xFC, 0x0F, 0x0F, 0x83, 0xF8, 0x1E,
  0x1F, 0x07, 0xF0, 0x7C, 0x1E, 0x0E, 0xE0, 0xF8, 0x3C, 0x1D, 0xE1, 0xE0,
  0x78, 0x7B, 0xC3, 0xC0, 0xF0, 0xF3, 0x87, 0x81, 0xE1, 0xC7, 0x8F, 0x03,
  0xE7, 0x8F, 0x1E, 0x03, 0xCF, 0x1E, 0x3C, 0x07, 0x9E, 0x1C, 0xF8, 0x0F,
  0x38, 0x3D, 0xE0, 0x1E, 0xF0, 0x7B, 0xC0, 0x3D, 0xE0, 0xF7, 0x80, 0x7B,
  0x80, 0xEF, 0x00, 0xF7, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF8, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xFC, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x7C, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C,
  0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3, 0x80,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x3C, 0x00,
  0x78, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xC0, 0x00, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x0F, 0xC0, 0xF8, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0x80, 0x1F,
  0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0xF0, 0x7E, 0x00, 0x3C,
  0x1F, 0x00, 0x0F, 0x0F, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC1, 0xE0, 0x07, 0xF0, 0x7C,
  0x03, 0xBE, 0x1F, 0x83, 0xCF, 0x83, 0xFF, 0xE1, 0xFC, 0x7F, 0xF0, 0x7F,
  0x07, 0xF0, 0x0F, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC1, 0xFC, 0x07,
  0x8F, 0xFE, 0x0F, 0x3F, 0xFE, 0x1E, 0xF0, 0x7E, 0x3D, 0x80, 0x7E, 0x7E,
  0x00, 0x7C, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0,
  0x01, 0xEF, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0xFC, 0x00, 0x7D, 0xF8, 0x01, 0xF3, 0xF8, 0x07, 0xE7, 0xBC, 0x1F, 0x8F,
  0x3F, 0xFE, 0x1E, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0x7E,
  0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x7E,
  0x0F, 0xC0, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xFC, 0x1E, 0x07, 0xFF, 0x1E,
  0x0F, 0xFF, 0x9E, 0x1F, 0x81, 0xDE, 0x3F, 0x00, 0xFE, 0x3E, 0x00, 0x7E,
  0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x3C, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0xFF, 0x1F, 0x83, 0xDF,
  0x0F, 0xFF, 0x9F, 0x07, 0xFF, 0x1F, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x3F, 0x81, 0xF0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x1F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x60, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x3C,
  0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x7E, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x7C, 0x7F, 0xFC, 0xF9,
  0xF8, 0x3D, 0xF7, 0xE0, 0x1F, 0xEF, 0x80, 0x1F, 0xDE, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xDF, 0x00, 0x3F, 0xBF, 0x00, 0xFF,
  0x3F, 0x07, 0xBE, 0x3F, 0xFE, 0x7C, 0x3F, 0xF8, 0xF8, 0x1F, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0xFC, 0x1F, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x07, 0xF0, 0x3C, 0x7F, 0xF0, 0xF3, 0xFF, 0xE3, 0xDE, 0x0F, 0xCF, 0x60,
  0x0F, 0xBF, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0xB0, 0x0F, 0xCF,
  0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x07, 0xEF, 0x80, 0x1F, 0x9F, 0x00, 0x7E, 0x3E,
  0x01, 0xF8, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0,
  0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xF9, 0xF0,
  0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC7,
  0xC0, 0x0F, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x7C, 0x39,
  0xFE, 0x3F, 0xCE, 0x7F, 0x9F, 0xF3, 0xB1, 0xF6, 0x3E, 0xE8, 0x3F, 0x07,
  0xBE, 0x0F, 0xC1, 0xEF, 0x83, 0xE0, 0x7B, 0xC0, 0xF8, 0x1E, 0xF0, 0x3E,
  0x07, 0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7F, 0xC0, 0xF8, 0x1F, 0xF0,
  0x3E, 0x07, 0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7F, 0xC0, 0xF8, 0x1F,
  0xF0, 0x3E, 0x07, 0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7F, 0xC0, 0xF8,
  0x1F, 0xF0, 0x3E, 0x07, 0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7F, 0xC0,
  0xF8, 0x1F, 0xF0, 0x3E, 0x07, 0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7F,
  0xC0, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xC7, 0xFF, 0x0F, 0x3F, 0xFF, 0x3D,
  0xE0, 0xFC, 0xF6, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x07, 0xBE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x07, 0xE1,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xE7, 0xC0,
  0x01, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x07, 0xE0, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xE3, 0xFF, 0x83, 0xCF, 0xFF, 0x87,
  0xBC, 0x1F, 0x8F, 0x60, 0x0F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF7, 0xC0, 0x01,
  0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x7C,
  0xFE, 0x01, 0xF9, 0xEF, 0x07, 0xE3, 0xCF, 0xFF, 0x87, 0x8F, 0xFE, 0x0F,
  0x07, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0x07,
  0xFF, 0x1F, 0x0F, 0xFF, 0x9F, 0x1F, 0x83, 0xDF, 0x3F, 0x00, 0xFF, 0x3E,
  0x00, 0x7F, 0x3C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x3C, 0x00, 0x7F, 0x3E, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x1F,
  0x83, 0xDF, 0x0F, 0xFF, 0x9F, 0x07, 0xFF, 0x1F, 0x01, 0xFC, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F,
  0xFE, 0xF1, 0xFF, 0xF7, 0x9F, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xF8, 0x0F, 0xC3, 0xE0, 0x07, 0xC7, 0x80, 0x07,
  0x9F, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE6, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xBC, 0x00, 0x1E, 0x7C, 0x00, 0x7C, 0x7E, 0x03, 0xF0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x83, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF8, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0x7E, 0x07, 0x7C,
  0xFF, 0xF9, 0xF1, 0xFF, 0xC7, 0xC1, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0x9E, 0x03, 0xE0, 0x3C, 0x78, 0x0F,
  0xC0, 0xF1, 0xF0, 0x7F, 0x03, 0xC7, 0xC1, 0xDC, 0x1F, 0x0F, 0x07, 0x70,
  0x7C, 0x3C, 0x3D, 0xE1, 0xE0, 0xF0, 0xF3, 0x87, 0x83, 0xC3, 0x8E, 0x1E,
  0x0F, 0x1E, 0x3C, 0x78, 0x3E, 0x78, 0xF3, 0xE0, 0x79, 0xC1, 0xCF, 0x81,
  0xEF, 0x07, 0xBC, 0x07, 0xBC, 0x1E, 0xF0, 0x1E, 0xE0, 0x3B, 0xC0, 0x7B,
  0x80, 0xEF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x1F,
  0x01, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x7C,
  0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xF0,
};

const GFXglyph LiberationMono_Regular52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 5, 34, 31, 13, -34 },
  { 23, 17, 16, 31, 7, -38 },
  { 57, 29, 34, 31, 1, -34 },
  { 181, 27, 41, 31, 2, -37 },
  { 320, 31, 36, 31, 0, -35 },
  { 460, 29, 35, 31, 1, -34 },
  { 587, 5, 16, 31, 13, -38 },
  { 597, 14, 49, 31, 9, -38 },
  { 683, 13, 49, 31, 9, -38 },
  { 763, 19, 18, 31, 6, -38 },
  { 806, 25, 26, 31, 3, -30 },
  { 888, 11, 17, 31, 7, -8 },
  { 912, 15, 4, 31, 8, -16 },
  { 920, 6, 8, 31, 13, -8 },
  { 926, 25, 39, 31, 3, -38 },
  { 1048, 25, 36, 31, 3, -35 },
  { 1161, 25, 34, 31, 4, -34 },
  { 1268, 24, 35, 31, 4, -35 },
  { 1373, 25, 36, 31, 3, -35 },
  { 1486, 26, 34, 31, 3, -34 },
  { 1597, 25, 35, 31, 3, -34 },
  { 1707, 24, 36, 31, 4, -35 },
  { 1815, 23, 34, 31, 4, -34 },
  { 1913, 25, 36, 31, 3, -35 },
  { 2026, 24, 36, 31, 4, -35 },
  { 2134, 6, 27, 31, 13, -27 },
  { 2155, 11, 36, 31, 9, -27 },
  { 2205, 25, 26, 31, 3, -30 },
  { 2287, 25, 17, 31, 3, -26 },
  { 2341, 25, 26, 31, 3, -30 },
  { 2423, 25, 35, 31, 2, -35 },
  { 2533, 29, 44, 31, 1, -38 },
  { 2693, 31, 34, 31, 0, -34 },
  { 2825, 25, 34, 31, 4, -34 },
  { 2932, 26, 36, 31, 3, -35 },
  { 3049, 25, 34, 31, 4, -34 },
  { 3156, 24, 34, 31, 4, -34 },
  { 3258, 23, 34, 31, 5, -34 },
  { 3356, 25, 36, 31, 3, -35 },
  { 3469, 23, 34, 31, 4, -34 },
  { 3567, 21, 34, 31, 5, -34 },
  { 3657, 21, 35, 31, 4, -34 },
  { 3749, 27, 34, 31, 4, -34 },
  { 3864, 22, 34, 31, 6, -34 },
  { 3958, 25, 34, 31, 3, -34 },
  { 4065, 23, 34, 31, 4, -34 },
  { 4163, 26, 36, 31, 3, -35 },
  { 4280, 24, 34, 31, 4, -34 },
  { 4382, 26, 45, 31, 3, -35 },
  { 4529, 26, 34, 31, 4, -34 },
  { 4640, 27, 36, 31, 2, -35 },
  { 4762, 27, 34, 31, 2, -34 },
  { 4877, 24, 35, 31, 4, -34 },
  { 4982, 31, 34, 31, 0, -34 },
  { 5114, 31, 34, 31, 0, -34 },
  { 5246, 29, 34, 31, 1, -34 },
  { 5370, 29, 34, 31, 1, -34 },
  { 5494, 27, 34, 31, 2, -34 },
  { 5609, 14, 49, 31, 10, -38 },
  { 5695, 25, 39, 31, 3, -38 },
  { 5817, 14, 49, 31, 7, -38 },
  { 5903, 25, 23, 31, 3, -34 },
  { 5975, 31, 2, 31, 0, 3 },
  { 5983, 11, 7, 31, 10, -38 },
  { 5993, 26, 29, 31, 3, -28 },
  { 6088, 23, 39, 31, 5, -38 },
  { 6201, 24, 29, 31, 3, -28 },
  { 6288, 24, 39, 31, 3, -38 },
  { 6405, 25, 29, 31, 3, -28 },
  { 6496, 25, 38, 31, 3, -38 },
  { 6615, 23, 39, 31, 4, -28 },
  { 6728, 22, 38, 31, 5, -38 },
  { 6833, 25, 38, 31, 4, -38 },
  { 6952, 18, 49, 31, 3, -38 },
  { 7063, 23, 38, 31, 6, -38 },
  { 7173, 25, 38, 31, 3, -38 },
  { 7292, 26, 28, 31, 3, -28 },
  { 7383, 22, 28, 31, 5, -28 },
  { 7460, 25, 29, 31, 3, -28 },
  { 7551, 23, 39, 31, 5, -28 },
  { 7664, 24, 39, 31, 3, -28 },
  { 7781, 21, 28, 31, 6, -28 },
  { 7855, 23, 29, 31, 4, -28 },
  { 7939, 21, 35, 31, 5, -34 },
  { 8031, 22, 28, 31, 5, -27 },
  { 8108, 27, 27, 31, 2, -27 },
  { 8200, 30, 27, 31, 1, -27 },
  { 8302, 27, 27, 31, 2, -27 },
  { 8394, 27, 38, 31, 2, -27 },
  { 8523, 23, 27, 31, 4, -27 },
  { 8601, 21, 49, 31, 6, -38 },
  { 8730, 5, 49, 31, 13, -38 },
  { 8761, 21, 49, 31, 4, -38 },
  { 8890, 25, 6, 31, 3, -20 },
};

const GFXfont LiberationMono_Regular52pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular52pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular52pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _LIBERATIONMONO_REGULAR52PT7B_H_
