#ifndef _LIBERATIONMONO_REGULAR48PT7B_H_
#define _LIBERATIONMONO_REGULAR48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x7B, 0xCE, 0x73,
  0x9C, 0xE7, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x7C, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78,
  0x1F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x78,
  0x0E, 0x78, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00,
  0xE0, 0x01, 0xC0, 0x38, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x0E,
  0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x06, 0x07,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x70, 0x0E,
  0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0,
  0x1C, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x18, 0x03, 0x80, 0x06, 0x00, 0xC0,
  0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFC, 0x73, 0xF8, 0x78, 0x38, 0x7C,
  0x7C, 0x1C, 0x1F, 0x3C, 0x0E, 0x07, 0x9E, 0x07, 0x03, 0x8F, 0x03, 0x80,
  0x07, 0x81, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xF8, 0x70, 0x00, 0x3F, 0x38,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xC7, 0xE0, 0x00, 0xE0, 0xF8, 0x00, 0x70, 0x3C, 0x00,
  0x38, 0x1F, 0x00, 0x1C, 0x07, 0x80, 0x0E, 0x03, 0xDC, 0x07, 0x01, 0xFE,
  0x03, 0x80, 0xFF, 0x01, 0xC0, 0xFF, 0xC0, 0xE0, 0x79, 0xF0, 0x70, 0x7C,
  0x7E, 0x38, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0xC0, 0x01, 0xE1, 0xFF, 0x00, 0x0E, 0x1F, 0xFC, 0x00, 0xE0,
  0xF0, 0xF0, 0x0F, 0x0F, 0x07, 0x80, 0x70, 0x78, 0x1C, 0x07, 0x03, 0xC0,
  0xE0, 0x78, 0x1C, 0x07, 0x07, 0x80, 0xF0, 0x38, 0x38, 0x07, 0x81, 0xC3,
  0xC0, 0x3C, 0x0E, 0x3C, 0x01, 0xE0, 0xF1, 0xC0, 0x07, 0x87, 0x9E, 0x00,
  0x3F, 0xF9, 0xE0, 0x00, 0xFF, 0x8E, 0x00, 0x01, 0xF8, 0xE0, 0x00, 0x00,
  0x0F, 0x1F, 0x80, 0x00, 0x73, 0xFF, 0x00, 0x07, 0x1F, 0xFC, 0x00, 0x79,
  0xE1, 0xE0, 0x03, 0x8E, 0x07, 0x00, 0x38, 0x70, 0x3C, 0x03, 0xC7, 0x81,
  0xE0, 0x1C, 0x3C, 0x0F, 0x01, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0,
  0xE0, 0x38, 0x1E, 0x0E, 0x01, 0xC0, 0xE0, 0xF0, 0x0F, 0x0F, 0x0F, 0x00,
  0x3F, 0xF0, 0x70, 0x00, 0xFF, 0x87, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0,
  0x07, 0x80, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x0F, 0x80, 0x01, 0xE7,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0x00,
  0x7F, 0x80, 0x78, 0x1F, 0xF0, 0x0F, 0x07, 0x8F, 0x01, 0xE1, 0xE1, 0xF0,
  0x38, 0x3C, 0x1E, 0x0F, 0x0F, 0x01, 0xE1, 0xE1, 0xE0, 0x1E, 0x38, 0x3C,
  0x03, 0xEF, 0x07, 0x80, 0x3F, 0xC0, 0xF0, 0x03, 0xF8, 0x1E, 0x00, 0x3F,
  0x01, 0xE0, 0x07, 0xE0, 0x3E, 0x01, 0xFE, 0x07, 0xE0, 0x7F, 0xF2, 0x7F,
  0xFF, 0x3F, 0xC3, 0xFF, 0xC3, 0xF8, 0x1F, 0xC0, 0x1E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xBC, 0xE7, 0x39, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x04, 0x1C, 0x17, 0x8E, 0x3B,
  0xF7, 0x7E, 0xFF, 0xFE, 0x0F, 0xF8, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xEE,
  0x00, 0xE7, 0x80, 0xF1, 0xC0, 0x70, 0xF0, 0x78, 0x38, 0x08, 0x08, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1C,
  0x0F, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xE0, 0x0F, 0x07, 0x80,
  0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xF0, 0x00,
  0x7B, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0x87,
  0xFC, 0x1F, 0x07, 0xF8, 0x3E, 0x0F, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8, 0x3F,
  0xC1, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0x9E,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF8, 0x00, 0xF0, 0xF0,
  0x03, 0xE1, 0xF0, 0x07, 0x81, 0xF8, 0x3E, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFB, 0xC0, 0x3F, 0xC7, 0x80,
  0x7C, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x3E,
  0x00, 0xF8, 0xF0, 0x01, 0xE7, 0xC0, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1F,
  0x3C, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x79, 0xF0, 0x01, 0xF3, 0xF0, 0x07,
  0xE3, 0xF0, 0x1F, 0x83, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0,
  0x03, 0xC0, 0xF0, 0x03, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0xF0,
  0x70, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC3, 0xF8, 0x07, 0x9F,
  0xFC, 0x0F, 0x7F, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x3D,
  0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xF3, 0xE0, 0x07, 0xC3, 0xF0, 0x3F, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0xF8, 0x1E, 0x01, 0xF0, 0xF0, 0x03,
  0xC7, 0xC0, 0x07, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x3F, 0x80, 0xF3, 0xFF, 0x83, 0xDF, 0xFF, 0x8F, 0xF0,
  0x7F, 0x3F, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x00, 0x07,
  0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x80,
  0x7C, 0x1F, 0x07, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xF8, 0x1F, 0x83,
  0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x78,
  0x00, 0x7C, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xE0,
  0x0F, 0x83, 0xE0, 0x7E, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x3E, 0x03, 0xE0, 0xF0, 0x03, 0xE3, 0xC0, 0x03, 0xE7, 0x80, 0x03,
  0xDF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xE0, 0x07, 0xE3, 0xF0, 0x1F, 0x83,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xE0, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x03,
  0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80,
  0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0xFC, 0xFE, 0x0F, 0xF1, 0xFF, 0xFB,
  0xC1, 0xFF, 0xCF, 0x01, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x38, 0x00, 0x79, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x80,
  0x78, 0x1F, 0x07, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0E,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0xCF, 0xC0, 0x0F, 0xDF, 0x00,
  0x0F, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC7, 0x81, 0xE0, 0x38, 0xE0,
  0xFE, 0x77, 0x1C, 0x3C, 0x6E, 0xE7, 0x0F, 0x0D, 0xCE, 0xE1, 0xC0, 0xF1,
  0xDC, 0x70, 0x1E, 0x3B, 0x8E, 0x03, 0xC7, 0xE3, 0xC0, 0x78, 0xFC, 0x70,
  0x0F, 0x1F, 0x8E, 0x01, 0xC3, 0xF1, 0xC0, 0x38, 0x7E, 0x38, 0x07, 0x0F,
  0xC7, 0x00, 0xE1, 0xF9, 0xE0, 0x3C, 0x37, 0x3C, 0x07, 0x06, 0xE3, 0x80,
  0xE1, 0xDC, 0x70, 0x3C, 0x3B, 0x8E, 0x07, 0x87, 0x71, 0xC0, 0xF0, 0xC7,
  0x38, 0x3E, 0x38, 0xE3, 0x8D, 0xCE, 0x1C, 0x7F, 0x1F, 0x83, 0xC3, 0xC1,
  0xE0, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x10, 0x0F,
  0x00, 0x07, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x81, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x3E, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xF8, 0x1E,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8, 0x78, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0x00, 0x3F, 0x1E, 0x00, 0x3F, 0x3C, 0x00, 0x3E,
  0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xE7,
  0x80, 0x0F, 0x8F, 0x00, 0x7E, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF1, 0xE0, 0x07, 0xF3, 0xC0, 0x01, 0xF7, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xF7, 0x80, 0x0F,
  0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0x81, 0xFC, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x78, 0x00, 0x18, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x08, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1E, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x7C, 0x1F, 0x81, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF0,
  0x1F, 0xE3, 0xC0, 0x0F, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF0, 0x00,
  0xFB, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0xCF,
  0x00, 0x3F, 0x3C, 0x03, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0x87, 0xC0, 0x0F, 0x9F, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x78, 0x00, 0x11, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xBE, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xF8, 0xFC, 0x07,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x80,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7B, 0xC0,
  0x1F, 0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x1F, 0x3F, 0x07, 0xE3, 0xFF,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xF0, 0x00, 0x7E, 0x78,
  0x00, 0x7E, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x3E, 0x07,
  0x80, 0x3E, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x1F, 0x00,
  0x78, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x1F, 0x00,
  0x07, 0x9F, 0x00, 0x03, 0xDF, 0xC0, 0x01, 0xEF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0x3E, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3F, 0x01, 0xE0, 0x0F, 0x80, 0xF0,
  0x03, 0xE0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7E, 0x1E, 0x00, 0x1F, 0x0F,
  0x00, 0x07, 0xC7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xFD, 0xE0, 0x00, 0x3E,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x77, 0xFB, 0x80, 0xEF, 0xF7, 0x83, 0xDF, 0xEF, 0x07,
  0x3F, 0xCE, 0x0E, 0x7F, 0x9E, 0x3C, 0xFF, 0x3C, 0x71, 0xFE, 0x38, 0xE3,
  0xFC, 0x7B, 0xC7, 0xF8, 0xF7, 0x0F, 0xF0, 0xEE, 0x1F, 0xE1, 0xFC, 0x3F,
  0xC1, 0xF0, 0x7F, 0x83, 0xE0, 0xFF, 0x07, 0xC1, 0xFE, 0x07, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xF7, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xF7, 0x80, 0x7F, 0xBC, 0x03, 0xFC, 0xF0, 0x1F, 0xE7, 0x80, 0xFF,
  0x1E, 0x07, 0xF8, 0xF0, 0x3F, 0xC3, 0xC1, 0xFE, 0x1E, 0x0F, 0xF0, 0x78,
  0x7F, 0x83, 0xC3, 0xFC, 0x1E, 0x1F, 0xE0, 0x78, 0xFF, 0x03, 0xC7, 0xF8,
  0x0F, 0x3F, 0xC0, 0x79, 0xFE, 0x01, 0xEF, 0xF0, 0x0F, 0x7F, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x7C, 0x1F, 0xC1, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xF0, 0x03, 0xFB, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xBC, 0x00, 0xFE,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1,
  0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1E,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xE7, 0x80, 0x01,
  0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF8, 0x00,
  0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xF8, 0x3F, 0x80,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xF0, 0x03, 0xF8, 0xF0, 0x00, 0xFC, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0,
  0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF0,
  0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x7E, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x3E, 0x00, 0x7E, 0x3C, 0x00, 0x3E, 0x3C,
  0x00, 0x1E, 0x7C, 0x00, 0x1C, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x30, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x3F, 0x7F, 0x80, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0x78, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x8F,
  0xC0, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7F,
  0x80, 0xF8, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C,
  0x78, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x3C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x07, 0xC0, 0x03,
  0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x0F, 0x03, 0xE0,
  0x78, 0x78, 0x1F, 0x03, 0xC3, 0xC0, 0xF8, 0x1E, 0x1E, 0x0F, 0xC0, 0xF0,
  0xF0, 0x77, 0x07, 0x87, 0x83, 0xB8, 0x78, 0x1E, 0x1D, 0xC3, 0xC0, 0xF1,
  0xEF, 0x1E, 0x07, 0x8E, 0x78, 0xF0, 0x3C, 0x71, 0xC7, 0x81, 0xE3, 0x8E,
  0x3C, 0x0F, 0x3C, 0x79, 0xC0, 0x79, 0xC3, 0xCE, 0x01, 0xCE, 0x0E, 0x70,
  0x0E, 0x70, 0x77, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x1F, 0x00,
  0x78, 0x01, 0xF0, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x03, 0xC0, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x78,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x1F, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x3C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0xC0, 0x7C, 0x00,
  0x78, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x70, 0x00,
  0x1C, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xC3, 0xC0, 0x07,
  0x83, 0x80, 0x0E, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x78, 0x0F, 0x00, 0xE0,
  0x1E, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x38, 0x3C, 0x00,
  0x78, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xEF, 0x00, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0x70, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x3F, 0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x7C,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0x00, 0xF0, 0x7C,
  0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF0,
  0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xF8, 0x7C,
  0x1E, 0x78, 0x7F, 0xFC, 0x7F, 0x3F, 0xF8, 0x7F, 0x0F, 0xE0, 0x1F, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE1, 0xFC, 0x0F, 0x9F, 0xFC, 0x3E, 0xFF, 0xF8, 0xFF, 0x83, 0xE3, 0xD8,
  0x07, 0xCF, 0xC0, 0x0F, 0x3F, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x01,
  0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80,
  0x07, 0xBE, 0x00, 0x1E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xCF, 0xE0, 0x1F,
  0x3D, 0xC0, 0xF8, 0xF3, 0xFF, 0xE3, 0xC7, 0xFE, 0x0F, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x3E,
  0x00, 0xF8, 0xF0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x03, 0xDF, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF8, 0x03,
  0xE1, 0xF8, 0x3F, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x0F, 0xE1, 0xE0, 0xFF, 0xE7, 0x87, 0xFF, 0xDE, 0x3F, 0x07, 0xF8,
  0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x78, 0x00, 0x79, 0xE0,
  0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x01,
  0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xE7,
  0x80, 0x07, 0x9E, 0x00, 0x3E, 0x78, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xE0,
  0x1F, 0x8F, 0xC1, 0xFE, 0x1F, 0xFF, 0x78, 0x3F, 0xF9, 0xE0, 0x3F, 0x87,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFC, 0x1F,
  0x83, 0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1F, 0x3C, 0x00, 0x1E,
  0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x01, 0x83, 0xC0,
  0x07, 0xC7, 0xC0, 0x1F, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x3C,
  0x3F, 0xF8, 0xF1, 0xFF, 0xF7, 0xCF, 0xC1, 0xFF, 0x3E, 0x01, 0xFD, 0xF0,
  0x07, 0xF7, 0xC0, 0x0F, 0xDE, 0x00, 0x3F, 0x78, 0x00, 0x7D, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80,
  0x07, 0xDE, 0x00, 0x3F, 0x7C, 0x01, 0xFC, 0xF8, 0x07, 0xF3, 0xF0, 0x7F,
  0xC7, 0xFF, 0xDF, 0x0F, 0xFE, 0x7C, 0x0F, 0xE1, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xE0, 0x0F, 0x87, 0xC0,
  0x3C, 0x1F, 0x83, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0x80,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC3, 0xF8, 0x3E, 0x7F, 0xF1, 0xF7, 0xFF, 0xCF, 0x78, 0x3E, 0x7B, 0x00,
  0xFB, 0xF0, 0x03, 0xDF, 0x80, 0x1E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC7, 0xFF,
  0xE3, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x40, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFC,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x01, 0xF0,
  0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF3, 0xE0,
  0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xDF,
  0x00, 0xF8, 0xF8, 0x0F, 0x07, 0x80, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF0,
  0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x03, 0xEF,
  0x00, 0x3E, 0xF0, 0x01, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF1, 0xE0,
  0x7C, 0xF3, 0xF1, 0xFE, 0xF7, 0xF9, 0xFE, 0xFE, 0x7B, 0x1F, 0xFC, 0x3F,
  0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x7F, 0x07, 0x8F, 0xFE, 0x3C, 0xFF, 0xF9,
  0xEF, 0x07, 0xCF, 0x60, 0x1F, 0x7E, 0x00, 0x7B, 0xF0, 0x03, 0xDF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFC, 0x1F,
  0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x1F, 0x00, 0x1F, 0x3C, 0x00, 0x1E,
  0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3D, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xE3, 0xC0,
  0x07, 0x87, 0xC0, 0x1F, 0x07, 0xE0, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x01, 0xFC, 0x00, 0xF0, 0x7F, 0x03, 0xC7, 0xFF, 0x0F, 0x3F, 0xFE,
  0x3F, 0xE0, 0xFC, 0xFE, 0x01, 0xF3, 0xF0, 0x03, 0xCF, 0xC0, 0x0F, 0xBE,
  0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1E,
  0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBF, 0x00, 0x3E, 0xFC,
  0x00, 0xF3, 0xF8, 0x07, 0xCF, 0xF0, 0x3E, 0x3E, 0xFF, 0xF8, 0xF9, 0xFF,
  0xC3, 0xE1, 0xFC, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x7C, 0x3F, 0xF9,
  0xF1, 0xFF, 0xF7, 0xCF, 0xC1, 0xFE, 0x3E, 0x01, 0xF9, 0xF0, 0x03, 0xE7,
  0x80, 0x0F, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80,
  0x07, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07,
  0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x9E,
  0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x77, 0x87, 0xFF,
  0xDE, 0x0F, 0xFE, 0x78, 0x0F, 0xE1, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0xF0, 0x3F,
  0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xF7, 0xBE, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7C, 0x07, 0xC7, 0xC0,
  0x1F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x79, 0xF8, 0x0F,
  0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x03,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03,
  0xF7, 0x80, 0x1F, 0xBE, 0x01, 0xBD, 0xF8, 0x3D, 0xE7, 0xFF, 0xCF, 0x1F,
  0xFC, 0x78, 0x3F, 0x83, 0xC0, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDE,
  0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3C,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x0F,
  0x80, 0x1F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xF1,
  0xE0, 0x00, 0x79, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x01, 0xE3, 0xC0, 0xF8, 0x1E, 0x3C, 0x0F, 0x81, 0xE3, 0xC1,
  0xF8, 0x1E, 0x3C, 0x1D, 0xC3, 0xE3, 0xC1, 0xDC, 0x3C, 0x1E, 0x3D, 0xC3,
  0xC1, 0xE3, 0x9E, 0x3C, 0x1E, 0x38, 0xE3, 0xC1, 0xE3, 0x8E, 0x3C, 0x1E,
  0x70, 0xE3, 0xC1, 0xE7, 0x07, 0x78, 0x0E, 0x70, 0x77, 0x80, 0xEF, 0x07,
  0x78, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x1F, 0x07, 0x80, 0x07, 0xC7, 0x80, 0x01,
  0xE7, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xF7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x03, 0xC0, 0x78, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0x3C, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE1,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x3F, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x00,
};

const GFXglyph LiberationMono_Regular48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 5, 32, 29, 12, -32 },
  { 21, 16, 15, 29, 6, -35 },
  { 51, 26, 32, 29, 1, -32 },
  { 155, 25, 39, 29, 2, -35 },
  { 277, 29, 32, 29, 0, -32 },
  { 393, 27, 32, 29, 1, -32 },
  { 501, 5, 15, 29, 12, -35 },
  { 511, 13, 45, 29, 8, -35 },
  { 585, 13, 45, 29, 8, -35 },
  { 659, 17, 17, 29, 6, -35 },
  { 696, 23, 23, 29, 3, -28 },
  { 763, 10, 16, 29, 6, -7 },
  { 783, 13, 4, 29, 8, -15 },
  { 790, 5, 7, 29, 12, -7 },
  { 795, 23, 35, 29, 3, -35 },
  { 896, 23, 32, 29, 3, -32 },
  { 988, 23, 32, 29, 3, -32 },
  { 1080, 22, 32, 29, 3, -32 },
  { 1168, 23, 32, 29, 3, -32 },
  { 1260, 24, 32, 29, 2, -32 },
  { 1356, 23, 32, 29, 3, -32 },
  { 1448, 22, 32, 29, 4, -32 },
  { 1536, 21, 32, 29, 4, -32 },
  { 1620, 23, 32, 29, 3, -32 },
  { 1712, 22, 32, 29, 3, -32 },
  { 1800, 5, 26, 29, 12, -26 },
  { 1817, 10, 35, 29, 8, -26 },
  { 1861, 23, 24, 29, 3, -28 },
  { 1930, 23, 16, 29, 3, -24 },
  { 1976, 23, 24, 29, 3, -28 },
  { 2045, 23, 32, 29, 2, -32 },
  { 2137, 27, 41, 29, 1, -35 },
  { 2276, 29, 32, 29, 0, -32 },
  { 2392, 23, 32, 29, 4, -32 },
  { 2484, 24, 32, 29, 3, -32 },
  { 2580, 22, 32, 29, 4, -32 },
  { 2668, 22, 32, 29, 4, -32 },
  { 2756, 20, 32, 29, 5, -32 },
  { 2836, 23, 32, 29, 3, -32 },
  { 2928, 21, 32, 29, 4, -32 },
  { 3012, 19, 32, 29, 5, -32 },
  { 3088, 19, 32, 29, 4, -32 },
  { 3164, 25, 32, 29, 4, -32 },
  { 3264, 20, 32, 29, 6, -32 },
  { 3344, 23, 32, 29, 3, -32 },
  { 3436, 21, 32, 29, 4, -32 },
  { 3520, 24, 32, 29, 2, -32 },
  { 3616, 22, 32, 29, 4, -32 },
  { 3704, 25, 41, 29, 2, -32 },
  { 3833, 24, 32, 29, 4, -32 },
  { 3929, 24, 32, 29, 2, -32 },
  { 4025, 25, 32, 29, 2, -32 },
  { 4125, 22, 32, 29, 3, -32 },
  { 4213, 29, 32, 29, 0, -32 },
  { 4329, 29, 32, 29, 0, -32 },
  { 4445, 27, 32, 29, 1, -32 },
  { 4553, 27, 32, 29, 1, -32 },
  { 4661, 25, 32, 29, 2, -32 },
  { 4761, 12, 45, 29, 10, -35 },
  { 4829, 23, 35, 29, 3, -35 },
  { 4930, 13, 45, 29, 6, -35 },
  { 5004, 23, 21, 29, 3, -32 },
  { 5065, 29, 2, 29, 0, 3 },
  { 5073, 10, 6, 29, 9, -34 },
  { 5081, 24, 26, 29, 3, -26 },
  { 5159, 22, 35, 29, 4, -35 },
  { 5256, 22, 26, 29, 3, -26 },
  { 5328, 22, 35, 29, 3, -35 },
  { 5425, 23, 26, 29, 3, -26 },
  { 5500, 23, 35, 29, 3, -35 },
  { 5601, 22, 36, 29, 3, -26 },
  { 5700, 21, 35, 29, 4, -35 },
  { 5792, 23, 35, 29, 3, -35 },
  { 5893, 17, 45, 29, 3, -35 },
  { 5989, 20, 35, 29, 6, -35 },
  { 6077, 23, 35, 29, 3, -35 },
  { 6178, 24, 26, 29, 2, -26 },
  { 6256, 21, 26, 29, 4, -26 },
  { 6325, 23, 26, 29, 3, -26 },
  { 6400, 22, 36, 29, 4, -26 },
  { 6499, 22, 36, 29, 3, -26 },
  { 6598, 19, 26, 29, 6, -26 },
  { 6660, 21, 26, 29, 4, -26 },
  { 6729, 20, 33, 29, 4, -33 },
  { 6812, 21, 26, 29, 4, -26 },
  { 6881, 25, 26, 29, 2, -26 },
  { 6963, 28, 26, 29, 0, -26 },
  { 7054, 25, 26, 29, 2, -26 },
  { 7136, 25, 36, 29, 2, -26 },
  { 7249, 22, 26, 29, 3, -26 },
  { 7321, 20, 45, 29, 5, -35 },
  { 7434, 4, 45, 29, 12, -35 },
  { 7457, 19, 45, 29, 4, -35 },
  { 7564, 23, 6, 29, 3, -19 },
};

const GFXfont LiberationMono_Regular48pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular48pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular48pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _LIBERATIONMONO_REGULAR48PT7B_H_
