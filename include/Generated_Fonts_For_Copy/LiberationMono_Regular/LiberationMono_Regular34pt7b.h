#ifndef _LIBERATIONMONO_REGULAR34PT7B_H_
#define _LIBERATIONMONO_REGULAR34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0x00, 0x7F, 0xC0, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1D, 0xC3, 0xB8, 0x77, 0x06, 0xE0, 0xDC, 0x1B,
  0x83, 0x00, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x08, 0x06,
  0x06, 0x01, 0x81, 0x87, 0xFF, 0xFD, 0xFF, 0xFF, 0x06, 0x0C, 0x03, 0x03,
  0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x08, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x60, 0x60, 0x18, 0x18, 0x06, 0x04, 0x01, 0x03, 0x00, 0xC0, 0xC0, 0x30,
  0x30, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F,
  0xE0, 0x1F, 0xFE, 0x0F, 0x33, 0xC7, 0x8C, 0x39, 0xC3, 0x0E, 0x70, 0xC1,
  0x9C, 0x30, 0x03, 0x8C, 0x00, 0xFB, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0D, 0xF0, 0x03, 0x1E, 0x00, 0xC1, 0xC0, 0x30, 0x76, 0x0C, 0x1F, 0x83,
  0x07, 0x70, 0xC1, 0xDE, 0x30, 0xF3, 0xCC, 0x78, 0x7F, 0xFC, 0x07, 0xFC,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x3E, 0x00, 0xE7, 0xF0, 0x0C,
  0xE3, 0x81, 0x8E, 0x18, 0x38, 0xC1, 0x83, 0x0C, 0x1C, 0x60, 0xC1, 0x8E,
  0x0E, 0x19, 0xC0, 0x63, 0x98, 0x07, 0xF3, 0x00, 0x3E, 0x70, 0x00, 0x06,
  0x7C, 0x00, 0xCF, 0xE0, 0x1D, 0xC7, 0x01, 0x9C, 0x30, 0x31, 0x83, 0x07,
  0x18, 0x30, 0xE1, 0x83, 0x0C, 0x1C, 0x31, 0x81, 0xC7, 0x38, 0x0F, 0xE3,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x38, 0x70, 0x0E, 0x06, 0x01,
  0xC0, 0xC0, 0x38, 0x18, 0x03, 0x07, 0x00, 0x63, 0xC0, 0x0F, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x0C, 0x3D, 0xC1, 0xC7, 0x38, 0x31, 0xC3, 0x86, 0x38,
  0x39, 0xC7, 0x07, 0x30, 0xE0, 0x7E, 0x1C, 0x07, 0x83, 0x80, 0xF8, 0x3C,
  0x3F, 0x93, 0xFF, 0x7E, 0x3F, 0x83, 0xC0, 0xFF, 0xF7, 0x77, 0x77, 0x76,
  0x60, 0x07, 0x07, 0x83, 0x83, 0x81, 0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0x78,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x3C,
  0x0E, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0,
  0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x83, 0xC1, 0xC1,
  0xC0, 0x06, 0x00, 0x60, 0x06, 0x04, 0x63, 0xF6, 0xF7, 0xFE, 0x0F, 0x00,
  0xF0, 0x1D, 0x81, 0x9C, 0x38, 0xC1, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x38, 0x70, 0x70, 0x70,
  0x60, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x3C, 0x3C, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3,
  0xC7, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x38,
  0x0E, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x01, 0xFC, 0x0F, 0xCE, 0x07, 0x87, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x07, 0xFF, 0xFB, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFC, 0x3C, 0x1E,
  0x78, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xF0, 0x1F, 0xFC, 0x3C, 0x1E, 0x78, 0x0E, 0x70, 0x0E,
  0x70, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0x70, 0x0F, 0x7C, 0x1E, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1B, 0x80, 0x1D, 0xC0, 0x1C, 0xE0, 0x1C,
  0x70, 0x0C, 0x38, 0x0E, 0x1C, 0x0E, 0x0E, 0x0E, 0x07, 0x06, 0x03, 0x86,
  0x01, 0xC7, 0x00, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x3F, 0xFE, 0x7F,
  0xFE, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x73, 0xF0, 0x7F, 0xFC, 0x7C, 0x3E, 0x70, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x0E, 0x3C,
  0x3E, 0x1F, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xFC, 0x1E, 0x1E, 0x3C,
  0x0E, 0x38, 0x0F, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x73, 0xF0, 0x77,
  0xFC, 0x6C, 0x1E, 0xF8, 0x0E, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70,
  0x07, 0x70, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x1E, 0x1E, 0x0F, 0xFC, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3C,
  0x1E, 0x70, 0x0E, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x3C,
  0x1C, 0x1F, 0xF8, 0x1F, 0xF8, 0x3C, 0x1E, 0x70, 0x0E, 0x70, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x0E, 0x3C, 0x1E, 0x1F,
  0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x3C, 0x78, 0x1E, 0x70,
  0x0E, 0x70, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x70,
  0x0F, 0x78, 0x0F, 0x3C, 0x3F, 0x1F, 0xF7, 0x0F, 0xC7, 0x00, 0x06, 0x00,
  0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x38, 0x1F, 0xF0, 0x0F, 0xE0, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x3C, 0x78, 0xF1, 0xE3,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x1E, 0x38, 0xF1,
  0xC3, 0x87, 0x1C, 0x38, 0x60, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x1F,
  0xFC, 0x7C, 0x1E, 0x70, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3C, 0x3C,
  0x0E, 0x01, 0xC3, 0x80, 0x18, 0x60, 0x03, 0x9C, 0x39, 0xB3, 0x1F, 0xB6,
  0x63, 0x1E, 0xDC, 0xE1, 0xCF, 0x18, 0x31, 0xE7, 0x06, 0x3C, 0xC0, 0xC7,
  0x98, 0x18, 0xF3, 0x03, 0x1E, 0x60, 0xE3, 0xCC, 0x18, 0xD9, 0x83, 0x1B,
  0x30, 0xE3, 0x66, 0x1C, 0x6C, 0xE7, 0x99, 0xCF, 0xBE, 0x18, 0xE3, 0x83,
  0x00, 0x00, 0x30, 0x01, 0x07, 0x00, 0xE0, 0x78, 0x38, 0x07, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1D, 0x80,
  0x01, 0xDC, 0x00, 0x39, 0xC0, 0x03, 0x8E, 0x00, 0x30, 0xE0, 0x07, 0x0E,
  0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x30, 0x0E, 0x03, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x70,
  0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0xFF,
  0xF8, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x78, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x3C, 0xE0,
  0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1E, 0xFF, 0xFC, 0xFF, 0xE0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x87,
  0x01, 0xC7, 0x00, 0x73, 0x80, 0x3B, 0xC0, 0x09, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x06, 0x70, 0x03, 0xBC, 0x03, 0x8E, 0x03, 0xC3, 0xC3, 0xC0,
  0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0x80, 0xFF, 0xE0, 0xE0, 0xF8, 0xE0, 0x3C,
  0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0xF8, 0xFF, 0xF0, 0xFF, 0x80,
  0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3C, 0x1E, 0x78, 0x0F, 0x70, 0x07,
  0x70, 0x06, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x07,
  0x70, 0x07, 0x38, 0x07, 0x1E, 0x0F, 0x0F, 0xFE, 0x07, 0xF0, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x81,
  0xDC, 0x0E, 0xF0, 0xE3, 0xFE, 0x07, 0xE0, 0xE0, 0x0F, 0x70, 0x0F, 0x38,
  0x0F, 0x1C, 0x0F, 0x0E, 0x0F, 0x07, 0x07, 0x03, 0x87, 0x01, 0xC7, 0x00,
  0xE7, 0x00, 0x77, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xBC, 0x07, 0x8F,
  0x03, 0x83, 0xC1, 0xC0, 0xE0, 0xE0, 0x78, 0x70, 0x1E, 0x38, 0x07, 0x9C,
  0x01, 0xCE, 0x00, 0xF7, 0x00, 0x3C, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC, 0x1B, 0xEC, 0x3B, 0xEE, 0x3B, 0xEE,
  0x33, 0xE6, 0x73, 0xE7, 0x63, 0xE7, 0x63, 0xE3, 0xE3, 0xE3, 0xC3, 0xE1,
  0xC3, 0xE1, 0xC3, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7D, 0xC0, 0xFB, 0x81, 0xF3, 0x03, 0xF7, 0x07, 0xE6, 0x0F, 0xCE, 0x1F,
  0x9C, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x39, 0xF8, 0x73, 0xF0, 0x77, 0xE0,
  0xEF, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xC0, 0x07,
  0xE0, 0x0F, 0xFC, 0x0F, 0x0F, 0x0F, 0x01, 0xC7, 0x00, 0xF7, 0x80, 0x3B,
  0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1D, 0xC0, 0x0E, 0xF0, 0x07, 0x38,
  0x07, 0x1E, 0x03, 0x87, 0x87, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xE0,
  0xFF, 0xF8, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0x0F,
  0x0F, 0x01, 0xC7, 0x00, 0xF7, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1D, 0xC0, 0x0E, 0xF0, 0x07, 0x38, 0x07, 0x1E, 0x03, 0x87, 0x87,
  0x81, 0xFF, 0x80, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0xFF, 0xE0, 0x7F, 0xFE, 0x38, 0x0F,
  0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0E, 0x1C, 0x07, 0x07, 0x03,
  0x83, 0xC1, 0xC0, 0xE0, 0xE0, 0x38, 0x70, 0x1E, 0x38, 0x07, 0x1C, 0x03,
  0xCE, 0x00, 0xF7, 0x00, 0x38, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xC0, 0xF0,
  0xE0, 0x1C, 0x78, 0x03, 0x9E, 0x00, 0xE7, 0x80, 0x00, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3D, 0x80, 0x07, 0xF0, 0x01, 0xDC, 0x00, 0xF7, 0x80, 0x38,
  0xF8, 0x3C, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x3C,
  0x1E, 0x1F, 0xFC, 0x0F, 0xF0, 0xF0, 0x00, 0x77, 0x00, 0x0F, 0x70, 0x00,
  0xE7, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0x80, 0x1C, 0x1C, 0x01, 0xC1, 0xC0,
  0x38, 0x1E, 0x03, 0x80, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00,
  0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0x77, 0x00, 0x07, 0x70, 0x00, 0xE7, 0x07, 0x0E, 0x70, 0xF0, 0xE3, 0x0F,
  0x0E, 0x38, 0xF8, 0xE3, 0x9D, 0x8E, 0x39, 0xD8, 0xC3, 0x99, 0xCC, 0x39,
  0x9D, 0xC3, 0xB8, 0xDC, 0x1B, 0x8D, 0xC1, 0xB0, 0xFC, 0x1B, 0x0F, 0x81,
  0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x70, 0x03, 0xCF, 0x00, 0x70,
  0xE0, 0x1C, 0x0E, 0x07, 0x81, 0xE0, 0xE0, 0x1C, 0x38, 0x01, 0xCF, 0x00,
  0x3D, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0x70, 0x01, 0xCF, 0x00, 0x70, 0xE0, 0x1E, 0x0E, 0x03,
  0x81, 0xE0, 0xE0, 0x1C, 0x3C, 0x01, 0xC7, 0x00, 0x3D, 0xC0, 0x03, 0x80,
  0xE0, 0x01, 0xCE, 0x00, 0x79, 0xE0, 0x0E, 0x1C, 0x03, 0x81, 0xC0, 0xF0,
  0x3C, 0x1C, 0x03, 0x87, 0x00, 0x39, 0xE0, 0x07, 0xB8, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x06,
  0x60, 0x06, 0x70, 0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x18, 0x18, 0x18, 0x38,
  0x1C, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x70, 0x70, 0x0F, 0xE0, 0x0F, 0xFC,
  0x0F, 0x0F, 0x0E, 0x03, 0x87, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x1F,
  0xFC, 0x3F, 0xFE, 0x3C, 0x07, 0x3C, 0x03, 0x9C, 0x03, 0xCE, 0x01, 0xE7,
  0x00, 0xF3, 0xC0, 0xB8, 0xE1, 0xDC, 0x7F, 0xCF, 0x8F, 0x83, 0xC0, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x71, 0xF0, 0xEF, 0xF9, 0xF8, 0x7B, 0xC0, 0x77, 0x80, 0xFE, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0x01, 0xFE, 0x03, 0xBE, 0x0F, 0x77, 0xFC, 0xE3, 0xE0, 0x07, 0xF0,
  0x1F, 0xF8, 0x3C, 0x1C, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x07,
  0x70, 0x0F, 0x78, 0x0E, 0x3C, 0x1C, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x87,
  0xE7, 0x1F, 0xEE, 0x78, 0x7D, 0xE0, 0x7B, 0x80, 0x77, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3B, 0x80, 0x77,
  0x00, 0xEE, 0x03, 0xCF, 0x0F, 0x9F, 0xF7, 0x0F, 0xC6, 0x07, 0xE0, 0x1F,
  0xF8, 0x3C, 0x1C, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70,
  0x06, 0x78, 0x0E, 0x3C, 0x1E, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x03,
  0xFF, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0xC6, 0x1F, 0xE6, 0x3C, 0x3E, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x3C, 0x3E, 0x3F, 0xEE, 0x0F, 0x8E, 0x00,
  0x0E, 0x00, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x3C, 0x3C, 0x1F, 0xF8, 0x07,
  0xF0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0xF8, 0xEF, 0xFB, 0xB0, 0xFF, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1C, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E,
  0xFF, 0xCF, 0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x1E, 0xE0, 0x79, 0xC0, 0xE3, 0x83, 0x87,
  0x0E, 0x0E, 0x38, 0x1C, 0xE0, 0x3B, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xE7,
  0x03, 0x8F, 0x07, 0x0F, 0x0E, 0x0E, 0x1C, 0x0E, 0x38, 0x1E, 0x70, 0x1E,
  0xE0, 0x1C, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xCF, 0x1E, 0x6F, 0x9F,
  0xB4, 0xF9, 0xDC, 0x78, 0x6E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3,
  0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x3F,
  0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xC0, 0xE3,
  0xF3, 0xBF, 0xEE, 0xC3, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x70, 0x07, 0xF0, 0x1F, 0xF8, 0x3C,
  0x1C, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x78,
  0x0E, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0xE3, 0xE1, 0xDF, 0xF3, 0xB0,
  0xF7, 0x80, 0xEF, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0x7C,
  0x1E, 0xEF, 0xF9, 0xC7, 0xC3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0F, 0xCE, 0x3F, 0xDC, 0xF0, 0xFB,
  0xC0, 0xF7, 0x00, 0xEE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x77, 0x00, 0xEE, 0x01, 0xDE, 0x07, 0x9E, 0x1F,
  0x1F, 0xEE, 0x1F, 0x9C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0xE1, 0xFF, 0x1F, 0xD9, 0xFE, 0xFC, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0F,
  0xE0, 0x7F, 0xE1, 0xE0, 0xE3, 0x80, 0xEE, 0x01, 0xCC, 0x00, 0x1E, 0x00,
  0x3F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0x38, 0x1E, 0x7F, 0xF8, 0x3F, 0xC0, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x03, 0xFF, 0xEF, 0xFF, 0x87, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3F, 0xF0,
  0x7F, 0x80, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x00, 0xEE, 0x01, 0xDC,
  0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x00,
  0xEE, 0x01, 0xDC, 0x03, 0xBC, 0x0F, 0x38, 0x36, 0x7F, 0xCC, 0x3F, 0x18,
  0xF0, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x0F,
  0x01, 0xC1, 0xC0, 0xF0, 0x70, 0x38, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0xE1,
  0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x00, 0xCE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0x77, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x0F, 0x0E, 0x70, 0xF0, 0xE3, 0x0F,
  0x8E, 0x39, 0xD8, 0xE3, 0x99, 0x8C, 0x39, 0x99, 0xC3, 0x98, 0xDC, 0x3B,
  0x8D, 0xC1, 0xB0, 0xDC, 0x1B, 0x0F, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0xF0, 0x07, 0x38, 0x07, 0x0E, 0x07, 0x87, 0x83, 0x81, 0xC3,
  0x80, 0x73, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF8, 0x01, 0xCE, 0x00, 0xE7, 0x80, 0xE1, 0xC0, 0xE0, 0x70, 0xF0, 0x1C,
  0x70, 0x0F, 0x70, 0x03, 0x80, 0xE0, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x38,
  0xE0, 0x0E, 0x38, 0x07, 0x0F, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x38, 0x0E,
  0x0E, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x03, 0x38, 0x00, 0xEE,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x3C,
  0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFC, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x0F, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0xF0, 0x7F,
  0xE0, 0x07, 0xC0,
};

const GFXglyph LiberationMono_Regular34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 3, 22, 20, 9, -22 },
  { 10, 11, 11, 20, 5, -25 },
  { 26, 18, 22, 20, 1, -22 },
  { 76, 18, 28, 20, 1, -25 },
  { 139, 20, 22, 20, 0, -22 },
  { 194, 19, 22, 20, 1, -22 },
  { 247, 4, 11, 20, 8, -25 },
  { 253, 9, 32, 20, 6, -25 },
  { 289, 9, 32, 20, 6, -25 },
  { 325, 12, 12, 20, 4, -25 },
  { 343, 16, 16, 20, 2, -20 },
  { 375, 8, 11, 20, 4, -5 },
  { 386, 9, 3, 20, 6, -10 },
  { 390, 4, 5, 20, 8, -5 },
  { 393, 16, 25, 20, 2, -25 },
  { 443, 16, 22, 20, 2, -22 },
  { 487, 17, 22, 20, 2, -22 },
  { 534, 16, 22, 20, 2, -22 },
  { 578, 16, 22, 20, 2, -22 },
  { 622, 17, 22, 20, 2, -22 },
  { 669, 16, 22, 20, 2, -22 },
  { 713, 16, 22, 20, 2, -22 },
  { 757, 15, 22, 20, 3, -22 },
  { 799, 16, 22, 20, 2, -22 },
  { 843, 16, 22, 20, 2, -22 },
  { 887, 4, 18, 20, 8, -18 },
  { 896, 7, 24, 20, 6, -18 },
  { 917, 16, 17, 20, 2, -20 },
  { 951, 16, 10, 20, 2, -17 },
  { 971, 16, 17, 20, 2, -20 },
  { 1005, 16, 22, 20, 2, -22 },
  { 1049, 19, 29, 20, 1, -25 },
  { 1118, 20, 22, 20, 0, -22 },
  { 1173, 16, 22, 20, 3, -22 },
  { 1217, 17, 22, 20, 2, -22 },
  { 1264, 16, 22, 20, 3, -22 },
  { 1308, 16, 22, 20, 3, -22 },
  { 1352, 15, 22, 20, 3, -22 },
  { 1394, 16, 22, 20, 2, -22 },
  { 1438, 15, 22, 20, 3, -22 },
  { 1480, 14, 22, 20, 3, -22 },
  { 1519, 13, 22, 20, 3, -22 },
  { 1555, 17, 22, 20, 3, -22 },
  { 1602, 14, 22, 20, 4, -22 },
  { 1641, 16, 22, 20, 2, -22 },
  { 1685, 15, 22, 20, 3, -22 },
  { 1727, 17, 22, 20, 2, -22 },
  { 1774, 16, 22, 20, 3, -22 },
  { 1818, 17, 28, 20, 2, -22 },
  { 1878, 17, 22, 20, 3, -22 },
  { 1925, 18, 22, 20, 1, -22 },
  { 1975, 18, 22, 20, 1, -22 },
  { 2025, 16, 22, 20, 2, -22 },
  { 2069, 20, 22, 20, 0, -22 },
  { 2124, 20, 22, 20, 0, -22 },
  { 2179, 19, 22, 20, 1, -22 },
  { 2232, 19, 22, 20, 1, -22 },
  { 2285, 18, 22, 20, 1, -22 },
  { 2335, 9, 32, 20, 7, -25 },
  { 2371, 17, 25, 20, 2, -25 },
  { 2425, 10, 32, 20, 4, -25 },
  { 2465, 16, 15, 20, 2, -22 },
  { 2495, 20, 2, 20, 0, 2 },
  { 2500, 7, 4, 20, 7, -24 },
  { 2504, 17, 18, 20, 2, -18 },
  { 2543, 15, 25, 20, 3, -25 },
  { 2590, 16, 18, 20, 2, -18 },
  { 2626, 15, 25, 20, 2, -25 },
  { 2673, 16, 18, 20, 2, -18 },
  { 2709, 16, 25, 20, 2, -25 },
  { 2759, 16, 25, 20, 2, -18 },
  { 2809, 14, 25, 20, 3, -25 },
  { 2853, 17, 25, 20, 2, -25 },
  { 2907, 12, 32, 20, 2, -25 },
  { 2955, 15, 25, 20, 4, -25 },
  { 3002, 17, 25, 20, 2, -25 },
  { 3056, 17, 18, 20, 2, -18 },
  { 3095, 14, 18, 20, 3, -18 },
  { 3127, 16, 18, 20, 2, -18 },
  { 3163, 15, 25, 20, 3, -18 },
  { 3210, 15, 25, 20, 2, -18 },
  { 3257, 13, 18, 20, 4, -18 },
  { 3287, 15, 18, 20, 3, -18 },
  { 3321, 14, 23, 20, 3, -23 },
  { 3362, 15, 18, 20, 3, -18 },
  { 3396, 18, 18, 20, 1, -18 },
  { 3437, 20, 18, 20, 0, -18 },
  { 3482, 17, 18, 20, 2, -18 },
  { 3521, 18, 25, 20, 1, -18 },
  { 3578, 16, 18, 20, 2, -18 },
  { 3614, 14, 32, 20, 4, -25 },
  { 3670, 3, 32, 20, 9, -25 },
  { 3682, 14, 32, 20, 3, -25 },
  { 3738, 17, 4, 20, 2, -13 },
};

const GFXfont LiberationMono_Regular34pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular34pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular34pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _LIBERATIONMONO_REGULAR34PT7B_H_
