#ifndef _LIBERATIONMONO_REGULAR54PT7B_H_
#define _LIBERATIONMONO_REGULAR54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3F, 0x7C, 0x0F, 0xDF,
  0x03, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xE7, 0xC0,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x07, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0x80, 0x00, 0xE0,
  0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0x80, 0x01, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0xE0, 0x00,
  0x38, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00,
  0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0,
  0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFC, 0x71, 0xFC, 0x3F, 0x07,
  0x07, 0xE3, 0xE0, 0x70, 0x3E, 0x7C, 0x07, 0x03, 0xE7, 0xC0, 0x70, 0x1C,
  0x7C, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xE0,
  0x70, 0x00, 0x1F, 0x07, 0x00, 0x01, 0xFE, 0x70, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x71, 0xFE, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x70,
  0x1F, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x00, 0xF3,
  0x00, 0x70, 0x0F, 0xF8, 0x07, 0x00, 0xFF, 0x80, 0x70, 0x1F, 0x7C, 0x07,
  0x01, 0xF7, 0xE0, 0x70, 0x3E, 0x3F, 0x87, 0x1F, 0xE1, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x3F, 0xF8, 0x00,
  0x38, 0x7C, 0x3C, 0x00, 0x78, 0x78, 0x3E, 0x00, 0xF0, 0xF0, 0x1E, 0x01,
  0xE0, 0xF0, 0x1E, 0x01, 0xE0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x1E, 0x1E,
  0x00, 0xF0, 0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x78,
  0x00, 0x3F, 0xF8, 0x78, 0x00, 0x1F, 0xF0, 0xF0, 0x00, 0x0F, 0xE1, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x83,
  0xF0, 0x00, 0x07, 0x0F, 0xFC, 0x00, 0x0F, 0x1F, 0xFE, 0x00, 0x1E, 0x3E,
  0x1E, 0x00, 0x1C, 0x3C, 0x0F, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x78, 0x78,
  0x0F, 0x00, 0xF0, 0x78, 0x07, 0x00, 0xF0, 0x78, 0x07, 0x01, 0xE0, 0x78,
  0x07, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x07, 0x80, 0x3C,
  0x0F, 0x0F, 0x00, 0x3C, 0x0F, 0x0F, 0x00, 0x3E, 0x1E, 0x1E, 0x00, 0x1F,
  0xFE, 0x3C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xE1, 0xF8, 0x00, 0x07, 0xBF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x01,
  0x80, 0x1F, 0xE0, 0x07, 0x81, 0xFF, 0xC0, 0x1E, 0x07, 0xCF, 0x00, 0x78,
  0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x7C, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x1E,
  0x03, 0xE0, 0xF0, 0xF8, 0x07, 0xC7, 0x83, 0xE0, 0x0F, 0x9E, 0x0F, 0x80,
  0x3E, 0xF8, 0x3E, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0xFF, 0x03, 0xE0, 0x01,
  0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0xE0, 0x3F, 0x03, 0xFF,
  0xFC, 0xFF, 0xFF, 0xDF, 0xF1, 0xFF, 0xFE, 0x3F, 0xC1, 0xFF, 0xE0, 0x7F,
  0x01, 0xFE, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x81, 0xC1, 0xBC, 0x38, 0xF7,
  0xF7, 0xFE, 0xFF, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0x80, 0x01, 0xF8, 0x00,
  0x7F, 0x80, 0x0E, 0x78, 0x03, 0xCF, 0x00, 0xF0, 0xF0, 0x3E, 0x0F, 0x03,
  0x81, 0xE0, 0x20, 0x10, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1,
  0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x0F, 0x83, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x9F,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0xDE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x3F,
  0x07, 0xFE, 0x0F, 0xC1, 0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8,
  0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0x78, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x79, 0xF0, 0x00,
  0x3E, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFB, 0xC0, 0x0F, 0xFC, 0xF0, 0x03, 0xFE, 0x3C, 0x00,
  0xFE, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0xE3, 0xF0,
  0x03, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3E, 0x3F,
  0x00, 0x1F, 0x87, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1E,
  0x7C, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x1E, 0x03,
  0xE0, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F,
  0x00, 0x3E, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x1F,
  0x07, 0x80, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x0F, 0xF0, 0x03, 0xCF, 0xFF, 0x00, 0xF7, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0,
  0x01, 0xF9, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFC,
  0x0F, 0xE0, 0xFC, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC1, 0xFC, 0x03, 0xE3, 0xFF, 0xC1, 0xF3, 0xFF, 0xF0,
  0xFB, 0xFF, 0xFC, 0x7F, 0xE0, 0xFF, 0x3F, 0xC0, 0x1F, 0x9F, 0xC0, 0x07,
  0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0,
  0xFE, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x3F, 0x03,
  0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xF0, 0x1F, 0xC1,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x03, 0xF8, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xF0, 0x01, 0xF9, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xDF, 0x00, 0x0F,
  0xEF, 0xC0, 0x0F, 0xF3, 0xF8, 0x1F, 0xF8, 0xFF, 0xFF, 0x7C, 0x3F, 0xFF,
  0x3C, 0x0F, 0xFE, 0x1E, 0x01, 0xFC, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xC0, 0x7F, 0x8F, 0xC0, 0x07, 0xE3, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x01, 0xE1, 0xC0, 0x7C, 0x03, 0x8F, 0x03, 0xF8, 0xEF, 0x38, 0x1F, 0xF7,
  0xBC, 0xE0, 0xF0, 0xFC, 0x77, 0x87, 0x81, 0xF1, 0xDE, 0x1C, 0x07, 0xC7,
  0x70, 0xF0, 0x1F, 0x1D, 0xC3, 0x80, 0x78, 0x77, 0x1E, 0x01, 0xE1, 0xFC,
  0x78, 0x07, 0x87, 0xF1, 0xC0, 0x1E, 0x1F, 0xC7, 0x00, 0x78, 0x7F, 0x3C,
  0x01, 0xC1, 0xF8, 0xF0, 0x07, 0x07, 0xE3, 0xC0, 0x3C, 0x1F, 0x8F, 0x00,
  0xF0, 0x7F, 0x3C, 0x03, 0xC3, 0xFC, 0xF0, 0x0E, 0x0E, 0xF1, 0xC0, 0x78,
  0x3B, 0xC7, 0x03, 0xE1, 0xE7, 0x1E, 0x0D, 0x87, 0x1C, 0x78, 0x76, 0x3C,
  0x70, 0xFF, 0x9F, 0xE1, 0xE1, 0xFC, 0x7F, 0x03, 0x83, 0xE0, 0xF8, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x08, 0x03, 0xC0, 0x00, 0x70, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0xF8, 0x01, 0xFE, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF3,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F, 0x80,
  0x1F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC3, 0xE0, 0x03, 0xFC, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFB, 0xE0, 0x01, 0xFE, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0xFE, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x08, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x04, 0x3E, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0xC0,
  0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xF8, 0x07, 0xF8, 0x3E,
  0x00, 0x7F, 0x0F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC3,
  0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x07, 0xE3, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0x87, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0xC0, 0x0F,
  0xC3, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xCE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0xC0, 0x7E, 0x3F, 0x07, 0xE1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE0,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8,
  0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xF9, 0xFC, 0x00, 0x0F, 0xBF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFB, 0xF0, 0x00, 0xFF, 0x1F, 0x80, 0x0F,
  0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0,
  0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80,
  0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xBF, 0xFE,
  0x01, 0xEF, 0xFB, 0xC0, 0x7B, 0xFE, 0xF0, 0x3C, 0xFF, 0xBE, 0x0F, 0x3F,
  0xE7, 0x83, 0xCF, 0xF9, 0xE1, 0xE3, 0xFE, 0x7C, 0x78, 0xFF, 0x8F, 0x1E,
  0x3F, 0xE3, 0xCF, 0x0F, 0xF8, 0x7B, 0xC3, 0xFE, 0x1E, 0xE0, 0xFF, 0x87,
  0xF8, 0x3F, 0xE0, 0xFE, 0x0F, 0xF8, 0x3F, 0x03, 0xFE, 0x0F, 0xC0, 0xFF,
  0x81, 0xF0, 0x3F, 0xE0, 0x78, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xF7, 0x80, 0x0F, 0xF7, 0xC0, 0x0F, 0xFB, 0xC0, 0x0F,
  0xFB, 0xC0, 0x0F, 0xFB, 0xE0, 0x0F, 0xF9, 0xE0, 0x0F, 0xF9, 0xF0, 0x0F,
  0xF8, 0xF0, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0x78, 0x0F, 0xF8, 0x7C, 0x0F,
  0xF8, 0x3C, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x1E, 0x0F, 0xF8, 0x1F, 0x0F,
  0xF8, 0x1F, 0x0F, 0xF8, 0x0F, 0x0F, 0xF8, 0x0F, 0x8F, 0xF8, 0x07, 0x8F,
  0xF8, 0x07, 0xCF, 0xF8, 0x03, 0xCF, 0xF8, 0x03, 0xEF, 0xF8, 0x01, 0xEF,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFE,
  0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x7E, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0xFB, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xF8, 0xFC,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x3F,
  0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0xFF, 0x3E, 0x00,
  0x0F, 0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x3F, 0x3E, 0x00, 0x7F, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0x80, 0x0F, 0xF1, 0xF0,
  0x00, 0x7F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F,
  0x9F, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF8,
  0xF8, 0x00, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x07,
  0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0,
  0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E,
  0x3E, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x38, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E,
  0x7F, 0x00, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3E, 0x3C, 0x03, 0xE0, 0x3E, 0x3E,
  0x03, 0xE0, 0x3C, 0x3E, 0x07, 0xE0, 0x3C, 0x3E, 0x07, 0xE0, 0x3C, 0x3E,
  0x07, 0xF0, 0x7C, 0x1E, 0x0F, 0xF0, 0x7C, 0x1E, 0x0F, 0x70, 0x7C, 0x1E,
  0x0F, 0x78, 0x7C, 0x1E, 0x0E, 0x78, 0x78, 0x1F, 0x1E, 0x78, 0x78, 0x1F,
  0x1E, 0x38, 0x78, 0x1F, 0x1E, 0x3C, 0x78, 0x0F, 0x1C, 0x3C, 0x78, 0x0F,
  0x3C, 0x3C, 0xF8, 0x0F, 0x3C, 0x1C, 0xF0, 0x0F, 0x3C, 0x1E, 0xF0, 0x0F,
  0x38, 0x1E, 0xF0, 0x0F, 0x78, 0x1E, 0xF0, 0x07, 0xF8, 0x0E, 0xF0, 0x07,
  0xF8, 0x0E, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x3F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x03, 0xC0,
  0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0x80, 0x78, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xC0, 0x1E, 0x07, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0xC0,
  0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7E,
  0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0xFE, 0x07, 0xC0, 0x1D, 0xF0, 0x7F,
  0x07, 0xDF, 0x03, 0xFF, 0xF9, 0xFF, 0x3F, 0xFF, 0x1F, 0xF1, 0xFF, 0xE0,
  0xFF, 0x07, 0xF8, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0xF8,
  0xFF, 0xE0, 0xFB, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFF, 0x81, 0xFC, 0xFF,
  0x00, 0xFC, 0xFE, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x7C, 0xFE,
  0x00, 0xFC, 0xFF, 0x81, 0xF8, 0xFF, 0xFF, 0xF8, 0xF3, 0xFF, 0xF0, 0xF1,
  0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xF0, 0xF8, 0x01, 0xF8,
  0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xFC, 0x1F,
  0x07, 0xFF, 0x1F, 0x1F, 0xFF, 0x9F, 0x3F, 0xFF, 0xDF, 0x3F, 0x83, 0xFF,
  0x7E, 0x00, 0xFF, 0x7C, 0x00, 0x7F, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7C, 0x00, 0x7F,
  0x7E, 0x00, 0xFF, 0x3F, 0x83, 0xDF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F,
  0x0F, 0xFF, 0x1F, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xE0, 0xFE, 0x07, 0xE0,
  0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x07,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x18,
  0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x07, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x1F, 0x1F, 0xFF, 0x9F, 0x3F, 0xFF,
  0xDF, 0x3F, 0x83, 0xDF, 0x7E, 0x00, 0xFF, 0x7C, 0x00, 0x7F, 0x7C, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7C, 0x00,
  0x7F, 0x7E, 0x00, 0xFF, 0x3F, 0x03, 0xDF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF,
  0x9F, 0x0F, 0xFE, 0x1F, 0x03, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x00,
  0x7C, 0x1F, 0xC1, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x7F, 0x03, 0xE3, 0xFF, 0x87,
  0xCF, 0xFF, 0x8F, 0xBF, 0xFF, 0x9E, 0xF8, 0x3F, 0xBF, 0xC0, 0x3F, 0x7F,
  0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xFD, 0x80, 0x7F, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC,
  0x07, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0,
  0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x7C, 0x00,
  0xFC, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xF0, 0x3E, 0x1E, 0x7F, 0x0F, 0xF3, 0xDF, 0xF3, 0xFE,
  0x7F, 0xFE, 0xFF, 0xEF, 0xE3, 0xDC, 0x7D, 0xF8, 0x7F, 0x0F, 0xBE, 0x07,
  0xC0, 0xF7, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7F,
  0xC0, 0x7C, 0x0F, 0xF8, 0x0F, 0x01, 0xFF, 0x01, 0xE0, 0x3F, 0xE0, 0x3C,
  0x07, 0xFC, 0x07, 0x80, 0xFF, 0x80, 0xF0, 0x1F, 0xF0, 0x1E, 0x03, 0xFE,
  0x03, 0xC0, 0x7F, 0xC0, 0x78, 0x0F, 0xF8, 0x0F, 0x01, 0xFF, 0x01, 0xE0,
  0x3F, 0xE0, 0x3C, 0x07, 0xFC, 0x07, 0x80, 0xFF, 0x80, 0xF0, 0x1F, 0xF0,
  0x1E, 0x03, 0xFE, 0x03, 0xC0, 0x7F, 0xC0, 0x78, 0x0F, 0xF8, 0x0F, 0x01,
  0xFF, 0x01, 0xE0, 0x3F, 0xE0, 0x3C, 0x07, 0xC0, 0x00, 0x3F, 0x81, 0xE1,
  0xFF, 0xC3, 0xC7, 0xFF, 0xC7, 0x9F, 0xFF, 0xCF, 0x7C, 0x1F, 0xDF, 0xE0,
  0x1F, 0xBF, 0x80, 0x1F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFD, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x0F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xF0, 0xFF, 0xE0, 0xF1, 0xFF,
  0xF0, 0xFB, 0xFF, 0xF8, 0xFF, 0x81, 0xFC, 0xFF, 0x00, 0xFC, 0xFE, 0x00,
  0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x7C, 0xFE, 0x00, 0xFC, 0xFF, 0x81,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFB, 0xFF, 0xF0, 0xF9, 0xFF, 0xE0, 0xF8, 0x3F,
  0x80, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0x07, 0xFF,
  0x1F, 0x1F, 0xFF, 0x9F, 0x3F, 0xFF, 0xDF, 0x3F, 0x83, 0xFF, 0x7E, 0x00,
  0xFF, 0x7C, 0x00, 0x7F, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7C, 0x00, 0x7F, 0x7E, 0x00,
  0xFF, 0x3F, 0x83, 0xDF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F, 0x0F, 0xFF,
  0x1F, 0x03, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0xFF, 0xE0, 0xFF, 0xF7, 0x87, 0xFF, 0xDF, 0x3F, 0xFF, 0x7C, 0xF8, 0x05,
  0xF7, 0x80, 0x07, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0x80, 0xFE,
  0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0x7F, 0x00, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x83, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x0C, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xE0,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFE,
  0xFC, 0x0F, 0x7D, 0xFF, 0xFE, 0xF9, 0xFF, 0xF9, 0xF1, 0xFF, 0xE3, 0xE0,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F,
  0x9E, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3E, 0x7C, 0x0F, 0xC0, 0x78,
  0xF8, 0x1F, 0x80, 0xF1, 0xF0, 0x3F, 0x83, 0xE3, 0xE0, 0x7F, 0x07, 0xC3,
  0xC1, 0xEE, 0x0F, 0x87, 0x83, 0xDC, 0x1F, 0x0F, 0x07, 0x3C, 0x3C, 0x1F,
  0x1E, 0x78, 0x78, 0x3E, 0x3C, 0x70, 0xF0, 0x7C, 0x70, 0xF3, 0xE0, 0x79,
  0xE1, 0xE7, 0xC0, 0xF3, 0xC1, 0xCF, 0x01, 0xE7, 0x03, 0x9E, 0x03, 0xDE,
  0x07, 0xBC, 0x07, 0xBC, 0x07, 0x78, 0x0F, 0x70, 0x0E, 0xF0, 0x0F, 0xE0,
  0x1D, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xC0, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7C,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xE0, 0x01,
  0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0x80,
};

const GFXglyph LiberationMono_Regular54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 5, 36, 32, 14, -36 },
  { 24, 18, 17, 32, 7, -39 },
  { 63, 30, 36, 32, 1, -36 },
  { 198, 28, 43, 32, 2, -39 },
  { 349, 32, 38, 32, 0, -37 },
  { 501, 30, 37, 32, 1, -36 },
  { 640, 6, 17, 32, 13, -39 },
  { 653, 15, 50, 32, 9, -39 },
  { 747, 14, 50, 32, 9, -39 },
  { 835, 19, 19, 32, 7, -39 },
  { 881, 26, 26, 32, 3, -31 },
  { 966, 11, 17, 32, 7, -8 },
  { 990, 15, 4, 32, 9, -16 },
  { 998, 6, 8, 32, 13, -8 },
  { 1004, 26, 40, 32, 3, -39 },
  { 1134, 26, 38, 32, 3, -37 },
  { 1258, 26, 36, 32, 4, -36 },
  { 1375, 25, 37, 32, 4, -37 },
  { 1491, 26, 38, 32, 3, -37 },
  { 1615, 27, 36, 32, 3, -36 },
  { 1737, 26, 37, 32, 3, -36 },
  { 1858, 25, 38, 32, 4, -37 },
  { 1977, 24, 36, 32, 4, -36 },
  { 2085, 26, 38, 32, 3, -37 },
  { 2209, 25, 38, 32, 4, -37 },
  { 2328, 6, 29, 32, 13, -29 },
  { 2350, 12, 38, 32, 9, -29 },
  { 2407, 26, 27, 32, 3, -31 },
  { 2495, 26, 17, 32, 3, -26 },
  { 2551, 26, 27, 32, 3, -31 },
  { 2639, 26, 37, 32, 2, -37 },
  { 2760, 30, 45, 32, 1, -39 },
  { 2929, 32, 36, 32, 0, -36 },
  { 3073, 26, 36, 32, 4, -36 },
  { 3190, 27, 38, 32, 3, -37 },
  { 3319, 26, 36, 32, 4, -36 },
  { 3436, 26, 36, 32, 4, -36 },
  { 3553, 24, 36, 32, 5, -36 },
  { 3661, 26, 38, 32, 3, -37 },
  { 3785, 24, 36, 32, 4, -36 },
  { 3893, 22, 36, 32, 5, -36 },
  { 3992, 21, 37, 32, 5, -36 },
  { 4090, 28, 36, 32, 4, -36 },
  { 4216, 23, 36, 32, 6, -36 },
  { 4320, 26, 36, 32, 3, -36 },
  { 4437, 24, 36, 32, 4, -36 },
  { 4545, 27, 38, 32, 3, -37 },
  { 4674, 26, 36, 32, 4, -36 },
  { 4791, 27, 47, 32, 3, -37 },
  { 4950, 27, 36, 32, 4, -36 },
  { 5072, 28, 38, 32, 2, -37 },
  { 5205, 28, 36, 32, 2, -36 },
  { 5331, 25, 37, 32, 4, -36 },
  { 5447, 32, 36, 32, 0, -36 },
  { 5591, 32, 36, 32, 0, -36 },
  { 5735, 30, 36, 32, 1, -36 },
  { 5870, 30, 36, 32, 1, -36 },
  { 6005, 28, 36, 32, 2, -36 },
  { 6131, 14, 50, 32, 11, -39 },
  { 6219, 26, 40, 32, 3, -39 },
  { 6349, 15, 50, 32, 7, -39 },
  { 6443, 26, 24, 32, 3, -36 },
  { 6521, 33, 3, 32, 0, 3 },
  { 6534, 11, 7, 32, 11, -39 },
  { 6544, 28, 31, 32, 3, -30 },
  { 6653, 24, 40, 32, 5, -39 },
  { 6773, 25, 31, 32, 3, -30 },
  { 6870, 24, 40, 32, 4, -39 },
  { 6990, 26, 31, 32, 3, -30 },
  { 7091, 25, 39, 32, 4, -39 },
  { 7213, 24, 41, 32, 4, -30 },
  { 7336, 23, 39, 32, 5, -39 },
  { 7449, 26, 39, 32, 4, -39 },
  { 7576, 19, 50, 32, 3, -39 },
  { 7695, 24, 39, 32, 6, -39 },
  { 7812, 25, 39, 32, 4, -39 },
  { 7934, 27, 30, 32, 3, -30 },
  { 8036, 23, 30, 32, 5, -30 },
  { 8123, 26, 31, 32, 3, -30 },
  { 8224, 24, 41, 32, 5, -30 },
  { 8347, 24, 41, 32, 4, -30 },
  { 8470, 22, 30, 32, 6, -30 },
  { 8553, 24, 31, 32, 4, -30 },
  { 8646, 22, 37, 32, 5, -36 },
  { 8748, 23, 30, 32, 5, -29 },
  { 8835, 29, 29, 32, 2, -29 },
  { 8941, 31, 29, 32, 1, -29 },
  { 9054, 28, 29, 32, 2, -29 },
  { 9156, 29, 40, 32, 2, -29 },
  { 9301, 24, 29, 32, 4, -29 },
  { 9388, 22, 50, 32, 6, -39 },
  { 9526, 4, 50, 32, 14, -39 },
  { 9551, 22, 50, 32, 4, -39 },
  { 9689, 27, 7, 32, 3, -22 },
};

const GFXfont LiberationMono_Regular54pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular54pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular54pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _LIBERATIONMONO_REGULAR54PT7B_H_
