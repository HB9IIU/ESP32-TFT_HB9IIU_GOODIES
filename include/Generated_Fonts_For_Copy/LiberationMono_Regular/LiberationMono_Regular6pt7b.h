#ifndef _LIBERATIONMONO_REGULAR6PT7B_H_
#define _LIBERATIONMONO_REGULAR6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular6pt7bBitmaps[] PROGMEM = {
  0x00, 0x40, 0xD0, 0x5F, 0x80, 0xF9, 0xF0, 0xCE, 0x73, 0x6B, 0x70, 0x80,
  0xAA, 0x80, 0x95, 0x80, 0xD0, 0x08, 0x80, 0xC0, 0x80, 0x29, 0x40, 0x76,
  0xB0, 0x44, 0xB0, 0x65, 0x60, 0x64, 0xF0, 0x2F, 0x90, 0x50, 0xB0, 0x7A,
  0xB0, 0x65, 0x20, 0xFE, 0xF0, 0x75, 0xB0, 0xA0, 0xB0, 0x09, 0x00, 0x48,
  0x0D, 0x80, 0xE5, 0x20, 0xFE, 0xF6, 0x46, 0x69, 0xFE, 0xF0, 0x72, 0x30,
  0xF6, 0xF0, 0xFA, 0x60, 0xEA, 0x72, 0xB0, 0x9E, 0xD0, 0xEA, 0xD7, 0xAC,
  0xAA, 0x2A, 0xBE, 0xC0, 0x9E, 0xD0, 0x76, 0xB0, 0xF7, 0x40, 0x76, 0xB2,
  0xF7, 0xD0, 0xF8, 0xF0, 0xE9, 0x20, 0x96, 0xF0, 0x8A, 0x64, 0x9D, 0xEA,
  0x24, 0x4A, 0x86, 0x44, 0xE5, 0x60, 0xAA, 0x80, 0x48, 0x90, 0xF8, 0x4E,
  0x00, 0xF0, 0x00, 0x3F, 0x80, 0xBF, 0xF3, 0x80, 0x76, 0xF0, 0xFF, 0x80,
  0x49, 0x20, 0xF7, 0x90, 0xBF, 0x09, 0x20, 0x15, 0x40, 0xBB, 0x49, 0x20,
  0xFE, 0x80, 0xFC, 0xF7, 0x80, 0xFE, 0xF7, 0x90, 0xA8, 0xED, 0x80, 0xAA,
  0xFC, 0xAD, 0x00, 0x9E, 0xA0, 0x6A, 0x80, 0xAD, 0x20, 0x2B, 0x00, 0xAA,
  0x80, 0x70, 0x48, 0xA4, 0x40,
};

const GFXglyph LiberationMono_Regular6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 2, 4, 1, -4 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 4, 4, 0, -4 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 4, 0, -4 },
  { 11, 1, 2, 4, 1, -4 },
  { 12, 2, 5, 4, 1, -4 },
  { 14, 2, 5, 4, 1, -4 },
  { 16, 2, 2, 4, 1, -4 },
  { 17, 3, 2, 4, 0, -3 },
  { 18, 1, 2, 4, 1, -1 },
  { 19, 2, 1, 4, 1, -2 },
  { 20, 1, 1, 4, 1, -1 },
  { 21, 3, 4, 4, 0, -4 },
  { 23, 3, 4, 4, 0, -4 },
  { 25, 3, 4, 4, 0, -4 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 0, -4 },
  { 43, 1, 3, 4, 1, -3 },
  { 44, 1, 4, 4, 1, -3 },
  { 45, 3, 4, 4, 0, -4 },
  { 47, 3, 2, 4, 0, -3 },
  { 48, 3, 4, 4, 0, -4 },
  { 50, 3, 4, 4, 0, -4 },
  { 52, 3, 5, 4, 0, -4 },
  { 54, 4, 4, 4, 0, -4 },
  { 56, 3, 4, 4, 0, -4 },
  { 58, 3, 4, 4, 0, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 3, 4, 4, 0, -4 },
  { 64, 2, 4, 4, 1, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 3, 4, 4, 0, -4 },
  { 69, 2, 4, 4, 1, -4 },
  { 70, 2, 4, 4, 1, -4 },
  { 71, 4, 4, 4, 0, -4 },
  { 73, 2, 4, 4, 1, -4 },
  { 74, 3, 4, 4, 0, -4 },
  { 76, 3, 4, 4, 0, -4 },
  { 78, 3, 4, 4, 0, -4 },
  { 80, 3, 4, 4, 0, -4 },
  { 82, 3, 5, 4, 0, -4 },
  { 84, 3, 4, 4, 0, -4 },
  { 86, 3, 4, 4, 0, -4 },
  { 88, 3, 4, 4, 0, -4 },
  { 90, 3, 4, 4, 0, -4 },
  { 92, 4, 4, 4, 0, -4 },
  { 94, 4, 4, 4, 0, -4 },
  { 96, 4, 4, 4, 0, -4 },
  { 98, 4, 4, 4, 0, -4 },
  { 100, 3, 4, 4, 0, -4 },
  { 102, 2, 5, 4, 1, -4 },
  { 104, 3, 4, 4, 0, -4 },
  { 106, 1, 5, 4, 1, -4 },
  { 107, 3, 3, 4, 0, -4 },
  { 109, 4, 1, 4, 0, 0 },
  { 110, 1, 1, 4, 1, -4 },
  { 111, 3, 3, 4, 0, -3 },
  { 113, 2, 4, 4, 1, -4 },
  { 114, 3, 3, 4, 0, -3 },
  { 116, 3, 4, 4, 0, -4 },
  { 118, 3, 3, 4, 0, -3 },
  { 120, 3, 4, 4, 0, -4 },
  { 122, 3, 4, 4, 0, -3 },
  { 124, 2, 4, 4, 1, -4 },
  { 125, 3, 4, 4, 0, -4 },
  { 127, 2, 5, 4, 0, -4 },
  { 129, 2, 4, 4, 1, -4 },
  { 130, 3, 4, 4, 0, -4 },
  { 132, 3, 3, 4, 0, -3 },
  { 134, 2, 3, 4, 1, -3 },
  { 135, 3, 3, 4, 0, -3 },
  { 137, 2, 4, 4, 1, -3 },
  { 138, 3, 4, 4, 0, -3 },
  { 140, 2, 3, 4, 1, -3 },
  { 141, 3, 3, 4, 0, -3 },
  { 143, 2, 4, 4, 1, -4 },
  { 144, 2, 3, 4, 1, -3 },
  { 145, 3, 3, 4, 0, -3 },
  { 147, 4, 3, 4, 0, -3 },
  { 149, 3, 3, 4, 0, -3 },
  { 151, 3, 4, 4, 0, -3 },
  { 153, 3, 3, 4, 0, -3 },
  { 155, 2, 5, 4, 1, -4 },
  { 157, 1, 5, 4, 1, -4 },
  { 158, 3, 5, 4, 0, -4 },
  { 160, 3, 1, 4, 0, -2 },
};

const GFXfont LiberationMono_Regular6pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular6pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _LIBERATIONMONO_REGULAR6PT7B_H_
