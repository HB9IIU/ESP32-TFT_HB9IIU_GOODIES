#ifndef _LIBERATIONMONO_REGULAR21PT7B_H_
#define _LIBERATIONMONO_REGULAR21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x50, 0xF0, 0xCF, 0x8F, 0x1E, 0x3C, 0x58, 0xB1, 0x00,
  0x08, 0xC2, 0x10, 0x42, 0x08, 0x4F, 0xFE, 0x62, 0x08, 0x41, 0x08, 0x21,
  0x1F, 0xFC, 0x88, 0x21, 0x04, 0x20, 0x84, 0x00, 0x04, 0x00, 0x80, 0xFC,
  0x32, 0xEC, 0x4D, 0x88, 0x91, 0x03, 0x20, 0x1E, 0x00, 0xB8, 0x13, 0x02,
  0x3C, 0x47, 0x88, 0xD9, 0x31, 0xFC, 0x04, 0x00, 0x80, 0x78, 0x36, 0x63,
  0x33, 0x11, 0x99, 0x0C, 0xD8, 0x66, 0x81, 0xE8, 0x00, 0xDE, 0x05, 0x90,
  0x48, 0xC6, 0x46, 0x62, 0x32, 0x19, 0x30, 0x70, 0x0F, 0x01, 0x88, 0x10,
  0xC1, 0x08, 0x11, 0x81, 0xF0, 0x1C, 0x67, 0xC6, 0x66, 0x4C, 0x24, 0xC3,
  0xC4, 0x18, 0x63, 0xC3, 0xE7, 0xFF, 0xF4, 0x0C, 0x63, 0x0C, 0x61, 0x86,
  0x18, 0x43, 0x04, 0x18, 0x61, 0x86, 0x0C, 0x30, 0x60, 0xC0, 0x60, 0xC3,
  0x06, 0x18, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0x86, 0x30, 0xC6,
  0x00, 0x10, 0x23, 0x5F, 0xE3, 0x8D, 0x11, 0x00, 0x04, 0x01, 0x00, 0x40,
  0x10, 0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x00, 0x76, 0x66, 0xCC, 0x80,
  0xFF, 0xF0, 0xFF, 0x80, 0x00, 0xC0, 0x30, 0x18, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x00, 0x1F,
  0x0C, 0x66, 0x0D, 0x03, 0xC0, 0xF0, 0x3C, 0xEF, 0x3B, 0xCE, 0xF0, 0x34,
  0x0D, 0x82, 0x31, 0x87, 0xC0, 0x0C, 0x0F, 0x0E, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0, 0x1F,
  0x0C, 0x66, 0x0D, 0x83, 0x00, 0xC0, 0x70, 0x18, 0x0C, 0x0E, 0x07, 0x03,
  0x80, 0xC0, 0x60, 0x3F, 0xF0, 0x1F, 0x0C, 0x66, 0x0D, 0x03, 0x00, 0xC0,
  0x60, 0xE0, 0x06, 0x00, 0xC0, 0x3C, 0x0D, 0x83, 0x71, 0x87, 0xC0, 0x03,
  0x80, 0xF0, 0x16, 0x06, 0xC1, 0x98, 0x23, 0x08, 0x63, 0x0C, 0xC1, 0x9F,
  0xFC, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0x98, 0x06, 0x01, 0x80,
  0x60, 0x1B, 0xC7, 0x19, 0x83, 0x00, 0xC0, 0x3C, 0x0D, 0x83, 0x71, 0x87,
  0xC0, 0x1E, 0x31, 0x90, 0x78, 0x0C, 0x04, 0xF2, 0x8D, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x36, 0x31, 0xF0, 0xFF, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x60,
  0x30, 0x10, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0x1F, 0x18, 0x66,
  0x0D, 0x83, 0x60, 0xCC, 0x61, 0xE1, 0x86, 0x60, 0xF0, 0x3C, 0x0D, 0x83,
  0x61, 0x87, 0xC0, 0x1F, 0x1C, 0x66, 0x09, 0x03, 0xC0, 0xD0, 0x36, 0x0D,
  0xC7, 0x1E, 0xC0, 0x30, 0x0D, 0x86, 0x63, 0x0F, 0x80, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x77, 0x70, 0x00, 0x00, 0x76, 0x6C, 0xCC, 0x80, 0x00, 0x40,
  0x60, 0xE1, 0xC0, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x40, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x40,
  0xE0, 0xE1, 0xC0, 0x80, 0x00, 0x3F, 0x1F, 0xEE, 0x1F, 0x03, 0x00, 0xC0,
  0x20, 0x38, 0x18, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x07,
  0x81, 0x84, 0x30, 0x22, 0x03, 0x67, 0x54, 0xD5, 0x48, 0xD5, 0x89, 0xD0,
  0x9D, 0x09, 0xD1, 0x95, 0x1B, 0x5A, 0xA4, 0xEC, 0x60, 0x02, 0x04, 0x10,
  0xC0, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x40, 0x1B, 0x00, 0x98, 0x0C, 0x40,
  0x63, 0x06, 0x08, 0x3F, 0xE1, 0x03, 0x18, 0x08, 0xC0, 0x64, 0x03, 0x60,
  0x18, 0xFE, 0x30, 0xCC, 0x1B, 0x06, 0xC1, 0xB0, 0xCF, 0xE3, 0x06, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xBF, 0x80, 0x1F, 0x06, 0x31, 0x83, 0x30,
  0x2C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x81, 0x30, 0x63,
  0x18, 0x3E, 0x00, 0xFC, 0x31, 0xCC, 0x13, 0x06, 0xC1, 0xB0, 0x2C, 0x0F,
  0x03, 0xC1, 0xB0, 0x6C, 0x1B, 0x0C, 0xC7, 0x3F, 0x00, 0xFF, 0xB0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0F, 0xF3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x1F, 0x0C, 0x66, 0x0D, 0x83,
  0xC0, 0x30, 0x0C, 0x03, 0x1F, 0xC0, 0xF0, 0x36, 0x0D, 0x83, 0x30, 0xC7,
  0xC0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0xFF, 0x8C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x87, 0xFC, 0x1F, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xC3, 0xC3, 0x66, 0x3C, 0xC1,
  0x98, 0x63, 0x1C, 0x63, 0x0C, 0xC1, 0xB0, 0x3E, 0x07, 0xE0, 0xCE, 0x18,
  0xC3, 0x0C, 0x61, 0xCC, 0x19, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFC, 0xE0,
  0xF8, 0x7F, 0x17, 0xC5, 0xDB, 0x76, 0x9C, 0xA7, 0x39, 0xCC, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x10, 0xC1, 0xF0, 0xF8, 0x76, 0x3B, 0x1C, 0x8E,
  0x67, 0x13, 0x8D, 0xC2, 0xE1, 0xF0, 0xF8, 0x3C, 0x1C, 0x1F, 0x06, 0x31,
  0x83, 0x20, 0x6C, 0x0D, 0x81, 0xB0, 0x3E, 0x07, 0xC0, 0xD8, 0x19, 0x83,
  0x30, 0x63, 0x18, 0x3E, 0x00, 0xFE, 0x61, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x0D, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x1F, 0x06, 0x31,
  0x83, 0x20, 0x6C, 0x0D, 0x81, 0xB0, 0x3E, 0x07, 0xC0, 0xD8, 0x19, 0x83,
  0x30, 0x63, 0x18, 0x3E, 0x01, 0x80, 0x30, 0x03, 0x00, 0x3C, 0xFF, 0x30,
  0x6C, 0x1B, 0x02, 0xC1, 0xB0, 0x6F, 0xE3, 0x30, 0xC6, 0x31, 0xCC, 0x33,
  0x0E, 0xC1, 0xB0, 0x30, 0x3F, 0x0C, 0x31, 0x83, 0x60, 0x66, 0x00, 0xE0,
  0x0F, 0xC0, 0x3E, 0x00, 0xC0, 0x0F, 0x01, 0xE0, 0x66, 0x1C, 0x7E, 0x00,
  0xFF, 0xE1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x34, 0x0D, 0x83, 0x61,
  0x87, 0xC0, 0xC0, 0x36, 0x03, 0x60, 0x36, 0x06, 0x30, 0x63, 0x04, 0x10,
  0xC1, 0x8C, 0x19, 0x80, 0x98, 0x0D, 0x80, 0xD0, 0x07, 0x00, 0x60, 0xC0,
  0x1E, 0x01, 0xB0, 0x0C, 0x80, 0x66, 0x63, 0x33, 0x99, 0x9C, 0xCC, 0xA4,
  0x6D, 0x23, 0x4D, 0x0A, 0x78, 0x51, 0xC3, 0x8E, 0x18, 0x70, 0x60, 0x63,
  0x06, 0x30, 0xC1, 0x98, 0x0D, 0x80, 0xF0, 0x06, 0x00, 0x70, 0x0D, 0x81,
  0x98, 0x18, 0xC3, 0x06, 0x60, 0x66, 0x03, 0x60, 0x36, 0x06, 0x30, 0x61,
  0x8C, 0x19, 0x80, 0xD8, 0x0F, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0xFF, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xFF, 0xC0,
  0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0F, 0xC0, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x0C, 0xF8, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x7E, 0x0E, 0x03,
  0x81, 0xA0, 0x4C, 0x31, 0x08, 0x66, 0x09, 0x83, 0x40, 0xC0, 0xFF, 0xF8,
  0xE6, 0x10, 0x3F, 0x0C, 0x31, 0x86, 0x00, 0xC3, 0xF8, 0xC3, 0x30, 0x66,
  0x0C, 0xC1, 0x8C, 0x50, 0xF3, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0D, 0xE7,
  0x1B, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x1B, 0x78, 0x1F,
  0x0C, 0x66, 0x0D, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0xCC, 0x61,
  0xF0, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x3E, 0xD8, 0x76, 0x1D, 0x03, 0xC0,
  0xF0, 0x3C, 0x0D, 0x03, 0x61, 0xD8, 0x73, 0xEC, 0x1F, 0x0C, 0x66, 0x0D,
  0x83, 0xC0, 0xFF, 0xFC, 0x01, 0x00, 0x60, 0xCC, 0x61, 0xF0, 0x07, 0xC3,
  0x01, 0x80, 0x60, 0xFF, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x3E, 0xD8, 0x76, 0x1D, 0x83, 0x40, 0xF0,
  0x3C, 0x0D, 0x03, 0x61, 0xD8, 0xB3, 0xCC, 0x03, 0x60, 0x8C, 0x61, 0xF0,
  0xC0, 0x60, 0x30, 0x18, 0x0D, 0xE7, 0x1B, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x06, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x3F, 0xF8, 0x03, 0x03, 0x00, 0x00, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0xFC, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC1, 0xB0, 0xCC, 0x63, 0x30, 0xD8, 0x3E, 0x0E, 0xC3, 0x18,
  0xC3, 0x30, 0xCC, 0x18, 0x3E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x8F, 0xFC, 0xF9,
  0xD9, 0xDB, 0x31, 0x66, 0x3C, 0xC7, 0x98, 0xF3, 0x1E, 0x63, 0xCC, 0x79,
  0x8F, 0x31, 0x80, 0xDE, 0x71, 0xB0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x60, 0x1F, 0x0C, 0x66, 0x0D, 0x03, 0xC0, 0xF0, 0x3C,
  0x0D, 0x03, 0x60, 0xCC, 0x61, 0xF0, 0xDE, 0x71, 0xB0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xF1, 0xB7, 0x98, 0x0C, 0x06, 0x03, 0x00, 0x3E,
  0xD8, 0x76, 0x1D, 0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x03, 0x61, 0xD8, 0x73,
  0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x4F, 0xBC, 0x1C, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x3E, 0x21, 0xB0, 0x78, 0x07,
  0x01, 0xF0, 0x0E, 0x03, 0x81, 0xE1, 0x9F, 0x80, 0x30, 0x30, 0x30, 0xFF,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1F, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xDF, 0x60, 0xC0,
  0x78, 0x19, 0x83, 0x30, 0xC3, 0x18, 0x63, 0x0C, 0xC0, 0xD8, 0x1A, 0x01,
  0xC0, 0x38, 0x00, 0xC0, 0x3C, 0x03, 0x40, 0x36, 0x63, 0x67, 0x36, 0x52,
  0x6D, 0x26, 0x9E, 0x28, 0xE3, 0x8E, 0x30, 0xE0, 0x60, 0xCC, 0x30, 0xC4,
  0x0D, 0x80, 0xE0, 0x18, 0x07, 0x80, 0xD8, 0x31, 0x8C, 0x33, 0x03, 0x00,
  0xC0, 0x78, 0x19, 0x83, 0x30, 0x42, 0x18, 0x63, 0x04, 0xC0, 0xD8, 0x1A,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x30, 0x1C, 0x00, 0x7F, 0xC0, 0x60,
  0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0F, 0xFC, 0x0F,
  0x8C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x70, 0x0C, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x03,
  0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0xF0, 0x78, 0x23, 0x10,
  0x3C,
};

const GFXglyph LiberationMono_Regular21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 2, 14, 13, 5, -14 },
  { 5, 7, 7, 13, 3, -15 },
  { 12, 11, 14, 13, 1, -14 },
  { 32, 11, 18, 13, 1, -16 },
  { 57, 13, 14, 13, 0, -14 },
  { 80, 12, 14, 13, 0, -14 },
  { 101, 2, 7, 13, 5, -15 },
  { 103, 6, 19, 13, 3, -15 },
  { 118, 6, 19, 13, 3, -15 },
  { 133, 7, 7, 13, 3, -15 },
  { 140, 10, 9, 13, 1, -12 },
  { 152, 4, 7, 13, 3, -3 },
  { 156, 6, 2, 13, 3, -6 },
  { 158, 3, 3, 13, 5, -3 },
  { 160, 10, 15, 13, 1, -15 },
  { 179, 10, 14, 13, 1, -14 },
  { 197, 10, 14, 13, 2, -14 },
  { 215, 10, 14, 13, 1, -14 },
  { 233, 10, 14, 13, 1, -14 },
  { 251, 11, 14, 13, 1, -14 },
  { 271, 10, 14, 13, 1, -14 },
  { 289, 9, 14, 13, 2, -14 },
  { 305, 9, 14, 13, 2, -14 },
  { 321, 10, 14, 13, 1, -14 },
  { 339, 10, 14, 13, 1, -14 },
  { 357, 3, 11, 13, 5, -11 },
  { 362, 4, 15, 13, 4, -11 },
  { 370, 10, 9, 13, 1, -12 },
  { 382, 10, 5, 13, 1, -10 },
  { 389, 10, 9, 13, 1, -12 },
  { 401, 10, 14, 13, 1, -14 },
  { 419, 12, 18, 13, 0, -15 },
  { 446, 13, 14, 13, 0, -14 },
  { 469, 10, 14, 13, 2, -14 },
  { 487, 11, 14, 13, 1, -14 },
  { 507, 10, 14, 13, 2, -14 },
  { 525, 10, 14, 13, 2, -14 },
  { 543, 9, 14, 13, 2, -14 },
  { 559, 10, 14, 13, 1, -14 },
  { 577, 9, 14, 13, 2, -14 },
  { 593, 9, 14, 13, 2, -14 },
  { 609, 8, 14, 13, 2, -14 },
  { 623, 11, 14, 13, 2, -14 },
  { 643, 9, 14, 13, 2, -14 },
  { 659, 10, 14, 13, 1, -14 },
  { 677, 9, 14, 13, 2, -14 },
  { 693, 11, 14, 13, 1, -14 },
  { 713, 9, 14, 13, 2, -14 },
  { 729, 11, 18, 13, 1, -14 },
  { 754, 10, 14, 13, 2, -14 },
  { 772, 11, 14, 13, 1, -14 },
  { 792, 11, 14, 13, 1, -14 },
  { 812, 10, 14, 13, 1, -14 },
  { 830, 12, 14, 13, 0, -14 },
  { 851, 13, 14, 13, 0, -14 },
  { 874, 12, 14, 13, 0, -14 },
  { 895, 12, 14, 13, 0, -14 },
  { 916, 11, 14, 13, 1, -14 },
  { 936, 6, 19, 13, 4, -15 },
  { 951, 10, 15, 13, 1, -15 },
  { 970, 5, 19, 13, 3, -15 },
  { 982, 10, 9, 13, 1, -14 },
  { 994, 13, 1, 13, 0, 1 },
  { 996, 4, 3, 13, 4, -15 },
  { 998, 11, 11, 13, 1, -11 },
  { 1014, 9, 15, 13, 2, -15 },
  { 1031, 10, 11, 13, 1, -11 },
  { 1045, 10, 15, 13, 1, -15 },
  { 1064, 10, 11, 13, 1, -11 },
  { 1078, 10, 15, 13, 1, -15 },
  { 1097, 10, 15, 13, 1, -11 },
  { 1116, 9, 15, 13, 2, -15 },
  { 1133, 11, 15, 13, 1, -15 },
  { 1154, 8, 19, 13, 1, -15 },
  { 1173, 10, 15, 13, 2, -15 },
  { 1192, 10, 15, 13, 1, -15 },
  { 1211, 11, 11, 13, 1, -11 },
  { 1227, 9, 11, 13, 2, -11 },
  { 1240, 10, 11, 13, 1, -11 },
  { 1254, 9, 15, 13, 2, -11 },
  { 1271, 10, 15, 13, 1, -11 },
  { 1290, 9, 11, 13, 2, -11 },
  { 1303, 9, 11, 13, 2, -11 },
  { 1316, 8, 14, 13, 2, -14 },
  { 1330, 9, 11, 13, 2, -11 },
  { 1343, 11, 11, 13, 1, -11 },
  { 1359, 12, 11, 13, 0, -11 },
  { 1376, 11, 11, 13, 1, -11 },
  { 1392, 11, 15, 13, 1, -11 },
  { 1413, 10, 11, 13, 1, -11 },
  { 1427, 9, 19, 13, 2, -15 },
  { 1449, 2, 19, 13, 5, -15 },
  { 1454, 8, 19, 13, 2, -15 },
  { 1473, 10, 3, 13, 1, -9 },
};

const GFXfont LiberationMono_Regular21pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular21pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular21pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _LIBERATIONMONO_REGULAR21PT7B_H_
