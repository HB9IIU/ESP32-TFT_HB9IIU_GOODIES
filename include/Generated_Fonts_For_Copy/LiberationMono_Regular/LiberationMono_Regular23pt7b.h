#ifndef _LIBERATIONMONO_REGULAR23PT7B_H_
#define _LIBERATIONMONO_REGULAR23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFC, 0x3C, 0xE7, 0xE7, 0xC7, 0xC6, 0xC6, 0xC2, 0x42,
  0x08, 0x60, 0x84, 0x08, 0x41, 0x84, 0xFF, 0xF1, 0x08, 0x10, 0x83, 0x08,
  0x20, 0x8F, 0xFF, 0x21, 0x02, 0x10, 0x61, 0x04, 0x30, 0x43, 0x00, 0x06,
  0x00, 0x60, 0x1F, 0x87, 0xFE, 0x66, 0x6C, 0x67, 0x46, 0x07, 0x60, 0x3F,
  0x00, 0xFC, 0x06, 0xE0, 0x63, 0x06, 0x3C, 0x63, 0xE6, 0x77, 0xFE, 0x3F,
  0x80, 0x60, 0x06, 0x00, 0x78, 0x1B, 0x30, 0xCC, 0x42, 0x31, 0x18, 0xC4,
  0xC3, 0x16, 0x04, 0xD0, 0x1E, 0xDE, 0x06, 0xC8, 0x12, 0x30, 0xD8, 0xC6,
  0x63, 0x10, 0x8C, 0xC3, 0x26, 0x07, 0x00, 0x0F, 0x80, 0xFE, 0x06, 0x30,
  0x30, 0x81, 0x8C, 0x0F, 0x80, 0x70, 0xC7, 0x86, 0x66, 0x32, 0x19, 0x30,
  0x78, 0xC3, 0x86, 0x1E, 0x3F, 0xFC, 0x78, 0xE0, 0xFF, 0xFC, 0x1C, 0x63,
  0x0C, 0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x61, 0x83,
  0x0C, 0x18, 0x70, 0xC1, 0x83, 0x0C, 0x18, 0x61, 0x83, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC6, 0x18, 0x63, 0x0C, 0x63, 0x00, 0x18, 0x18, 0x9B, 0xFF,
  0x18, 0x3C, 0x64, 0x44, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x61, 0xFF,
  0xFF, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x3B, 0x9C, 0xC6,
  0x63, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x00, 0x1F, 0x07, 0xF9, 0xC3, 0x30,
  0x36, 0x07, 0xC0, 0xF1, 0x9E, 0x33, 0xC6, 0x6C, 0x0D, 0x81, 0xB0, 0x37,
  0x0C, 0x7F, 0x87, 0xC0, 0x06, 0x01, 0xC0, 0xD8, 0x7B, 0x0C, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x61, 0xFF, 0xFF,
  0xF8, 0x3F, 0x1F, 0xEE, 0x1F, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x0C, 0x0E,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0x3F, 0xFF, 0xFC, 0x1F, 0x87, 0xF9, 0xC3,
  0xB0, 0x30, 0x06, 0x01, 0x83, 0xE0, 0x7C, 0x00, 0xE0, 0x0C, 0x01, 0xF0,
  0x37, 0x0E, 0xFF, 0x87, 0xE0, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x0D,
  0xC1, 0x9C, 0x11, 0xC3, 0x1C, 0x61, 0xC4, 0x1C, 0xFF, 0xFF, 0xFF, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x7F, 0xCF, 0xF9, 0x80, 0x30, 0x06, 0x00, 0xDF,
  0x1F, 0xF3, 0x87, 0x00, 0x60, 0x0C, 0x01, 0xF0, 0x37, 0x0E, 0x7F, 0x87,
  0xC0, 0x1F, 0x0F, 0xE6, 0x1B, 0x03, 0xC0, 0x37, 0xCF, 0xFB, 0x87, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0x61, 0xDF, 0xE1, 0xF0, 0xFF, 0xFF, 0xF0, 0x0C,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x1F, 0x87, 0xF9, 0xC3, 0xB0, 0x36, 0x06, 0xE1, 0x8F,
  0xE1, 0xFC, 0x70, 0xEC, 0x0D, 0x81, 0xB0, 0x37, 0x0E, 0x7F, 0x87, 0xE0,
  0x3E, 0x1F, 0xEE, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x87, 0x7F, 0xCF,
  0x30, 0x0F, 0x07, 0xE3, 0x9F, 0xC3, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x31,
  0x8C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xE7, 0x31, 0x98, 0xC0, 0x00, 0x20,
  0x3C, 0x3F, 0x1F, 0x0F, 0x81, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3C,
  0x00, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1E, 0x00, 0x40, 0x78, 0x7E, 0x3E,
  0x1F, 0x03, 0x00, 0x00, 0x1F, 0x87, 0xF9, 0xC3, 0xF0, 0x3C, 0x06, 0x00,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x07, 0xC0, 0x63, 0x04, 0x0C, 0x60, 0x22, 0x3B, 0xB2, 0x75, 0x31,
  0xA9, 0x09, 0x58, 0x4A, 0xC2, 0x56, 0x32, 0xB1, 0x95, 0x8C, 0xAC, 0x4D,
  0x26, 0x4D, 0xCC, 0x20, 0x01, 0x81, 0x06, 0x18, 0x1F, 0x00, 0x03, 0x00,
  0x1E, 0x00, 0x78, 0x03, 0x20, 0x0C, 0xC0, 0x33, 0x01, 0x86, 0x06, 0x18,
  0x30, 0x60, 0xFF, 0xC3, 0xFF, 0x1C, 0x0C, 0x60, 0x19, 0x80, 0x6C, 0x01,
  0xC0, 0xFF, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x0D, 0x83, 0x3F, 0xC7, 0xFC,
  0xC0, 0xD8, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0xFF, 0xBF, 0xC0, 0x0F, 0x83,
  0xFC, 0x70, 0xE6, 0x06, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x06, 0x03, 0x70, 0x63, 0xFC, 0x0F, 0x80, 0xFE, 0x1F, 0xE3,
  0x0E, 0x60, 0xEC, 0x0D, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1B, 0x03,
  0x60, 0xEC, 0x39, 0xFE, 0x3F, 0x80, 0xFF, 0xDF, 0xFB, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x3F, 0xE7, 0xFC, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF,
  0xFF, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x0F, 0x87,
  0xF9, 0xC3, 0xB0, 0x36, 0x01, 0xC0, 0x38, 0x07, 0x1F, 0xE3, 0xFC, 0x0D,
  0x81, 0xB0, 0x37, 0x06, 0x7F, 0xC3, 0xE0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0C, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x1F, 0x8F, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xF0, 0x78, 0x36, 0x3B,
  0xF8, 0xF8, 0xC0, 0xCC, 0x1C, 0xC3, 0x8C, 0x70, 0xC6, 0x0C, 0xC0, 0xD8,
  0x0F, 0xC0, 0xEE, 0x0C, 0x70, 0xC3, 0x0C, 0x18, 0xC1, 0xCC, 0x0E, 0xC0,
  0x60, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xE0, 0x7E, 0x1F, 0xC2, 0xE8, 0xDD,
  0x9B, 0xB2, 0x73, 0xCE, 0x79, 0xC6, 0x38, 0xC7, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x08, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xF6, 0x3D, 0x8F,
  0x33, 0xCC, 0xF1, 0xBC, 0x6F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1C, 0x1F, 0x03,
  0xFC, 0x70, 0xE6, 0x06, 0xE0, 0x6E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E,
  0x07, 0xE0, 0x66, 0x06, 0x70, 0xE3, 0xFC, 0x1F, 0x00, 0xFF, 0x1F, 0xF3,
  0x07, 0x60, 0x6C, 0x0F, 0x81, 0xF0, 0x36, 0x0E, 0xFF, 0x9F, 0xE3, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x1F, 0x03, 0xFC, 0x70, 0xE6, 0x06,
  0xE0, 0x6E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x66, 0x06,
  0x70, 0xE3, 0xFC, 0x1F, 0x00, 0x70, 0x03, 0x80, 0x3F, 0x00, 0xF0, 0xFF,
  0x1F, 0xFB, 0x03, 0x60, 0x7C, 0x0F, 0x81, 0xBF, 0xE7, 0xF8, 0xC6, 0x18,
  0x63, 0x0C, 0x60, 0xCC, 0x1D, 0x81, 0xB0, 0x38, 0x1F, 0x87, 0xFC, 0x60,
  0xE6, 0x06, 0x60, 0x07, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xE0, 0x06, 0x00,
  0x3C, 0x07, 0xE0, 0x67, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE1, 0xDF, 0xE3,
  0xF0, 0xE0, 0x19, 0x80, 0x66, 0x01, 0x9C, 0x0C, 0x30, 0x30, 0xC1, 0xC1,
  0x86, 0x06, 0x18, 0x18, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x60, 0x07, 0x80,
  0x1E, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0x98, 0x06, 0x60,
  0x19, 0x8C, 0x66, 0x31, 0x99, 0xE6, 0x67, 0x90, 0x92, 0xC2, 0xCB, 0x0F,
  0x3C, 0x38, 0xF0, 0xE1, 0xC3, 0x87, 0x00, 0x60, 0x39, 0x81, 0x86, 0x18,
  0x31, 0xC0, 0xCC, 0x03, 0xC0, 0x1C, 0x00, 0x60, 0x07, 0x80, 0x6E, 0x07,
  0x30, 0x30, 0xC3, 0x07, 0x38, 0x19, 0x80, 0x60, 0x60, 0x1B, 0x81, 0x8C,
  0x1C, 0x30, 0xC1, 0xCC, 0x06, 0xE0, 0x1E, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF,
  0xF0, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xF0, 0x06, 0x01, 0xE0, 0x2C,
  0x0C, 0xC1, 0x18, 0x61, 0x0C, 0x31, 0x02, 0x60, 0x68, 0x0C, 0xFF, 0xFC,
  0xC6, 0x30, 0x1F, 0x03, 0xFC, 0x60, 0xC0, 0x0C, 0x00, 0xC1, 0xFC, 0x7F,
  0xC7, 0x0C, 0xE0, 0xCE, 0x0C, 0x61, 0xC7, 0xEF, 0x3C, 0x70, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xCF, 0x37, 0xEE, 0x1F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF8, 0x3E, 0x1F, 0xFE, 0xCF, 0x00, 0x1F, 0x87, 0xF9, 0xC3,
  0xB0, 0x36, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x0D, 0xC3, 0x9F,
  0xE1, 0xF8, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x3C, 0xDF, 0xBE, 0x3F, 0x07,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7E, 0x3D, 0xFB, 0x3C, 0xC0,
  0x1F, 0x07, 0xF9, 0xC3, 0x30, 0x36, 0x06, 0xFF, 0xDF, 0xFB, 0x00, 0x60,
  0x0C, 0x0D, 0xC3, 0x9F, 0xE1, 0xF0, 0x0F, 0xC7, 0xF1, 0x80, 0x60, 0xFF,
  0xFF, 0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x00, 0x3C, 0xDF, 0xBE, 0x3F, 0x07, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x7E, 0x3D, 0xFB, 0x3C, 0xC0, 0x30, 0x1F, 0x86,
  0x7F, 0x8F, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCF, 0x37, 0xEF, 0x1F,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xC0, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0x03, 0x00, 0x00, 0x3F, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0xFE, 0xFC, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC1, 0xB0, 0xCC, 0x63, 0x30, 0xD8, 0x3E, 0x0F,
  0x83, 0x70, 0xCC, 0x31, 0x8C, 0x33, 0x0E, 0xC1, 0x80, 0x3E, 0x03, 0xE0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0xDC,
  0xEF, 0xDE, 0xE7, 0x6C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x30, 0xCF, 0x37, 0xEF, 0x1F, 0x83,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0,
  0x1F, 0x87, 0xF9, 0xC3, 0xB0, 0x36, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0x60,
  0x6C, 0x0D, 0xC3, 0x1F, 0xE1, 0xF0, 0xCF, 0x37, 0xEE, 0x1F, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x1F, 0xFE, 0xCF, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x00, 0x3C, 0xDF, 0xBE, 0x3F, 0x07, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7E, 0x3D, 0xFB, 0x3C, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0xCF, 0xEF, 0xFC, 0x1C, 0x0E, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x3F, 0x1F, 0xE6, 0x1F, 0x00,
  0xE0, 0x1F, 0x03, 0xF0, 0x0E, 0x00, 0xC0, 0x3C, 0x1F, 0xFE, 0x3F, 0x00,
  0x10, 0x18, 0x0C, 0x1F, 0xFF, 0xF9, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xFE, 0x3F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7E, 0x3D, 0xFB, 0x3C, 0xC0, 0xC0,
  0x3E, 0x06, 0x60, 0x66, 0x0E, 0x70, 0xC3, 0x0C, 0x31, 0xC1, 0x98, 0x19,
  0x81, 0xB0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xC0, 0x0B, 0x00, 0x66, 0x01,
  0x98, 0x06, 0x63, 0x19, 0x9C, 0x66, 0x79, 0x99, 0x2C, 0x2C, 0xB0, 0xF3,
  0xC3, 0x8F, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0x66, 0x0C, 0x30, 0xC1, 0x98,
  0x1B, 0x00, 0xF0, 0x06, 0x00, 0xF0, 0x1B, 0x83, 0x98, 0x30, 0xC6, 0x0E,
  0xE0, 0x60, 0xC0, 0x3C, 0x06, 0x60, 0x66, 0x06, 0x30, 0xC3, 0x0C, 0x30,
  0x81, 0x98, 0x19, 0x80, 0xB0, 0x0F, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x78, 0x07, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03,
  0x81, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0x8F,
  0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x38, 0x38, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xF8, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7E, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x03, 0x00, 0xE0, 0x70, 0x60, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x8F, 0xC7, 0xC0, 0x78, 0x1F, 0xE3, 0x87, 0xF0, 0x1E,
};

const GFXglyph LiberationMono_Regular23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 2, 15, 14, 6, -15 },
  { 5, 8, 7, 14, 3, -17 },
  { 12, 12, 15, 14, 1, -15 },
  { 35, 12, 19, 14, 1, -17 },
  { 64, 14, 15, 14, 0, -15 },
  { 91, 13, 15, 14, 0, -15 },
  { 116, 2, 7, 14, 6, -17 },
  { 118, 6, 22, 14, 4, -17 },
  { 135, 6, 22, 14, 4, -17 },
  { 152, 8, 8, 14, 3, -17 },
  { 160, 11, 12, 14, 1, -14 },
  { 177, 5, 7, 14, 3, -3 },
  { 182, 6, 2, 14, 4, -7 },
  { 184, 2, 3, 14, 6, -3 },
  { 185, 12, 17, 14, 1, -17 },
  { 211, 11, 15, 14, 1, -15 },
  { 232, 11, 15, 14, 2, -15 },
  { 253, 10, 15, 14, 2, -15 },
  { 272, 11, 15, 14, 1, -15 },
  { 293, 12, 15, 14, 1, -15 },
  { 316, 11, 15, 14, 1, -15 },
  { 337, 10, 15, 14, 2, -15 },
  { 356, 10, 15, 14, 2, -15 },
  { 375, 11, 15, 14, 1, -15 },
  { 396, 10, 15, 14, 2, -15 },
  { 415, 2, 13, 14, 6, -13 },
  { 419, 5, 17, 14, 4, -13 },
  { 430, 11, 11, 14, 1, -13 },
  { 446, 11, 7, 14, 1, -11 },
  { 456, 11, 11, 14, 1, -13 },
  { 472, 11, 15, 14, 1, -15 },
  { 493, 13, 20, 14, 0, -17 },
  { 526, 14, 15, 14, 0, -15 },
  { 553, 11, 15, 14, 2, -15 },
  { 574, 12, 15, 14, 1, -15 },
  { 597, 11, 15, 14, 2, -15 },
  { 618, 11, 15, 14, 2, -15 },
  { 639, 10, 15, 14, 2, -15 },
  { 658, 11, 15, 14, 1, -15 },
  { 679, 10, 15, 14, 2, -15 },
  { 698, 10, 15, 14, 2, -15 },
  { 717, 9, 15, 14, 2, -15 },
  { 734, 12, 15, 14, 2, -15 },
  { 757, 9, 15, 14, 3, -15 },
  { 774, 11, 15, 14, 1, -15 },
  { 795, 10, 15, 14, 2, -15 },
  { 814, 12, 15, 14, 1, -15 },
  { 837, 11, 15, 14, 2, -15 },
  { 858, 12, 19, 14, 1, -15 },
  { 887, 11, 15, 14, 2, -15 },
  { 908, 12, 15, 14, 1, -15 },
  { 931, 12, 15, 14, 1, -15 },
  { 954, 10, 15, 14, 2, -15 },
  { 973, 14, 15, 14, 0, -15 },
  { 1000, 14, 15, 14, 0, -15 },
  { 1027, 13, 15, 14, 0, -15 },
  { 1052, 13, 15, 14, 0, -15 },
  { 1077, 12, 15, 14, 1, -15 },
  { 1100, 6, 22, 14, 5, -17 },
  { 1117, 12, 17, 14, 1, -17 },
  { 1143, 6, 22, 14, 3, -17 },
  { 1160, 11, 10, 14, 1, -15 },
  { 1174, 14, 1, 14, 0, 1 },
  { 1176, 4, 3, 14, 5, -17 },
  { 1178, 12, 13, 14, 1, -13 },
  { 1198, 10, 17, 14, 2, -17 },
  { 1220, 11, 13, 14, 1, -13 },
  { 1238, 10, 17, 14, 2, -17 },
  { 1260, 11, 13, 14, 1, -13 },
  { 1278, 10, 17, 14, 2, -17 },
  { 1300, 10, 18, 14, 2, -13 },
  { 1323, 10, 17, 14, 2, -17 },
  { 1345, 11, 17, 14, 2, -17 },
  { 1369, 8, 22, 14, 1, -17 },
  { 1391, 10, 17, 14, 3, -17 },
  { 1413, 12, 17, 14, 1, -17 },
  { 1439, 12, 13, 14, 1, -13 },
  { 1459, 10, 13, 14, 2, -13 },
  { 1476, 11, 13, 14, 1, -13 },
  { 1494, 10, 18, 14, 2, -13 },
  { 1517, 10, 18, 14, 2, -13 },
  { 1540, 9, 13, 14, 3, -13 },
  { 1555, 10, 13, 14, 2, -13 },
  { 1572, 9, 16, 14, 2, -16 },
  { 1590, 10, 13, 14, 2, -13 },
  { 1607, 12, 13, 14, 1, -13 },
  { 1627, 14, 13, 14, 0, -13 },
  { 1650, 12, 13, 14, 1, -13 },
  { 1670, 12, 18, 14, 1, -13 },
  { 1697, 10, 13, 14, 2, -13 },
  { 1714, 9, 22, 14, 3, -17 },
  { 1739, 2, 22, 14, 6, -17 },
  { 1745, 9, 22, 14, 2, -17 },
  { 1770, 12, 4, 14, 1, -10 },
};

const GFXfont LiberationMono_Regular23pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular23pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular23pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _LIBERATIONMONO_REGULAR23PT7B_H_
