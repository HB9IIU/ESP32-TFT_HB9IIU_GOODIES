#ifndef _LIBERATIONMONO_REGULAR13PT7B_H_
#define _LIBERATIONMONO_REGULAR13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular13pt7bBitmaps[] PROGMEM = {
  0x00, 0xEA, 0xA8, 0xC0, 0x99, 0x99, 0x12, 0x49, 0xF9, 0x22, 0x5F, 0xD2,
  0x24, 0x48, 0x10, 0x79, 0x4A, 0x85, 0x07, 0x84, 0x89, 0x52, 0xF8, 0x40,
  0xE2, 0x94, 0x94, 0xE8, 0x10, 0x16, 0x29, 0x49, 0x46, 0x38, 0x24, 0x24,
  0x28, 0x72, 0xD2, 0x8C, 0xCC, 0x7B, 0xFA, 0x26, 0x44, 0xC8, 0x88, 0xC4,
  0x46, 0x20, 0x44, 0x22, 0x23, 0x33, 0x22, 0x24, 0x40, 0x4D, 0x66, 0x90,
  0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0x7A, 0xF0, 0xF0, 0x04, 0x20, 0x84,
  0x10, 0x82, 0x10, 0x42, 0x00, 0x7B, 0x28, 0x61, 0xB6, 0x18, 0x72, 0x78,
  0x33, 0x41, 0x04, 0x10, 0x41, 0x04, 0xFC, 0x7A, 0x30, 0x42, 0x18, 0xC6,
  0x30, 0xFC, 0x7A, 0x30, 0x42, 0x30, 0x30, 0x63, 0x78, 0x18, 0x62, 0x92,
  0x4A, 0x2F, 0xC2, 0x08, 0xFA, 0x08, 0x2E, 0xCC, 0x10, 0x63, 0x78, 0x79,
  0x38, 0x2E, 0xCE, 0x18, 0x53, 0x78, 0xFC, 0x20, 0x84, 0x10, 0x82, 0x08,
  0x20, 0x7B, 0x38, 0x72, 0x72, 0x38, 0x63, 0x78, 0x7B, 0x28, 0x61, 0xCD,
  0xD0, 0x62, 0x70, 0xF0, 0x3C, 0x6C, 0x00, 0xD2, 0x80, 0x04, 0x6E, 0x20,
  0x60, 0x60, 0x40, 0xFC, 0x00, 0x3F, 0x81, 0x81, 0x81, 0x19, 0x88, 0x00,
  0x7A, 0x38, 0x43, 0x18, 0xC2, 0x00, 0x20, 0x1C, 0x22, 0x42, 0x5D, 0xA5,
  0xA5, 0xA5, 0xAA, 0xB6, 0x40, 0x42, 0x3C, 0x18, 0x18, 0x24, 0x24, 0x24,
  0x7E, 0x42, 0x42, 0x83, 0xFA, 0x38, 0x62, 0xFA, 0x18, 0x61, 0xF8, 0x33,
  0x38, 0x60, 0x82, 0x08, 0x53, 0x30, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x62,
  0xF0, 0xFE, 0x08, 0x20, 0xFA, 0x08, 0x20, 0xFC, 0xFE, 0x08, 0x20, 0xFE,
  0x08, 0x20, 0x80, 0x3B, 0x18, 0x20, 0x9E, 0x18, 0x71, 0x78, 0x86, 0x18,
  0x61, 0xFE, 0x18, 0x61, 0x84, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0xFC,
  0x38, 0x42, 0x10, 0x86, 0x39, 0x70, 0x8D, 0x12, 0x45, 0x0F, 0x12, 0x22,
  0x46, 0x84, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFC, 0xCF, 0x3C, 0xED,
  0xB6, 0xD8, 0x61, 0x84, 0xC7, 0x1E, 0x69, 0xA6, 0x59, 0x63, 0x8C, 0x7B,
  0x38, 0x61, 0x86, 0x18, 0x73, 0x78, 0xFA, 0x18, 0x63, 0xFA, 0x08, 0x20,
  0x80, 0x7B, 0x38, 0x61, 0x86, 0x18, 0x73, 0x78, 0x41, 0xC0, 0xFA, 0x18,
  0x63, 0xFA, 0x48, 0xA3, 0x84, 0x3C, 0x8D, 0x03, 0x01, 0xC0, 0x40, 0xA1,
  0x3C, 0xFE, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x73, 0x78, 0xC3, 0x42, 0x42, 0x44, 0x24, 0x24, 0x28, 0x18,
  0x18, 0x81, 0x83, 0xDA, 0x5A, 0x5A, 0x5A, 0x66, 0x66, 0x66, 0x42, 0x64,
  0x2C, 0x18, 0x18, 0x38, 0x24, 0x46, 0x42, 0xC2, 0x42, 0x24, 0x24, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x7E, 0x0C, 0x10, 0x41, 0x06, 0x08, 0x20, 0xFE,
  0xF2, 0x49, 0x24, 0x92, 0x4E, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08,
  0x10, 0xE4, 0x92, 0x49, 0x24, 0x9E, 0x30, 0xC4, 0x92, 0x8A, 0x10, 0xFF,
  0x90, 0x7A, 0x20, 0x9E, 0x8A, 0x2F, 0xC0, 0x82, 0x08, 0x2E, 0xCE, 0x18,
  0x61, 0xCE, 0xE0, 0x7B, 0x38, 0x20, 0x83, 0x37, 0x80, 0x0C, 0x30, 0xDF,
  0xCE, 0x38, 0xE3, 0xCD, 0xD0, 0x7B, 0x38, 0x7F, 0x83, 0x37, 0x80, 0x3C,
  0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x80, 0x77, 0x38, 0xE1, 0x8F, 0x37,
  0x43, 0xC9, 0xE0, 0x82, 0x08, 0x2E, 0xCE, 0x18, 0x61, 0x86, 0x10, 0x30,
  0x00, 0x1C, 0x10, 0x41, 0x04, 0x13, 0xF0, 0x10, 0x07, 0x11, 0x11, 0x11,
  0x11, 0xE0, 0xC3, 0x0C, 0x33, 0xDB, 0xCF, 0x34, 0xCB, 0x30, 0x70, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x13, 0xF0, 0xEE, 0xDA, 0x69, 0xA6, 0x9A, 0x40,
  0xBB, 0x38, 0x61, 0x86, 0x18, 0x40, 0x7B, 0x38, 0x61, 0x87, 0x37, 0x80,
  0xBB, 0x38, 0x61, 0x87, 0x3B, 0xA0, 0x82, 0x00, 0x77, 0x38, 0xE3, 0x8F,
  0x37, 0xC3, 0x0C, 0x30, 0xBE, 0x21, 0x08, 0x42, 0x00, 0x7A, 0x2C, 0x1E,
  0x0E, 0x17, 0x80, 0x42, 0x3E, 0x84, 0x21, 0x0C, 0x38, 0x86, 0x18, 0x61,
  0x8F, 0x37, 0x40, 0x42, 0x85, 0x91, 0x22, 0xC3, 0x06, 0x00, 0x83, 0x82,
  0x5A, 0x5A, 0x6A, 0x66, 0x66, 0x8D, 0x23, 0x0C, 0x71, 0x28, 0x40, 0x42,
  0x85, 0x91, 0x22, 0x43, 0x06, 0x08, 0x10, 0xC0, 0xFC, 0x21, 0x08, 0x63,
  0x0F, 0xC0, 0x1C, 0x82, 0x08, 0x20, 0x8C, 0x08, 0x20, 0x82, 0x08, 0x1C,
  0xFF, 0xF8, 0xE1, 0x8C, 0x63, 0x08, 0x22, 0x31, 0x8C, 0x6E, 0x00, 0xE0,
  0x70,
};

const GFXglyph LiberationMono_Regular13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 4, 8, 2, -10 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 7, 11, 8, 0, -10 },
  { 24, 8, 9, 8, 0, -9 },
  { 33, 8, 9, 8, 0, -9 },
  { 42, 2, 4, 8, 3, -10 },
  { 43, 4, 13, 8, 2, -10 },
  { 50, 4, 13, 8, 2, -10 },
  { 57, 4, 5, 8, 2, -10 },
  { 60, 6, 7, 8, 1, -8 },
  { 66, 2, 4, 8, 2, -2 },
  { 67, 4, 1, 8, 2, -4 },
  { 68, 2, 2, 8, 3, -2 },
  { 69, 6, 10, 8, 1, -10 },
  { 77, 6, 9, 8, 1, -9 },
  { 84, 6, 9, 8, 1, -9 },
  { 91, 6, 9, 8, 1, -9 },
  { 98, 6, 9, 8, 1, -9 },
  { 105, 6, 9, 8, 1, -9 },
  { 112, 6, 9, 8, 1, -9 },
  { 119, 6, 9, 8, 1, -9 },
  { 126, 6, 9, 8, 1, -9 },
  { 133, 6, 9, 8, 1, -9 },
  { 140, 6, 9, 8, 1, -9 },
  { 147, 2, 7, 8, 3, -7 },
  { 149, 3, 9, 8, 2, -7 },
  { 153, 6, 7, 8, 1, -8 },
  { 159, 6, 4, 8, 1, -6 },
  { 162, 6, 7, 8, 1, -8 },
  { 168, 6, 9, 8, 1, -9 },
  { 175, 8, 12, 8, 0, -10 },
  { 187, 8, 9, 8, 0, -9 },
  { 196, 6, 9, 8, 1, -9 },
  { 203, 6, 9, 8, 1, -9 },
  { 210, 6, 9, 8, 1, -9 },
  { 217, 6, 9, 8, 1, -9 },
  { 224, 6, 9, 8, 1, -9 },
  { 231, 6, 9, 8, 1, -9 },
  { 238, 6, 9, 8, 1, -9 },
  { 245, 6, 9, 8, 1, -9 },
  { 252, 5, 9, 8, 1, -9 },
  { 258, 7, 9, 8, 1, -9 },
  { 266, 6, 9, 8, 1, -9 },
  { 273, 6, 9, 8, 1, -9 },
  { 280, 6, 9, 8, 1, -9 },
  { 287, 6, 9, 8, 1, -9 },
  { 294, 6, 9, 8, 1, -9 },
  { 301, 6, 11, 8, 1, -9 },
  { 310, 6, 9, 8, 1, -9 },
  { 317, 7, 9, 8, 0, -9 },
  { 325, 7, 9, 8, 0, -9 },
  { 333, 6, 9, 8, 1, -9 },
  { 340, 8, 9, 8, 0, -9 },
  { 349, 8, 9, 8, 0, -9 },
  { 358, 8, 9, 8, 0, -9 },
  { 367, 8, 9, 8, 0, -9 },
  { 376, 7, 9, 8, 0, -9 },
  { 384, 3, 13, 8, 3, -10 },
  { 389, 6, 10, 8, 1, -10 },
  { 397, 3, 13, 8, 2, -10 },
  { 402, 6, 6, 8, 1, -9 },
  { 407, 8, 1, 8, 0, 1 },
  { 408, 2, 2, 8, 3, -10 },
  { 409, 6, 7, 8, 1, -7 },
  { 415, 6, 10, 8, 1, -10 },
  { 423, 6, 7, 8, 1, -7 },
  { 429, 6, 10, 8, 1, -10 },
  { 437, 6, 7, 8, 1, -7 },
  { 443, 6, 10, 8, 1, -10 },
  { 451, 6, 10, 8, 1, -7 },
  { 459, 6, 10, 8, 1, -10 },
  { 467, 6, 10, 8, 1, -10 },
  { 475, 4, 13, 8, 1, -10 },
  { 482, 6, 10, 8, 1, -10 },
  { 490, 6, 10, 8, 1, -10 },
  { 498, 6, 7, 8, 1, -7 },
  { 504, 6, 7, 8, 1, -7 },
  { 510, 6, 7, 8, 1, -7 },
  { 516, 6, 10, 8, 1, -7 },
  { 524, 6, 10, 8, 1, -7 },
  { 532, 5, 7, 8, 2, -7 },
  { 537, 6, 7, 8, 1, -7 },
  { 543, 5, 9, 8, 1, -9 },
  { 549, 6, 7, 8, 1, -7 },
  { 555, 7, 7, 8, 0, -7 },
  { 562, 8, 7, 8, 0, -7 },
  { 569, 6, 7, 8, 1, -7 },
  { 575, 7, 10, 8, 0, -7 },
  { 584, 6, 7, 8, 1, -7 },
  { 590, 6, 13, 8, 1, -10 },
  { 600, 1, 13, 8, 3, -10 },
  { 602, 5, 13, 8, 1, -10 },
  { 611, 6, 2, 8, 1, -6 },
};

const GFXfont LiberationMono_Regular13pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular13pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _LIBERATIONMONO_REGULAR13PT7B_H_
