#ifndef _LIBERATIONMONO_REGULAR20PT7B_H_
#define _LIBERATIONMONO_REGULAR20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xC3, 0xC0, 0xCF, 0x3C, 0xF3, 0xCF, 0x30, 0x10, 0x84,
  0x21, 0x08, 0x44, 0xFF, 0xC8, 0x42, 0x10, 0x8C, 0xFF, 0xD0, 0x84, 0x21,
  0x08, 0x44, 0x00, 0x0C, 0x03, 0x03, 0xF1, 0xB6, 0xCC, 0xF3, 0x06, 0xC0,
  0x78, 0x0D, 0x83, 0x30, 0xCC, 0x31, 0x8C, 0xF3, 0x63, 0xF0, 0x30, 0x0C,
  0x00, 0x78, 0x6C, 0x84, 0x8C, 0xC8, 0xD8, 0xC9, 0x07, 0xA0, 0x06, 0x00,
  0x5E, 0x09, 0x31, 0xB1, 0x33, 0x12, 0x13, 0x61, 0xE0, 0x0F, 0x01, 0x98,
  0x10, 0x81, 0x18, 0x13, 0x01, 0xE0, 0x38, 0x46, 0xC4, 0x46, 0xCC, 0x38,
  0x41, 0x86, 0x3C, 0x3E, 0x70, 0xFF, 0xF0, 0x18, 0x63, 0x08, 0x61, 0x84,
  0x30, 0xC3, 0x0C, 0x30, 0x41, 0x86, 0x08, 0x30, 0x61, 0x80, 0x61, 0x83,
  0x04, 0x18, 0x60, 0x83, 0x0C, 0x30, 0xC3, 0x08, 0x61, 0x84, 0x31, 0x86,
  0x00, 0x18, 0x18, 0x5A, 0x7E, 0x18, 0x24, 0x24, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x76, 0xEC, 0x88, 0xFF,
  0xF0, 0xFC, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30,
  0x08, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x1E, 0x18, 0x66,
  0x19, 0x02, 0xC0, 0xF3, 0x3C, 0xCF, 0x03, 0xC0, 0xD0, 0x26, 0x18, 0x84,
  0x1E, 0x00, 0x06, 0x07, 0x8F, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x7F, 0xC0, 0x1F, 0x18, 0x66, 0x19, 0x02,
  0x01, 0x80, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xFF, 0xC0,
  0x1F, 0x18, 0x66, 0x19, 0x02, 0x01, 0x80, 0xC0, 0xE0, 0x06, 0x00, 0xF0,
  0x34, 0x0D, 0x86, 0x1F, 0x00, 0x03, 0x01, 0xC0, 0xF0, 0x2C, 0x1B, 0x0C,
  0xC2, 0x31, 0x8C, 0xC3, 0x3F, 0xF0, 0x30, 0x0C, 0x03, 0x00, 0x7F, 0x98,
  0x06, 0x01, 0x80, 0x60, 0x17, 0xC6, 0x18, 0x03, 0x00, 0xC0, 0x3C, 0x09,
  0x86, 0x3E, 0x00, 0x1F, 0x0C, 0x66, 0x19, 0x80, 0x40, 0x13, 0xCF, 0x1B,
  0x82, 0x40, 0xD8, 0x36, 0x08, 0xC6, 0x1F, 0x00, 0xFF, 0x03, 0x02, 0x06,
  0x04, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x1E, 0x18, 0x66,
  0x19, 0x02, 0x61, 0x98, 0x61, 0xE1, 0x86, 0xC0, 0xF0, 0x3C, 0x0D, 0x86,
  0x3F, 0x00, 0x3E, 0x18, 0xC4, 0x1B, 0x02, 0xC0, 0xD0, 0x76, 0x1C, 0xFB,
  0x00, 0x80, 0x66, 0x19, 0x8C, 0x3E, 0x00, 0xFC, 0x00, 0xFC, 0x31, 0x8C,
  0x00, 0x00, 0x00, 0x31, 0x98, 0xC4, 0x20, 0x00, 0x40, 0xE0, 0xC1, 0xC0,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x40, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x40, 0xE0, 0xC1, 0xC0,
  0x80, 0x00, 0x3F, 0x30, 0xF0, 0x38, 0x10, 0x18, 0x1C, 0x18, 0x18, 0x18,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x0F, 0x81, 0x8C, 0x30, 0x62, 0x02, 0x67,
  0xA4, 0x9A, 0x58, 0xB5, 0x0B, 0xD1, 0xBD, 0x1A, 0xD1, 0x25, 0x12, 0x53,
  0x64, 0xCC, 0x40, 0x02, 0x04, 0x30, 0xC0, 0xF0, 0x06, 0x00, 0xF0, 0x0F,
  0x00, 0x90, 0x19, 0x81, 0x98, 0x30, 0xC3, 0x0C, 0x3F, 0xC6, 0x06, 0x60,
  0x64, 0x02, 0xC0, 0x30, 0xFE, 0x41, 0xA0, 0xD0, 0x28, 0x34, 0x1B, 0xF1,
  0x06, 0x81, 0xC0, 0xE0, 0x70, 0x7F, 0xE0, 0x1F, 0x0C, 0x66, 0x0F, 0x03,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x36, 0x0C, 0xC6, 0x1F, 0x00,
  0xFC, 0x43, 0x20, 0xD0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0xD0, 0xCF, 0xC0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFD, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x0F, 0xF8, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0xFD, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x1F, 0x1C, 0x66,
  0x0B, 0x03, 0xC0, 0x30, 0x0C, 0x7F, 0x03, 0xC0, 0xD0, 0x36, 0x0C, 0xC7,
  0x1F, 0x00, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0x1F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0xC3, 0xC2, 0x66, 0x3C, 0x81, 0xA0, 0xC8, 0x62, 0x30, 0x98, 0x2C,
  0x0F, 0x83, 0x30, 0x8E, 0x21, 0x88, 0x32, 0x06, 0x81, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F,
  0xF8, 0xE1, 0xF8, 0x7F, 0x1F, 0xCF, 0xD2, 0xF6, 0xBD, 0xEF, 0x33, 0xCC,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0xC1, 0xC1, 0xE1, 0xA1, 0xB1, 0x91,
  0x99, 0x89, 0x8D, 0x85, 0x87, 0x87, 0x83, 0x1E, 0x18, 0x66, 0x1B, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x36, 0x19, 0x86, 0x1E, 0x00,
  0xFE, 0x41, 0xA0, 0x70, 0x38, 0x1C, 0x0E, 0x0D, 0xFC, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x00, 0x1E, 0x18, 0x66, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x36, 0x19, 0x86, 0x1E, 0x01, 0x00, 0x60, 0x1C, 0x03,
  0xC0, 0xFE, 0x20, 0xC8, 0x1A, 0x06, 0x81, 0xA0, 0xCF, 0xE2, 0x30, 0x86,
  0x21, 0x88, 0x32, 0x0E, 0x81, 0x80, 0x3F, 0x18, 0x64, 0x0F, 0x00, 0x60,
  0x1E, 0x01, 0xF0, 0x07, 0x00, 0xF0, 0x3C, 0x0D, 0x86, 0x3F, 0x00, 0xFF,
  0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x34, 0x19, 0x86, 0x3F, 0x00, 0xC0, 0x36, 0x06,
  0x60, 0x66, 0x06, 0x30, 0xC3, 0x0C, 0x10, 0x81, 0x98, 0x19, 0x80, 0x90,
  0x0F, 0x00, 0xF0, 0x06, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x02, 0x46,
  0x26, 0x66, 0x6F, 0x66, 0xF6, 0x69, 0x62, 0x94, 0x39, 0xC3, 0x9C, 0x30,
  0xC0, 0x60, 0x63, 0x0C, 0x30, 0xC1, 0x98, 0x0F, 0x00, 0x60, 0x06, 0x00,
  0xF0, 0x19, 0x81, 0x98, 0x30, 0xC6, 0x06, 0x60, 0x60, 0x60, 0x66, 0x06,
  0x30, 0xC1, 0x98, 0x19, 0x80, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xFF, 0xC0, 0xFE, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3E, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xFE, 0x0C, 0x07, 0x81, 0x20, 0x48, 0x33, 0x08,
  0x46, 0x19, 0x02, 0x40, 0x80, 0xFF, 0xF0, 0xC6, 0x30, 0x3E, 0x18, 0xC6,
  0x18, 0x06, 0x3F, 0x98, 0x6C, 0x1B, 0x06, 0xC3, 0x99, 0xE7, 0x8C, 0xC0,
  0x60, 0x30, 0x18, 0x0D, 0xE7, 0x1B, 0x0D, 0x82, 0xC1, 0xE0, 0xF0, 0x78,
  0x2C, 0x37, 0x1B, 0x78, 0x1F, 0x18, 0x66, 0x0B, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x60, 0x98, 0x61, 0xF0, 0x01, 0x80, 0xC0, 0x60, 0x33, 0xDB,
  0x1D, 0x86, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x36, 0x1B, 0x1C, 0xF2, 0x1E,
  0x1C, 0x66, 0x1B, 0x02, 0xC0, 0xFF, 0xFC, 0x01, 0x00, 0x60, 0x98, 0x61,
  0xF0, 0x0F, 0xC6, 0x01, 0x80, 0x60, 0xFF, 0x86, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x3C, 0xB1, 0x58, 0x68,
  0x3C, 0x1E, 0x0F, 0x06, 0x83, 0x61, 0xB1, 0xCF, 0x60, 0x36, 0x19, 0x88,
  0x78, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x7C, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x0F, 0xFC, 0x06,
  0x0C, 0x00, 0x07, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0B, 0xE0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x36, 0x33, 0x19,
  0x98, 0xD8, 0x7C, 0x3B, 0x19, 0x8C, 0x66, 0x1B, 0x06, 0x3C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x0F, 0xFC, 0xBB, 0xB2, 0xBC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C,
  0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCC, 0x9E, 0xA3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x1E, 0x18, 0x66, 0x1B, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x61, 0x98, 0x61, 0xE0, 0xDE, 0x71, 0xB0, 0xD8, 0x2C,
  0x1E, 0x0F, 0x07, 0x82, 0xC3, 0x71, 0xB7, 0x98, 0x0C, 0x06, 0x03, 0x00,
  0x3D, 0xB1, 0xD8, 0x68, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x61, 0xB1, 0xCF,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0xCF, 0x50, 0x50, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x3C, 0xC3, 0xC3, 0xC0, 0xF0, 0x3E, 0x07, 0x01,
  0x81, 0xC3, 0x7E, 0x20, 0x20, 0x20, 0xFE, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x20, 0x30, 0x1F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC5, 0x79, 0xC0, 0xF0, 0x36, 0x19, 0x86, 0x61, 0x8C, 0xC3,
  0x30, 0x48, 0x1E, 0x07, 0x80, 0xC0, 0xC0, 0x3C, 0x03, 0x40, 0x24, 0x62,
  0x66, 0x66, 0xF6, 0x69, 0x66, 0x96, 0x39, 0xC3, 0x0C, 0x30, 0xC0, 0xC0,
  0x98, 0x63, 0x30, 0x58, 0x1E, 0x03, 0x01, 0xE0, 0xCC, 0x33, 0x18, 0x6C,
  0x0C, 0xC0, 0xF0, 0x34, 0x09, 0x86, 0x21, 0x0C, 0xC3, 0x30, 0x48, 0x1E,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x07, 0x00, 0x7F, 0x80, 0xC0, 0xC0,
  0xC0, 0x40, 0x60, 0x60, 0x60, 0x30, 0x30, 0x3F, 0xE0, 0x0F, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0xC0, 0x30, 0x10, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x03, 0x0C, 0x08, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xF0, 0xF8, 0x41, 0xF0,
};

const GFXglyph LiberationMono_Regular20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 13, 12, 5, -13 },
  { 5, 6, 6, 12, 3, -15 },
  { 10, 10, 13, 12, 1, -13 },
  { 27, 10, 17, 12, 1, -15 },
  { 49, 12, 13, 12, 0, -13 },
  { 69, 12, 13, 12, 0, -13 },
  { 89, 2, 6, 12, 5, -15 },
  { 91, 6, 19, 12, 3, -15 },
  { 106, 6, 19, 12, 3, -15 },
  { 121, 8, 7, 12, 2, -15 },
  { 128, 10, 9, 12, 1, -11 },
  { 140, 4, 6, 12, 3, -3 },
  { 143, 6, 2, 12, 3, -6 },
  { 145, 2, 3, 12, 5, -3 },
  { 146, 10, 15, 12, 1, -15 },
  { 165, 10, 13, 12, 1, -13 },
  { 182, 10, 13, 12, 1, -13 },
  { 199, 10, 13, 12, 1, -13 },
  { 216, 10, 13, 12, 1, -13 },
  { 233, 10, 13, 12, 1, -13 },
  { 250, 10, 13, 12, 1, -13 },
  { 267, 10, 13, 12, 1, -13 },
  { 284, 8, 13, 12, 2, -13 },
  { 297, 10, 13, 12, 1, -13 },
  { 314, 10, 13, 12, 1, -13 },
  { 331, 2, 11, 12, 5, -11 },
  { 334, 5, 14, 12, 3, -11 },
  { 343, 10, 9, 12, 1, -12 },
  { 355, 10, 5, 12, 1, -9 },
  { 362, 10, 9, 12, 1, -12 },
  { 374, 9, 13, 12, 1, -13 },
  { 389, 12, 18, 12, 0, -15 },
  { 416, 12, 13, 12, 0, -13 },
  { 436, 9, 13, 12, 2, -13 },
  { 451, 10, 13, 12, 1, -13 },
  { 468, 9, 13, 12, 2, -13 },
  { 483, 9, 13, 12, 2, -13 },
  { 498, 9, 13, 12, 2, -13 },
  { 513, 10, 13, 12, 1, -13 },
  { 530, 8, 13, 12, 2, -13 },
  { 543, 8, 13, 12, 2, -13 },
  { 556, 8, 13, 12, 2, -13 },
  { 569, 10, 13, 12, 2, -13 },
  { 586, 9, 13, 12, 2, -13 },
  { 601, 10, 13, 12, 1, -13 },
  { 618, 8, 13, 12, 2, -13 },
  { 631, 10, 13, 12, 1, -13 },
  { 648, 9, 13, 12, 2, -13 },
  { 663, 10, 17, 12, 1, -13 },
  { 685, 10, 13, 12, 2, -13 },
  { 702, 10, 13, 12, 1, -13 },
  { 719, 10, 13, 12, 1, -13 },
  { 736, 10, 13, 12, 1, -13 },
  { 753, 12, 13, 12, 0, -13 },
  { 773, 12, 13, 12, 0, -13 },
  { 793, 12, 13, 12, 0, -13 },
  { 813, 12, 13, 12, 0, -13 },
  { 833, 10, 13, 12, 1, -13 },
  { 850, 5, 19, 12, 4, -15 },
  { 862, 10, 15, 12, 1, -15 },
  { 881, 5, 19, 12, 3, -15 },
  { 893, 10, 9, 12, 1, -13 },
  { 905, 12, 1, 12, 0, 1 },
  { 907, 4, 3, 12, 4, -15 },
  { 909, 10, 11, 12, 1, -11 },
  { 923, 9, 15, 12, 2, -15 },
  { 940, 10, 11, 12, 1, -11 },
  { 954, 9, 15, 12, 1, -15 },
  { 971, 10, 11, 12, 1, -11 },
  { 985, 10, 15, 12, 1, -15 },
  { 1004, 9, 15, 12, 1, -11 },
  { 1021, 8, 15, 12, 2, -15 },
  { 1036, 10, 15, 12, 1, -15 },
  { 1055, 7, 19, 12, 1, -15 },
  { 1072, 9, 15, 12, 2, -15 },
  { 1089, 10, 15, 12, 1, -15 },
  { 1108, 10, 11, 12, 1, -11 },
  { 1122, 8, 11, 12, 2, -11 },
  { 1133, 10, 11, 12, 1, -11 },
  { 1147, 9, 15, 12, 2, -11 },
  { 1164, 9, 15, 12, 1, -11 },
  { 1181, 8, 11, 12, 2, -11 },
  { 1192, 8, 11, 12, 2, -11 },
  { 1203, 8, 14, 12, 2, -14 },
  { 1217, 8, 11, 12, 2, -11 },
  { 1228, 10, 11, 12, 1, -11 },
  { 1242, 12, 11, 12, 0, -11 },
  { 1259, 10, 11, 12, 1, -11 },
  { 1273, 10, 15, 12, 1, -11 },
  { 1292, 9, 11, 12, 1, -11 },
  { 1305, 8, 19, 12, 2, -15 },
  { 1324, 2, 19, 12, 5, -15 },
  { 1329, 8, 19, 12, 2, -15 },
  { 1348, 10, 2, 12, 1, -7 },
};

const GFXfont LiberationMono_Regular20pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular20pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _LIBERATIONMONO_REGULAR20PT7B_H_
