#ifndef _LIBERATIONMONO_REGULAR47PT7B_H_
#define _LIBERATIONMONO_REGULAR47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x78,
  0x1F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x00,
  0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x30,
  0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00,
  0x60, 0x00, 0xC0, 0x38, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x06,
  0x00, 0xC0, 0x01, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00,
  0x0E, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x0E,
  0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x81, 0x80, 0x30, 0x00, 0x60,
  0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x60, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0,
  0x01, 0xC0, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x1C,
  0xFC, 0x3C, 0x1C, 0x3E, 0x78, 0x1C, 0x1E, 0x78, 0x1C, 0x1E, 0x78, 0x1C,
  0x0C, 0x78, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x3E, 0x1C,
  0x00, 0x1F, 0x9C, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1C, 0x7E, 0x00, 0x1C, 0x1E, 0x00, 0x1C,
  0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0F, 0x70, 0x1C, 0x0F, 0xF0, 0x1C,
  0x0F, 0xF0, 0x1C, 0x0F, 0xF8, 0x1C, 0x0F, 0x7C, 0x1C, 0x1E, 0x3F, 0x1C,
  0x7E, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x80,
  0x01, 0xC3, 0xFE, 0x00, 0x38, 0x7F, 0xF0, 0x07, 0x87, 0x8F, 0x00, 0x70,
  0xF0, 0x78, 0x0E, 0x0F, 0x03, 0x81, 0xE0, 0xE0, 0x38, 0x1C, 0x0E, 0x03,
  0x83, 0x80, 0xE0, 0x38, 0x78, 0x0E, 0x03, 0x87, 0x00, 0xF0, 0x38, 0xE0,
  0x0F, 0x07, 0x9E, 0x00, 0x78, 0xF3, 0xC0, 0x07, 0xFF, 0x38, 0x00, 0x3F,
  0xE7, 0x00, 0x00, 0xF8, 0xF1, 0xF8, 0x00, 0x0E, 0x7F, 0xC0, 0x01, 0xCF,
  0xFE, 0x00, 0x3C, 0xF0, 0xE0, 0x03, 0x9E, 0x0F, 0x00, 0x71, 0xE0, 0x70,
  0x0F, 0x1C, 0x07, 0x00, 0xE1, 0xC0, 0x70, 0x1C, 0x1C, 0x07, 0x03, 0xC1,
  0xC0, 0x70, 0x38, 0x1E, 0x07, 0x07, 0x01, 0xE0, 0xF0, 0xF0, 0x0F, 0x1E,
  0x1E, 0x00, 0xFF, 0xE1, 0xC0, 0x07, 0xFC, 0x38, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x87, 0xC0,
  0x07, 0x80, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01,
  0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x7C, 0x00, 0x0F,
  0x7E, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xC0,
  0x7F, 0xC0, 0x3C, 0x3E, 0xF0, 0x0E, 0x1F, 0x1E, 0x03, 0x87, 0x83, 0xC1,
  0xE3, 0xC0, 0xF0, 0x70, 0xF0, 0x1E, 0x1C, 0x3C, 0x03, 0xCF, 0x0F, 0x00,
  0x7B, 0x83, 0xC0, 0x1F, 0xE0, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x07,
  0x80, 0x3F, 0x81, 0xF8, 0x3F, 0xF9, 0x3F, 0xFF, 0xBF, 0xC7, 0xFF, 0x87,
  0xF0, 0x3F, 0x80, 0x7C, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xC0, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x0F,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78,
  0x0F, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC3,
  0xF1, 0x8F, 0xFF, 0xBF, 0x7F, 0xFE, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x0E, 0x70, 0x1E, 0x78, 0x3C, 0x3C, 0x38, 0x1C, 0x08, 0x10, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F,
  0x83, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xC0, 0xF8, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00,
  0x1E, 0x78, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC3, 0xF0, 0xFF, 0x0F, 0xC3, 0xFC, 0x3F, 0x0F, 0xF0,
  0xFC, 0x3F, 0xC3, 0xF0, 0xFF, 0x0F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1E, 0x78, 0x00, 0x78,
  0xF0, 0x03, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFD, 0xE0, 0x1F, 0xF3, 0xC0, 0x3F, 0xC7,
  0x80, 0x7C, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0xFC, 0x3E, 0x00,
  0xF9, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0xFC,
  0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0xF8,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xE0, 0x01,
  0xF7, 0xC0, 0x0F, 0x8F, 0xC0, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xF0,
  0x00, 0x79, 0xF0, 0x00, 0x71, 0xF0, 0x00, 0xF1, 0xF0, 0x01, 0xE1, 0xF0,
  0x01, 0xC1, 0xF0, 0x03, 0x81, 0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x01, 0xF0,
  0x0E, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x78, 0x01, 0xF0,
  0x70, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x1F, 0x80, 0x79, 0xFF, 0xC1,
  0xEF, 0xFF, 0x87, 0xF0, 0x3F, 0x1F, 0x00, 0x3E, 0x78, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x03, 0xE7,
  0xC0, 0x1F, 0x8F, 0xC0, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xF0,
  0xFC, 0x1F, 0x00, 0xF8, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x1F, 0xC0, 0x79,
  0xFF, 0xC1, 0xEF, 0xFF, 0x8F, 0xF8, 0x3F, 0x3F, 0x80, 0x3E, 0xFC, 0x00,
  0x7B, 0xE0, 0x01, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D,
  0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDF, 0x00, 0x0F, 0x3C, 0x00, 0x7C, 0xF8,
  0x01, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC0,
  0xFC, 0x3C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E,
  0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x1F,
  0x03, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x3F, 0x03,
  0xF0, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xE0,
  0x01, 0xE7, 0xC0, 0x0F, 0x8F, 0xC0, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xC1, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x9E,
  0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDF, 0x00, 0x3F,
  0x3E, 0x01, 0xFC, 0xFC, 0x1E, 0xF1, 0xFF, 0xF3, 0xC3, 0xFF, 0x8F, 0x03,
  0xF8, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0xF1, 0xF0, 0x07, 0xC3, 0xC0, 0x3E, 0x0F, 0xC1, 0xF0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xF0,
  0x78, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFC, 0x0F, 0xC3, 0xE0, 0x07, 0xCF, 0x80, 0x07, 0x9E, 0x00,
  0x0F, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0x81, 0xF0,
  0x07, 0x80, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0x70, 0x78, 0x00,
  0x1E, 0x1C, 0x00, 0x03, 0x8E, 0x07, 0xC6, 0xE3, 0x83, 0xF9, 0x9D, 0xE1,
  0xC6, 0xE7, 0x70, 0xE0, 0xF9, 0xDC, 0x78, 0x3E, 0x77, 0x1C, 0x07, 0x1F,
  0x87, 0x01, 0xC7, 0xE3, 0x80, 0x71, 0xF8, 0xE0, 0x1C, 0x7E, 0x38, 0x07,
  0x1F, 0x8E, 0x03, 0x87, 0xE7, 0x80, 0xE1, 0xF9, 0xC0, 0x38, 0x7E, 0x70,
  0x0E, 0x1F, 0x9C, 0x03, 0x87, 0xE7, 0x81, 0xE1, 0xB8, 0xE0, 0x70, 0xEE,
  0x38, 0x3C, 0x3B, 0x8E, 0x0B, 0x0C, 0x71, 0xC6, 0xE7, 0x1C, 0x7F, 0x3F,
  0x87, 0x0F, 0x87, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0x01, 0xE0, 0x00, 0xC0, 0x3C, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0,
  0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x78,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF0, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF0, 0x07, 0xF3,
  0xC0, 0x07, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x07, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xC0, 0x0F, 0xEF,
  0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xF8, 0x1F, 0x87, 0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0xF8,
  0x00, 0x11, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x03, 0x1E, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7C,
  0x7C, 0x01, 0xF8, 0xFE, 0x07, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF0, 0x1F, 0xE3, 0xC0, 0x1F, 0x8F, 0x00,
  0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xEF, 0x00, 0x07,
  0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x7C,
  0xF0, 0x01, 0xF3, 0xC0, 0x1F, 0x8F, 0x01, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x83, 0xF8, 0xF8, 0x03,
  0xE7, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x33, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDF,
  0x00, 0x0F, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xF8, 0x0F, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xDC, 0x00,
  0xFF, 0xC0, 0x1E, 0xF8, 0x03, 0xCF, 0x80, 0xF9, 0xF8, 0x3E, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0,
  0x07, 0xC0, 0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0,
  0x7C, 0x00, 0xF0, 0xF8, 0x00, 0xF1, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xF3,
  0xE0, 0x00, 0xF7, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFE,
  0x7C, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xF0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xE0, 0xF0, 0x03, 0xE0, 0xF0,
  0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0x7F, 0xF0, 0x1D, 0xFD, 0xC0, 0xF7, 0xF7, 0x83, 0x9F,
  0xDE, 0x1E, 0xFF, 0x38, 0x7B, 0xFC, 0xF1, 0xCF, 0xF3, 0xCF, 0x3F, 0xC7,
  0x38, 0xFF, 0x1E, 0xE3, 0xFC, 0x7B, 0x8F, 0xF0, 0xFC, 0x3F, 0xC3, 0xF0,
  0xFF, 0x07, 0xC3, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xEF, 0x00, 0x7E, 0xF0, 0x07, 0xF7, 0x80, 0x7F,
  0x78, 0x07, 0xF3, 0xC0, 0x7F, 0x3C, 0x07, 0xF1, 0xE0, 0x7F, 0x1E, 0x07,
  0xF0, 0xF0, 0x7F, 0x0F, 0x07, 0xF0, 0x70, 0x7F, 0x07, 0x87, 0xF0, 0x78,
  0x7F, 0x03, 0xC7, 0xF0, 0x3C, 0x7F, 0x01, 0xE7, 0xF0, 0x1E, 0x7F, 0x00,
  0xF7, 0xF0, 0x0F, 0x7F, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x00,
  0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0xFC, 0x1F, 0xC1, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xF0, 0x07, 0xF3, 0xC0, 0x07, 0xEF, 0x00, 0x0F, 0xBC,
  0x00, 0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00, 0x1F, 0xBC, 0x01, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x1F, 0xC1, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x00, 0x3F, 0x9E, 0x00, 0x1F, 0x3C,
  0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0,
  0x01, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x7E, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xC0, 0xF8,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xE0,
  0x78, 0x03, 0xE0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0xC7,
  0x80, 0x07, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0x81, 0xF8,
  0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1C,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x30, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7F, 0x00, 0xFE, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xDE, 0x00, 0x1F,
  0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3E, 0x3C, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x78,
  0x1F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xC0, 0x3E,
  0x00, 0x3C, 0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F, 0x78,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E, 0x3C, 0x0F, 0x01, 0xE3,
  0xC0, 0xF8, 0x3C, 0x3C, 0x1F, 0x83, 0xC3, 0xC1, 0xF8, 0x3C, 0x3C, 0x1F,
  0x83, 0xC3, 0xC1, 0xFC, 0x3C, 0x1C, 0x3D, 0xC3, 0xC1, 0xE3, 0x9C, 0x38,
  0x1E, 0x39, 0xE3, 0x81, 0xE7, 0x9E, 0x78, 0x1E, 0x78, 0xE7, 0x81, 0xE7,
  0x0E, 0x78, 0x0E, 0x70, 0xF7, 0x80, 0xEF, 0x07, 0x78, 0x0E, 0xE0, 0x77,
  0x00, 0xEE, 0x07, 0x70, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x00,
  0x0F, 0x8F, 0x00, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x0F,
  0x00, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x03, 0xC0,
  0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xBC, 0x00,
  0x03, 0xCF, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x0F,
  0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x0F, 0x81, 0xE0,
  0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0xF8, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0xF0,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x3E, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xCE,
  0x00, 0x0F, 0x3C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x1C, 0x0E, 0x00, 0xF0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x78,
  0x03, 0x81, 0xC0, 0x0E, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0x71, 0xE0, 0x01,
  0xE7, 0x80, 0x03, 0x9C, 0x00, 0x0E, 0xF0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0x07, 0xE0,
  0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x7F, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0xF8, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xF0,
  0xF8, 0x06, 0xF0, 0x7C, 0x1E, 0xF8, 0x7F, 0xFC, 0xFF, 0x3F, 0xF8, 0x7F,
  0x0F, 0xE0, 0x3F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x83, 0xF0, 0x3C, 0x7F, 0xE1, 0xE7, 0xFF, 0x8F, 0x70,
  0x7E, 0x7F, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xEF, 0xC0, 0x1F, 0x7F, 0x00, 0xF3, 0xDC, 0x1F,
  0x9E, 0xFF, 0xF8, 0xF1, 0xFF, 0x87, 0x83, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0xFC, 0x3E, 0x00, 0xF9, 0xF0,
  0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x01, 0xF7, 0x80,
  0x07, 0xDF, 0x00, 0x1E, 0x3E, 0x00, 0xF8, 0x7C, 0x0F, 0xC0, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0xC3, 0xC3, 0xFF, 0x9E, 0x3F,
  0xFE, 0xF3, 0xF0, 0x77, 0x9E, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x00, 0x1F,
  0x78, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0xC0, 0x1F, 0x9E, 0x01,
  0xFC, 0xFC, 0x1D, 0xE3, 0xFF, 0xCF, 0x0F, 0xFC, 0x78, 0x1F, 0x83, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0xFC, 0x3E,
  0x00, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x03, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0xF8, 0x7E, 0x0F,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x78, 0x7F, 0xE3,
  0xC7, 0xFF, 0xDE, 0x7E, 0x0E, 0xF3, 0xE0, 0x3F, 0xBE, 0x00, 0xFD, 0xE0,
  0x03, 0xEF, 0x00, 0x1F, 0x78, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF8, 0x03, 0xF7,
  0xC0, 0x3F, 0x9F, 0x83, 0xBC, 0x7F, 0xF9, 0xE1, 0xFF, 0x8F, 0x03, 0xF0,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF1, 0xC0, 0x0F, 0x9F,
  0x00, 0x78, 0x78, 0x07, 0xC3, 0xF0, 0x7C, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x7F, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x07, 0xE0, 0xF1, 0xFF, 0x8F, 0x3F, 0xFC, 0xF7, 0x07, 0xEF,
  0xE0, 0x1E, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x3E, 0x80, 0x7E, 0xFF, 0xFC, 0xFF, 0xF0, 0x7F, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x0F,
  0xBE, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x0F, 0x83, 0xE0,
  0xF8, 0x1F, 0x07, 0x80, 0xF8, 0x78, 0x07, 0xC7, 0x80, 0x3E, 0x78, 0x01,
  0xF7, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x9F,
  0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F,
  0x80, 0xF8, 0x7C, 0x03, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x01,
  0xF7, 0xC0, 0x07, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xE0, 0xF8, 0xF7, 0xF1, 0xFC,
  0xF7, 0xFB, 0xFE, 0xFC, 0x7B, 0x1E, 0xFC, 0x3E, 0x1E, 0xF8, 0x3E, 0x0F,
  0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x7F, 0x0F,
  0x1F, 0xF8, 0xF3, 0xFF, 0xCF, 0x70, 0x7E, 0xFE, 0x01, 0xEF, 0xC0, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0xFC, 0x3E,
  0x00, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xE0,
  0x01, 0xF7, 0x80, 0x07, 0x9F, 0x00, 0x3E, 0x3E, 0x01, 0xF0, 0x7C, 0x0F,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0xF0, 0x7E, 0x07,
  0x8F, 0xFC, 0x3C, 0xFF, 0xF1, 0xEE, 0x0F, 0xCF, 0xE0, 0x1F, 0x7E, 0x00,
  0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3D, 0xF8,
  0x03, 0xEF, 0xE0, 0x1F, 0x7B, 0x83, 0xF3, 0xCF, 0xFF, 0x1E, 0x3F, 0xF0,
  0xF0, 0x7E, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8, 0x78, 0x7F, 0xF3, 0xC7, 0xFF,
  0xDE, 0x7E, 0x0E, 0xF3, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xE0, 0x03, 0xEF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF8, 0x03, 0xF3, 0xC0, 0x3F,
  0x9F, 0x83, 0xBC, 0x7F, 0xF9, 0xE1, 0xFF, 0x8F, 0x03, 0xF8, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xC0,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xE0, 0x3E, 0x78, 0x01, 0xE7, 0x80,
  0x0F, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xF7, 0xC0, 0x3E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x03, 0xFC,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC1, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x10, 0x7F, 0xFE, 0x07, 0xFF,
  0xC0, 0x3F, 0xE0, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x03, 0xF7, 0xE0, 0xEF, 0x3F, 0xFE,
  0xF1, 0xFF, 0x8F, 0x07, 0xE0, 0xF0, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x0F,
  0x9E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE1, 0xE0, 0x01,
  0xE0, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x3C,
  0x0F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x00,
  0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x01, 0xE3, 0xC0, 0xF0, 0x3C, 0x3C, 0x1F, 0x83, 0xC3, 0xC1, 0xF8, 0x3C,
  0x3C, 0x1F, 0x83, 0xC3, 0xC3, 0xDC, 0x3C, 0x1C, 0x39, 0xC3, 0xC1, 0xE3,
  0x9C, 0x78, 0x1E, 0x79, 0xE7, 0x81, 0xE7, 0x0E, 0x78, 0x1E, 0x70, 0xE7,
  0x81, 0xEF, 0x0F, 0x78, 0x0E, 0xE0, 0x77, 0x80, 0xEE, 0x07, 0x70, 0x0E,
  0xE0, 0x77, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x07,
  0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x01, 0xE7, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xE7, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xC3, 0xC0, 0x07,
  0x81, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x7C,
  0x00, 0x07, 0x9E, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xC7, 0xC0, 0x01, 0xE1,
  0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x78,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x87, 0x80, 0x01, 0xE3,
  0xC0, 0x00, 0xF1, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3E,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x01, 0xF8,
};

const GFXglyph LiberationMono_Regular47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 4, 31, 28, 12, -31 },
  { 17, 16, 15, 28, 6, -34 },
  { 47, 26, 31, 28, 1, -31 },
  { 148, 24, 38, 28, 2, -34 },
  { 262, 28, 31, 28, 0, -31 },
  { 371, 26, 31, 28, 1, -31 },
  { 472, 5, 15, 28, 12, -34 },
  { 482, 12, 44, 28, 8, -34 },
  { 548, 12, 44, 28, 8, -34 },
  { 614, 16, 16, 28, 6, -34 },
  { 646, 23, 23, 28, 3, -27 },
  { 713, 10, 15, 28, 6, -7 },
  { 732, 13, 4, 28, 8, -14 },
  { 739, 6, 7, 28, 11, -7 },
  { 745, 23, 34, 28, 3, -34 },
  { 843, 22, 31, 28, 3, -31 },
  { 929, 23, 31, 28, 3, -31 },
  { 1019, 22, 31, 28, 3, -31 },
  { 1105, 22, 31, 28, 3, -31 },
  { 1191, 24, 31, 28, 2, -31 },
  { 1284, 22, 31, 28, 3, -31 },
  { 1370, 22, 31, 28, 3, -31 },
  { 1456, 21, 31, 28, 4, -31 },
  { 1538, 22, 31, 28, 3, -31 },
  { 1624, 22, 31, 28, 3, -31 },
  { 1710, 6, 25, 28, 11, -25 },
  { 1729, 10, 33, 28, 8, -25 },
  { 1771, 23, 23, 28, 3, -27 },
  { 1838, 23, 15, 28, 3, -23 },
  { 1882, 23, 23, 28, 3, -27 },
  { 1949, 23, 31, 28, 2, -31 },
  { 2039, 26, 40, 28, 1, -34 },
  { 2169, 28, 31, 28, 0, -31 },
  { 2278, 22, 31, 28, 4, -31 },
  { 2364, 23, 31, 28, 3, -31 },
  { 2454, 22, 31, 28, 4, -31 },
  { 2540, 22, 31, 28, 4, -31 },
  { 2626, 21, 31, 28, 4, -31 },
  { 2708, 22, 31, 28, 3, -31 },
  { 2794, 20, 31, 28, 4, -31 },
  { 2872, 19, 31, 28, 5, -31 },
  { 2946, 19, 31, 28, 4, -31 },
  { 3020, 24, 31, 28, 4, -31 },
  { 3113, 20, 31, 28, 5, -31 },
  { 3191, 22, 31, 28, 3, -31 },
  { 3277, 20, 31, 28, 4, -31 },
  { 3355, 24, 31, 28, 2, -31 },
  { 3448, 22, 31, 28, 4, -31 },
  { 3534, 24, 40, 28, 2, -31 },
  { 3654, 23, 31, 28, 4, -31 },
  { 3744, 24, 31, 28, 2, -31 },
  { 3837, 24, 31, 28, 2, -31 },
  { 3930, 22, 31, 28, 3, -31 },
  { 4016, 28, 31, 28, 0, -31 },
  { 4125, 28, 31, 28, 0, -31 },
  { 4234, 26, 31, 28, 1, -31 },
  { 4335, 26, 31, 28, 1, -31 },
  { 4436, 25, 31, 28, 2, -31 },
  { 4533, 13, 44, 28, 9, -34 },
  { 4605, 23, 34, 28, 3, -34 },
  { 4703, 13, 44, 28, 6, -34 },
  { 4775, 22, 21, 28, 3, -31 },
  { 4833, 28, 2, 28, 0, 3 },
  { 4840, 10, 6, 28, 9, -34 },
  { 4848, 24, 25, 28, 3, -25 },
  { 4923, 21, 34, 28, 4, -34 },
  { 5013, 22, 25, 28, 3, -25 },
  { 5082, 21, 34, 28, 3, -34 },
  { 5172, 22, 25, 28, 3, -25 },
  { 5241, 22, 34, 28, 3, -34 },
  { 5335, 21, 35, 28, 3, -25 },
  { 5427, 20, 34, 28, 4, -34 },
  { 5512, 23, 34, 28, 3, -34 },
  { 5610, 16, 44, 28, 3, -34 },
  { 5698, 21, 34, 28, 5, -34 },
  { 5788, 23, 34, 28, 3, -34 },
  { 5886, 24, 25, 28, 2, -25 },
  { 5961, 20, 25, 28, 4, -25 },
  { 6024, 22, 25, 28, 3, -25 },
  { 6093, 21, 35, 28, 4, -25 },
  { 6185, 21, 35, 28, 3, -25 },
  { 6277, 18, 25, 28, 6, -25 },
  { 6334, 20, 25, 28, 4, -25 },
  { 6397, 19, 31, 28, 4, -31 },
  { 6471, 20, 25, 28, 4, -25 },
  { 6534, 25, 25, 28, 2, -25 },
  { 6613, 28, 25, 28, 0, -25 },
  { 6701, 24, 25, 28, 2, -25 },
  { 6776, 25, 35, 28, 2, -25 },
  { 6886, 22, 25, 28, 3, -25 },
  { 6955, 19, 44, 28, 5, -34 },
  { 7060, 4, 44, 28, 12, -34 },
  { 7082, 19, 44, 28, 4, -34 },
  { 7187, 24, 6, 28, 2, -19 },
};

const GFXfont LiberationMono_Regular47pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular47pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular47pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _LIBERATIONMONO_REGULAR47PT7B_H_
