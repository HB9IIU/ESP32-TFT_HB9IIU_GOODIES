#ifndef _LIBERATIONMONO_REGULAR15PT7B_H_
#define _LIBERATIONMONO_REGULAR15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x40, 0xDE, 0xF7, 0x18, 0x80, 0x11, 0x09, 0x04, 0x8F, 0xF2,
  0x21, 0x13, 0xFC, 0x48, 0x44, 0x22, 0x00, 0x08, 0x3E, 0x6B, 0x49, 0x68,
  0x3C, 0x0B, 0x09, 0x49, 0x69, 0x3E, 0x08, 0x71, 0x49, 0x24, 0x92, 0x87,
  0x80, 0x78, 0x52, 0x49, 0x24, 0xA3, 0x80, 0x1C, 0x11, 0x08, 0x85, 0x83,
  0x12, 0x8B, 0x29, 0x94, 0x46, 0x3C, 0xC0, 0xF8, 0x11, 0x18, 0x84, 0x21,
  0x08, 0x42, 0x10, 0xC2, 0x08, 0x42, 0x31, 0x11, 0x11, 0x11, 0x13, 0x24,
  0x25, 0x5C, 0xAD, 0x00, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x6B,
  0x40, 0xF8, 0xC0, 0x02, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x82,
  0x00, 0x38, 0x8B, 0x1C, 0x19, 0x32, 0x60, 0xE3, 0x44, 0x70, 0x18, 0x73,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x19, 0xFC, 0x3C, 0x8F, 0x18, 0x30, 0x43,
  0x0C, 0x30, 0xC1, 0xFC, 0x3C, 0x8F, 0x18, 0x23, 0x80, 0xC0, 0xC1, 0xC6,
  0xF8, 0x0C, 0x28, 0xD1, 0x24, 0x50, 0xBF, 0x82, 0x04, 0x08, 0x7D, 0x83,
  0x07, 0xEC, 0x60, 0x40, 0xC1, 0xC4, 0xF0, 0x3C, 0x8D, 0x05, 0xEC, 0x78,
  0x70, 0xE1, 0x46, 0x78, 0xFE, 0x08, 0x10, 0x41, 0x82, 0x04, 0x18, 0x20,
  0x40, 0x7D, 0x8F, 0x1A, 0x23, 0x98, 0xE0, 0xC1, 0xC6, 0xF8, 0x38, 0x8B,
  0x1C, 0x1C, 0x68, 0xDE, 0x83, 0xC4, 0xF0, 0xC3, 0x48, 0x00, 0x16, 0x90,
  0x02, 0x39, 0x84, 0x06, 0x03, 0x80, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x80,
  0xE0, 0x30, 0x10, 0xCE, 0x20, 0x00, 0x39, 0x8E, 0x08, 0x30, 0xC3, 0x0C,
  0x00, 0x00, 0x60, 0x1E, 0x10, 0x90, 0x4B, 0xD5, 0x2D, 0x16, 0x93, 0x49,
  0xA5, 0x2D, 0x90, 0x04, 0x61, 0xC0, 0x0C, 0x0A, 0x05, 0x06, 0xC2, 0x21,
  0x11, 0xFC, 0x82, 0x41, 0x60, 0xC0, 0xFD, 0x8F, 0x1E, 0x2F, 0x98, 0xF0,
  0xE1, 0xC7, 0xF8, 0x3C, 0x8F, 0x0C, 0x08, 0x10, 0x20, 0x61, 0x46, 0x78,
  0xF9, 0x8B, 0x1E, 0x1C, 0x38, 0x70, 0xE3, 0xC5, 0xF0, 0xFF, 0x83, 0x06,
  0x0F, 0xD8, 0x30, 0x60, 0xC1, 0xFC, 0xFF, 0x83, 0x06, 0x0F, 0xF8, 0x30,
  0x60, 0xC1, 0x80, 0x38, 0x8F, 0x0C, 0x08, 0x11, 0xE0, 0xE1, 0x42, 0x78,
  0xC7, 0x8F, 0x1E, 0x3F, 0xF8, 0xF1, 0xE3, 0xC7, 0x8C, 0xFE, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x1C, 0x10, 0x41, 0x04, 0x10, 0x71,
  0x4C, 0xE0, 0xC6, 0xC4, 0xC8, 0xD0, 0xF0, 0xD8, 0xC8, 0xC4, 0xC6, 0xC3,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0xC7, 0x8F, 0x1D, 0x5A,
  0xB5, 0x64, 0xC1, 0x83, 0x04, 0xC3, 0x86, 0x8D, 0x19, 0x32, 0x62, 0xC5,
  0x8F, 0x0C, 0x38, 0x8B, 0x1C, 0x18, 0x30, 0x60, 0xE3, 0x44, 0x70, 0xFD,
  0x8F, 0x0E, 0x3F, 0xD8, 0x30, 0x60, 0xC1, 0x80, 0x38, 0x8B, 0x1C, 0x18,
  0x30, 0x60, 0xE3, 0x44, 0x70, 0x60, 0x40, 0xE0, 0xFC, 0xC6, 0xC2, 0xC6,
  0xFC, 0xC8, 0xCC, 0xC4, 0xC6, 0xC2, 0x7D, 0x8E, 0x0E, 0x07, 0x81, 0xC0,
  0xC1, 0xC6, 0xF8, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE3, 0xC6, 0xF8, 0xC1, 0xA0, 0x90,
  0x4C, 0x62, 0x21, 0x10, 0xD8, 0x28, 0x14, 0x04, 0x00, 0x80, 0xE0, 0xF0,
  0x69, 0x25, 0x52, 0xA9, 0x54, 0xAA, 0x63, 0x31, 0x80, 0x41, 0x11, 0x0D,
  0x82, 0x80, 0x80, 0xE0, 0x50, 0x44, 0x63, 0x20, 0x80, 0x41, 0x20, 0x88,
  0x84, 0x41, 0x40, 0xA0, 0x20, 0x10, 0x08, 0x04, 0x00, 0xFE, 0x0C, 0x30,
  0x41, 0x06, 0x18, 0x20, 0x81, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x8F, 0x80, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x08, 0xF1,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x10, 0x50, 0xA2, 0x24, 0x48, 0xA0,
  0x80, 0xFF, 0x80, 0xC4, 0x78, 0xC4, 0x04, 0x7C, 0xC4, 0x84, 0xCC, 0x77,
  0xC1, 0x83, 0x07, 0xEC, 0x78, 0xF0, 0xE1, 0xC7, 0x8F, 0xF0, 0x3C, 0x8E,
  0x04, 0x08, 0x18, 0x11, 0x9E, 0x06, 0x0C, 0x1B, 0xFC, 0x78, 0xE1, 0xC3,
  0xC7, 0x8D, 0xF8, 0x3C, 0x8E, 0x0F, 0xF8, 0x18, 0x11, 0x9E, 0x1E, 0x60,
  0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x7F, 0x8F, 0x1C, 0x38,
  0x78, 0xF1, 0xBF, 0x06, 0x89, 0xF0, 0xC1, 0x83, 0x07, 0xEC, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x18, 0x10, 0x00, 0x03, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x23, 0xF8, 0x08, 0x00, 0xF0, 0x84, 0x21, 0x08, 0x42, 0x11, 0xF8, 0x82,
  0x08, 0x23, 0x9A, 0xCE, 0x3C, 0x92, 0x28, 0xC0, 0x70, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x23, 0xF8, 0xFF, 0x26, 0x4C, 0x99, 0x32, 0x64,
  0xC9, 0xFD, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x7C, 0x8F, 0x1C, 0x18,
  0x38, 0xD1, 0x3C, 0xFD, 0x8F, 0x0E, 0x1C, 0x38, 0xF1, 0xFE, 0xC1, 0x83,
  0x00, 0x7F, 0x8F, 0x1C, 0x38, 0x78, 0xF1, 0xBF, 0x06, 0x0C, 0x18, 0xBE,
  0x8C, 0x30, 0x82, 0x08, 0x20, 0x7C, 0x89, 0x03, 0x80, 0xC0, 0xF1, 0xBE,
  0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08, 0x20, 0xF0, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xD1, 0xBF, 0x41, 0x63, 0x62, 0x22, 0x36, 0x14, 0x14, 0x18, 0xC1,
  0xE0, 0xD2, 0x4A, 0xA5, 0x52, 0xA9, 0x94, 0xC6, 0xC6, 0x88, 0xA1, 0xC3,
  0x85, 0x11, 0x43, 0x41, 0x20, 0x88, 0x84, 0x43, 0x20, 0xA0, 0x50, 0x10,
  0x08, 0x08, 0x1C, 0x00, 0xFE, 0x08, 0x20, 0x83, 0x0C, 0x10, 0x7F, 0x3C,
  0x82, 0x08, 0x21, 0x88, 0x18, 0x20, 0x82, 0x08, 0x20, 0xF0, 0xFF, 0xFC,
  0xF0, 0x41, 0x04, 0x10, 0x60, 0x46, 0x10, 0x41, 0x04, 0x13, 0xC0, 0xF0,
  0x3C,
};

const GFXglyph LiberationMono_Regular15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 1, 10, 9, 4, -10 },
  { 3, 5, 5, 9, 2, -11 },
  { 7, 9, 10, 9, 0, -10 },
  { 19, 8, 12, 9, 0, -11 },
  { 31, 9, 10, 9, 0, -10 },
  { 43, 9, 10, 9, 0, -10 },
  { 55, 1, 5, 9, 4, -11 },
  { 56, 5, 14, 9, 2, -11 },
  { 65, 4, 14, 9, 2, -11 },
  { 72, 5, 5, 9, 2, -11 },
  { 76, 7, 7, 9, 1, -9 },
  { 83, 3, 4, 9, 2, -2 },
  { 85, 5, 1, 9, 2, -5 },
  { 86, 1, 2, 9, 4, -2 },
  { 87, 7, 11, 9, 1, -11 },
  { 97, 7, 10, 9, 1, -10 },
  { 106, 7, 10, 9, 1, -10 },
  { 115, 7, 10, 9, 1, -10 },
  { 124, 7, 10, 9, 1, -10 },
  { 133, 7, 10, 9, 1, -10 },
  { 142, 7, 10, 9, 1, -10 },
  { 151, 7, 10, 9, 1, -10 },
  { 160, 7, 10, 9, 1, -10 },
  { 169, 7, 10, 9, 1, -10 },
  { 178, 7, 10, 9, 1, -10 },
  { 187, 1, 8, 9, 4, -8 },
  { 188, 3, 10, 9, 3, -8 },
  { 192, 7, 7, 9, 1, -9 },
  { 199, 7, 4, 9, 1, -7 },
  { 203, 7, 7, 9, 1, -9 },
  { 210, 7, 10, 9, 1, -10 },
  { 219, 9, 13, 9, 0, -11 },
  { 234, 9, 10, 9, 0, -10 },
  { 246, 7, 10, 9, 1, -10 },
  { 255, 7, 10, 9, 1, -10 },
  { 264, 7, 10, 9, 1, -10 },
  { 273, 7, 10, 9, 1, -10 },
  { 282, 7, 10, 9, 1, -10 },
  { 291, 7, 10, 9, 1, -10 },
  { 300, 7, 10, 9, 1, -10 },
  { 309, 7, 10, 9, 1, -10 },
  { 318, 6, 10, 9, 1, -10 },
  { 326, 8, 10, 9, 1, -10 },
  { 336, 6, 10, 9, 2, -10 },
  { 344, 7, 10, 9, 1, -10 },
  { 353, 7, 10, 9, 1, -10 },
  { 362, 7, 10, 9, 1, -10 },
  { 371, 7, 10, 9, 1, -10 },
  { 380, 7, 13, 9, 1, -10 },
  { 392, 8, 10, 9, 1, -10 },
  { 402, 7, 10, 9, 1, -10 },
  { 411, 7, 10, 9, 1, -10 },
  { 420, 7, 10, 9, 1, -10 },
  { 429, 9, 10, 9, 0, -10 },
  { 441, 9, 10, 9, 0, -10 },
  { 453, 9, 10, 9, 0, -10 },
  { 465, 9, 10, 9, 0, -10 },
  { 477, 7, 10, 9, 1, -10 },
  { 486, 4, 14, 9, 3, -11 },
  { 493, 7, 11, 9, 1, -11 },
  { 503, 4, 14, 9, 2, -11 },
  { 510, 7, 7, 9, 1, -10 },
  { 517, 9, 1, 9, 0, 1 },
  { 519, 3, 2, 9, 3, -11 },
  { 520, 8, 8, 9, 1, -8 },
  { 528, 7, 11, 9, 1, -11 },
  { 538, 7, 8, 9, 1, -8 },
  { 545, 7, 11, 9, 1, -11 },
  { 555, 7, 8, 9, 1, -8 },
  { 562, 7, 11, 9, 1, -11 },
  { 572, 7, 11, 9, 1, -8 },
  { 582, 7, 11, 9, 1, -11 },
  { 592, 7, 11, 9, 1, -11 },
  { 602, 5, 14, 9, 1, -11 },
  { 611, 6, 11, 9, 2, -11 },
  { 620, 7, 11, 9, 1, -11 },
  { 630, 7, 8, 9, 1, -8 },
  { 637, 7, 8, 9, 1, -8 },
  { 644, 7, 8, 9, 1, -8 },
  { 651, 7, 11, 9, 1, -8 },
  { 661, 7, 11, 9, 1, -8 },
  { 671, 6, 8, 9, 2, -8 },
  { 677, 7, 8, 9, 1, -8 },
  { 684, 6, 10, 9, 1, -10 },
  { 692, 7, 8, 9, 1, -8 },
  { 699, 8, 8, 9, 0, -8 },
  { 707, 9, 8, 9, 0, -8 },
  { 716, 7, 8, 9, 1, -8 },
  { 723, 9, 11, 9, 0, -8 },
  { 736, 7, 8, 9, 1, -8 },
  { 743, 6, 14, 9, 2, -11 },
  { 754, 1, 14, 9, 4, -11 },
  { 756, 6, 14, 9, 1, -11 },
  { 767, 7, 2, 9, 1, -6 },
};

const GFXfont LiberationMono_Regular15pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular15pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular15pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _LIBERATIONMONO_REGULAR15PT7B_H_
