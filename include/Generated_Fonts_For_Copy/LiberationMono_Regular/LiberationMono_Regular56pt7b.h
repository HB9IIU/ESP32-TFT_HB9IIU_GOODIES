#ifndef _LIBERATIONMONO_REGULAR56PT7B_H_
#define _LIBERATIONMONO_REGULAR56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0xFB, 0xEF, 0xBE, 0xF8, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3E, 0xF8,
  0x0F, 0xBE, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x80, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x01,
  0xC0, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xC0, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0,
  0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x03,
  0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80,
  0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x70, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xC7, 0x9F, 0xE1, 0xF8, 0x3C, 0x3F, 0x0F, 0x81, 0xE0, 0xFC,
  0x7C, 0x0F, 0x03, 0xE3, 0xC0, 0x78, 0x1F, 0x1E, 0x03, 0xC0, 0x60, 0xF0,
  0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xFC, 0x3C,
  0x00, 0x07, 0xF9, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0x8F, 0xE0, 0x00, 0x3C, 0x1F, 0x80, 0x01, 0xE0, 0x7E, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xC0, 0x3C, 0xE0, 0x1E, 0x01,
  0xFF, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0x80, 0xFB, 0xE0, 0x3C, 0x07, 0xDF,
  0x81, 0xE0, 0x7E, 0x7E, 0x0F, 0x07, 0xE3, 0xFC, 0x78, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0x83, 0xFF, 0xC0, 0x01, 0xE1, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x1E, 0x00,
  0x78, 0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x00,
  0xF0, 0x78, 0x03, 0xC0, 0x7C, 0x3C, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x3E,
  0x07, 0x87, 0x80, 0x07, 0x81, 0xE3, 0xC0, 0x01, 0xF0, 0xF0, 0xF0, 0x00,
  0x3F, 0xFC, 0x78, 0x00, 0x07, 0xFE, 0x3C, 0x00, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x01, 0xE1,
  0xFF, 0x80, 0x00, 0x78, 0xFF, 0xF0, 0x00, 0x3C, 0x7C, 0x3C, 0x00, 0x1E,
  0x1E, 0x07, 0x80, 0x07, 0x8F, 0x01, 0xE0, 0x03, 0xC3, 0xC0, 0x78, 0x01,
  0xE0, 0xF0, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xC0, 0x3C, 0x07,
  0x81, 0xE0, 0x0F, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x3C, 0x00, 0x7C,
  0x3C, 0x1E, 0x00, 0x0F, 0xFF, 0x0F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x0F,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x3C, 0x7F, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0x80,
  0x3F, 0xF0, 0x03, 0xC0, 0xFD, 0xF0, 0x07, 0x83, 0xF3, 0xE0, 0x0F, 0x07,
  0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xC0, 0x78, 0x3C, 0x07, 0xC0, 0xF0, 0xF8,
  0x07, 0xC3, 0xE1, 0xF0, 0x07, 0xC7, 0x83, 0xE0, 0x0F, 0x8F, 0x07, 0xC0,
  0x0F, 0xBE, 0x0F, 0x80, 0x0F, 0xF8, 0x1F, 0x00, 0x0F, 0xF0, 0x3E, 0x00,
  0x1F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0xC0, 0x7F, 0x03,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xF0, 0x7F, 0xFC,
  0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE,
  0xFB, 0xEF, 0xBE, 0x79, 0xE7, 0x9E, 0x78, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x04, 0x0E, 0x02, 0x70, 0xE1, 0xEF, 0xEE, 0x7E, 0xFF,
  0xFF, 0xF3, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00,
  0x3B, 0xC0, 0x07, 0x9E, 0x00, 0xF1, 0xE0, 0x1F, 0x0F, 0x01, 0xE0, 0xF8,
  0x1C, 0x07, 0x00, 0x40, 0x20, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xF0,
  0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0xF8, 0x1F, 0x83, 0xFF, 0x03, 0xF0, 0x7F, 0xE0, 0x7E, 0x0F, 0xFC,
  0x0F, 0xC1, 0xFF, 0x81, 0xF8, 0x3F, 0xF0, 0x3F, 0x07, 0xFE, 0x07, 0xE0,
  0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xF0,
  0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFB, 0xE0, 0x07, 0xFE, 0x7C, 0x00, 0xFF, 0x0F,
  0x80, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xC7, 0xF0, 0x03, 0xF8, 0x7F,
  0x81, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0x3E, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0,
  0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x03, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3E, 0x01, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x3E,
  0x0F, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC1, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x3F,
  0xC0, 0x0F, 0x9F, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07,
  0xF8, 0x0F, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0xFC, 0x00,
  0x3E, 0x3E, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x81, 0xFC, 0x03,
  0xE3, 0xFF, 0xC0, 0xF9, 0xFF, 0xFC, 0x3E, 0xFF, 0xFF, 0x8F, 0xFC, 0x0F,
  0xF3, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xEF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xE0,
  0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC3,
  0xF0, 0x03, 0xE0, 0x7E, 0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0xFE, 0x0F, 0x80,
  0x0F, 0xC7, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x7C, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0xC3, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xC1,
  0xFC, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0xFC,
  0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x01, 0xFD, 0xF8,
  0x00, 0xFF, 0x3F, 0x00, 0x7F, 0xCF, 0xF0, 0x7D, 0xF1, 0xFF, 0xFF, 0x7C,
  0x3F, 0xFF, 0x9E, 0x07, 0xFF, 0x87, 0x80, 0x3F, 0x83, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x03,
  0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F, 0xC0, 0x7F,
  0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x03, 0xE0, 0x1C,
  0x3C, 0x0F, 0xF1, 0xDE, 0x3C, 0x1F, 0xFB, 0xCE, 0x38, 0x3E, 0x3B, 0x8E,
  0x78, 0x3C, 0x1F, 0x8E, 0x78, 0x78, 0x0F, 0x8E, 0x78, 0x70, 0x0F, 0x8E,
  0x70, 0xF0, 0x0F, 0x8E, 0x70, 0xF0, 0x0F, 0x0F, 0x70, 0xE0, 0x0F, 0x0F,
  0xF1, 0xE0, 0x0F, 0x0F, 0xF1, 0xE0, 0x0F, 0x0E, 0xF1, 0xE0, 0x0F, 0x0E,
  0xF1, 0xC0, 0x0E, 0x0E, 0xF1, 0xC0, 0x1E, 0x0E, 0xF1, 0xC0, 0x1E, 0x0E,
  0xF1, 0xC0, 0x1E, 0x0E, 0xF1, 0xC0, 0x1E, 0x1E, 0xF1, 0xC0, 0x3C, 0x1E,
  0xF1, 0xC0, 0x3C, 0x1C, 0xF1, 0xE0, 0x3C, 0x1C, 0x71, 0xE0, 0x7C, 0x3C,
  0x71, 0xE0, 0xFC, 0x38, 0x70, 0xF1, 0xDC, 0x78, 0x78, 0xFF, 0xDF, 0xF0,
  0x78, 0x7F, 0x8F, 0xE0, 0x38, 0x3E, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x40, 0x07, 0x80, 0x00, 0xE0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0x0F,
  0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x7F, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x01,
  0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x08, 0x7E, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x1F, 0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC0,
  0xFC, 0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0,
  0x7F, 0xC1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x3F, 0x7E, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x07, 0xF0, 0xFC, 0x03, 0xFC,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x07,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7D, 0xF8, 0x00, 0x0C, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9,
  0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0xC0,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xCE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x01, 0xF8,
  0xFE, 0x0F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x9F, 0x80, 0x03, 0xFC, 0x3F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xBF, 0xDE,
  0x01, 0xEF, 0xF7, 0x80, 0x7B, 0xFD, 0xF0, 0x3C, 0xFF, 0x3C, 0x0F, 0x3F,
  0xCF, 0x03, 0xCF, 0xF3, 0xE1, 0xE3, 0xFC, 0x78, 0x78, 0xFF, 0x1E, 0x3E,
  0x3F, 0xC7, 0xCF, 0x0F, 0xF0, 0xF3, 0xC3, 0xFC, 0x3C, 0xF0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x0F, 0xC0, 0xFF,
  0x03, 0xF0, 0x3F, 0xC0, 0xF8, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFB, 0xC0, 0x0F, 0xFD, 0xF0, 0x07, 0xFE, 0x78, 0x03, 0xFF,
  0x3E, 0x01, 0xFF, 0x8F, 0x00, 0xFF, 0xC7, 0xC0, 0x7F, 0xE1, 0xE0, 0x3F,
  0xF0, 0xF8, 0x1F, 0xF8, 0x7C, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83,
  0xFF, 0x03, 0xE1, 0xFF, 0x81, 0xF0, 0xFF, 0xC0, 0x78, 0x7F, 0xE0, 0x3E,
  0x3F, 0xF0, 0x0F, 0x1F, 0xF8, 0x07, 0xCF, 0xFC, 0x01, 0xE7, 0xFE, 0x00,
  0xF9, 0xFF, 0x00, 0x7C, 0xFF, 0x80, 0x1F, 0x7F, 0xC0, 0x0F, 0xBF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xE0, 0xFF, 0x01, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0x7C,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x8F, 0xC0, 0x0F, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFB,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xF3, 0xF0, 0x03, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF,
  0x01, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x3E, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7C,
  0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFE, 0x03, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x7C, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0E, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF1, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x3F,
  0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xBF, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7C, 0x7E, 0x00,
  0x3F, 0x0F, 0xE0, 0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0x1F, 0x0F, 0x80,
  0xFC, 0x07, 0xC3, 0xE0, 0x7F, 0x01, 0xE0, 0xF8, 0x1F, 0xC0, 0xF8, 0x1E,
  0x07, 0xF8, 0x3E, 0x07, 0x81, 0xDE, 0x0F, 0x81, 0xF0, 0xF7, 0x83, 0xE0,
  0x7C, 0x3C, 0xE0, 0xF8, 0x1F, 0x0F, 0x3C, 0x3C, 0x07, 0xC3, 0xCF, 0x0F,
  0x00, 0xF1, 0xE3, 0xC3, 0xC0, 0x3C, 0x78, 0x79, 0xF0, 0x0F, 0x1E, 0x1E,
  0x7C, 0x03, 0xC7, 0x87, 0x9F, 0x00, 0xFB, 0xC1, 0xE7, 0x80, 0x3E, 0xF0,
  0x39, 0xE0, 0x0F, 0xBC, 0x0F, 0x78, 0x01, 0xEE, 0x03, 0xDE, 0x00, 0x7F,
  0x80, 0xF7, 0x80, 0x1F, 0xE0, 0x1D, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x03,
  0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x0F,
  0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x00,
  0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFE, 0x00, 0xF8, 0x1F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F,
  0x80, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF8, 0x1F, 0x80,
  0x3B, 0xE0, 0xFE, 0x07, 0x9F, 0x03, 0xFF, 0xFC, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x1F, 0x1F, 0xFE, 0x0F, 0x9F, 0xFF,
  0x87, 0xDF, 0xFF, 0xE3, 0xFF, 0x07, 0xF1, 0xFE, 0x00, 0xFC, 0xFE, 0x00,
  0x3E, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0,
  0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xDF, 0xC0, 0x07,
  0xCF, 0xF0, 0x07, 0xE7, 0xFE, 0x0F, 0xE3, 0xEF, 0xFF, 0xF1, 0xF3, 0xFF,
  0xF0, 0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF,
  0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFD, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF0,
  0x7F, 0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x7F, 0x03, 0xE0, 0xFF, 0xF1, 0xF0, 0xFF, 0xFC, 0xF8, 0xFF, 0xFF, 0x7C,
  0xFE, 0x07, 0xBE, 0x7E, 0x00, 0xFF, 0x7E, 0x00, 0x3F, 0xBE, 0x00, 0x1F,
  0xDF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xBE,
  0x00, 0x1F, 0xDF, 0x00, 0x0F, 0xEF, 0xC0, 0x0F, 0xF3, 0xF0, 0x0F, 0xF9,
  0xFC, 0x0F, 0x7C, 0x7F, 0xFF, 0x3E, 0x1F, 0xFF, 0x9F, 0x07, 0xFF, 0x0F,
  0x80, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x06, 0x0F, 0x80, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0x7F, 0x03, 0xFC, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x87, 0xC3, 0xFF, 0xF3, 0xE3,
  0xFF, 0xFD, 0xF3, 0xF8, 0x1E, 0xF9, 0xF8, 0x07, 0xFD, 0xF8, 0x01, 0xFE,
  0xF8, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFD, 0xF0,
  0x00, 0xFE, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xBF, 0x00, 0x7F, 0xCF,
  0xE0, 0x7B, 0xE3, 0xFF, 0xF9, 0xF1, 0xFF, 0xF8, 0xF8, 0x3F, 0xF8, 0x7C,
  0x07, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC3, 0xC0, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03,
  0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x1F, 0xC0, 0xF8, 0xFF, 0xF0, 0xF9, 0xFF, 0xF8, 0xFB, 0xFF, 0xFC, 0xFF,
  0xC1, 0xFE, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0xC0, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0xEF, 0x80, 0x07, 0xE7, 0xC0, 0x07, 0xE3,
  0xE0, 0x07, 0xE1, 0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0,
  0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xFB, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xE3, 0xF0, 0x07, 0xE0,
  0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x1F,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x1F, 0x0F,
  0x3F, 0xC3, 0xFC, 0xF7, 0xFC, 0x7F, 0xCF, 0x7F, 0xEF, 0xFE, 0xFE, 0x3E,
  0xE3, 0xEF, 0xC1, 0xFC, 0x3E, 0xFC, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F,
  0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81,
  0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01,
  0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8,
  0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0,
  0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF,
  0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F,
  0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xF0, 0x00, 0x1F, 0xC0,
  0xF8, 0xFF, 0xF0, 0xF9, 0xFF, 0xF8, 0xFB, 0xFF, 0xFC, 0xFF, 0xC1, 0xFE,
  0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xBF,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x7F, 0x03,
  0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x7C, 0x7F, 0xF8, 0x3E, 0x7F, 0xFE, 0x1F,
  0x7F, 0xFF, 0x8F, 0xBC, 0x0F, 0xE7, 0xF8, 0x03, 0xF3, 0xF8, 0x00, 0xF9,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFB, 0xF0,
  0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0x3F,
  0xC0, 0x1F, 0x9F, 0xF8, 0x3F, 0x8F, 0xBF, 0xFF, 0xC7, 0xCF, 0xFF, 0xC3,
  0xE3, 0xFF, 0xC1, 0xF0, 0x7F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0x83, 0xFF, 0xC7, 0xC3,
  0xFF, 0xF3, 0xE3, 0xFF, 0xFD, 0xF3, 0xF8, 0x1E, 0xF9, 0xF8, 0x03, 0xFD,
  0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x7F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0xBF,
  0x00, 0x3F, 0xCF, 0xC0, 0x3F, 0xE7, 0xF0, 0x3D, 0xF1, 0xFF, 0xFC, 0xF8,
  0x7F, 0xFC, 0x7C, 0x1F, 0xFC, 0x3E, 0x03, 0xF8, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFD, 0xE7, 0xE0,
  0x17, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x00,
  0xFC, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x70, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0xFE, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x38, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x7C, 0x00, 0xFF, 0x7F, 0x03, 0xDF,
  0x3F, 0xFF, 0xDF, 0x3F, 0xFF, 0x9F, 0x1F, 0xFE, 0x1F, 0x07, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x3E, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3C, 0x7C, 0x0F, 0xE0,
  0x7C, 0x7C, 0x0F, 0xE0, 0x7C, 0x3C, 0x0E, 0xF0, 0x7C, 0x3C, 0x1E, 0xF0,
  0x7C, 0x3E, 0x1E, 0x70, 0x7C, 0x3E, 0x1E, 0x78, 0x78, 0x3E, 0x1C, 0x78,
  0x78, 0x3E, 0x3C, 0x38, 0xF8, 0x1E, 0x3C, 0x3C, 0xF8, 0x1E, 0x38, 0x3C,
  0xF8, 0x1E, 0x78, 0x3C, 0xF0, 0x1F, 0x78, 0x1C, 0xF0, 0x1F, 0x70, 0x1E,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF8,
  0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0x00,
};

const GFXglyph LiberationMono_Regular56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 6, 37, 34, 14, -37 },
  { 29, 18, 17, 34, 8, -41 },
  { 68, 31, 37, 34, 1, -37 },
  { 212, 29, 45, 34, 2, -41 },
  { 376, 34, 39, 34, 0, -38 },
  { 542, 31, 38, 34, 1, -37 },
  { 690, 6, 17, 34, 14, -41 },
  { 703, 15, 53, 34, 9, -41 },
  { 803, 15, 53, 34, 9, -41 },
  { 903, 20, 20, 34, 7, -41 },
  { 953, 27, 28, 34, 3, -33 },
  { 1048, 12, 18, 34, 7, -8 },
  { 1075, 15, 4, 34, 9, -17 },
  { 1083, 6, 8, 34, 14, -8 },
  { 1089, 27, 42, 34, 3, -41 },
  { 1231, 27, 39, 34, 3, -38 },
  { 1363, 27, 37, 34, 4, -37 },
  { 1488, 26, 38, 34, 4, -38 },
  { 1612, 27, 39, 34, 3, -38 },
  { 1744, 28, 37, 34, 3, -37 },
  { 1874, 27, 38, 34, 3, -37 },
  { 2003, 26, 39, 34, 4, -38 },
  { 2130, 25, 37, 34, 4, -37 },
  { 2246, 26, 39, 34, 4, -38 },
  { 2373, 26, 39, 34, 4, -38 },
  { 2500, 6, 30, 34, 14, -30 },
  { 2523, 12, 40, 34, 10, -30 },
  { 2583, 27, 29, 34, 3, -33 },
  { 2681, 27, 18, 34, 3, -27 },
  { 2742, 27, 29, 34, 3, -33 },
  { 2840, 26, 38, 34, 3, -38 },
  { 2964, 32, 49, 34, 1, -41 },
  { 3160, 34, 37, 34, 0, -37 },
  { 3318, 28, 37, 34, 4, -37 },
  { 3448, 28, 39, 34, 3, -38 },
  { 3585, 27, 37, 34, 4, -37 },
  { 3710, 27, 37, 34, 4, -37 },
  { 3835, 25, 37, 34, 5, -37 },
  { 3951, 27, 39, 34, 3, -38 },
  { 4083, 25, 37, 34, 4, -37 },
  { 4199, 22, 37, 34, 6, -37 },
  { 4301, 22, 38, 34, 5, -37 },
  { 4406, 30, 37, 34, 4, -37 },
  { 4545, 24, 37, 34, 6, -37 },
  { 4656, 26, 37, 34, 4, -37 },
  { 4777, 25, 37, 34, 4, -37 },
  { 4893, 28, 39, 34, 3, -38 },
  { 5030, 27, 37, 34, 4, -37 },
  { 5155, 28, 49, 34, 3, -38 },
  { 5327, 28, 37, 34, 4, -37 },
  { 5457, 29, 39, 34, 2, -38 },
  { 5599, 30, 37, 34, 2, -37 },
  { 5738, 26, 38, 34, 4, -37 },
  { 5862, 33, 37, 34, 0, -37 },
  { 6015, 34, 37, 34, 0, -37 },
  { 6173, 32, 37, 34, 1, -37 },
  { 6321, 32, 37, 34, 1, -37 },
  { 6469, 30, 37, 34, 2, -37 },
  { 6608, 15, 53, 34, 11, -41 },
  { 6708, 27, 42, 34, 3, -41 },
  { 6850, 15, 53, 34, 7, -41 },
  { 6950, 26, 25, 34, 4, -37 },
  { 7032, 34, 3, 34, 0, 3 },
  { 7045, 12, 7, 34, 11, -40 },
  { 7056, 29, 32, 34, 3, -31 },
  { 7172, 25, 42, 34, 5, -41 },
  { 7304, 26, 32, 34, 4, -31 },
  { 7408, 25, 42, 34, 4, -41 },
  { 7540, 26, 32, 34, 4, -31 },
  { 7644, 26, 41, 34, 4, -41 },
  { 7778, 25, 43, 34, 4, -31 },
  { 7913, 24, 41, 34, 5, -41 },
  { 8036, 27, 41, 34, 4, -41 },
  { 8175, 20, 53, 34, 3, -41 },
  { 8308, 25, 41, 34, 6, -41 },
  { 8437, 27, 41, 34, 4, -41 },
  { 8576, 28, 31, 34, 3, -31 },
  { 8685, 24, 31, 34, 5, -31 },
  { 8778, 26, 32, 34, 4, -31 },
  { 8882, 25, 43, 34, 5, -31 },
  { 9017, 25, 43, 34, 4, -31 },
  { 9152, 22, 31, 34, 7, -31 },
  { 9238, 24, 32, 34, 5, -31 },
  { 9334, 23, 39, 34, 5, -38 },
  { 9447, 24, 31, 34, 5, -30 },
  { 9540, 30, 30, 34, 2, -30 },
  { 9653, 32, 30, 34, 1, -30 },
  { 9773, 28, 30, 34, 3, -30 },
  { 9878, 30, 42, 34, 2, -30 },
  { 10036, 25, 30, 34, 4, -30 },
  { 10130, 23, 53, 34, 6, -41 },
  { 10283, 4, 53, 34, 15, -41 },
  { 10310, 22, 53, 34, 5, -41 },
  { 10456, 28, 7, 34, 3, -22 },
};

const GFXfont LiberationMono_Regular56pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular56pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular56pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _LIBERATIONMONO_REGULAR56PT7B_H_
