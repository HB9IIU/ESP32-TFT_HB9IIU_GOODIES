#ifndef _LIBERATIONMONO_REGULAR45PT7B_H_
#define _LIBERATIONMONO_REGULAR45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x38, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xDE, 0x0F, 0x3C, 0x1E, 0x70,
  0x3C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x80, 0x00,
  0x60, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x03, 0x00,
  0x0E, 0x03, 0x80, 0x06, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x60,
  0x01, 0xC0, 0x30, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x30, 0x0C,
  0x00, 0x38, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0C, 0x03, 0x80, 0x06, 0x01,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x30, 0x1F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x70, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x1C,
  0x07, 0x00, 0x0C, 0x03, 0x80, 0x06, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x03,
  0x80, 0x60, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0x1C, 0xFC, 0x3E, 0x1C, 0x3E, 0x3C, 0x1C, 0x1E,
  0x3C, 0x1C, 0x1E, 0x3C, 0x1C, 0x0C, 0x3C, 0x1C, 0x00, 0x3C, 0x1C, 0x00,
  0x1E, 0x1C, 0x00, 0x1F, 0xDC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1C, 0x7E, 0x00, 0x1C, 0x1E,
  0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0F, 0x30, 0x1C, 0x0F,
  0x78, 0x1C, 0x0F, 0x78, 0x1C, 0x0F, 0x7C, 0x1C, 0x0F, 0x3E, 0x1C, 0x1E,
  0x1F, 0x9C, 0x7E, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x1F, 0x80, 0x03, 0x87, 0xFC, 0x00, 0xE1, 0xE3, 0xC0, 0x3C, 0x38, 0x38,
  0x07, 0x0F, 0x07, 0x01, 0xC1, 0xC0, 0xE0, 0x78, 0x38, 0x1E, 0x0E, 0x07,
  0x03, 0xC3, 0x80, 0xE0, 0x78, 0xF0, 0x1C, 0x0E, 0x1C, 0x03, 0xC1, 0xC7,
  0x00, 0x38, 0x39, 0xE0, 0x07, 0x8E, 0x38, 0x00, 0x7F, 0xCE, 0x00, 0x07,
  0xE3, 0x80, 0x00, 0x00, 0x71, 0xF8, 0x00, 0x1C, 0xFF, 0x80, 0x07, 0x3C,
  0x78, 0x00, 0xE7, 0x07, 0x00, 0x38, 0xE0, 0x70, 0x0E, 0x1C, 0x0E, 0x03,
  0xC7, 0x81, 0xC0, 0x70, 0xF0, 0x38, 0x1C, 0x1E, 0x07, 0x07, 0x81, 0xC0,
  0xE0, 0xE0, 0x38, 0x3C, 0x38, 0x07, 0x07, 0x0F, 0x00, 0x71, 0xE1, 0xC0,
  0x0F, 0xF8, 0x70, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x0E, 0x00, 0x38, 0x07,
  0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x01, 0xE0, 0x03, 0x81,
  0xE0, 0x01, 0xE7, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0xC0, 0x7F, 0x80, 0x70, 0x7D, 0xE0, 0x38, 0x3C, 0xF0, 0x1C, 0x3C,
  0x3C, 0x1E, 0x3C, 0x0F, 0x0E, 0x1E, 0x07, 0x87, 0x0F, 0x01, 0xE7, 0x87,
  0x80, 0x7B, 0x83, 0xC0, 0x1F, 0xC1, 0xE0, 0x0F, 0xC0, 0xF0, 0x03, 0xE0,
  0x3C, 0x01, 0xF8, 0x1F, 0x83, 0xFF, 0x27, 0xFF, 0xEF, 0xF1, 0xFF, 0xE3,
  0xF8, 0x3F, 0x80, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0x73, 0x9C, 0xE7,
  0x38, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x00,
  0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x06, 0x1C, 0x33, 0xCE, 0x79, 0xFF, 0xFC, 0x7F, 0xFC,
  0x07, 0xF0, 0x01, 0xF0, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xE3, 0x80, 0xF1,
  0xE0, 0x70, 0x70, 0x10, 0x30, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3C,
  0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7E, 0x0F, 0x83,
  0xC0, 0x1E, 0x3C, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0x87, 0xF8,
  0x7C, 0x3F, 0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0xF0, 0xF8, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0,
  0x03, 0xCF, 0x00, 0x1E, 0x7C, 0x01, 0xE1, 0xE0, 0x1F, 0x07, 0xC1, 0xF0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0xF0,
  0x0F, 0xE3, 0xC0, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7E, 0x0F, 0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0x79, 0xE0,
  0x03, 0xCF, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7E, 0x0F,
  0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xE0, 0x0F, 0x8F, 0xC0,
  0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xDE, 0x00,
  0x07, 0xBC, 0x00, 0x0E, 0x78, 0x00, 0x38, 0xF0, 0x00, 0xF1, 0xE0, 0x01,
  0xC3, 0xC0, 0x07, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xE0,
  0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x70, 0x03,
  0xC1, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF1, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE1, 0xF8, 0x1F, 0x8F, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xF3, 0xE0, 0x0F, 0x8F, 0x81, 0xF8, 0x7F,
  0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xF0, 0x1F, 0x07, 0xC1, 0xE0, 0x1F, 0x1F, 0x00, 0x78, 0xF0,
  0x03, 0x8F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0xFC, 0x0F, 0x1F, 0xF8, 0x7B, 0xFF, 0xF3, 0xDC, 0x0F, 0x9F, 0xC0,
  0x3E, 0xFC, 0x00, 0xF7, 0xC0, 0x03, 0xFE, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0x1F, 0x3C, 0x00,
  0xF0, 0xF0, 0x0F, 0x87, 0xE0, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7E, 0x0F, 0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF,
  0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x03,
  0xC1, 0xF0, 0x7C, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x3E,
  0x03, 0xE3, 0xE0, 0x0F, 0x9E, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xE0,
  0x0F, 0x9F, 0x80, 0xFC, 0x7F, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7E, 0x0F, 0x87, 0xC0,
  0x3E, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xBC, 0x00,
  0x7D, 0xE0, 0x07, 0xEF, 0x80, 0x3F, 0x3F, 0x07, 0x78, 0xFF, 0xFB, 0xC3,
  0xFF, 0x1E, 0x07, 0xE0, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xCF, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xE0, 0x1E, 0x0F, 0x83, 0xF0, 0x3F,
  0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8,
  0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x3E, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC,
  0x3C, 0x00, 0xF9, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0xBC, 0x00, 0x0F, 0xF0,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7C, 0x1F,
  0x00, 0x78, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x38, 0x00,
  0x0E, 0x3C, 0x1E, 0x37, 0x1C, 0x3F, 0x9B, 0x8E, 0x3C, 0x6C, 0xEE, 0x1C,
  0x3E, 0x77, 0x1C, 0x0F, 0x3B, 0x8E, 0x07, 0x9D, 0x8E, 0x03, 0x8F, 0xC7,
  0x01, 0xC7, 0xE3, 0x80, 0xE3, 0xF3, 0x80, 0x71, 0xF9, 0xC0, 0x38, 0xFC,
  0xE0, 0x38, 0x7E, 0x70, 0x1C, 0x3F, 0x38, 0x0E, 0x1F, 0x9C, 0x07, 0x0F,
  0xCE, 0x03, 0x86, 0xE7, 0x03, 0xC7, 0x71, 0x81, 0xE3, 0xB8, 0xE1, 0xF1,
  0x8C, 0x71, 0xB9, 0xC7, 0x1F, 0x8F, 0xC3, 0x87, 0x87, 0x81, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x04, 0x07, 0xC0,
  0x0F, 0x01, 0xF0, 0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x80,
  0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0xE0, 0x1F, 0x8F, 0x00, 0x3E, 0x78, 0x00, 0xF3,
  0xC0, 0x07, 0x9E, 0x00, 0x3E, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00,
  0x79, 0xE0, 0x07, 0x8F, 0x00, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0xF0, 0x07, 0xE7, 0x80, 0x0F, 0xBC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xBC, 0x01, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x7E, 0x0F, 0x81, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x3E,
  0x00, 0x1E, 0x7C, 0x00, 0x10, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x01, 0x8F, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9F, 0x00, 0x1E,
  0x3E, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x3F, 0x07, 0xC0, 0x3F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC1, 0xE0, 0x7F, 0x0F, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xC0, 0x07,
  0x9E, 0x00, 0x3E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xC7,
  0x80, 0x3E, 0x3C, 0x07, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xE0, 0x7C, 0x1F, 0x00,
  0xF8, 0xF8, 0x01, 0xE3, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0x7C, 0x00, 0x31,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xFF, 0x78, 0x0F, 0xFD, 0xE0, 0x3F,
  0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0xF3,
  0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0xF0, 0xFC,
  0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xDC, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x1E, 0x78, 0x07, 0x9F, 0x03, 0xE3, 0xE1, 0xF0, 0xFF,
  0xF8, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0xF9, 0xE0, 0x03, 0xE3,
  0xC0, 0x0F, 0x87, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x3C,
  0x07, 0xC0, 0x78, 0x1F, 0x00, 0xF0, 0x7C, 0x01, 0xE1, 0xF0, 0x03, 0xC7,
  0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0xFE, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF0,
  0x07, 0x81, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xE0,
  0x78, 0x03, 0xE0, 0xF0, 0x03, 0xE1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0xC7,
  0x80, 0x07, 0xCF, 0x00, 0x07, 0xDE, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xF7, 0x01,
  0xDF, 0xBC, 0x0E, 0xFD, 0xE0, 0xF7, 0xE7, 0x07, 0x3F, 0x3C, 0x39, 0xF9,
  0xE3, 0xCF, 0xC7, 0x1C, 0x7E, 0x3C, 0xE3, 0xF0, 0xEE, 0x1F, 0x87, 0x70,
  0xFC, 0x3F, 0x87, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC0,
  0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1C, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFB, 0x80, 0x3F, 0x78, 0x07, 0xE7,
  0x00, 0xFC, 0xF0, 0x1F, 0x8E, 0x03, 0xF1, 0xE0, 0x7E, 0x3C, 0x0F, 0xC3,
  0xC1, 0xF8, 0x78, 0x3F, 0x07, 0x87, 0xE0, 0xF0, 0xFC, 0x0E, 0x1F, 0x81,
  0xE3, 0xF0, 0x1C, 0x7E, 0x03, 0xCF, 0xC0, 0x39, 0xF8, 0x07, 0xBF, 0x00,
  0xF7, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x00, 0x1E,
  0x3E, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF7,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFB, 0xC0,
  0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9F, 0x00, 0x1F, 0x1E, 0x00,
  0x3C, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x7E, 0x0F, 0x80, 0x7F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xE0, 0x0F, 0xCF, 0x00, 0x1F, 0x78, 0x00, 0xFB, 0xC0,
  0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3D,
  0xE0, 0x01, 0xEF, 0x00, 0x1F, 0x78, 0x01, 0xF3, 0xC0, 0x3F, 0x9F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFC,
  0x1F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x00, 0x1E, 0x3E, 0x00,
  0x3E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE7,
  0x80, 0x03, 0xCF, 0x00, 0x07, 0x9F, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x3E,
  0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3C, 0x01, 0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xEF, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x1F, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0xF0, 0x1F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF8, 0x3C, 0x01,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x7C,
  0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0xC1, 0xF8, 0x0F, 0x83, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x9E,
  0x00, 0x1F, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xEE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0xF8, 0xFC, 0x07, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xEF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xE0, 0x0F, 0x8F, 0x81, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x79, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78,
  0x7C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1F, 0x00,
  0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03,
  0xC0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x70,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x03, 0xE0, 0x78, 0xF0,
  0x7C, 0x0E, 0x1E, 0x0F, 0x83, 0xC3, 0xC1, 0xF0, 0x78, 0x78, 0x77, 0x0F,
  0x0F, 0x0E, 0xE1, 0xE1, 0xE1, 0xDC, 0x3C, 0x1C, 0x3B, 0x87, 0x03, 0x8E,
  0x38, 0xE0, 0x79, 0xC7, 0x1C, 0x0F, 0x38, 0xE7, 0x81, 0xE7, 0x1C, 0xF0,
  0x3D, 0xC1, 0xDE, 0x07, 0xB8, 0x3B, 0xC0, 0x77, 0x07, 0x70, 0x0E, 0xE0,
  0xEE, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x1F, 0x1E, 0x00,
  0x0F, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x7C,
  0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xE3, 0xE0, 0x00,
  0xF1, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x1F, 0x00,
  0x7C, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0x80,
  0x00, 0xF7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0x9F,
  0x00, 0x07, 0xC7, 0x80, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF8, 0x03, 0xE0,
  0x3C, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x77, 0x00, 0x03,
  0xB8, 0x00, 0x3D, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE0, 0xE0,
  0x07, 0x07, 0x00, 0x78, 0x3C, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0,
  0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xF3,
  0x80, 0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0xFC,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0x81, 0xF0, 0x7C, 0x03, 0xC1,
  0xE0, 0x07, 0x87, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7E, 0x01, 0xE3, 0xE0, 0x07,
  0x8F, 0x80, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x8F,
  0x00, 0x7E, 0x3E, 0x03, 0xF8, 0xFC, 0x1D, 0xF1, 0xFF, 0xE3, 0xF3, 0xFF,
  0x0F, 0xC3, 0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x0F, 0xE0, 0xF3, 0xFF, 0x0F, 0x7F, 0xF8, 0xFF, 0x07,
  0xCF, 0xC0, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xEF,
  0x80, 0x1E, 0xFC, 0x03, 0xEF, 0xE0, 0x7C, 0xF7, 0xFF, 0x8F, 0x3F, 0xF0,
  0xF0, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7E,
  0x07, 0xC3, 0xC0, 0x1F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0xFB,
  0xC0, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xF0, 0x7E, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3F, 0x0F, 0x0F, 0xFC, 0xF1, 0xFF, 0xEF,
  0x3E, 0x0F, 0xF7, 0xC0, 0x3F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0x78,
  0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xF3, 0xE0, 0xEF, 0x3F, 0xFE, 0xF1,
  0xFF, 0xCF, 0x07, 0xF0, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7E, 0x0F, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xDE,
  0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x03, 0x1F, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xF0, 0x7E,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x07,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xF0, 0xF0, 0xFF, 0xCF, 0x1F, 0xFE, 0xF3, 0xE0, 0xFF, 0x7C, 0x03, 0xF7,
  0x80, 0x3F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x03, 0xF7, 0xC0,
  0x3F, 0x3E, 0x0E, 0xF3, 0xFF, 0xEF, 0x1F, 0xFC, 0xF0, 0x7F, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF3, 0xC0, 0x1E, 0x3E, 0x01, 0xE3,
  0xF0, 0x7C, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x1F, 0xC3, 0xCF, 0xFE,
  0x7B, 0xFF, 0xCF, 0xF0, 0x7D, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xE0,
  0x3F, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3E, 0xF0, 0x07, 0xCF, 0x00,
  0xF8, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x80, 0xF0,
  0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x7C, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0xFD, 0xF0, 0x0F, 0x8F, 0x80, 0xF0, 0x78, 0x0F, 0x03, 0xC0,
  0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x07,
  0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE3, 0xE0, 0xF1, 0xEF, 0xE7, 0xF3, 0xFF, 0xCF, 0xF7, 0xE3, 0xB1,
  0xEF, 0x87, 0xC1, 0xDF, 0x0F, 0x83, 0xFC, 0x0F, 0x07, 0xF8, 0x1E, 0x0F,
  0xF0, 0x38, 0x1F, 0xE0, 0x70, 0x3F, 0xC0, 0xE0, 0x7F, 0x81, 0xC0, 0xFF,
  0x03, 0x81, 0xFE, 0x07, 0x03, 0xFC, 0x0E, 0x07, 0xF8, 0x1C, 0x0F, 0xF0,
  0x38, 0x1F, 0xE0, 0x70, 0x3F, 0xC0, 0xE0, 0x7F, 0x81, 0xC0, 0xFF, 0x03,
  0x81, 0xFE, 0x07, 0x03, 0xFC, 0x0E, 0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0xFE,
  0x1E, 0x7F, 0xF3, 0xDF, 0xFF, 0x7F, 0x83, 0xEF, 0xC0, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x01, 0xFC, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7E, 0x0F, 0xC3, 0xC0, 0x1F, 0x3C, 0x00, 0x79, 0xE0,
  0x03, 0xDF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x03, 0xC3,
  0xF0, 0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0xF0, 0xFE,
  0x0F, 0x3F, 0xF0, 0xF7, 0xFF, 0x8F, 0x70, 0x7C, 0xFC, 0x03, 0xEF, 0x80,
  0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0xC0, 0x3E,
  0xFE, 0x07, 0xCF, 0x7F, 0xF8, 0xF3, 0xFF, 0x0F, 0x0F, 0xE0, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0xF0,
  0xFF, 0xCF, 0x1F, 0xFE, 0xF3, 0xE0, 0xFF, 0x7C, 0x03, 0xF7, 0x80, 0x1F,
  0x78, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x3F, 0x3E,
  0x0E, 0xF3, 0xFF, 0xEF, 0x0F, 0xFC, 0xF0, 0x7F, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x3F, 0xDC, 0x3F,
  0xF7, 0x9F, 0xFD, 0xE7, 0xFF, 0x7B, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3E, 0x03, 0xE7,
  0x80, 0x1C, 0xE0, 0x03, 0xDC, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xEC, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xF7, 0xC0, 0x7C, 0x7F, 0xFF, 0x87, 0xFF, 0xC0, 0x3F, 0xE0, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x83, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x04,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xBC, 0x03, 0xF7, 0xC1, 0xFE, 0xFF, 0xFB, 0xCF,
  0xFE, 0x78, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xE0, 0x00,
  0xF3, 0xC0, 0x01, 0xE7, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x1F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x01,
  0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x07, 0xBC, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x70, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0xE1, 0xE0, 0xF8, 0x3C, 0x3C, 0x1F, 0x07, 0x87, 0x83, 0xE0, 0xF0, 0xF0,
  0xEE, 0x1E, 0x1E, 0x1D, 0xC3, 0xC1, 0xC3, 0xB8, 0x70, 0x38, 0xE3, 0x9E,
  0x07, 0x9C, 0x73, 0xC0, 0xF3, 0x8E, 0x78, 0x1E, 0xE0, 0xEF, 0x03, 0xDC,
  0x1D, 0xE0, 0x3B, 0x83, 0xB8, 0x07, 0xE0, 0x77, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0xF0, 0xF8, 0x03, 0xE0, 0xF0, 0x0F, 0x80, 0xF0, 0x1E,
  0x00, 0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x01, 0xE3, 0xC0, 0x01, 0xEF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xC7, 0x80, 0x0F,
  0x07, 0x80, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x81, 0xE0, 0x0F, 0x07, 0x80,
  0x0F, 0x1E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xE0, 0x03, 0xE0, 0xF0,
  0x01, 0xE0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x7C, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x0E, 0x0F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0x7B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0xFE, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x3F, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
};

const GFXglyph LiberationMono_Regular45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 5, 30, 27, 11, -30 },
  { 20, 15, 14, 27, 6, -33 },
  { 47, 25, 30, 27, 1, -30 },
  { 141, 24, 37, 27, 1, -33 },
  { 252, 27, 30, 27, 0, -30 },
  { 354, 25, 30, 27, 1, -30 },
  { 448, 5, 14, 27, 11, -33 },
  { 457, 12, 42, 27, 8, -33 },
  { 520, 12, 42, 27, 7, -33 },
  { 583, 17, 16, 27, 5, -33 },
  { 617, 21, 21, 27, 3, -26 },
  { 673, 9, 15, 27, 6, -7 },
  { 690, 13, 4, 27, 7, -14 },
  { 697, 5, 7, 27, 11, -7 },
  { 702, 22, 33, 27, 2, -33 },
  { 793, 21, 30, 27, 3, -30 },
  { 872, 22, 30, 27, 3, -30 },
  { 955, 21, 30, 27, 3, -30 },
  { 1034, 21, 30, 27, 3, -30 },
  { 1113, 23, 30, 27, 2, -30 },
  { 1200, 21, 30, 27, 3, -30 },
  { 1279, 21, 30, 27, 3, -30 },
  { 1358, 20, 30, 27, 3, -30 },
  { 1433, 21, 30, 27, 3, -30 },
  { 1512, 21, 30, 27, 3, -30 },
  { 1591, 5, 24, 27, 11, -24 },
  { 1606, 9, 32, 27, 8, -24 },
  { 1642, 21, 23, 27, 3, -26 },
  { 1703, 21, 14, 27, 3, -22 },
  { 1740, 21, 23, 27, 3, -26 },
  { 1801, 22, 30, 27, 2, -30 },
  { 1884, 25, 39, 27, 1, -33 },
  { 2006, 27, 30, 27, 0, -30 },
  { 2108, 21, 30, 27, 4, -30 },
  { 2187, 23, 30, 27, 2, -30 },
  { 2274, 21, 30, 27, 4, -30 },
  { 2353, 21, 30, 27, 4, -30 },
  { 2432, 20, 30, 27, 4, -30 },
  { 2507, 22, 30, 27, 2, -30 },
  { 2590, 19, 30, 27, 4, -30 },
  { 2662, 19, 30, 27, 4, -30 },
  { 2734, 18, 30, 27, 4, -30 },
  { 2802, 23, 30, 27, 4, -30 },
  { 2889, 19, 30, 27, 5, -30 },
  { 2961, 21, 30, 27, 3, -30 },
  { 3040, 19, 30, 27, 4, -30 },
  { 3112, 23, 30, 27, 2, -30 },
  { 3199, 21, 30, 27, 4, -30 },
  { 3278, 23, 39, 27, 2, -30 },
  { 3391, 22, 30, 27, 4, -30 },
  { 3474, 23, 30, 27, 2, -30 },
  { 3561, 23, 30, 27, 2, -30 },
  { 3648, 21, 30, 27, 3, -30 },
  { 3727, 27, 30, 27, 0, -30 },
  { 3829, 27, 30, 27, 0, -30 },
  { 3931, 25, 30, 27, 1, -30 },
  { 4025, 25, 30, 27, 1, -30 },
  { 4119, 23, 30, 27, 2, -30 },
  { 4206, 12, 42, 27, 9, -33 },
  { 4269, 21, 33, 27, 3, -33 },
  { 4356, 12, 42, 27, 6, -33 },
  { 4419, 21, 20, 27, 3, -30 },
  { 4472, 27, 2, 27, 0, 3 },
  { 4479, 9, 6, 27, 9, -32 },
  { 4486, 22, 24, 27, 3, -24 },
  { 4552, 20, 33, 27, 4, -33 },
  { 4635, 21, 24, 27, 3, -24 },
  { 4698, 20, 33, 27, 3, -33 },
  { 4781, 21, 24, 27, 3, -24 },
  { 4844, 21, 33, 27, 3, -33 },
  { 4931, 20, 33, 27, 3, -24 },
  { 5014, 19, 33, 27, 4, -33 },
  { 5093, 22, 33, 27, 3, -33 },
  { 5184, 15, 42, 27, 3, -33 },
  { 5263, 20, 33, 27, 5, -33 },
  { 5346, 22, 33, 27, 3, -33 },
  { 5437, 23, 24, 27, 2, -24 },
  { 5506, 19, 24, 27, 4, -24 },
  { 5563, 21, 24, 27, 3, -24 },
  { 5626, 20, 33, 27, 4, -24 },
  { 5709, 20, 33, 27, 3, -24 },
  { 5792, 18, 24, 27, 5, -24 },
  { 5846, 19, 24, 27, 4, -24 },
  { 5903, 18, 30, 27, 4, -30 },
  { 5971, 19, 24, 27, 4, -24 },
  { 6028, 23, 24, 27, 2, -24 },
  { 6097, 27, 24, 27, 0, -24 },
  { 6178, 23, 24, 27, 2, -24 },
  { 6247, 25, 33, 27, 1, -24 },
  { 6351, 20, 24, 27, 3, -24 },
  { 6411, 18, 42, 27, 5, -33 },
  { 6506, 3, 42, 27, 12, -33 },
  { 6522, 18, 42, 27, 4, -33 },
  { 6617, 23, 6, 27, 2, -18 },
};

const GFXfont LiberationMono_Regular45pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular45pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular45pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _LIBERATIONMONO_REGULAR45PT7B_H_
