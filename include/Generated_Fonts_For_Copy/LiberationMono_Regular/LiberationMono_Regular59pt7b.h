#ifndef _LIBERATIONMONO_REGULAR59PT7B_H_
#define _LIBERATIONMONO_REGULAR59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0x7C, 0x07, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x70,
  0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0,
  0x0F, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xE3, 0xCF,
  0xF0, 0x7F, 0x07, 0x87, 0xF0, 0xFC, 0x0F, 0x03, 0xE1, 0xF0, 0x1E, 0x07,
  0xE3, 0xE0, 0x3C, 0x07, 0xC7, 0xC0, 0x78, 0x0E, 0x0F, 0x80, 0xF0, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0x7F, 0x0F, 0x00, 0x00, 0x7F, 0x9E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0x8F, 0xF0, 0x00, 0x0F, 0x07, 0xF0, 0x00,
  0x1E, 0x07, 0xE0, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x1F, 0x38, 0x03, 0xC0, 0x3F, 0xF0, 0x07,
  0x80, 0x7F, 0xF0, 0x0F, 0x00, 0xFB, 0xE0, 0x1E, 0x03, 0xF7, 0xE0, 0x3C,
  0x07, 0xC7, 0xE0, 0x78, 0x3F, 0x8F, 0xF8, 0xF1, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xF0, 0xFF, 0xF8, 0x00, 0x3C, 0x3E, 0x1F, 0x00,
  0x0F, 0x87, 0x81, 0xF0, 0x01, 0xE1, 0xF0, 0x1E, 0x00, 0x78, 0x3E, 0x03,
  0xC0, 0x1F, 0x07, 0x80, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x78, 0x07, 0x81, 0xE0,
  0x0F, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x1E, 0x1F, 0x00, 0x1E, 0x03, 0xC3,
  0xC0, 0x03, 0xC0, 0xF8, 0xF0, 0x00, 0x7C, 0x3E, 0x3E, 0x00, 0x07, 0xFF,
  0x87, 0x80, 0x00, 0x7F, 0xE1, 0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xFC, 0x00, 0x00, 0xF0, 0xFF,
  0xC0, 0x00, 0x1E, 0x3F, 0xFC, 0x00, 0x07, 0x8F, 0x87, 0xC0, 0x01, 0xE1,
  0xE0, 0x7C, 0x00, 0x7C, 0x7C, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0xF0, 0x03,
  0xC1, 0xE0, 0x1E, 0x00, 0xF8, 0x3C, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x0F, 0x00, 0x78, 0x07, 0x83, 0xC0, 0x0F, 0x80, 0xF0, 0x78, 0x00,
  0xF0, 0x3C, 0x1E, 0x00, 0x1F, 0x0F, 0x87, 0x80, 0x01, 0xFF, 0xE0, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0x80, 0x1F,
  0x00, 0x03, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1E, 0x03,
  0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xCF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x08, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0xFF, 0xE0, 0x07, 0xC0, 0xF8,
  0xF8, 0x03, 0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0xFC, 0x1F, 0x01, 0xF0, 0x7C,
  0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xF0, 0x78, 0x3E, 0x00, 0xF8, 0x7C, 0x1F,
  0x00, 0x3E, 0x3E, 0x0F, 0x80, 0x0F, 0x9E, 0x07, 0xC0, 0x07, 0xFF, 0x03,
  0xE0, 0x01, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xF0, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xDF, 0xF8, 0x7F, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0x81,
  0xFE, 0x01, 0xFE, 0x00, 0x1E, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBE,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x3C, 0x78, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x01, 0x81, 0xC0, 0x4F, 0x8E, 0x1E, 0x7F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0x78, 0x00, 0xF9, 0xE0, 0x07, 0x8F, 0x80, 0x78, 0x3C,
  0x07, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0x60, 0x10, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0,
  0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x83, 0xF8, 0x3F, 0xF8,
  0x3F, 0x83, 0xFF, 0x83, 0xF8, 0x3F, 0xF8, 0x3F, 0x83, 0xFF, 0x83, 0xF8,
  0x3F, 0xF8, 0x3F, 0x83, 0xFF, 0x83, 0xF8, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C,
  0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xDF, 0x00, 0x1F, 0xFC, 0xF8,
  0x00, 0xFF, 0xC7, 0xC0, 0x07, 0xF8, 0x3E, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x7F,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xC0, 0x7F, 0x83, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0xFC, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3,
  0xF0, 0x01, 0xFC, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x0F, 0x80,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x1E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x01,
  0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0,
  0x78, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x1F, 0xE0, 0x07,
  0xCF, 0xFF, 0x80, 0x7D, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0,
  0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x83, 0xFC, 0x07,
  0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xF8,
  0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x7C,
  0x7F, 0xFC, 0x0F, 0xCF, 0xFF, 0xE0, 0xFD, 0xFF, 0xFF, 0x0F, 0xFE, 0x07,
  0xF8, 0xFF, 0x80, 0x1F, 0xCF, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E,
  0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xC0, 0x7F, 0x83, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7C, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x3E, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFD, 0xF0,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF3, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x7F,
  0xC7, 0xF0, 0x3F, 0xF8, 0x7F, 0xFF, 0xDF, 0x07, 0xFF, 0xF3, 0xE0, 0x7F,
  0xF8, 0x7C, 0x03, 0xFC, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x1C, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x01,
  0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x00, 0xFE,
  0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x3E, 0x01,
  0xE1, 0xC0, 0x7F, 0x8E, 0x71, 0xE0, 0x7F, 0xE7, 0x3C, 0xF0, 0x7C, 0x77,
  0x9E, 0x70, 0x7C, 0x1F, 0xCF, 0x78, 0x3C, 0x07, 0xC7, 0xBC, 0x3C, 0x03,
  0xE1, 0xDE, 0x1E, 0x01, 0xF0, 0xEF, 0x1E, 0x00, 0xF8, 0x77, 0x0F, 0x00,
  0x7C, 0x3B, 0x87, 0x80, 0x3C, 0x1F, 0xC3, 0x80, 0x1E, 0x0F, 0xE3, 0xC0,
  0x0F, 0x07, 0xF1, 0xE0, 0x07, 0x83, 0xF8, 0xF0, 0x03, 0xC1, 0xFC, 0x78,
  0x03, 0xC1, 0xFE, 0x3C, 0x01, 0xE0, 0xFF, 0x1E, 0x00, 0xF0, 0x7F, 0x8F,
  0x00, 0x78, 0x3B, 0xC7, 0x80, 0x7C, 0x1D, 0xE3, 0xC0, 0x3C, 0x1E, 0x71,
  0xE0, 0x3E, 0x0F, 0x38, 0x70, 0x1F, 0x07, 0x1E, 0x3C, 0x1F, 0x87, 0x8F,
  0x1F, 0x1D, 0xE7, 0x87, 0x87, 0xFC, 0x7F, 0x81, 0xC1, 0xFC, 0x3F, 0x80,
  0xF0, 0x7C, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x01, 0xF0, 0x00, 0x0E,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x3F,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0x0F, 0x80,
  0x03, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x07, 0xF8, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0xFE, 0xF8, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x0F, 0x1F, 0x80, 0x00, 0x30, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x61, 0xF8,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E, 0x3F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0x80, 0x7F,
  0xE1, 0xF0, 0x01, 0xFC, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0xF8,
  0x00, 0x1F, 0x9F, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00,
  0x1F, 0xBE, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x1F,
  0x00, 0x1F, 0xC3, 0xE0, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x20, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x81, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF1, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xBE, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xF8, 0xFC, 0x03, 0xF1,
  0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0xF8, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x3F, 0x8F, 0x80, 0x00,
  0xFC, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8,
  0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x7F, 0x00, 0xF8, 0x03, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8,
  0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE7, 0xF0, 0x00, 0x0F, 0xBF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x7E, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x3E, 0x00, 0x7F, 0x00, 0xF8,
  0x00, 0xFE, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xF0, 0x3E, 0x00,
  0x0F, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0xFE, 0x3E, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xF7, 0x80, 0x1F, 0xFF, 0x78, 0x03, 0xDF, 0xF7,
  0xC0, 0x3D, 0xFF, 0x3C, 0x03, 0xDF, 0xF3, 0xE0, 0x79, 0xFF, 0x3E, 0x07,
  0x9F, 0xF1, 0xE0, 0xF9, 0xFF, 0x1F, 0x0F, 0x1F, 0xF1, 0xF0, 0xF1, 0xFF,
  0x0F, 0x1F, 0x1F, 0xF0, 0xF9, 0xE1, 0xFF, 0x07, 0x9E, 0x1F, 0xF0, 0x7B,
  0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x03, 0xF8, 0x1F,
  0xF0, 0x3F, 0x81, 0xFF, 0x01, 0xF8, 0x1F, 0xF0, 0x1F, 0x01, 0xFF, 0x00,
  0xF0, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xDF,
  0x00, 0x1F, 0xF7, 0xC0, 0x07, 0xFC, 0xF0, 0x01, 0xFF, 0x3E, 0x00, 0x7F,
  0xCF, 0x80, 0x1F, 0xF9, 0xF0, 0x07, 0xFE, 0x7C, 0x01, 0xFF, 0x8F, 0x80,
  0x7F, 0xE3, 0xE0, 0x1F, 0xF8, 0x7C, 0x07, 0xFE, 0x1F, 0x01, 0xFF, 0x83,
  0xE0, 0x7F, 0xE0, 0xF8, 0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x07, 0xC1, 0xFF,
  0x80, 0xF0, 0x7F, 0xE0, 0x3E, 0x1F, 0xF8, 0x0F, 0x87, 0xFE, 0x01, 0xF1,
  0xFF, 0x80, 0x7C, 0x7F, 0xE0, 0x0F, 0x9F, 0xF8, 0x03, 0xE7, 0xFE, 0x00,
  0x7D, 0xFF, 0x80, 0x1F, 0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x07,
  0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x8F, 0x80, 0x0F, 0xF9, 0xF0, 0x00, 0x3F, 0xBE, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0xFE, 0x7C, 0x00, 0x7F, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x0F, 0x80, 0x07, 0xF8, 0x7C, 0x00, 0x0F, 0xE3, 0xE0, 0x00,
  0x3F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x1F, 0xC7, 0xC0, 0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x3F,
  0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0xCF, 0x80,
  0x00, 0x7E, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01,
  0xC0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC7, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC1, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0xE3, 0xE0, 0x1F, 0x00, 0xF8,
  0x7C, 0x03, 0xF0, 0x1F, 0x0F, 0x80, 0x7E, 0x03, 0xE1, 0xF0, 0x1F, 0xC0,
  0x7C, 0x1F, 0x03, 0xF8, 0x0F, 0x83, 0xE0, 0x7F, 0x81, 0xF0, 0x7C, 0x1E,
  0xF0, 0x3E, 0x0F, 0x83, 0xDE, 0x0F, 0x81, 0xF0, 0x79, 0xE1, 0xF0, 0x3E,
  0x0F, 0x3C, 0x3E, 0x03, 0xC3, 0xC7, 0x87, 0xC0, 0x78, 0x78, 0xF0, 0xF8,
  0x0F, 0x8F, 0x1F, 0x1F, 0x01, 0xF1, 0xE1, 0xE3, 0xC0, 0x3E, 0x78, 0x3C,
  0x78, 0x07, 0xCF, 0x07, 0x8F, 0x00, 0xF9, 0xE0, 0x7B, 0xE0, 0x0F, 0x3C,
  0x0F, 0x7C, 0x01, 0xEF, 0x01, 0xEF, 0x80, 0x3D, 0xE0, 0x3D, 0xF0, 0x07,
  0xBC, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3C,
  0x07, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x1E,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x7C, 0x1F, 0xC0, 0x03,
  0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x87, 0xC0,
  0x03, 0xFC, 0x3F, 0x00, 0x1F, 0xE1, 0xF8, 0x03, 0xDF, 0x07, 0xF0, 0x7C,
  0xFC, 0x3F, 0xFF, 0xC7, 0xFC, 0xFF, 0xFC, 0x1F, 0xE3, 0xFF, 0xC0, 0xFF,
  0x07, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0xFC, 0x7F, 0xF8, 0x3F, 0x3F,
  0xFF, 0x0F, 0x9F, 0xFF, 0xE3, 0xEF, 0x83, 0xFC, 0xFB, 0x80, 0x3F, 0x3F,
  0xC0, 0x07, 0xEF, 0xE0, 0x00, 0xFB, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x3E, 0xFE, 0x00, 0x0F, 0xBF, 0xC0, 0x07, 0xEF, 0xF8, 0x03, 0xF3, 0xEF,
  0x83, 0xFC, 0xF9, 0xFF, 0xFE, 0x3E, 0x7F, 0xFF, 0x0F, 0x87, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0xC0,
  0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0x07, 0xFF,
  0xC7, 0xC3, 0xFF, 0xF9, 0xF1, 0xFF, 0xFF, 0x7C, 0x7F, 0x03, 0xDF, 0x3F,
  0x00, 0x3F, 0xCF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xF0, 0x00, 0x3F,
  0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0xFD, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xF3, 0xF0,
  0x07, 0xFC, 0xFF, 0x03, 0xDF, 0x1F, 0xFF, 0xE7, 0xC3, 0xFF, 0xF9, 0xF0,
  0x7F, 0xF8, 0x7C, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0x03,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0x07, 0xE0, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xE1, 0xF0, 0xFF, 0xFE, 0x7C, 0x7F, 0xFF, 0xDF, 0x1F, 0xC1,
  0xF7, 0xCF, 0xC0, 0x1F, 0xF3, 0xE0, 0x03, 0xFD, 0xF8, 0x00, 0x7F, 0x7C,
  0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xF3, 0xF0, 0x07,
  0xFC, 0xFF, 0x07, 0xDF, 0x1F, 0xFF, 0xE7, 0xC3, 0xFF, 0xF1, 0xF0, 0x7F,
  0xF8, 0x7C, 0x07, 0xF8, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x0F, 0x00, 0x0F, 0x8F, 0xC0, 0x03,
  0xE1, 0xF8, 0x01, 0xF8, 0x7F, 0x81, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x0F, 0xC7, 0xFF,
  0x87, 0xC7, 0xFF, 0xE3, 0xE7, 0xFF, 0xF9, 0xF7, 0xC0, 0xFE, 0xFB, 0x80,
  0x3F, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xB8, 0x03, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x7F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF7,
  0xC0, 0x03, 0xF3, 0xE0, 0x03, 0xF1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF0,
  0x7C, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0x81, 0xF8,
  0x07, 0xC1, 0xF8, 0x03, 0xE1, 0xF8, 0x01, 0xF1, 0xF8, 0x00, 0xF9, 0xF8,
  0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x07, 0xFB, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F,
  0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xFC,
  0xF8, 0x00, 0x7F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xE0, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0xC7, 0x8F, 0xE0, 0xFF,
  0x3C, 0xFF, 0x8F, 0xFD, 0xEF, 0xFE, 0xFF, 0xEF, 0x71, 0xF7, 0x1F, 0xFF,
  0x0F, 0xF0, 0x7F, 0xF0, 0x3F, 0x03, 0xFF, 0x81, 0xF8, 0x1F, 0xFC, 0x0F,
  0xC0, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x1F, 0xF0, 0x1F, 0x00,
  0xFF, 0x80, 0xF8, 0x07, 0xFC, 0x07, 0xC0, 0x3F, 0xE0, 0x3E, 0x01, 0xFF,
  0x01, 0xF0, 0x0F, 0xF8, 0x0F, 0x80, 0x7F, 0xC0, 0x7C, 0x03, 0xFE, 0x03,
  0xE0, 0x1F, 0xF0, 0x1F, 0x00, 0xFF, 0x80, 0xF8, 0x07, 0xFC, 0x07, 0xC0,
  0x3F, 0xE0, 0x3E, 0x01, 0xFF, 0x01, 0xF0, 0x0F, 0xF8, 0x0F, 0x80, 0x7F,
  0xC0, 0x7C, 0x03, 0xFE, 0x03, 0xE0, 0x1F, 0xF0, 0x1F, 0x00, 0xFF, 0x80,
  0xF8, 0x07, 0xFC, 0x07, 0xC0, 0x3F, 0xE0, 0x3E, 0x01, 0xFF, 0x01, 0xF0,
  0x0F, 0x00, 0x0F, 0xE0, 0x7C, 0x3F, 0xFC, 0x3E, 0x3F, 0xFF, 0x9F, 0x3F,
  0xFF, 0xCF, 0xBE, 0x07, 0xF7, 0xDC, 0x01, 0xFB, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x3E, 0x1F, 0xFE, 0x0F, 0x8F, 0xFF, 0xC3, 0xE7,
  0xFF, 0xF8, 0xFB, 0xE0, 0x7F, 0x3E, 0xE0, 0x0F, 0xCF, 0xF0, 0x01, 0xFB,
  0xF8, 0x00, 0x3E, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xBF, 0x80,
  0x03, 0xEF, 0xF0, 0x01, 0xFB, 0xFE, 0x00, 0xFC, 0xFB, 0xE0, 0x7F, 0x3F,
  0x7F, 0xFF, 0x8F, 0xCF, 0xFF, 0xC3, 0xF1, 0xFF, 0xE0, 0xFC, 0x1F, 0xE0,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x07, 0xC1, 0xFF, 0xF1, 0xF0, 0xFF, 0xFE, 0x7C, 0x7F, 0xFF,
  0xDF, 0x1F, 0xC0, 0xF7, 0xCF, 0xC0, 0x0F, 0xF3, 0xE0, 0x01, 0xFD, 0xF8,
  0x00, 0x7F, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xDF, 0x80, 0x07,
  0xF7, 0xE0, 0x03, 0xFC, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0xF7, 0xC7, 0xFF,
  0xF9, 0xF0, 0xFF, 0xFC, 0x7C, 0x1F, 0xFE, 0x1F, 0x00, 0xFE, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFB, 0xE3, 0xFF, 0xF7, 0xCF,
  0xFF, 0xEF, 0x9F, 0x80, 0x1F, 0x7C, 0x00, 0x3E, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0x80, 0x7F, 0x0F,
  0x80, 0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x30, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF9, 0xF0,
  0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0xBE, 0x00, 0x1F, 0xDF, 0x80, 0x1F, 0xEF, 0xF0, 0x3D, 0xF3, 0xFF,
  0xFE, 0xF8, 0xFF, 0xFE, 0x7C, 0x3F, 0xFC, 0x3E, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x0F,
  0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x03,
  0xF0, 0x1F, 0x1F, 0x01, 0xFC, 0x07, 0xC7, 0xC0, 0x7F, 0x01, 0xF0, 0xF8,
  0x1F, 0xE0, 0x7C, 0x3E, 0x0F, 0x78, 0x1F, 0x0F, 0x83, 0xDE, 0x0F, 0x83,
  0xE0, 0xF3, 0x83, 0xE0, 0xF8, 0x3C, 0xF0, 0xF8, 0x3E, 0x1E, 0x3C, 0x3E,
  0x07, 0x87, 0x8F, 0x0F, 0x81, 0xF1, 0xE1, 0xE3, 0xE0, 0x7C, 0xF0, 0x78,
  0xF0, 0x1F, 0x3C, 0x1E, 0x7C, 0x07, 0xCF, 0x03, 0xDF, 0x01, 0xF7, 0x80,
  0xF7, 0xC0, 0x3D, 0xE0, 0x3D, 0xF0, 0x0F, 0x78, 0x07, 0x78, 0x03, 0xDC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x07,
  0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F,
  0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00,
};

const GFXglyph LiberationMono_Regular59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 6, 39, 35, 15, -39 },
  { 31, 19, 18, 35, 8, -43 },
  { 74, 32, 39, 35, 2, -39 },
  { 230, 31, 48, 35, 2, -43 },
  { 416, 35, 41, 35, 0, -40 },
  { 596, 33, 40, 35, 1, -39 },
  { 761, 7, 18, 35, 14, -43 },
  { 777, 16, 55, 35, 10, -43 },
  { 887, 16, 55, 35, 10, -43 },
  { 997, 21, 21, 35, 7, -43 },
  { 1053, 29, 28, 35, 3, -34 },
  { 1155, 13, 19, 35, 7, -9 },
  { 1186, 16, 5, 35, 10, -18 },
  { 1196, 7, 9, 35, 14, -9 },
  { 1204, 29, 44, 35, 3, -43 },
  { 1364, 28, 41, 35, 4, -40 },
  { 1508, 29, 39, 35, 4, -39 },
  { 1650, 27, 40, 35, 4, -40 },
  { 1785, 28, 41, 35, 4, -40 },
  { 1929, 29, 39, 35, 3, -39 },
  { 2071, 28, 40, 35, 4, -39 },
  { 2211, 28, 41, 35, 4, -40 },
  { 2355, 26, 39, 35, 5, -39 },
  { 2482, 28, 41, 35, 4, -40 },
  { 2626, 27, 41, 35, 4, -40 },
  { 2765, 7, 31, 35, 14, -31 },
  { 2793, 13, 41, 35, 10, -31 },
  { 2860, 29, 30, 35, 3, -34 },
  { 2969, 29, 19, 35, 3, -29 },
  { 3038, 29, 30, 35, 3, -34 },
  { 3147, 28, 40, 35, 3, -40 },
  { 3287, 33, 50, 35, 1, -43 },
  { 3494, 35, 39, 35, 0, -39 },
  { 3665, 28, 39, 35, 5, -39 },
  { 3802, 30, 41, 35, 3, -40 },
  { 3956, 27, 39, 35, 5, -39 },
  { 4088, 27, 39, 35, 5, -39 },
  { 4220, 25, 39, 35, 6, -39 },
  { 4342, 29, 41, 35, 3, -40 },
  { 4491, 26, 39, 35, 5, -39 },
  { 4618, 24, 39, 35, 6, -39 },
  { 4735, 23, 40, 35, 5, -39 },
  { 4850, 30, 39, 35, 5, -39 },
  { 4997, 25, 39, 35, 7, -39 },
  { 5119, 28, 39, 35, 4, -39 },
  { 5256, 26, 39, 35, 5, -39 },
  { 5383, 29, 41, 35, 3, -40 },
  { 5532, 27, 39, 35, 5, -39 },
  { 5664, 30, 51, 35, 3, -40 },
  { 5856, 29, 39, 35, 5, -39 },
  { 5998, 31, 41, 35, 2, -40 },
  { 6157, 31, 39, 35, 2, -39 },
  { 6309, 27, 40, 35, 4, -39 },
  { 6444, 35, 39, 35, 0, -39 },
  { 6615, 35, 39, 35, 0, -39 },
  { 6786, 33, 39, 35, 1, -39 },
  { 6947, 33, 39, 35, 1, -39 },
  { 7108, 31, 39, 35, 2, -39 },
  { 7260, 16, 55, 35, 12, -43 },
  { 7370, 29, 44, 35, 3, -43 },
  { 7530, 16, 55, 35, 8, -43 },
  { 7640, 28, 26, 35, 4, -39 },
  { 7731, 36, 3, 35, 0, 4 },
  { 7745, 12, 7, 35, 12, -42 },
  { 7756, 29, 33, 35, 4, -32 },
  { 7876, 26, 44, 35, 5, -43 },
  { 8019, 27, 33, 35, 4, -32 },
  { 8131, 26, 44, 35, 4, -43 },
  { 8274, 28, 33, 35, 4, -32 },
  { 8390, 28, 43, 35, 4, -43 },
  { 8541, 26, 44, 35, 4, -32 },
  { 8684, 25, 43, 35, 5, -43 },
  { 8819, 28, 43, 35, 4, -43 },
  { 8970, 21, 55, 35, 3, -43 },
  { 9115, 25, 43, 35, 7, -43 },
  { 9250, 28, 43, 35, 4, -43 },
  { 9401, 29, 32, 35, 3, -32 },
  { 9517, 25, 32, 35, 5, -32 },
  { 9617, 28, 33, 35, 4, -32 },
  { 9733, 26, 44, 35, 5, -32 },
  { 9876, 26, 44, 35, 4, -32 },
  { 10019, 23, 32, 35, 7, -32 },
  { 10111, 26, 33, 35, 5, -32 },
  { 10219, 24, 40, 35, 5, -39 },
  { 10339, 25, 32, 35, 5, -31 },
  { 10439, 31, 31, 35, 2, -31 },
  { 10560, 34, 31, 35, 1, -31 },
  { 10692, 30, 31, 35, 3, -31 },
  { 10809, 31, 43, 35, 2, -31 },
  { 10976, 27, 31, 35, 4, -31 },
  { 11081, 24, 55, 35, 7, -43 },
  { 11246, 5, 55, 35, 15, -43 },
  { 11281, 24, 55, 35, 5, -43 },
  { 11446, 29, 7, 35, 3, -23 },
};

const GFXfont LiberationMono_Regular59pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular59pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular59pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _LIBERATIONMONO_REGULAR59PT7B_H_
