#ifndef _LIBERATIONMONO_REGULAR39PT7B_H_
#define _LIBERATIONMONO_REGULAR39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x1E, 0xE0, 0xF7, 0x07, 0xB8, 0x3D,
  0xC1, 0xEE, 0x0F, 0x70, 0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0x60, 0x00, 0xC0,
  0x60, 0x0C, 0x07, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00,
  0xC0, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC1, 0xC0, 0xE0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18,
  0x0C, 0x01, 0xC0, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x83, 0x01, 0x80,
  0x18, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01,
  0x80, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xF8,
  0xCF, 0x87, 0x86, 0x1E, 0x38, 0x30, 0xF3, 0xC1, 0x83, 0x8E, 0x0C, 0x00,
  0x70, 0x60, 0x03, 0xC3, 0x00, 0x0F, 0x98, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0C, 0x7C, 0x00, 0x60, 0xE0,
  0x03, 0x07, 0xB8, 0x18, 0x1F, 0xC0, 0xC0, 0xEE, 0x06, 0x0F, 0x78, 0x30,
  0x71, 0xF1, 0x8F, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x1C, 0xFF, 0x00,
  0x71, 0xC7, 0x01, 0xC7, 0x07, 0x03, 0x8E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38,
  0x38, 0x38, 0x70, 0x70, 0x71, 0xC0, 0xE0, 0xE7, 0x01, 0xC1, 0xCE, 0x01,
  0xC7, 0x38, 0x03, 0xFC, 0xE0, 0x01, 0xF1, 0x80, 0x00, 0x07, 0x3F, 0x00,
  0x1C, 0xFF, 0x00, 0x33, 0x87, 0x00, 0xE7, 0x0E, 0x03, 0x8C, 0x1C, 0x06,
  0x18, 0x18, 0x1C, 0x70, 0x30, 0x70, 0x60, 0x60, 0xC0, 0xC1, 0xC3, 0x81,
  0xC3, 0x8E, 0x03, 0x8F, 0x38, 0x03, 0xFC, 0x70, 0x03, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xC1, 0xE0, 0x0E, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0xE0, 0x30, 0x03, 0x81, 0xC0, 0x0E, 0x1E, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x10, 0x1F, 0x80, 0xE0, 0xE7, 0x03,
  0x87, 0x1E, 0x0E, 0x3C, 0x38, 0x38, 0xE0, 0x71, 0xC3, 0x81, 0xE7, 0x0E,
  0x03, 0xF8, 0x38, 0x07, 0xE0, 0xE0, 0x0F, 0x83, 0xC0, 0x3E, 0x07, 0x83,
  0xFE, 0x5F, 0xFF, 0x7F, 0x3F, 0xF8, 0xFC, 0x3F, 0x81, 0xE0, 0xFF, 0xFF,
  0xFE, 0xEE, 0xEE, 0xEE, 0x03, 0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x03,
  0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3C,
  0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78,
  0x0F, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80,
  0xE0, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0xC3, 0x1B,
  0xEF, 0xEF, 0xFF, 0xC3, 0xE0, 0x0F, 0x80, 0x37, 0x01, 0xCC, 0x0E, 0x38,
  0x38, 0x70, 0x41, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0x70,
  0x60, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0x07, 0xC3, 0xC0, 0x38, 0xF0, 0x07, 0x9E, 0x00, 0x73,
  0x80, 0x0E, 0x70, 0x01, 0xEE, 0x00, 0x3F, 0xC7, 0xC7, 0xF8, 0xF8, 0xFF,
  0x1F, 0x1F, 0xE3, 0xE3, 0xFC, 0x7C, 0x7F, 0x80, 0x0F, 0x70, 0x01, 0xEE,
  0x00, 0x3D, 0xC0, 0x07, 0x3C, 0x00, 0xE3, 0x80, 0x3C, 0x78, 0x0F, 0x07,
  0x83, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF, 0x01, 0xF9, 0xE0, 0x38,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF0, 0x7C, 0x78, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x07, 0xC7, 0x80, 0x3C, 0xF0, 0x07,
  0x9C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x80, 0x1E,
  0xF8, 0x07, 0x8F, 0x81, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xDE, 0x00, 0x73, 0xC0, 0x0E, 0x78, 0x03, 0x8F, 0x00, 0xE1, 0xE0,
  0x1C, 0x3C, 0x07, 0x07, 0x81, 0xC0, 0xF0, 0x70, 0x1E, 0x0E, 0x03, 0xC3,
  0x80, 0x78, 0xE0, 0x0F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x3F, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF0, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xF8,
  0x00, 0xF7, 0x80, 0x1C, 0xF0, 0x07, 0x8F, 0x83, 0xE1, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8,
  0x3C, 0x3C, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x7E, 0x0E, 0x7F, 0xE3, 0xBF, 0xFC, 0xFE, 0x1F, 0xBE, 0x01, 0xEF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xC0,
  0x0F, 0x78, 0x03, 0x9E, 0x01, 0xE3, 0xE0, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xF1, 0xF0, 0x7C, 0x70, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x07, 0x9E, 0x01, 0xC3, 0xC1, 0xF0,
  0x7F, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0x87, 0xC0, 0xF3, 0xC0, 0x1E, 0xF0,
  0x03, 0xB8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xE7, 0xC0, 0xF9, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0xF8, 0x0F, 0x3C, 0x01, 0xEF,
  0x00, 0x7B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x1F, 0xF8, 0x07, 0xDF, 0x07, 0xF3, 0xFF, 0xFC, 0x7F, 0xCF, 0x07, 0xC3,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0xF0, 0x07, 0x1C, 0x03, 0xC7,
  0xC3, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70,
  0xE0, 0xE0, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x1E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03,
  0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x1F, 0x80, 0x03, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF,
  0xC3, 0xFF, 0xF9, 0xF8, 0x3F, 0x78, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFE,
  0x00, 0x78, 0x3C, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x60, 0x60, 0x01, 0xC3,
  0x80, 0x03, 0x0C, 0x1E, 0x7E, 0x70, 0xFD, 0x99, 0x87, 0x1E, 0x66, 0x38,
  0x79, 0xB8, 0xC0, 0xE7, 0xE7, 0x03, 0x9F, 0x9C, 0x0C, 0x7C, 0x60, 0x31,
  0xF1, 0x80, 0xC7, 0xCE, 0x07, 0x1F, 0x38, 0x1C, 0x6C, 0xE0, 0x71, 0xB3,
  0x81, 0x86, 0xCE, 0x0E, 0x1B, 0x18, 0x38, 0xEE, 0x61, 0xE3, 0x39, 0xCD,
  0x9C, 0x63, 0xF7, 0xE1, 0x87, 0x0F, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x40, 0x70, 0x03, 0x80, 0xF0, 0x3C, 0x01, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xE3,
  0xC0, 0x01, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0E, 0x0F, 0x00, 0x3C, 0x0E,
  0x00, 0x78, 0x1C, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0x03, 0x87, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x70,
  0x00, 0x1F, 0xE0, 0x00, 0x3C, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x78, 0x0F, 0xCF, 0x00, 0x79, 0xE0, 0x07, 0x3C, 0x00, 0xE7, 0x80, 0x1C,
  0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x7C, 0x7F, 0xFF, 0x0F, 0xFF, 0x81,
  0xFF, 0xFE, 0x3C, 0x03, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xBC, 0x03, 0xF7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x83, 0xF0, 0x7C, 0x3C, 0x03, 0xC7, 0xC0, 0x1E, 0x78, 0x01,
  0xE7, 0x80, 0x08, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0xC7, 0x80, 0x0F, 0x3C, 0x01, 0xE3,
  0xC0, 0x3E, 0x1F, 0x07, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0,
  0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xC0, 0xFC, 0xF0, 0x0F, 0x3C,
  0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC,
  0x03, 0xCF, 0x03, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0x83, 0xE3, 0xC0, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x23, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xEE, 0x00,
  0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xC7, 0xC1,
  0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x70, 0x0F, 0x70, 0x0F,
  0x78, 0x0E, 0x78, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0,
  0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x1E,
  0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E,
  0x00, 0xF3, 0xC0, 0x0F, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFD,
  0xF0, 0x0F, 0x8F, 0x80, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F,
  0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x07, 0xCF, 0x00, 0x3E,
  0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFE, 0xE0, 0x7F, 0xDC, 0x0D, 0xFB,
  0x83, 0xBF, 0x38, 0x77, 0xE7, 0x0C, 0xFE, 0xE3, 0x9F, 0xCE, 0x73, 0xF9,
  0xCC, 0x7F, 0x3B, 0x8F, 0xE3, 0xF1, 0xFC, 0x7C, 0x3F, 0x87, 0x87, 0xF0,
  0xF0, 0xFE, 0x1C, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1C, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0x70, 0x1F,
  0xB8, 0x0F, 0xCE, 0x07, 0xE7, 0x03, 0xF3, 0xC1, 0xF8, 0xE0, 0xFC, 0x78,
  0x7E, 0x1C, 0x3F, 0x0F, 0x1F, 0x83, 0x8F, 0xC1, 0xC7, 0xE0, 0x73, 0xF0,
  0x39, 0xF8, 0x0E, 0xFC, 0x07, 0x7E, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0x07, 0xC3, 0xC0, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3D, 0xC0, 0x07, 0xBC, 0x00, 0xE7, 0x80, 0x3C, 0x78, 0x0F, 0x8F,
  0x83, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xF8, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xC0, 0x3E, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1E,
  0xF0, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xE0, 0xF8, 0x3C, 0x07, 0xC7, 0x80, 0x3C, 0x78,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0x70, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x03,
  0xC3, 0xC0, 0x7C, 0x3E, 0x0F, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x78, 0x07, 0xCF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0x77,
  0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x07, 0xCF,
  0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0x83, 0x80, 0xF0, 0x78, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C,
  0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3C, 0x01, 0xFE, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xF0, 0x3E, 0x3C, 0x01, 0xE3, 0x80, 0x0F,
  0x38, 0x00, 0xE3, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x30, 0x00, 0x77, 0x00, 0x07, 0x78,
  0x00, 0xF7, 0xC0, 0x0F, 0x3F, 0x03, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0x80,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0E, 0xF0, 0x07, 0xBC, 0x01,
  0xE7, 0xC1, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE3, 0xC0, 0x03,
  0xC7, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0xF0,
  0x1C, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0x70, 0x1E, 0x00,
  0xF0, 0x38, 0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0xC3, 0x80, 0x03,
  0x8F, 0x00, 0x07, 0x1C, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0xF0, 0x00, 0x1D,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7B, 0x80, 0x00,
  0xF7, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0x3C, 0x00, 0x0E,
  0x78, 0x3C, 0x1C, 0xF0, 0x78, 0x38, 0xE1, 0xF0, 0xF1, 0xC3, 0xE1, 0xE3,
  0x86, 0xE3, 0x87, 0x0D, 0xC7, 0x0E, 0x3B, 0x8E, 0x1E, 0x73, 0x1C, 0x1C,
  0xE7, 0x38, 0x39, 0x8E, 0x70, 0x77, 0x1C, 0xE0, 0xEE, 0x1B, 0x81, 0xD8,
  0x3F, 0x03, 0xB0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x01,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xC3, 0xC0, 0x1E,
  0x07, 0x80, 0x78, 0x1E, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0x78, 0x78, 0x01,
  0xE3, 0xC0, 0x03, 0xCE, 0x00, 0x07, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x77, 0x80,
  0x03, 0xCE, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0x78, 0x03, 0xC0, 0xE0, 0x1E,
  0x03, 0xC0, 0x78, 0x07, 0x83, 0xC0, 0x0E, 0x1E, 0x00, 0x3C, 0x78, 0x00,
  0x7B, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x79, 0xC0, 0x01, 0xE7, 0x80, 0x0F,
  0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0x00, 0xE0, 0x3C, 0x03,
  0xC1, 0xE0, 0x07, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0xE0, 0x00, 0x77,
  0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x37, 0x00, 0x1D, 0xC0, 0x07, 0x38, 0x03, 0x8E, 0x00, 0xE1, 0x80, 0x30,
  0x70, 0x1C, 0x1C, 0x07, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x18, 0x70, 0x07,
  0x1C, 0x01, 0xC6, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xE0, 0xF0, 0x38, 0x07, 0x87, 0x80, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF,
  0x87, 0xE0, 0x38, 0x78, 0x03, 0x87, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0x78, 0x70, 0x0F, 0x87, 0x83, 0xBC, 0x7F, 0xF3, 0xF3, 0xFE, 0x3F, 0x0F,
  0xC1, 0xF0, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC7, 0xE0, 0x73, 0xFE, 0x1D, 0xFF,
  0xC7, 0xE0, 0xF1, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x3D,
  0xC0, 0x0F, 0x70, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x0F, 0x70,
  0x03, 0xDC, 0x00, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0xFE, 0x0F, 0x3D, 0xFF,
  0xCF, 0x7F, 0xE3, 0xC7, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0x03, 0xE3, 0xC0, 0x3C, 0xF0, 0x03, 0x9E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x7B, 0xC0, 0x1E, 0x3C, 0x03, 0xC7, 0xC1, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x1F, 0x8F,
  0x1F, 0xF7, 0x9F, 0xFF, 0xDF, 0x07, 0xEF, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0x7C, 0x3B,
  0xBF, 0xFD, 0xCF, 0xFC, 0xE1, 0xF8, 0x70, 0x07, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0xE1, 0xF0, 0x7C, 0x78, 0x07, 0xBC, 0x00, 0xEE, 0x00, 0x3B, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x0C, 0x78, 0x07, 0x9F, 0x03, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x03, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0xC3,
  0x8F, 0xF9, 0xCF, 0xFE, 0xEF, 0x87, 0x77, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xBE, 0x1D,
  0xDF, 0xFE, 0xE7, 0xFE, 0x70, 0xFC, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0xF0,
  0x0F, 0x78, 0x0F, 0x1E, 0x0F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE3, 0xF0, 0xE7, 0xFC, 0xEF, 0xFE, 0xFC, 0x1E, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x80, 0xFB, 0xFF, 0xCF, 0xFE,
  0x1F, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x3C,
  0x0F, 0x1E, 0x0F, 0x0F, 0x0F, 0x07, 0x8F, 0x03, 0xCF, 0x01, 0xEF, 0x00,
  0xF7, 0x80, 0x7F, 0xE0, 0x3F, 0x70, 0x1F, 0x3C, 0x0F, 0x0F, 0x07, 0x83,
  0xC3, 0xC1, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x78, 0x07, 0xBC, 0x03, 0xDE,
  0x00, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x87, 0x9D, 0xF9, 0xFB, 0xFF, 0x7F,
  0xFC, 0xFC, 0xFF, 0x0F, 0x0F, 0xE1, 0xE1, 0xF8, 0x3C, 0x3F, 0x07, 0x07,
  0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F,
  0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F,
  0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0E, 0xF0, 0xF8, 0x79, 0xFF, 0x3D,
  0xFF, 0xDF, 0xC1, 0xE7, 0xC0, 0x7B, 0xC0, 0x3D, 0xC0, 0x1E, 0xE0, 0x07,
  0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80,
  0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE,
  0x00, 0x77, 0x00, 0x38, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F,
  0x07, 0xC3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0x73, 0x80, 0x0F, 0x70,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xF7, 0x00, 0x1E, 0xE0,
  0x03, 0xDE, 0x00, 0x73, 0xC0, 0x1E, 0x3C, 0x03, 0xC7, 0xC1, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0xF1, 0xF8, 0x3C, 0xFF, 0x8F, 0x7F,
  0xF3, 0xF8, 0x3C, 0x7C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x39, 0xC0, 0x0F,
  0x70, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x0F, 0x70, 0x03, 0xDC,
  0x00, 0xF7, 0x00, 0x39, 0xE0, 0x1E, 0x78, 0x07, 0x9F, 0x83, 0xC7, 0x7F,
  0xF1, 0xDF, 0xF8, 0x71, 0xF8, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0xC3, 0x8F, 0xFB, 0xCF, 0xFF, 0xEF, 0x83, 0xF7, 0x80, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xBE, 0x1F, 0xCF, 0xFF, 0xE7, 0xFE, 0xF0, 0xFC, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0xB8, 0x0F, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF,
  0xCF, 0x81, 0xE7, 0x00, 0x7B, 0x80, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3C,
  0x00, 0x0E, 0xC0, 0x07, 0xF0, 0x03, 0xBC, 0x07, 0xDF, 0xFF, 0xC3, 0xFF,
  0xC0, 0x7F, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0xFF,
  0x0F, 0xFE, 0x07, 0xF8, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x37, 0xFF, 0xF7, 0x7F, 0xE7, 0x1F, 0x87, 0x70, 0x00,
  0x7B, 0xC0, 0x03, 0x9E, 0x00, 0x3C, 0x70, 0x01, 0xE3, 0xC0, 0x0E, 0x1E,
  0x00, 0xF0, 0x78, 0x07, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x1C,
  0x03, 0xC1, 0xE0, 0x0E, 0x0E, 0x00, 0x78, 0xF0, 0x01, 0xC7, 0x80, 0x0F,
  0x38, 0x00, 0x7B, 0xC0, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x3D,
  0xC0, 0x00, 0x7B, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCF, 0x00, 0x03, 0x9E,
  0x0F, 0x07, 0x1C, 0x3E, 0x1E, 0x38, 0x7C, 0x3C, 0x70, 0xDC, 0x70, 0xE3,
  0xB8, 0xE1, 0xE7, 0x31, 0xC3, 0xCC, 0x73, 0x83, 0xB8, 0xEF, 0x07, 0x70,
  0xDE, 0x0E, 0xE1, 0xB8, 0x1D, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x00, 0xF0, 0x01, 0xE7, 0x80, 0x3C,
  0x3C, 0x03, 0x81, 0xC0, 0x78, 0x1E, 0x0F, 0x00, 0xF1, 0xE0, 0x07, 0x1C,
  0x00, 0x3B, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0x1E, 0x00, 0xE0, 0xF0, 0x1E,
  0x07, 0x03, 0xC0, 0x78, 0x38, 0x03, 0xC7, 0x80, 0x1C, 0xF0, 0x01, 0xE0,
  0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3C, 0x70, 0x01, 0xE3, 0xC0,
  0x0E, 0x0E, 0x00, 0xF0, 0x78, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0,
  0x78, 0x1C, 0x01, 0xC1, 0xE0, 0x0F, 0x0E, 0x00, 0x38, 0xF0, 0x01, 0xE7,
  0x00, 0x07, 0x38, 0x00, 0x3B, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0xFE, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xF0, 0x01, 0xF8,
};

const GFXglyph LiberationMono_Regular39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 4, 26, 23, 10, -26 },
  { 14, 13, 12, 23, 5, -28 },
  { 34, 21, 26, 23, 1, -26 },
  { 103, 21, 32, 23, 1, -29 },
  { 187, 23, 26, 23, 0, -26 },
  { 262, 22, 26, 23, 1, -26 },
  { 334, 4, 12, 23, 10, -28 },
  { 340, 10, 36, 23, 7, -28 },
  { 385, 11, 36, 23, 6, -28 },
  { 435, 14, 14, 23, 5, -28 },
  { 460, 19, 19, 23, 2, -22 },
  { 506, 8, 13, 23, 5, -6 },
  { 519, 11, 3, 23, 6, -12 },
  { 524, 5, 6, 23, 9, -6 },
  { 528, 19, 28, 23, 2, -28 },
  { 595, 19, 26, 23, 2, -26 },
  { 657, 19, 26, 23, 3, -26 },
  { 719, 18, 26, 23, 3, -26 },
  { 778, 19, 26, 23, 2, -26 },
  { 840, 19, 26, 23, 2, -26 },
  { 902, 19, 26, 23, 2, -26 },
  { 964, 18, 26, 23, 3, -26 },
  { 1023, 17, 26, 23, 3, -26 },
  { 1079, 18, 26, 23, 3, -26 },
  { 1138, 18, 26, 23, 3, -26 },
  { 1197, 5, 21, 23, 9, -21 },
  { 1211, 8, 28, 23, 7, -21 },
  { 1239, 19, 20, 23, 2, -23 },
  { 1287, 19, 12, 23, 2, -19 },
  { 1316, 19, 20, 23, 2, -23 },
  { 1364, 18, 26, 23, 2, -26 },
  { 1423, 22, 33, 23, 1, -28 },
  { 1514, 23, 26, 23, 0, -26 },
  { 1589, 19, 26, 23, 3, -26 },
  { 1651, 20, 26, 23, 2, -26 },
  { 1716, 18, 26, 23, 3, -26 },
  { 1775, 18, 26, 23, 3, -26 },
  { 1834, 17, 26, 23, 4, -26 },
  { 1890, 19, 26, 23, 2, -26 },
  { 1952, 17, 26, 23, 3, -26 },
  { 2008, 16, 26, 23, 4, -26 },
  { 2060, 16, 26, 23, 3, -26 },
  { 2112, 20, 26, 23, 3, -26 },
  { 2177, 16, 26, 23, 5, -26 },
  { 2229, 19, 26, 23, 2, -26 },
  { 2291, 17, 26, 23, 3, -26 },
  { 2347, 19, 26, 23, 2, -26 },
  { 2409, 18, 26, 23, 3, -26 },
  { 2468, 20, 33, 23, 2, -26 },
  { 2551, 19, 26, 23, 3, -26 },
  { 2613, 20, 26, 23, 1, -26 },
  { 2678, 21, 26, 23, 1, -26 },
  { 2747, 18, 26, 23, 3, -26 },
  { 2806, 23, 26, 23, 0, -26 },
  { 2881, 23, 26, 23, 0, -26 },
  { 2956, 22, 26, 23, 1, -26 },
  { 3028, 22, 26, 23, 1, -26 },
  { 3100, 21, 26, 23, 1, -26 },
  { 3169, 10, 36, 23, 8, -28 },
  { 3214, 19, 28, 23, 2, -28 },
  { 3281, 11, 36, 23, 5, -28 },
  { 3331, 18, 17, 23, 3, -26 },
  { 3370, 23, 2, 23, 0, 2 },
  { 3376, 8, 5, 23, 8, -28 },
  { 3381, 20, 21, 23, 2, -21 },
  { 3434, 18, 28, 23, 3, -28 },
  { 3497, 19, 21, 23, 2, -21 },
  { 3547, 17, 28, 23, 3, -28 },
  { 3607, 18, 21, 23, 3, -21 },
  { 3655, 18, 28, 23, 3, -28 },
  { 3718, 17, 29, 23, 3, -21 },
  { 3780, 16, 28, 23, 4, -28 },
  { 3836, 18, 28, 23, 3, -28 },
  { 3899, 14, 36, 23, 2, -28 },
  { 3962, 17, 28, 23, 4, -28 },
  { 4022, 18, 28, 23, 3, -28 },
  { 4085, 19, 21, 23, 2, -21 },
  { 4135, 17, 21, 23, 3, -21 },
  { 4180, 19, 21, 23, 2, -21 },
  { 4230, 18, 29, 23, 3, -21 },
  { 4296, 17, 29, 23, 3, -21 },
  { 4358, 15, 21, 23, 5, -21 },
  { 4398, 17, 21, 23, 3, -21 },
  { 4443, 15, 26, 23, 4, -26 },
  { 4492, 16, 21, 23, 4, -21 },
  { 4534, 21, 21, 23, 1, -21 },
  { 4590, 23, 21, 23, 0, -21 },
  { 4651, 20, 21, 23, 2, -21 },
  { 4704, 21, 29, 23, 1, -21 },
  { 4781, 17, 21, 23, 3, -21 },
  { 4826, 16, 36, 23, 4, -28 },
  { 4898, 3, 36, 23, 10, -28 },
  { 4912, 16, 36, 23, 3, -28 },
  { 4984, 19, 5, 23, 2, -16 },
};

const GFXfont LiberationMono_Regular39pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular39pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular39pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _LIBERATIONMONO_REGULAR39PT7B_H_
