#ifndef _LIBERATIONMONO_REGULAR55PT7B_H_
#define _LIBERATIONMONO_REGULAR55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFC, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xC0, 0x3E, 0x78, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x0F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00,
  0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x80, 0x01, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x07,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xC7, 0x1F, 0xE1, 0xF8, 0x38, 0x3F, 0x0F, 0x81, 0xC0, 0xF8,
  0x78, 0x0E, 0x03, 0xE7, 0xC0, 0x70, 0x1C, 0x3E, 0x03, 0x80, 0x00, 0xF0,
  0x1C, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x3E, 0x07, 0x00, 0x00, 0xFC, 0x38,
  0x00, 0x07, 0xF9, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0x0F, 0xE0, 0x00, 0x38, 0x1F, 0x80, 0x01, 0xC0, 0x7C, 0x00, 0x0E,
  0x01, 0xF0, 0x00, 0x70, 0x0F, 0x98, 0x03, 0x80, 0x7F, 0xE0, 0x1C, 0x03,
  0xFF, 0x00, 0xE0, 0x1F, 0xFC, 0x07, 0x00, 0xFB, 0xF0, 0x38, 0x0F, 0x9F,
  0xC1, 0xC0, 0xFC, 0x7F, 0x8E, 0x1F, 0xC1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x0F, 0xFF, 0x00, 0x0F,
  0x0F, 0x87, 0x80, 0x0F, 0x07, 0x81, 0xE0, 0x07, 0x87, 0x80, 0xF0, 0x07,
  0x83, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x83, 0xC0, 0x1E, 0x03, 0xC1,
  0xE0, 0x0F, 0x01, 0xE1, 0xE0, 0x03, 0xC0, 0xF1, 0xE0, 0x01, 0xF0, 0xF0,
  0xF0, 0x00, 0x7F, 0xF8, 0xF0, 0x00, 0x1F, 0xF8, 0xF0, 0x00, 0x03, 0xF0,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x38, 0x3F, 0x80, 0x00, 0x3C, 0x7F, 0xE0, 0x00, 0x3C, 0x7F, 0xF8, 0x00,
  0x3C, 0x3C, 0x3E, 0x00, 0x1E, 0x3C, 0x0F, 0x00, 0x1E, 0x1E, 0x03, 0xC0,
  0x1E, 0x0F, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xF0, 0x1E, 0x07, 0x80, 0x78, 0x0F,
  0x07, 0x80, 0x3C, 0x07, 0x87, 0x80, 0x1E, 0x07, 0x83, 0xC0, 0x07, 0x87,
  0xC3, 0xC0, 0x03, 0xFF, 0xC3, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x1E, 0x1F, 0x80, 0x00, 0x3C, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0xC0, 0x0F, 0xF0, 0x01, 0xE0, 0x3F,
  0xF0, 0x07, 0xC0, 0xF9, 0xF0, 0x0F, 0x03, 0xE1, 0xE0, 0x1E, 0x0F, 0x83,
  0xE0, 0x3C, 0x1E, 0x03, 0xE0, 0xF8, 0x3C, 0x03, 0xC1, 0xE0, 0xF8, 0x07,
  0xC3, 0xC1, 0xF0, 0x07, 0xCF, 0x03, 0xE0, 0x07, 0xDE, 0x07, 0xC0, 0x0F,
  0xFC, 0x0F, 0x80, 0x0F, 0xF0, 0x1F, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0x81, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFC, 0x7F, 0xFF, 0x8F, 0xF8, 0x3F, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x03,
  0xC0, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3C, 0x38, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x81, 0xC0, 0xBE, 0x38, 0xFF, 0xF7, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x0F,
  0x78, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0x80, 0xE0, 0x30,
  0x10, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0xF7, 0xC1, 0xFC, 0x1E, 0xF8, 0x3F, 0x83, 0xFF,
  0x07, 0xF0, 0x7F, 0xE0, 0xFE, 0x0F, 0xFC, 0x1F, 0xC1, 0xFF, 0x83, 0xF8,
  0x3F, 0xF0, 0x7F, 0x07, 0xFE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0xF8, 0x03, 0xFE, 0x3E,
  0x00, 0xFE, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xE1,
  0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x7E, 0x00, 0x7F,
  0x0F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x0F, 0xF0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0x8F, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC0, 0xF8,
  0x00, 0x78, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x07, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0xC0,
  0x78, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x3F, 0x80, 0x0F, 0x9F, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x3C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE1,
  0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0,
  0xFC, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0C,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC1, 0xFE, 0x03, 0xE3, 0xFF, 0xC1, 0xF3, 0xFF, 0xF0, 0xFB, 0xFF,
  0xFE, 0x7F, 0xE0, 0x7F, 0x3F, 0xC0, 0x0F, 0xDF, 0xC0, 0x03, 0xEF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3E,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x83, 0xF8, 0x0F, 0xE3, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3F,
  0x01, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xE3, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0x7D,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x3F, 0xC0, 0x7F, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03,
  0xF8, 0x1F, 0xC3, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xE0,
  0x0F, 0xF3, 0xF8, 0x1F, 0xF8, 0xFF, 0xFF, 0x7C, 0x3F, 0xFF, 0x3E, 0x0F,
  0xFF, 0x1F, 0x01, 0xFE, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF1, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0xC1, 0xFC, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0xFE,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xC0, 0xFF, 0x1F, 0xC0, 0x07, 0xE7, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x70, 0x78, 0x0F, 0x80, 0xF0, 0xE0, 0x7F, 0x9D, 0xE3, 0xC1, 0xFF,
  0x39, 0xC7, 0x07, 0xC7, 0x73, 0x8E, 0x0F, 0x07, 0xE7, 0x3C, 0x3C, 0x0F,
  0xCF, 0x78, 0x70, 0x0F, 0x1E, 0xE1, 0xE0, 0x1E, 0x1D, 0xC3, 0x80, 0x3C,
  0x3B, 0x8F, 0x00, 0x78, 0x7F, 0x1E, 0x00, 0xF0, 0xFE, 0x3C, 0x01, 0xC1,
  0xFC, 0x70, 0x07, 0x83, 0xF8, 0xE0, 0x0F, 0x07, 0xF1, 0xC0, 0x1E, 0x1F,
  0xE7, 0x80, 0x3C, 0x3F, 0xCF, 0x00, 0x70, 0x7F, 0x9E, 0x00, 0xE0, 0xEF,
  0x3C, 0x03, 0xC1, 0xDE, 0x38, 0x07, 0x83, 0xBC, 0x70, 0x0F, 0x0F, 0x78,
  0xE0, 0x3E, 0x1C, 0x71, 0xE0, 0x7C, 0x38, 0xE3, 0xC1, 0xB8, 0xF1, 0xC3,
  0xC7, 0x73, 0xC3, 0xC7, 0xFC, 0xFF, 0x03, 0x87, 0xF0, 0xFC, 0x07, 0x07,
  0xC0, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x3E, 0x00, 0x07, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0x80, 0x0F, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xFC, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0x7C,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x7F,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x7C, 0x00, 0x3F, 0x8F, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x1F,
  0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xF7, 0xC0, 0x03, 0xFC, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3C, 0x7C,
  0x00, 0x03, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x87, 0xE0,
  0x00, 0x1E, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x80, 0xFF, 0x07, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0xF8, 0x07, 0xFC, 0x3E, 0x00, 0x3F, 0x8F, 0x80, 0x07, 0xF3,
  0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E,
  0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xE3, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x07, 0xF0,
  0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x61, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE,
  0x07, 0xFC, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xCE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7D,
  0xF0, 0x07, 0xEF, 0xC0, 0x3E, 0x3F, 0x07, 0xF1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x07,
  0xE0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0,
  0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF9, 0xFC, 0x00, 0x07, 0xDF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x7F,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xFC,
  0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x1F,
  0x00, 0x03, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xDE, 0x01, 0xDF, 0xFB, 0xC0, 0x7B,
  0xFF, 0x78, 0x0F, 0x7F, 0xE7, 0x83, 0xCF, 0xFC, 0xF0, 0x79, 0xFF, 0x9F,
  0x0F, 0x3F, 0xF1, 0xE3, 0xC7, 0xFE, 0x3C, 0x78, 0xFF, 0xC7, 0xCF, 0x1F,
  0xF8, 0x7B, 0xC3, 0xFF, 0x0F, 0x78, 0x7F, 0xE0, 0xFE, 0x0F, 0xFC, 0x1F,
  0xC1, 0xFF, 0x83, 0xF8, 0x3F, 0xF0, 0x3E, 0x07, 0xFE, 0x07, 0xC0, 0xFF,
  0xC0, 0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFB, 0xC0, 0x0F,
  0xFD, 0xF0, 0x07, 0xFE, 0x78, 0x03, 0xFF, 0x3E, 0x01, 0xFF, 0x8F, 0x00,
  0xFF, 0xC7, 0xC0, 0x7F, 0xE3, 0xE0, 0x3F, 0xF0, 0xF8, 0x1F, 0xF8, 0x7C,
  0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x03, 0xC1, 0xFF, 0x81,
  0xF0, 0xFF, 0xC0, 0x78, 0x7F, 0xE0, 0x3E, 0x3F, 0xF0, 0x0F, 0x1F, 0xF8,
  0x07, 0xCF, 0xFC, 0x01, 0xE7, 0xFE, 0x00, 0xFB, 0xFF, 0x00, 0x7D, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xF9, 0xF0,
  0x00, 0x1F, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE1, 0xF8, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xF8,
  0x00, 0xFF, 0x3E, 0x00, 0x0F, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0xCF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x7E,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0x8F, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8,
  0xF8, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8,
  0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x38, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF1, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x7E, 0x3F, 0x80, 0xFE, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x81, 0xF0, 0xF8, 0x1F, 0xC0,
  0xF8, 0x7C, 0x0F, 0xE0, 0x7C, 0x1E, 0x07, 0x70, 0x3C, 0x0F, 0x07, 0xBC,
  0x1E, 0x07, 0xC3, 0xDE, 0x0F, 0x03, 0xE1, 0xEF, 0x0F, 0x81, 0xF0, 0xE3,
  0x87, 0xC0, 0xF8, 0xF1, 0xE3, 0xE0, 0x3C, 0x78, 0xF1, 0xE0, 0x1E, 0x3C,
  0x78, 0xF0, 0x0F, 0x1C, 0x1E, 0x78, 0x07, 0x9E, 0x0F, 0x3C, 0x03, 0xCF,
  0x07, 0x9E, 0x01, 0xF7, 0x83, 0xCF, 0x00, 0xFB, 0x80, 0xEF, 0x80, 0x3F,
  0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x03,
  0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x07,
  0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00,
  0x03, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x3C,
  0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xC0, 0x1F, 0x07, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xF0, 0x7C, 0x00, 0xFF, 0x07, 0xE0, 0x1F, 0xF0, 0x7F,
  0x07, 0xDF, 0x83, 0xFF, 0xF9, 0xFF, 0x3F, 0xFF, 0x0F, 0xF0, 0xFF, 0xE0,
  0xFF, 0x07, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x3F, 0x80, 0xF8, 0xFF, 0xE0, 0xF9, 0xFF, 0xF8, 0xFB, 0xFF, 0xF8, 0xFF,
  0xC1, 0xFC, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFE,
  0x00, 0x7E, 0xFF, 0x00, 0x7C, 0xFF, 0x81, 0xFC, 0xFB, 0xFF, 0xF8, 0xFB,
  0xFF, 0xF0, 0xF8, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F,
  0x07, 0xE0, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xFE, 0x07, 0xF0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xFC, 0x1F, 0x07, 0xFF,
  0x1F, 0x1F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0x81, 0xFF, 0x7E, 0x00,
  0xFF, 0x7C, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00,
  0xFF, 0x3F, 0x83, 0xFF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F, 0x07, 0xFF,
  0x1F, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xC1, 0xF8, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x18, 0x7E, 0x00, 0x1F, 0x1F, 0x80,
  0x1F, 0x87, 0xF0, 0x3F, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x0F, 0x1F, 0xFF, 0x9F,
  0x1F, 0xFF, 0xDF, 0x3F, 0x83, 0xFF, 0x7E, 0x00, 0xFF, 0x7E, 0x00, 0x7F,
  0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x3F, 0x83, 0xFF, 0x3F, 0xFF, 0xDF,
  0x1F, 0xFF, 0x9F, 0x0F, 0xFF, 0x1F, 0x03, 0xFC, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0xFE, 0x07, 0xC7, 0xFF, 0x8F, 0x9F, 0xFF, 0x9F, 0x7F, 0xFF, 0xBF, 0xF0,
  0x7F, 0x7F, 0x80, 0x3E, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xB0, 0x07, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0x7F, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03,
  0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x3F,
  0x00, 0xF8, 0x7E, 0x00, 0xF8, 0xFC, 0x00, 0xF9, 0xF8, 0x00, 0xF9, 0xF0,
  0x00, 0xFB, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x01,
  0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x3F, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x1F, 0x1E, 0x7F, 0x0F, 0xF3, 0xDF, 0xF3, 0xFF, 0x7B, 0xFE, 0x7F,
  0xEF, 0xE3, 0xFC, 0x7F, 0xF8, 0x3F, 0x07, 0xFE, 0x07, 0xE0, 0xFF, 0xC0,
  0xF8, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x03, 0xE0, 0x3F, 0xE0, 0x7C, 0x07,
  0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x1F, 0xE0, 0x3E, 0x03, 0xFC, 0x07,
  0xC0, 0x7F, 0x80, 0xF8, 0x0F, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x3F,
  0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x1F, 0xE0, 0x3E,
  0x03, 0xFC, 0x07, 0xC0, 0x7F, 0x80, 0xF8, 0x0F, 0xF0, 0x1F, 0x01, 0xFE,
  0x03, 0xE0, 0x3F, 0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xF0,
  0x1F, 0xE0, 0x3E, 0x03, 0xC0, 0x00, 0x3F, 0x81, 0xE1, 0xFF, 0xE3, 0xC7,
  0xFF, 0xE7, 0xDF, 0xFF, 0xEF, 0xFC, 0x1F, 0xDF, 0xE0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F,
  0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x7E, 0x00,
  0x0F, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xFC, 0x0F, 0xF0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0xF8, 0xFF, 0xE0, 0xF9, 0xFF, 0xF8, 0xFB, 0xFF,
  0xF8, 0xFF, 0xC1, 0xFC, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3E, 0xFE, 0x00, 0x7E, 0xFF, 0x00, 0x7E, 0xFF, 0x81, 0xFC, 0xFB, 0xFF,
  0xF8, 0xF9, 0xFF, 0xF0, 0xF8, 0xFF, 0xE0, 0xF8, 0x3F, 0x80, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0x07, 0xFF, 0x1F, 0x1F, 0xFF,
  0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0x81, 0xFF, 0x7E, 0x00, 0xFF, 0x7E, 0x00,
  0x7F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x3F, 0x83,
  0xFF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F, 0x07, 0xFF, 0x1F, 0x01, 0xFC,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFD, 0xE0, 0x7F,
  0xF7, 0xC7, 0xFF, 0xDF, 0x1F, 0xFF, 0x7C, 0xF8, 0x01, 0xF7, 0x80, 0x03,
  0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0x80, 0xFE, 0x3E, 0x00, 0x3E,
  0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7F, 0x00, 0x7E, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x30, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x80,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0x7C, 0x01, 0xFE,
  0xFE, 0x07, 0xBD, 0xFF, 0xFE, 0x79, 0xFF, 0xF8, 0xF1, 0xFF, 0xE1, 0xE0,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3F, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3E, 0x7C, 0x07, 0xC0, 0x7C,
  0xF8, 0x1F, 0xC0, 0xF9, 0xF0, 0x3F, 0x81, 0xF1, 0xE0, 0x77, 0x03, 0xC3,
  0xC1, 0xEE, 0x07, 0x87, 0x83, 0xDE, 0x1F, 0x0F, 0x87, 0xBC, 0x3E, 0x1F,
  0x1E, 0x38, 0x7C, 0x3E, 0x3C, 0x78, 0xF8, 0x3C, 0x78, 0xF1, 0xE0, 0x78,
  0xE0, 0xE3, 0xC0, 0xF3, 0xC1, 0xE7, 0x81, 0xE7, 0x83, 0xDF, 0x03, 0xCE,
  0x03, 0xBE, 0x07, 0xFC, 0x07, 0x78, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
};

const GFXglyph LiberationMono_Regular55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 5, 36, 33, 14, -36 },
  { 24, 19, 17, 33, 7, -40 },
  { 65, 30, 36, 33, 1, -36 },
  { 200, 29, 44, 33, 2, -40 },
  { 360, 33, 38, 33, 0, -37 },
  { 517, 31, 37, 33, 1, -36 },
  { 661, 7, 17, 33, 13, -40 },
  { 676, 15, 51, 33, 9, -40 },
  { 772, 15, 51, 33, 9, -40 },
  { 868, 19, 19, 33, 7, -40 },
  { 914, 27, 28, 33, 3, -32 },
  { 1009, 12, 18, 33, 7, -8 },
  { 1036, 15, 4, 33, 9, -17 },
  { 1044, 7, 8, 33, 13, -8 },
  { 1051, 27, 41, 33, 3, -40 },
  { 1190, 27, 38, 33, 3, -37 },
  { 1319, 26, 36, 33, 4, -36 },
  { 1436, 25, 37, 33, 4, -37 },
  { 1552, 27, 38, 33, 3, -37 },
  { 1681, 27, 36, 33, 3, -36 },
  { 1803, 27, 37, 33, 3, -36 },
  { 1928, 25, 38, 33, 4, -37 },
  { 2047, 25, 36, 33, 4, -36 },
  { 2160, 25, 38, 33, 4, -37 },
  { 2279, 25, 38, 33, 4, -37 },
  { 2398, 7, 29, 33, 13, -29 },
  { 2424, 12, 39, 33, 9, -29 },
  { 2483, 27, 28, 33, 3, -32 },
  { 2578, 27, 18, 33, 3, -27 },
  { 2639, 27, 28, 33, 3, -32 },
  { 2734, 26, 37, 33, 3, -37 },
  { 2855, 31, 48, 33, 1, -40 },
  { 3041, 33, 36, 33, 0, -36 },
  { 3190, 27, 36, 33, 4, -36 },
  { 3312, 28, 38, 33, 3, -37 },
  { 3445, 26, 36, 33, 4, -36 },
  { 3562, 26, 36, 33, 4, -36 },
  { 3679, 24, 36, 33, 5, -36 },
  { 3787, 27, 38, 33, 3, -37 },
  { 3916, 25, 36, 33, 4, -36 },
  { 4029, 23, 36, 33, 5, -36 },
  { 4133, 21, 37, 33, 5, -36 },
  { 4231, 29, 36, 33, 4, -36 },
  { 4362, 24, 36, 33, 6, -36 },
  { 4470, 27, 36, 33, 3, -36 },
  { 4592, 25, 36, 33, 4, -36 },
  { 4705, 27, 38, 33, 3, -37 },
  { 4834, 26, 36, 33, 4, -36 },
  { 4951, 28, 47, 33, 3, -37 },
  { 5116, 28, 36, 33, 4, -36 },
  { 5242, 28, 38, 33, 2, -37 },
  { 5375, 29, 36, 33, 2, -36 },
  { 5506, 25, 37, 33, 4, -36 },
  { 5622, 33, 36, 33, 0, -36 },
  { 5771, 33, 36, 33, 0, -36 },
  { 5920, 31, 36, 33, 1, -36 },
  { 6060, 31, 36, 33, 1, -36 },
  { 6200, 29, 36, 33, 2, -36 },
  { 6331, 15, 51, 33, 11, -40 },
  { 6427, 27, 41, 33, 3, -40 },
  { 6566, 15, 51, 33, 7, -40 },
  { 6662, 25, 24, 33, 4, -36 },
  { 6737, 33, 3, 33, 0, 3 },
  { 6750, 11, 7, 33, 11, -39 },
  { 6760, 28, 31, 33, 3, -30 },
  { 6869, 24, 41, 33, 5, -40 },
  { 6992, 26, 31, 33, 3, -30 },
  { 7093, 24, 41, 33, 4, -40 },
  { 7216, 25, 31, 33, 4, -30 },
  { 7313, 26, 40, 33, 4, -40 },
  { 7443, 24, 41, 33, 4, -30 },
  { 7566, 23, 40, 33, 5, -40 },
  { 7681, 26, 40, 33, 4, -40 },
  { 7811, 19, 51, 33, 3, -40 },
  { 7933, 24, 40, 33, 6, -40 },
  { 8053, 26, 40, 33, 4, -40 },
  { 8183, 27, 30, 33, 3, -30 },
  { 8285, 23, 30, 33, 5, -30 },
  { 8372, 26, 31, 33, 3, -30 },
  { 8473, 24, 41, 33, 5, -30 },
  { 8596, 24, 41, 33, 4, -30 },
  { 8719, 22, 30, 33, 6, -30 },
  { 8802, 24, 31, 33, 4, -30 },
  { 8895, 22, 38, 33, 5, -37 },
  { 9000, 23, 30, 33, 5, -29 },
  { 9087, 29, 29, 33, 2, -29 },
  { 9193, 31, 29, 33, 1, -29 },
  { 9306, 27, 29, 33, 3, -29 },
  { 9404, 29, 40, 33, 2, -29 },
  { 9549, 25, 29, 33, 4, -29 },
  { 9640, 23, 51, 33, 6, -40 },
  { 9787, 5, 51, 33, 14, -40 },
  { 9819, 23, 51, 33, 4, -40 },
  { 9966, 27, 7, 33, 3, -22 },
};

const GFXfont LiberationMono_Regular55pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular55pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular55pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _LIBERATIONMONO_REGULAR55PT7B_H_
