#ifndef _LIBERATIONMONO_REGULAR71PT7B_H_
#define _LIBERATIONMONO_REGULAR71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFB,
  0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0x9F,
  0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF9, 0xF0,
  0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0x80, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC7, 0xCF, 0xFC, 0x07,
  0xF8, 0x1F, 0x07, 0xF8, 0x1F, 0xC0, 0x7C, 0x0F, 0xF0, 0x7E, 0x01, 0xF0,
  0x1F, 0xC1, 0xF8, 0x07, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x00, 0xFE, 0x3F,
  0x80, 0x7C, 0x01, 0x80, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x3F,
  0x81, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x9F, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xCF, 0xFE, 0x00, 0x00,
  0x1F, 0x07, 0xFC, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x0F,
  0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0xC0, 0x07, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0x00, 0x3F, 0x7E, 0x00, 0x7C, 0x00, 0xFD, 0xF8, 0x01,
  0xF0, 0x07, 0xF7, 0xF0, 0x07, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F, 0x00, 0xFE,
  0x3F, 0xC0, 0x7C, 0x07, 0xF8, 0x7F, 0x81, 0xF0, 0x3F, 0xC0, 0xFF, 0xC7,
  0xC7, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x7F, 0xFE, 0x00, 0x00, 0xF8, 0x1F,
  0xFF, 0xE0, 0x00, 0x3E, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xC0, 0xF8, 0x07,
  0xC0, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x1F, 0x00, 0x01, 0xFC, 0x3F, 0x07, 0xC0,
  0x00, 0x1F, 0xFF, 0xE1, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x3E, 0x00, 0x00,
  0x1F, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x3E, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0x83, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0xFF, 0xFF,
  0x00, 0x00, 0x7C, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x7E, 0x00,
  0x07, 0xC1, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x00, 0x3E,
  0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x01, 0xF0,
  0x00, 0x7C, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x1F, 0x00, 0x00,
  0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7C,
  0x03, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xF0,
  0x0F, 0xE7, 0xE0, 0x03, 0xF0, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0x3F, 0x83,
  0xF0, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0x7F, 0x01, 0xFC, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x8F, 0x80, 0xFC, 0x00, 0x1F,
  0xDF, 0x80, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00,
  0x7E, 0x00, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x7E, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x3E, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x78, 0x06, 0x78, 0x3C, 0x1F, 0x7F,
  0x9E, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x1F,
  0x00, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x1E, 0x00, 0xE0, 0x02, 0x00,
  0x40, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x07,
  0xF8, 0x0F, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xF8,
  0x1F, 0xE0, 0x3F, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0x81, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0x80, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xFE, 0x07, 0xF8, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xC0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xF0, 0x00,
  0xFF, 0xFC, 0xFC, 0x00, 0x3F, 0xFE, 0x3F, 0x00, 0x0F, 0xFE, 0x0F, 0xC0,
  0x03, 0xFC, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0xFF, 0x80, 0x03, 0xF0, 0xFF, 0xFC, 0x00, 0xFC, 0xFF, 0xFF, 0xC0,
  0x3F, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0C, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xFE,
  0x00, 0x1F, 0x83, 0xFF, 0xE0, 0x0F, 0xC7, 0xFF, 0xFC, 0x0F, 0xE7, 0xFF,
  0xFF, 0x07, 0xE7, 0xFF, 0xFF, 0xC3, 0xF7, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0,
  0x07, 0xFC, 0xFF, 0xC0, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x81, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0x03, 0xFD,
  0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x01, 0xFF,
  0x9F, 0xF0, 0x03, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0xF7,
  0xF0, 0x7F, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xF1, 0xF8, 0x03, 0xFF, 0xE0,
  0xFC, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x38, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0,
  0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x00, 0x07, 0x83, 0xE0, 0x0F, 0xC0, 0x0F, 0x87,
  0x80, 0x3F, 0xC3, 0xDF, 0x1F, 0x01, 0xFF, 0xC7, 0x9E, 0x3E, 0x07, 0xFF,
  0xDF, 0x3C, 0x78, 0x1F, 0x87, 0xBC, 0x7D, 0xF0, 0x3E, 0x07, 0xF8, 0xFB,
  0xE0, 0xF8, 0x07, 0xF0, 0xF7, 0x81, 0xF0, 0x0F, 0xE1, 0xEF, 0x07, 0xC0,
  0x0F, 0xC3, 0xFE, 0x0F, 0x80, 0x1F, 0x07, 0xFC, 0x3E, 0x00, 0x3E, 0x0F,
  0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0xE0, 0xF0, 0x00, 0xF8, 0x3F, 0xC3, 0xE0,
  0x01, 0xF0, 0x7F, 0x87, 0xC0, 0x03, 0xC0, 0xFF, 0x0F, 0x80, 0x0F, 0x81,
  0xFE, 0x1F, 0x00, 0x1F, 0x03, 0xFC, 0x3E, 0x00, 0x3E, 0x07, 0xF8, 0x78,
  0x00, 0x7C, 0x0F, 0xF0, 0xF0, 0x00, 0xF0, 0x1F, 0xE1, 0xE0, 0x01, 0xE0,
  0x7F, 0xC3, 0xC0, 0x07, 0xC0, 0xFF, 0x87, 0x80, 0x0F, 0x81, 0xEF, 0x0F,
  0x00, 0x1F, 0x03, 0xDE, 0x1E, 0x00, 0x7E, 0x07, 0xBC, 0x3E, 0x00, 0xF8,
  0x1F, 0x78, 0x7C, 0x01, 0xF0, 0x3C, 0xF0, 0xF8, 0x07, 0xE0, 0x79, 0xF1,
  0xF0, 0x1D, 0xC1, 0xF3, 0xE1, 0xF0, 0x7B, 0x83, 0xC3, 0xC3, 0xF1, 0xE7,
  0x8F, 0x07, 0x83, 0xFF, 0xCF, 0xFE, 0x0F, 0x87, 0xFF, 0x1F, 0xF8, 0x1F,
  0x07, 0xFC, 0x1F, 0xE0, 0x1E, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x10, 0x00, 0xF8, 0x00,
  0x00, 0x70, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0x00, 0x07, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x83, 0xF0,
  0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0x00, 0x03, 0xFF, 0x0F, 0xC0, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0x00, 0x01, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0x00,
  0x40, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x02, 0x07,
  0xF0, 0x00, 0x00, 0x7C, 0x3F, 0x80, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xE0, 0x0F, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0xC1, 0xF8, 0x00, 0x1F, 0xF0,
  0xFC, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7F,
  0x9F, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xF0,
  0xFC, 0x00, 0x1F, 0xF0, 0x7E, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x3E, 0x7F, 0x00, 0x00, 0x0C, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3F,
  0x1F, 0xE0, 0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03,
  0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x0E, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7F, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xFC, 0x01, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x87, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0xC1, 0xF8,
  0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x03, 0xFC,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x01,
  0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFC,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x0F, 0xF0, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x00, 0x7E, 0x7F,
  0xE0, 0x00, 0x03, 0xF7, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xF1, 0xFE,
  0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x07, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0x80,
  0x7E, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x00,
  0x3F, 0xC0, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x01,
  0xFE, 0x7E, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xDF, 0xFD, 0xF0, 0x01, 0xF7, 0xFF, 0x7C,
  0x00, 0x7D, 0xFF, 0xDF, 0x80, 0x3E, 0x7F, 0xF3, 0xE0, 0x0F, 0x9F, 0xFC,
  0xF8, 0x03, 0xEF, 0xFF, 0x3F, 0x01, 0xF3, 0xFF, 0xCF, 0xC0, 0x7C, 0xFF,
  0xF1, 0xF0, 0x1F, 0x3F, 0xFC, 0x7E, 0x0F, 0x8F, 0xFF, 0x0F, 0x83, 0xE3,
  0xFF, 0xC3, 0xF1, 0xF8, 0xFF, 0xF0, 0xFC, 0x7C, 0x3F, 0xFC, 0x1F, 0x1F,
  0x0F, 0xFF, 0x07, 0xC7, 0xC3, 0xFF, 0xC1, 0xFB, 0xE0, 0xFF, 0xF0, 0x3E,
  0xF8, 0x3F, 0xFC, 0x0F, 0xBC, 0x0F, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xC0, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xFC, 0x03, 0xF8, 0x0F, 0xFF,
  0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xF7, 0xE0, 0x00, 0xFF, 0xEF, 0xC0, 0x01, 0xFF, 0xCF,
  0xC0, 0x03, 0xFF, 0x9F, 0x80, 0x07, 0xFF, 0x1F, 0x80, 0x0F, 0xFE, 0x3F,
  0x00, 0x1F, 0xFC, 0x3E, 0x00, 0x3F, 0xFC, 0x7E, 0x00, 0x7F, 0xF8, 0xFC,
  0x00, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xE1, 0xF8, 0x03, 0xFF, 0xC1, 0xF8,
  0x07, 0xFF, 0x83, 0xF0, 0x0F, 0xFF, 0x03, 0xF0, 0x1F, 0xFE, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x7F, 0xF8, 0x0F, 0xC0, 0xFF, 0xF0, 0x0F, 0xC1,
  0xFF, 0xE0, 0x1F, 0x83, 0xFF, 0xC0, 0x1F, 0x07, 0xFF, 0x80, 0x3F, 0x0F,
  0xFF, 0x00, 0x7E, 0x1F, 0xFE, 0x00, 0x7E, 0x3F, 0xFC, 0x00, 0xFC, 0x7F,
  0xF8, 0x00, 0xFC, 0xFF, 0xF0, 0x01, 0xF9, 0xFF, 0xE0, 0x01, 0xFB, 0xFF,
  0xC0, 0x03, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x87, 0xE0, 0x00, 0xFF, 0xE3, 0xF0, 0x00, 0x0F, 0xF9, 0xF8,
  0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F,
  0xF3, 0xF0, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xF8, 0x00, 0x1F,
  0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0x07, 0xF8, 0xFC, 0x00,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7F,
  0x3F, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x01, 0xFC, 0x7E, 0x00,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0xE1, 0xF8, 0x00, 0x1F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00,
  0x7E, 0x7F, 0x80, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xE0,
  0x00, 0x3F, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x01,
  0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0xF0, 0x1F,
  0x80, 0x7E, 0x07, 0xDF, 0x03, 0xF0, 0x0F, 0xC0, 0xFB, 0xE0, 0x7E, 0x01,
  0xF8, 0x3E, 0x7C, 0x0F, 0xC0, 0x3F, 0x07, 0xC7, 0xC1, 0xF0, 0x07, 0xE0,
  0xF8, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xC3,
  0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x3E, 0x3F, 0x00, 0x3F, 0x1F, 0x07, 0xC7,
  0xE0, 0x07, 0xE3, 0xE0, 0xF8, 0xFC, 0x00, 0xFC, 0xF8, 0x1F, 0x1F, 0x00,
  0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x00, 0x3E,
  0x78, 0x07, 0xCF, 0x80, 0x07, 0xDF, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xE0,
  0x0F, 0xFE, 0x00, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x7E, 0x00, 0x03, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0x00,
  0x0F, 0x7E, 0x07, 0xF8, 0x01, 0xF7, 0xE0, 0x3F, 0xC0, 0xFE, 0x7E, 0x03,
  0xFF, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xF0, 0xFF, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0xFE, 0x0F, 0xFF, 0x80, 0xFE, 0x3F, 0xFF, 0xC0, 0xFE, 0x7F,
  0xFF, 0xE0, 0xFE, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xF8, 0xFF, 0xE0,
  0x07, 0xF8, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0x80,
  0x00, 0xFC, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x7E, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0xFC, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0xE0,
  0x07, 0xF8, 0xFF, 0xF8, 0x0F, 0xF8, 0xFE, 0xFF, 0xFF, 0xF0, 0xFC, 0x7F,
  0xFF, 0xE0, 0xFC, 0x3F, 0xFF, 0xC0, 0xFC, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFC,
  0x07, 0xE0, 0x3F, 0xFE, 0x0F, 0xC1, 0xFF, 0xFF, 0x1F, 0x87, 0xFF, 0xFF,
  0x3F, 0x0F, 0xFF, 0xFF, 0x7E, 0x3F, 0xE0, 0x3E, 0xFC, 0xFF, 0x00, 0x1F,
  0xF9, 0xFC, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F,
  0xDF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x1F, 0xF3, 0xF8, 0x00, 0x3F, 0xE7, 0xF8, 0x01, 0xFF, 0xC7, 0xFC, 0x0F,
  0xDF, 0x8F, 0xFF, 0xFF, 0x3F, 0x0F, 0xFF, 0xFE, 0x7E, 0x0F, 0xFF, 0xF8,
  0xFC, 0x07, 0xFF, 0xC1, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0xC0, 0x00,
  0x7E, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x04, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xFC,
  0x7E, 0x0F, 0xFF, 0xFE, 0x7E, 0x0F, 0xFF, 0xFF, 0x7E, 0x1F, 0xF0, 0x3F,
  0x7E, 0x3F, 0xC0, 0x0F, 0xFE, 0x3F, 0x80, 0x07, 0xFE, 0x7F, 0x00, 0x03,
  0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x03, 0xFE, 0x3F, 0x80, 0x07, 0xFE, 0x3F, 0xC0, 0x0F,
  0xFE, 0x1F, 0xF0, 0x3F, 0x7E, 0x1F, 0xFF, 0xFE, 0x7E, 0x0F, 0xFF, 0xFC,
  0x7E, 0x07, 0xFF, 0xF8, 0x7E, 0x03, 0xFF, 0xF0, 0x7E, 0x00, 0x7F, 0x80,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x07, 0x80, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x03,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x3F, 0xFE, 0x0F, 0xE3, 0xFF, 0xFC, 0x3F, 0x9F, 0xFF,
  0xF8, 0xFE, 0xFF, 0xFF, 0xF3, 0xF7, 0xE0, 0x3F, 0xEF, 0xDE, 0x00, 0x7F,
  0xBF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xCF, 0x00, 0x7F,
  0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xBF,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x7F,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x3F, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x1F,
  0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF8, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0x00, 0x7E, 0x0F, 0xC7, 0xFC, 0x0F, 0xF8, 0x7C, 0xFF, 0xE1,
  0xFF, 0xC7, 0xDF, 0xFE, 0x3F, 0xFC, 0x7D, 0xFF, 0xE7, 0xFF, 0xE7, 0xFC,
  0x7F, 0x70, 0xFE, 0x7F, 0x83, 0xFE, 0x07, 0xE7, 0xF0, 0x1F, 0xE0, 0x7F,
  0x7F, 0x01, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xC0, 0x3F, 0x7E, 0x01, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0xC0, 0x3F, 0x7E, 0x01, 0xF8, 0x03, 0xF7, 0xE0,
  0x1F, 0x80, 0x3F, 0x7E, 0x01, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x80, 0x3F,
  0x7E, 0x01, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x80, 0x3F, 0x7E, 0x01, 0xF8,
  0x03, 0xF7, 0xE0, 0x1F, 0x80, 0x3F, 0x7E, 0x01, 0xF8, 0x03, 0xF7, 0xE0,
  0x1F, 0x80, 0x3F, 0x7E, 0x01, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x80, 0x3F,
  0x7E, 0x01, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x80, 0x3F, 0x7E, 0x01, 0xF8,
  0x03, 0xF7, 0xE0, 0x1F, 0x80, 0x3F, 0x7E, 0x01, 0xF8, 0x03, 0xF7, 0xE0,
  0x1F, 0x80, 0x3F, 0x7E, 0x01, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x80, 0x3F,
  0x7E, 0x01, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x80, 0x3F, 0x7E, 0x01, 0xF8,
  0x03, 0xF7, 0xE0, 0x1F, 0x80, 0x3F, 0x7E, 0x01, 0xF8, 0x03, 0xF7, 0xE0,
  0x1F, 0x80, 0x3F, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xFE, 0x03,
  0xF0, 0x3F, 0xFE, 0x0F, 0xC3, 0xFF, 0xFE, 0x3F, 0x1F, 0xFF, 0xFC, 0xFC,
  0xFF, 0xFF, 0xF3, 0xF7, 0xE0, 0x3F, 0xEF, 0xDE, 0x00, 0x7F, 0xBF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x1F, 0xFF, 0x80, 0xFC, 0x3F, 0xFF,
  0xC0, 0xFC, 0x7F, 0xFF, 0xE0, 0xFE, 0xFF, 0xFF, 0xF0, 0xFE, 0xF8, 0x0F,
  0xF8, 0xFF, 0xE0, 0x03, 0xF8, 0xFF, 0xC0, 0x01, 0xFC, 0xFF, 0x80, 0x01,
  0xFC, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0x7E, 0xFF, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFC, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0xC0, 0x03,
  0xFC, 0xFF, 0xE0, 0x07, 0xF8, 0xFF, 0xF8, 0x0F, 0xF8, 0xFE, 0xFF, 0xFF,
  0xF0, 0xFE, 0x7F, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0xFF,
  0x80, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0xF1,
  0xF8, 0x7F, 0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0xF7, 0xE3, 0xFE, 0x07, 0xEF,
  0xCF, 0xF0, 0x01, 0xFF, 0x9F, 0xC0, 0x01, 0xFF, 0x7F, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0x7F, 0xBF, 0x80, 0x01, 0xFF, 0x3F, 0x80, 0x07, 0xFE, 0x7F, 0x80, 0x1F,
  0xFC, 0x7F, 0xC0, 0xFD, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0xE7,
  0xE0, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0xFC, 0x1F, 0x80, 0x3F, 0xE0, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xEF, 0xC0,
  0x3F, 0xFF, 0x7E, 0x07, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0x7E, 0x1F, 0xFF,
  0xF7, 0xE3, 0xFF, 0xFF, 0x7F, 0x3F, 0x80, 0x13, 0xF7, 0xE0, 0x00, 0x3F,
  0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x01, 0xE1, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC6, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF9,
  0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0x9F,
  0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xFC, 0x7F,
  0xC0, 0x7D, 0xF8, 0xFF, 0xFF, 0xFB, 0xF0, 0xFF, 0xFF, 0xE3, 0xE0, 0xFF,
  0xFF, 0x87, 0xC0, 0xFF, 0xFC, 0x0F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xE0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xFC, 0x03, 0xF0,
  0xFC, 0x03, 0xFE, 0x03, 0xF0, 0x7E, 0x03, 0xEF, 0x01, 0xF8, 0x3F, 0x01,
  0xF7, 0xC0, 0xFC, 0x0F, 0xC0, 0xF3, 0xE0, 0x7E, 0x07, 0xE0, 0xF9, 0xF0,
  0x3F, 0x03, 0xF0, 0x7C, 0x78, 0x1F, 0x81, 0xF8, 0x3C, 0x3E, 0x1F, 0x80,
  0xFC, 0x3E, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F, 0x07, 0x87, 0xE0, 0x1F, 0x0F,
  0x83, 0xE3, 0xF0, 0x0F, 0xCF, 0x81, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x78,
  0xF8, 0x03, 0xF3, 0xE0, 0x3C, 0x7C, 0x01, 0xF9, 0xE0, 0x1F, 0x7E, 0x00,
  0xFD, 0xF0, 0x0F, 0xBF, 0x00, 0x3E, 0xF8, 0x03, 0xDF, 0x80, 0x1F, 0x78,
  0x01, 0xFF, 0xC0, 0x0F, 0xBC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF4, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
};

const GFXglyph LiberationMono_Regular71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 7, 47, 43, 18, -47 },
  { 43, 23, 22, 43, 10, -51 },
  { 107, 38, 47, 43, 2, -47 },
  { 331, 38, 58, 43, 2, -52 },
  { 607, 43, 49, 43, 0, -48 },
  { 871, 40, 48, 43, 1, -47 },
  { 1111, 8, 22, 43, 17, -51 },
  { 1133, 19, 66, 43, 12, -51 },
  { 1290, 19, 66, 43, 12, -51 },
  { 1447, 25, 25, 43, 9, -51 },
  { 1526, 35, 35, 43, 4, -41 },
  { 1680, 15, 23, 43, 9, -10 },
  { 1724, 19, 6, 43, 12, -22 },
  { 1739, 8, 10, 43, 17, -10 },
  { 1749, 35, 52, 43, 4, -51 },
  { 1977, 34, 49, 43, 4, -48 },
  { 2186, 34, 47, 43, 5, -47 },
  { 2386, 33, 48, 43, 5, -48 },
  { 2584, 34, 49, 43, 4, -48 },
  { 2793, 35, 47, 43, 4, -47 },
  { 2999, 34, 48, 43, 4, -47 },
  { 3203, 33, 49, 43, 5, -48 },
  { 3406, 32, 47, 43, 5, -47 },
  { 3594, 33, 49, 43, 5, -48 },
  { 3797, 33, 49, 43, 5, -48 },
  { 4000, 8, 38, 43, 17, -38 },
  { 4038, 15, 51, 43, 12, -38 },
  { 4134, 35, 36, 43, 4, -41 },
  { 4292, 35, 23, 43, 4, -35 },
  { 4393, 35, 36, 43, 4, -41 },
  { 4551, 34, 48, 43, 3, -48 },
  { 4755, 39, 61, 43, 2, -51 },
  { 5053, 43, 47, 43, 0, -47 },
  { 5306, 34, 47, 43, 6, -47 },
  { 5506, 36, 49, 43, 4, -48 },
  { 5727, 33, 47, 43, 6, -47 },
  { 5921, 33, 47, 43, 6, -47 },
  { 6115, 31, 47, 43, 7, -47 },
  { 6298, 34, 49, 43, 4, -48 },
  { 6507, 31, 47, 43, 6, -47 },
  { 6690, 29, 47, 43, 7, -47 },
  { 6861, 28, 48, 43, 6, -47 },
  { 7029, 37, 47, 43, 6, -47 },
  { 7247, 30, 47, 43, 8, -47 },
  { 7424, 34, 47, 43, 4, -47 },
  { 7624, 31, 47, 43, 6, -47 },
  { 7807, 35, 49, 43, 4, -48 },
  { 8022, 33, 47, 43, 6, -47 },
  { 8216, 35, 61, 43, 4, -48 },
  { 8483, 35, 47, 43, 6, -47 },
  { 8689, 36, 49, 43, 3, -48 },
  { 8910, 37, 47, 43, 3, -47 },
  { 9128, 33, 48, 43, 5, -47 },
  { 9326, 42, 47, 43, 0, -47 },
  { 9573, 43, 47, 43, 0, -47 },
  { 9826, 40, 47, 43, 1, -47 },
  { 10061, 40, 47, 43, 1, -47 },
  { 10296, 37, 47, 43, 3, -47 },
  { 10514, 19, 66, 43, 14, -51 },
  { 10671, 35, 52, 43, 4, -51 },
  { 10899, 19, 66, 43, 9, -51 },
  { 11056, 33, 31, 43, 5, -47 },
  { 11184, 43, 3, 43, 0, 4 },
  { 11201, 15, 9, 43, 14, -51 },
  { 11218, 36, 40, 43, 4, -39 },
  { 11398, 32, 52, 43, 6, -51 },
  { 11606, 33, 40, 43, 4, -39 },
  { 11771, 31, 52, 43, 5, -51 },
  { 11973, 33, 40, 43, 5, -39 },
  { 12138, 33, 51, 43, 5, -51 },
  { 12349, 32, 54, 43, 5, -39 },
  { 12565, 30, 51, 43, 6, -51 },
  { 12757, 34, 51, 43, 5, -51 },
  { 12974, 25, 66, 43, 4, -51 },
  { 13181, 31, 51, 43, 8, -51 },
  { 13379, 34, 51, 43, 5, -51 },
  { 13596, 36, 39, 43, 3, -39 },
  { 13772, 30, 39, 43, 6, -39 },
  { 13919, 34, 40, 43, 4, -39 },
  { 14089, 32, 54, 43, 6, -39 },
  { 14305, 31, 54, 43, 5, -39 },
  { 14515, 28, 39, 43, 8, -39 },
  { 14652, 31, 40, 43, 6, -39 },
  { 14807, 28, 49, 43, 7, -48 },
  { 14979, 31, 39, 43, 6, -38 },
  { 15131, 38, 38, 43, 2, -38 },
  { 15312, 41, 38, 43, 1, -38 },
  { 15507, 36, 38, 43, 3, -38 },
  { 15678, 38, 53, 43, 2, -38 },
  { 15930, 32, 38, 43, 5, -38 },
  { 16082, 29, 66, 43, 8, -51 },
  { 16322, 6, 66, 43, 18, -51 },
  { 16372, 29, 66, 43, 6, -51 },
  { 16612, 35, 9, 43, 4, -28 },
};

const GFXfont LiberationMono_Regular71pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular71pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular71pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _LIBERATIONMONO_REGULAR71PT7B_H_
