#ifndef _LIBERATIONMONO_REGULAR53PT7B_H_
#define _LIBERATIONMONO_REGULAR53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0xFC,
  0x0F, 0xFF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0x9F, 0x03,
  0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x78, 0x0F, 0x9E, 0x03, 0xE7, 0x80, 0xF9,
  0xE0, 0x3E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0,
  0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x70, 0x07, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0,
  0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x18, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x03, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x01, 0xC0,
  0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xF8, 0xF3,
  0xF8, 0x3E, 0x0F, 0x0F, 0xC3, 0xC0, 0xF0, 0x7C, 0x7C, 0x0F, 0x03, 0xE7,
  0xC0, 0xF0, 0x38, 0x7C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x0F,
  0x00, 0x03, 0xF0, 0xF0, 0x00, 0x1F, 0xEF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0x1F, 0xC0, 0x00, 0xF0, 0x7E, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x30,
  0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0xC0, 0xF0,
  0x3E, 0x7E, 0x0F, 0x07, 0xE3, 0xF8, 0xF1, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3C, 0x3F, 0xF8, 0x00, 0x78,
  0x7C, 0x7C, 0x00, 0xF0, 0x78, 0x3C, 0x00, 0xE0, 0xF0, 0x1E, 0x01, 0xE0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x1E, 0x0E, 0x00, 0xF0, 0x1E, 0x1E, 0x00,
  0xF0, 0x1C, 0x3C, 0x00, 0x78, 0x3C, 0x78, 0x00, 0x7C, 0x7C, 0x78, 0x00,
  0x3F, 0xF8, 0xF0, 0x00, 0x1F, 0xF1, 0xE0, 0x00, 0x0F, 0xC1, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x87, 0xF0, 0x00, 0x07, 0x0F, 0xF8,
  0x00, 0x0F, 0x1F, 0xFC, 0x00, 0x1E, 0x3E, 0x3E, 0x00, 0x1C, 0x3C, 0x1E,
  0x00, 0x3C, 0x78, 0x0E, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x70, 0x78, 0x0F,
  0x00, 0xF0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x0E, 0x0F, 0x00, 0x3C, 0x1E,
  0x0E, 0x00, 0x3E, 0x3E, 0x1E, 0x00, 0x1F, 0xFC, 0x3C, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0,
  0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x3E,
  0x00, 0x01, 0xE3, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x01, 0x80, 0x3F, 0xE0, 0x07, 0x81,
  0xF7, 0xC0, 0x3C, 0x0F, 0x8F, 0x00, 0xF0, 0x7C, 0x1E, 0x03, 0xC1, 0xE0,
  0x7C, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x3E, 0x03, 0xE1, 0xE0, 0xF8, 0x07,
  0xC7, 0x83, 0xC0, 0x0F, 0xBC, 0x0F, 0x00, 0x1F, 0xF0, 0x3E, 0x00, 0x7F,
  0x80, 0xF8, 0x00, 0xFE, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xF0,
  0x1F, 0xC0, 0xFF, 0xFB, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xF0,
  0xFF, 0xF8, 0x3F, 0xC0, 0x7F, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xBE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0xC1, 0xC0, 0x9E, 0x38, 0x7B, 0xFF, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0,
  0x03, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0x38, 0x01, 0xE7, 0x80,
  0x78, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xE0, 0x10, 0x18, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xE1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07,
  0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFC, 0x07,
  0xC0, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F,
  0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0x78, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0xFC, 0x1E, 0xF8,
  0x3F, 0x07, 0xBE, 0x0F, 0xC1, 0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F,
  0xF8, 0x3F, 0x07, 0xFE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE0,
  0x7C, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0x7C, 0x01, 0xFF, 0x3E, 0x00, 0xFE, 0x1F, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81,
  0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFC,
  0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x3F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC3, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE1, 0xFE, 0x00, 0xF7, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xF9, 0xF8, 0x00,
  0xFC, 0x7F, 0x01, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0x3E, 0x3E, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0xF8,
  0xFF, 0xE0, 0xFB, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFC, 0xFF,
  0x00, 0x7E, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0xC1, 0xFC, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE1, 0xF8, 0x01, 0xF8,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0x9F, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xE1, 0xF0,
  0x01, 0xF9, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFB,
  0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x7F,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x3F, 0x83, 0xF8, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x3F, 0x83,
  0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0x07, 0xFF, 0x1F, 0x01, 0xFC,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x01,
  0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83,
  0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01,
  0xC0, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F,
  0x0F, 0xC0, 0x07, 0xE3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xDE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x7C, 0x07, 0x8F, 0x07,
  0xF9, 0xCE, 0x38, 0x3F, 0xF7, 0x39, 0xE1, 0xF1, 0xDC, 0xE7, 0x87, 0x83,
  0xF3, 0xDC, 0x3C, 0x07, 0x87, 0x70, 0xE0, 0x1E, 0x1D, 0xC7, 0x80, 0x78,
  0x7F, 0x1E, 0x01, 0xE1, 0xFC, 0x70, 0x07, 0x87, 0xF1, 0xC0, 0x1C, 0x1F,
  0x8F, 0x00, 0x70, 0xFE, 0x3C, 0x03, 0xC3, 0xF8, 0xF0, 0x0F, 0x0E, 0xE3,
  0xC0, 0x38, 0x3B, 0x8F, 0x00, 0xE0, 0xEE, 0x3C, 0x07, 0x83, 0xBC, 0xF0,
  0x1E, 0x1C, 0xF1, 0xC0, 0xF8, 0x71, 0xC7, 0x07, 0xE3, 0xC7, 0x1E, 0x3B,
  0x8E, 0x1C, 0x3F, 0xEF, 0xF8, 0x78, 0xFF, 0x1F, 0xC1, 0xE0, 0xF0, 0x3C,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x02, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3C, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xF8,
  0x01, 0xFE, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xFC,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x83, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3,
  0xE0, 0x03, 0xF8, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xEF,
  0x80, 0x0F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xC1, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x3E,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x03,
  0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x80, 0x7F,
  0x87, 0xC0, 0x0F, 0xE3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x3F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x0F,
  0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x0F, 0xE3, 0xE0, 0x1F, 0xE1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xE0,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xDF,
  0x00, 0x01, 0x87, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0x7E,
  0x00, 0x3F, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x9C, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7E, 0x00, 0xF9,
  0xF0, 0x0F, 0x8F, 0xE0, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F,
  0x80, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x0F,
  0x80, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x7E,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF3,
  0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0xC0,
  0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xF8,
  0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xBC, 0x01, 0xFF, 0xDE, 0x01, 0xFF, 0xEF, 0x00, 0xFF, 0xF3, 0xC0, 0xF7,
  0xF9, 0xE0, 0x7B, 0xFC, 0xF0, 0x3D, 0xFE, 0x3C, 0x3C, 0xFF, 0x1E, 0x1E,
  0x7F, 0x8F, 0x0F, 0x3F, 0xC3, 0xCF, 0x1F, 0xE1, 0xE7, 0x8F, 0xF0, 0xF3,
  0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFF, 0x03,
  0xF0, 0x7F, 0x81, 0xF8, 0x3F, 0xC0, 0x78, 0x1F, 0xE0, 0x3C, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xF7, 0x80, 0x1F, 0xF7, 0x80, 0x1F, 0xF7, 0xC0,
  0x1F, 0xF3, 0xC0, 0x1F, 0xFB, 0xE0, 0x1F, 0xF9, 0xE0, 0x1F, 0xF9, 0xF0,
  0x1F, 0xF8, 0xF0, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0x78, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x1E, 0x1F, 0xF8, 0x1E,
  0x1F, 0xF8, 0x1F, 0x1F, 0xF8, 0x0F, 0x1F, 0xF8, 0x0F, 0x9F, 0xF8, 0x07,
  0x9F, 0xF8, 0x07, 0xDF, 0xF8, 0x03, 0xDF, 0xF8, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F,
  0x9F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xF0, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0x80, 0x1F, 0xE7,
  0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x7E, 0x7C, 0x00, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xC0, 0xFE, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xC3,
  0xF0, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0xFF, 0x3E, 0x00, 0x0F, 0xCF,
  0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xBE, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x03, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xF8, 0x0F, 0x80,
  0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x03,
  0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81,
  0xFC, 0x07, 0xF8, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x9C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF3, 0xF8, 0x00, 0x7E, 0x3F, 0xC0,
  0x3F, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7E, 0x00, 0x7E, 0x7F, 0x01, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0,
  0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78,
  0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x03,
  0xC0, 0x7C, 0x3E, 0x07, 0xE0, 0x7C, 0x3E, 0x07, 0xE0, 0x7C, 0x3E, 0x07,
  0xE0, 0x7C, 0x3E, 0x0F, 0xE0, 0x78, 0x1E, 0x0F, 0xF0, 0x78, 0x1E, 0x0E,
  0xF0, 0x78, 0x1E, 0x0E, 0x70, 0x78, 0x1E, 0x1E, 0x78, 0xF8, 0x1F, 0x1E,
  0x78, 0xF8, 0x1F, 0x1E, 0x78, 0xF0, 0x0F, 0x1C, 0x38, 0xF0, 0x0F, 0x3C,
  0x3C, 0xF0, 0x0F, 0x3C, 0x3C, 0xF0, 0x0F, 0x38, 0x3C, 0xF0, 0x0F, 0x38,
  0x1C, 0xF0, 0x0F, 0x78, 0x1E, 0xF0, 0x0F, 0x78, 0x1E, 0xE0, 0x07, 0x70,
  0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x01,
  0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x3E,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0xF0,
  0x00, 0x0F, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3,
  0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xF0,
  0x1E, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x1C,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x38, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x7C,
  0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x3F, 0x80, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87,
  0xE0, 0x07, 0xF0, 0x7C, 0x01, 0xFE, 0x0F, 0xC0, 0xF7, 0xE1, 0xFF, 0xFE,
  0x7F, 0x9F, 0xFF, 0x8F, 0xF1, 0xFF, 0xC0, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x7F, 0x03, 0xC7, 0xFF, 0x07, 0x9F, 0xFF, 0x8F, 0x7F,
  0xFF, 0x9E, 0xF0, 0x7F, 0x3F, 0x80, 0x3F, 0x7E, 0x00, 0x3E, 0xFC, 0x00,
  0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xFC,
  0x01, 0xFB, 0xDE, 0x0F, 0xE7, 0xBF, 0xFF, 0x8F, 0x3F, 0xFF, 0x1E, 0x3F,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0xF8, 0x01, 0xF8,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x0F,
  0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x7C, 0x3F, 0xFC, 0xF8, 0xFF,
  0xFD, 0xF3, 0xFF, 0xFF, 0xE7, 0xE0, 0x7F, 0xDF, 0x80, 0x3F, 0xBE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C,
  0x00, 0xFE, 0xFC, 0x03, 0xFC, 0xFC, 0x0F, 0xF9, 0xFF, 0xFD, 0xF1, 0xFF,
  0xF9, 0xE1, 0xFF, 0xC3, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE1,
  0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0x3E, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x30, 0x7E, 0x00, 0x1E, 0x1F,
  0x80, 0x3F, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x3C, 0x7F, 0xFE, 0x79, 0xFF, 0xFC, 0xF3,
  0xF0, 0x3D, 0xEF, 0xC0, 0x3F, 0xDF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xDF, 0x00, 0x3F, 0xBF, 0x00, 0xFF, 0x7F, 0x03, 0xFE,
  0x7F, 0xFF, 0x7C, 0x7F, 0xFC, 0xF8, 0x7F, 0xF1, 0xF0, 0x3F, 0x83, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x1C, 0x00, 0x3E, 0x7C,
  0x00, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x0F, 0xE1, 0xFF, 0xFF, 0x81, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0xFE, 0x0F, 0x0F,
  0xFE, 0x3C, 0xFF, 0xFC, 0xF7, 0xFF, 0xFB, 0xDE, 0x0F, 0xEF, 0xE0, 0x0F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xEC,
  0x03, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0x1F, 0xF0, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80,
  0x1F, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F,
  0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0x80,
  0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xF0,
  0x07, 0xE3, 0xE0, 0x07, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x07, 0xDF, 0x00,
  0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x3E, 0x38, 0xFE, 0x3F,
  0xCF, 0x7F, 0x8F, 0xFB, 0xFF, 0xF7, 0xFE, 0xFC, 0x7F, 0x8F, 0xFF, 0x0F,
  0xC1, 0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0x7C, 0x0F, 0xF8, 0x1E, 0x03, 0xFC,
  0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03,
  0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E,
  0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0,
  0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F,
  0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78,
  0x0F, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x3F, 0x83, 0xC3, 0xFF, 0x8F, 0x3F,
  0xFF, 0x3D, 0xFF, 0xFE, 0xF7, 0x83, 0xFB, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7C, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x81, 0xFC, 0x0F, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0xFC,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x0F, 0xE0, 0x7F, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x01, 0xE3, 0xFF, 0xC3, 0xCF, 0xFF, 0xC7, 0xBF, 0xFF, 0xCF, 0x78,
  0x3F, 0x9F, 0xC0, 0x1F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFE, 0x00, 0xFD, 0xEF,
  0x07, 0xF3, 0xDF, 0xFF, 0xC7, 0x9F, 0xFF, 0x8F, 0x1F, 0xFC, 0x1E, 0x0F,
  0xF0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFC, 0x1E, 0x1F, 0xFE, 0x7C,
  0x7F, 0xFE, 0xF9, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0xEF, 0xC0, 0x1F, 0xDF,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xBE, 0x00, 0x7F, 0x7E, 0x01, 0xFE, 0x7E, 0x07, 0xFC, 0xFF, 0xFE, 0xF8,
  0xFF, 0xF9, 0xF0, 0xFF, 0xE3, 0xE0, 0x7F, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xDE, 0x1F, 0xFE, 0xF1, 0xFF, 0xF7,
  0xDF, 0x80, 0x3E, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF0, 0x0F, 0xC7, 0xC0, 0x07, 0x8F,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0x7C, 0x00, 0x3E, 0xFE, 0x01, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0x80, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x7F, 0x7E, 0x07, 0xBD, 0xFF, 0xFC, 0xF3, 0xFF, 0xF3, 0xC7, 0xFF,
  0x0F, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x80,
  0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3E,
  0x78, 0x0F, 0xC0, 0xF9, 0xF0, 0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0x0F, 0x1F,
  0x07, 0xF0, 0x3C, 0x3C, 0x1D, 0xE0, 0xF0, 0xF0, 0x73, 0x87, 0xC3, 0xC3,
  0xCE, 0x1F, 0x0F, 0x8F, 0x3C, 0x7C, 0x3E, 0x38, 0xF1, 0xE0, 0x79, 0xE1,
  0xC7, 0x81, 0xE7, 0x87, 0x9E, 0x07, 0x9C, 0x1E, 0x78, 0x1E, 0xF0, 0x3B,
  0xE0, 0x7B, 0xC0, 0xFF, 0x01, 0xEE, 0x03, 0xFC, 0x03, 0xB8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x03,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x3E,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0x3C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x3C, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xE0,
};

const GFXglyph LiberationMono_Regular53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 5, 35, 32, 13, -35 },
  { 23, 18, 17, 32, 7, -38 },
  { 62, 29, 35, 32, 1, -35 },
  { 189, 28, 42, 32, 2, -38 },
  { 336, 32, 37, 32, 0, -36 },
  { 484, 30, 36, 32, 1, -35 },
  { 619, 6, 17, 32, 13, -38 },
  { 632, 14, 49, 32, 9, -38 },
  { 718, 14, 49, 32, 9, -38 },
  { 804, 19, 19, 32, 6, -38 },
  { 850, 26, 26, 32, 3, -31 },
  { 935, 11, 17, 32, 7, -8 },
  { 959, 14, 4, 32, 9, -16 },
  { 966, 6, 8, 32, 13, -8 },
  { 972, 26, 39, 32, 3, -38 },
  { 1099, 26, 37, 32, 3, -36 },
  { 1220, 25, 35, 32, 4, -35 },
  { 1330, 24, 36, 32, 4, -36 },
  { 1438, 25, 37, 32, 3, -36 },
  { 1554, 26, 35, 32, 3, -35 },
  { 1668, 25, 36, 32, 3, -35 },
  { 1781, 24, 37, 32, 4, -36 },
  { 1892, 24, 35, 32, 4, -35 },
  { 1997, 25, 37, 32, 3, -36 },
  { 2113, 24, 37, 32, 4, -36 },
  { 2224, 6, 28, 32, 13, -28 },
  { 2245, 11, 37, 32, 9, -28 },
  { 2296, 26, 27, 32, 3, -31 },
  { 2384, 26, 17, 32, 3, -26 },
  { 2440, 26, 27, 32, 3, -31 },
  { 2528, 26, 36, 32, 2, -36 },
  { 2645, 30, 44, 32, 1, -38 },
  { 2810, 32, 35, 32, 0, -35 },
  { 2950, 26, 35, 32, 4, -35 },
  { 3064, 27, 37, 32, 3, -36 },
  { 3189, 25, 35, 32, 4, -35 },
  { 3299, 25, 35, 32, 4, -35 },
  { 3409, 23, 35, 32, 5, -35 },
  { 3510, 26, 37, 32, 3, -36 },
  { 3631, 24, 35, 32, 4, -35 },
  { 3736, 22, 35, 32, 5, -35 },
  { 3833, 21, 36, 32, 5, -35 },
  { 3928, 28, 35, 32, 4, -35 },
  { 4051, 22, 35, 32, 6, -35 },
  { 4148, 25, 35, 32, 3, -35 },
  { 4258, 24, 35, 32, 4, -35 },
  { 4363, 26, 37, 32, 3, -36 },
  { 4484, 25, 35, 32, 4, -35 },
  { 4594, 26, 46, 32, 3, -36 },
  { 4744, 26, 35, 32, 4, -35 },
  { 4858, 27, 37, 32, 2, -36 },
  { 4983, 28, 35, 32, 2, -35 },
  { 5106, 24, 36, 32, 4, -35 },
  { 5214, 32, 35, 32, 0, -35 },
  { 5354, 32, 35, 32, 0, -35 },
  { 5494, 30, 35, 32, 1, -35 },
  { 5626, 30, 35, 32, 1, -35 },
  { 5758, 28, 35, 32, 2, -35 },
  { 5881, 14, 49, 32, 11, -38 },
  { 5967, 26, 39, 32, 3, -38 },
  { 6094, 14, 49, 32, 7, -38 },
  { 6180, 25, 23, 32, 3, -35 },
  { 6252, 32, 2, 32, 0, 3 },
  { 6260, 11, 7, 32, 10, -38 },
  { 6270, 27, 30, 32, 3, -29 },
  { 6372, 23, 39, 32, 5, -38 },
  { 6485, 25, 30, 32, 3, -29 },
  { 6579, 23, 39, 32, 4, -38 },
  { 6692, 25, 30, 32, 3, -29 },
  { 6786, 24, 38, 32, 4, -38 },
  { 6900, 23, 40, 32, 4, -29 },
  { 7015, 22, 38, 32, 5, -38 },
  { 7120, 25, 38, 32, 4, -38 },
  { 7239, 19, 49, 32, 3, -38 },
  { 7356, 23, 38, 32, 6, -38 },
  { 7466, 26, 38, 32, 3, -38 },
  { 7590, 26, 29, 32, 3, -29 },
  { 7685, 22, 29, 32, 5, -29 },
  { 7765, 25, 30, 32, 3, -29 },
  { 7859, 23, 40, 32, 5, -29 },
  { 7974, 23, 40, 32, 4, -29 },
  { 8089, 21, 29, 32, 6, -29 },
  { 8166, 23, 30, 32, 4, -29 },
  { 8253, 21, 36, 32, 5, -35 },
  { 8348, 22, 29, 32, 5, -28 },
  { 8428, 28, 28, 32, 2, -28 },
  { 8526, 30, 28, 32, 1, -28 },
  { 8631, 27, 28, 32, 2, -28 },
  { 8726, 28, 39, 32, 2, -28 },
  { 8863, 24, 28, 32, 4, -28 },
  { 8947, 21, 49, 32, 6, -38 },
  { 9076, 4, 49, 32, 14, -38 },
  { 9101, 22, 49, 32, 4, -38 },
  { 9236, 26, 7, 32, 3, -21 },
};

const GFXfont LiberationMono_Regular53pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular53pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular53pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _LIBERATIONMONO_REGULAR53PT7B_H_
