#ifndef _LIBERATIONMONO_REGULAR43PT7B_H_
#define _LIBERATIONMONO_REGULAR43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x3B, 0xC0, 0xE7, 0x03, 0x9C, 0x0E,
  0x70, 0x38, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x0C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x60, 0x18, 0x00, 0xC0,
  0x30, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x0E, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xC0,
  0x06, 0x01, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x1C, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x1C,
  0x07, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xC6, 0x3E, 0x1E, 0x0C, 0x3E, 0x3C, 0x18,
  0x3C, 0x70, 0x30, 0x38, 0xE0, 0x60, 0x01, 0xE0, 0xC0, 0x03, 0xE1, 0x80,
  0x03, 0xF3, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x37, 0xF0, 0x00, 0x61, 0xF0, 0x00, 0xC1, 0xE0, 0x01, 0x81, 0xE0,
  0x03, 0x03, 0xC0, 0x06, 0x03, 0x98, 0x0C, 0x0F, 0x70, 0x18, 0x1E, 0xF0,
  0x30, 0x3D, 0xF0, 0x60, 0xF1, 0xF8, 0xC7, 0xE1, 0xFF, 0xFF, 0x81, 0xFF,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0x80, 0x07, 0x0F, 0xF0, 0x03, 0x87, 0x0E, 0x01, 0xE3, 0xC3,
  0xC0, 0x70, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x03,
  0x81, 0xC3, 0x80, 0xE0, 0x71, 0xC0, 0x38, 0x1C, 0x70, 0x07, 0x0E, 0x38,
  0x01, 0xC3, 0x9C, 0x00, 0x3F, 0xCF, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x01,
  0xC7, 0xE0, 0x00, 0xE7, 0xFC, 0x00, 0x39, 0xC7, 0x80, 0x1C, 0xE0, 0xE0,
  0x0E, 0x38, 0x1C, 0x03, 0x8E, 0x07, 0x01, 0xC3, 0x81, 0xC0, 0xE0, 0xE0,
  0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x0F, 0x0E, 0x03, 0x83, 0x87, 0x00,
  0x71, 0xE1, 0xC0, 0x0F, 0xF0, 0xE0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x01, 0xC0, 0x0F,
  0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x07,
  0x0F, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x30, 0x1F,
  0xC0, 0x38, 0x3D, 0xE0, 0x38, 0x78, 0xF0, 0x38, 0x70, 0x70, 0x78, 0xF0,
  0x78, 0x70, 0xF0, 0x3C, 0x70, 0xE0, 0x1E, 0xF0, 0xE0, 0x0F, 0xE0, 0xF0,
  0x0F, 0xE0, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x1F, 0xF9, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFC, 0x7F, 0x07, 0xF0, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xE0, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1E, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x41,
  0x86, 0x79, 0x9E, 0xFF, 0xFE, 0x1F, 0xF8, 0x03, 0xC0, 0x07, 0xE0, 0x0E,
  0xE0, 0x0E, 0x70, 0x1C, 0x38, 0x3C, 0x3C, 0x08, 0x10, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1E, 0x07,
  0x83, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xE0, 0x7C, 0x7C, 0x03, 0xC7, 0x80, 0x1E, 0x70, 0x01, 0xEF,
  0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0x0F,
  0xE1, 0xF0, 0xFE, 0x1F, 0x0F, 0xE1, 0xF0, 0xFE, 0x1F, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x3E, 0x0F, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0xFB, 0x80, 0x7F, 0x9C, 0x03, 0xF0, 0xE0, 0x1E, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xEF,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xF7, 0x80, 0x1E, 0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x3F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0x3C, 0x00, 0x38, 0xF0,
  0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x38, 0x3C, 0x01, 0xC0, 0xF0, 0x0F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x3C, 0x0E, 0x00, 0xF0, 0x78, 0x03,
  0xC1, 0xC0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x79, 0xFC, 0x07, 0x7F,
  0xF0, 0x7F, 0xFF, 0xC7, 0xE0, 0x7C, 0x78, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xEF, 0x80, 0x3E, 0x7E, 0x0F, 0xC3, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x81, 0xF0, 0x7C, 0x3E, 0x03, 0xE3, 0xC0, 0x1E, 0x78, 0x01, 0xC7, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0xFC, 0x0F, 0x3F, 0xF0, 0xF7,
  0xFF, 0xCF, 0xF0, 0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F,
  0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x1F, 0x07, 0xC0, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xE0, 0x7C, 0x78, 0x03, 0xE7, 0x80,
  0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1E, 0x70, 0x01, 0xE7, 0x80, 0x1E, 0x78,
  0x03, 0xC3, 0xE0, 0x7C, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x83,
  0xE0, 0x7C, 0x78, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xF7, 0x80, 0x1E, 0x7E, 0x07,
  0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xE0, 0xF8, 0x7C, 0x03, 0xC7, 0x80, 0x3E, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x3F, 0x3E, 0x0F, 0xF3, 0xFF, 0xEF,
  0x1F, 0xFC, 0xF0, 0x3F, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE7, 0x00, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x78, 0x3E, 0x0F, 0x83, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x7C, 0x1F, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7E, 0x07, 0xC7, 0xC0, 0x1F, 0x3C, 0x00,
  0x7B, 0xE0, 0x01, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0x78, 0x0E,
  0x00, 0x38, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x38,
  0x3C, 0x7E, 0x30, 0x7F, 0x66, 0x70, 0xE3, 0x67, 0x71, 0xC1, 0xE7, 0x61,
  0x81, 0xE7, 0xE3, 0x81, 0xE7, 0xE3, 0x81, 0xC7, 0xE7, 0x01, 0xC7, 0xE7,
  0x01, 0xC7, 0xE7, 0x01, 0xC7, 0xE7, 0x01, 0xC7, 0xE7, 0x01, 0x87, 0xE7,
  0x03, 0x87, 0xE7, 0x03, 0x86, 0xE7, 0x03, 0x86, 0xE7, 0x03, 0x8E, 0xE7,
  0x07, 0x8E, 0xE7, 0x0D, 0x8C, 0x63, 0x9D, 0x9C, 0x63, 0xF9, 0xF8, 0x70,
  0xF0, 0xF0, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x10, 0x0E, 0x00, 0x78, 0x07, 0x81, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x3C,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1C,
  0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0x1C, 0x00,
  0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xE0, 0x0F, 0xCF, 0x00, 0x3E, 0x78, 0x00,
  0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C,
  0x00, 0xF1, 0xE0, 0x1F, 0x8F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xFF,
  0x1E, 0x00, 0x7C, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1E,
  0xF0, 0x03, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x3E, 0x00,
  0xF0, 0xF0, 0x01, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x08, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x0C, 0x7C, 0x00, 0x3C, 0xF0, 0x01, 0xE3,
  0xE0, 0x07, 0x87, 0x80, 0x3C, 0x1F, 0x83, 0xF0, 0x3F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xE0, 0x3F, 0x0F, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0x9E, 0x00,
  0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1F, 0x78,
  0x00, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0xF8, 0xF0, 0x1F, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F,
  0x07, 0xC3, 0xE0, 0x1F, 0x1E, 0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x00, 0x0C,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x7B,
  0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0xC0, 0x07, 0x9E, 0x00,
  0x3C, 0xF8, 0x01, 0xE3, 0xC0, 0x0F, 0x1F, 0x81, 0xF8, 0x7F, 0xFF, 0x80,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7B, 0xC0, 0x3C, 0xF0, 0x1E, 0x7C, 0x3E, 0x1F, 0xFF, 0x07, 0xFF,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0xF9, 0xE0, 0x03, 0xE3, 0xC0, 0x0F, 0x87,
  0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78,
  0x1E, 0x00, 0xF0, 0x7C, 0x01, 0xE1, 0xF0, 0x03, 0xC7, 0xC0, 0x07, 0x8F,
  0x00, 0x0F, 0x3E, 0x00, 0x1E, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7C,
  0x00, 0xFC, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xF1, 0xE0, 0x01, 0xF3, 0xC0, 0x01, 0xF7, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFE, 0xE0, 0x77, 0xEE, 0x07, 0x7E, 0xF0, 0xF7, 0xE7,
  0x0E, 0x7E, 0x70, 0xE7, 0xE7, 0x9E, 0x7E, 0x39, 0xC7, 0xE3, 0x9C, 0x7E,
  0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF0, 0x7E, 0x0F, 0x07,
  0xE0, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x01, 0xFD, 0xC0, 0x3F, 0xBC, 0x07, 0xF7, 0x80, 0xFE, 0x78,
  0x1F, 0xCF, 0x03, 0xF8, 0xE0, 0x7F, 0x1E, 0x0F, 0xE1, 0xC1, 0xFC, 0x3C,
  0x3F, 0x83, 0x87, 0xF0, 0x78, 0xFE, 0x07, 0x1F, 0xC0, 0xF3, 0xF8, 0x0E,
  0x7F, 0x01, 0xEF, 0xE0, 0x1D, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC1, 0xF8, 0x3E, 0x01, 0xF0, 0xF0, 0x03,
  0xC7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xE0, 0x01, 0xEF,
  0x80, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xEF, 0x80, 0x07,
  0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x80, 0x78, 0x1F, 0x07, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xE0, 0x0F, 0xCF,
  0x00, 0x1F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1E, 0x78,
  0x03, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xC1, 0xF8, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x9E, 0x00,
  0x1E, 0x78, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0x79, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x80, 0x78, 0x1F, 0x07, 0xE0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x3C, 0x01, 0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xCF, 0x00,
  0x0F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F,
  0x3C, 0x00, 0x7C, 0xF0, 0x07, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF8,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0x01,
  0xFE, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x3C, 0x00,
  0xF1, 0xE0, 0x03, 0xE7, 0x80, 0x07, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x07, 0x9F, 0x00, 0x3E, 0x7E, 0x03, 0xF0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x7E, 0x07, 0xC3,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80,
  0x78, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x0E, 0x07, 0x81, 0xC3, 0x81,
  0xE0, 0xF0, 0xE0, 0xF8, 0x3C, 0x3C, 0x3F, 0x0F, 0x0F, 0x0F, 0xC3, 0xC3,
  0xC3, 0xF0, 0xF0, 0xF1, 0xCE, 0x38, 0x1C, 0x73, 0x8E, 0x07, 0x1C, 0xE3,
  0x81, 0xCE, 0x39, 0xE0, 0x73, 0x87, 0x78, 0x1E, 0xE1, 0xDE, 0x07, 0xB8,
  0x77, 0x00, 0xFC, 0x1D, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0,
  0x0F, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xE7, 0x80,
  0x01, 0xE7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xE7, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x81, 0xE0,
  0x0F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x7C,
  0x7C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x1E, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xE0,
  0x03, 0xC3, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3B, 0x80,
  0x03, 0x9C, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x0F,
  0x00, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x3C, 0x03, 0x83, 0x80,
  0x3C, 0x38, 0x01, 0xC7, 0x00, 0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0E, 0xE0,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1E, 0x07,
  0x80, 0xE0, 0x38, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFC,
  0x1F, 0x07, 0x80, 0x7C, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xE0,
  0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0xC7,
  0x80, 0x3E, 0x3C, 0x03, 0xF1, 0xF0, 0x77, 0xC7, 0xFF, 0x9F, 0x9F, 0xF8,
  0xFC, 0x7F, 0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0xFC, 0x1E, 0x7F, 0xE3, 0xDF, 0xFE, 0x7F, 0x07, 0xCF, 0xC0, 0x7D, 0xF0,
  0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x1F, 0x7F, 0x07, 0xCF, 0xFF,
  0xF1, 0xEF, 0xFC, 0x38, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0xF7, 0x80, 0x1E, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0xFF, 0x80, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x07,
  0xE1, 0xE3, 0xFF, 0x3C, 0xFF, 0xF7, 0x9F, 0x07, 0xF7, 0x80, 0x7E, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x1F, 0xBF, 0x07, 0xF3, 0xFF,
  0xDE, 0x3F, 0xF3, 0xC1, 0xF8, 0x78, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x0C, 0x7C, 0x01, 0xE3, 0xF0, 0x7E, 0x1F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE1,
  0xE3, 0xFF, 0x3C, 0xFF, 0xF7, 0x9F, 0x07, 0xF7, 0xC0, 0x7E, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x1F, 0xBF, 0x07, 0xF3, 0xFF, 0xDE,
  0x3F, 0xF3, 0xC1, 0xF8, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xE0, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0,
  0x1F, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0xFC, 0x3C, 0xFF,
  0xCF, 0x7F, 0xFB, 0xF8, 0x3E, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0xC0, 0x7C,
  0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x07, 0xDE, 0x01, 0xF3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x03,
  0xC1, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x1E, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xDE, 0x01, 0xF3, 0xE0, 0x3C, 0x3C,
  0x07, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0xC3, 0xC0, 0x78, 0x78, 0x07,
  0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0xBC, 0x00, 0xF0, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE3, 0xC1, 0xE3, 0x9F, 0x9F, 0xCE, 0xFF, 0x7F, 0xBB, 0x3F,
  0x1E, 0xF8, 0x7C, 0x3B, 0xC1, 0xE0, 0xEF, 0x07, 0x83, 0xFC, 0x1E, 0x0F,
  0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0,
  0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78,
  0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F,
  0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xC0, 0xE0, 0xFC, 0x38, 0xFF, 0xCE, 0x7F,
  0xFB, 0xB8, 0x3E, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0x80,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x03, 0xC3, 0xE0, 0x7C,
  0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xE1, 0xFC, 0x1E, 0x7F,
  0xE3, 0xDF, 0xFE, 0x7F, 0x07, 0xCF, 0xC0, 0x7D, 0xF0, 0x07, 0xBC, 0x00,
  0xF7, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03,
  0xDF, 0x00, 0x7B, 0xF0, 0x1F, 0x7F, 0x07, 0xCF, 0x7F, 0xF9, 0xE7, 0xFC,
  0x3C, 0x7F, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xF1, 0xE3, 0xFF, 0x3C, 0xFF, 0xF7, 0x9F, 0x07, 0xF7, 0x80, 0x7E,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x1F, 0xBF, 0x07, 0xF3,
  0xFF, 0xDE, 0x3F, 0xF3, 0xC1, 0xF8, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0xF0, 0x7F, 0xF8, 0x7F, 0xDC, 0x7F, 0xEE, 0x78,
  0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0x03, 0xE3, 0x80, 0x1C, 0xF0, 0x03, 0xDE, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xEE, 0x00, 0x1D,
  0xE0, 0x07, 0xBE, 0x01, 0xE3, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x43, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0xE0, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFD, 0xF0, 0x7F, 0x7F,
  0xFB, 0xCF, 0xFC, 0xF0, 0xFC, 0x1C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC3, 0xC0, 0x0F, 0x07,
  0x80, 0x1E, 0x0F, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x1E,
  0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xDE, 0x00, 0x03, 0xBC,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x38, 0xE0, 0x78, 0x1C, 0x70,
  0x7C, 0x1E, 0x38, 0x3F, 0x0F, 0x1E, 0x1F, 0x87, 0x8F, 0x1D, 0xC3, 0xC7,
  0x8E, 0x71, 0xC1, 0xC7, 0x38, 0xE0, 0xE3, 0x1C, 0xF0, 0x73, 0x86, 0x78,
  0x39, 0xC3, 0xBC, 0x1E, 0xE1, 0xDE, 0x0F, 0xE0, 0xEE, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xE0, 0x78, 0x00, 0x79, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x07, 0x80, 0x78,
  0x0F, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0x78, 0x70, 0x00, 0xF3, 0xC0, 0x01,
  0xDE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x87, 0x80,
  0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xF1, 0xE0,
  0x03, 0xEF, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80,
  0x1E, 0x07, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x1E, 0x07,
  0x80, 0x3C, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x78, 0x00, 0x70, 0xE0,
  0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xCE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x7F, 0xE0, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x0F, 0xC0,
  0x1F, 0xC0, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x07,
  0xE0,
};

const GFXglyph LiberationMono_Regular43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 4, 28, 26, 11, -28 },
  { 15, 14, 13, 26, 6, -31 },
  { 38, 23, 28, 26, 1, -28 },
  { 119, 23, 34, 26, 1, -31 },
  { 217, 26, 28, 26, 0, -28 },
  { 308, 24, 28, 26, 1, -28 },
  { 392, 4, 13, 26, 11, -31 },
  { 399, 12, 40, 26, 7, -31 },
  { 459, 12, 40, 26, 7, -31 },
  { 519, 16, 15, 26, 5, -31 },
  { 549, 21, 21, 26, 2, -25 },
  { 605, 10, 14, 26, 5, -6 },
  { 623, 12, 3, 26, 7, -13 },
  { 628, 5, 6, 26, 10, -6 },
  { 632, 21, 31, 26, 2, -31 },
  { 714, 20, 28, 26, 3, -28 },
  { 784, 21, 28, 26, 3, -28 },
  { 858, 20, 28, 26, 3, -28 },
  { 928, 20, 28, 26, 3, -28 },
  { 998, 22, 28, 26, 2, -28 },
  { 1075, 20, 28, 26, 3, -28 },
  { 1145, 20, 28, 26, 3, -28 },
  { 1215, 19, 28, 26, 3, -28 },
  { 1282, 20, 28, 26, 3, -28 },
  { 1352, 20, 28, 26, 3, -28 },
  { 1422, 5, 23, 26, 10, -23 },
  { 1437, 10, 31, 26, 7, -23 },
  { 1476, 21, 22, 26, 2, -25 },
  { 1534, 21, 14, 26, 2, -21 },
  { 1571, 21, 22, 26, 2, -25 },
  { 1629, 21, 28, 26, 2, -28 },
  { 1703, 24, 37, 26, 1, -31 },
  { 1814, 26, 28, 26, 0, -28 },
  { 1905, 21, 28, 26, 3, -28 },
  { 1979, 22, 28, 26, 2, -28 },
  { 2056, 21, 28, 26, 3, -28 },
  { 2130, 21, 28, 26, 3, -28 },
  { 2204, 19, 28, 26, 4, -28 },
  { 2271, 21, 28, 26, 2, -28 },
  { 2345, 19, 28, 26, 3, -28 },
  { 2412, 18, 28, 26, 4, -28 },
  { 2475, 17, 28, 26, 4, -28 },
  { 2535, 23, 28, 26, 3, -28 },
  { 2616, 18, 28, 26, 5, -28 },
  { 2679, 20, 28, 26, 3, -28 },
  { 2749, 19, 28, 26, 3, -28 },
  { 2816, 22, 28, 26, 2, -28 },
  { 2893, 21, 28, 26, 3, -28 },
  { 2967, 22, 36, 26, 2, -28 },
  { 3066, 22, 28, 26, 3, -28 },
  { 3143, 22, 28, 26, 2, -28 },
  { 3220, 22, 28, 26, 2, -28 },
  { 3297, 20, 28, 26, 3, -28 },
  { 3367, 26, 28, 26, 0, -28 },
  { 3458, 26, 28, 26, 0, -28 },
  { 3549, 24, 28, 26, 1, -28 },
  { 3633, 24, 28, 26, 1, -28 },
  { 3717, 22, 28, 26, 2, -28 },
  { 3794, 11, 40, 26, 9, -31 },
  { 3849, 21, 31, 26, 2, -31 },
  { 3931, 11, 40, 26, 6, -31 },
  { 3986, 20, 19, 26, 3, -28 },
  { 4034, 26, 2, 26, 0, 3 },
  { 4041, 9, 5, 26, 8, -30 },
  { 4047, 21, 23, 26, 3, -23 },
  { 4108, 19, 31, 26, 4, -31 },
  { 4182, 20, 23, 26, 3, -23 },
  { 4240, 19, 31, 26, 3, -31 },
  { 4314, 20, 23, 26, 3, -23 },
  { 4372, 20, 31, 26, 3, -31 },
  { 4450, 19, 32, 26, 3, -23 },
  { 4526, 18, 31, 26, 4, -31 },
  { 4596, 21, 31, 26, 3, -31 },
  { 4678, 16, 40, 26, 2, -31 },
  { 4758, 19, 31, 26, 5, -31 },
  { 4832, 20, 31, 26, 3, -31 },
  { 4910, 22, 23, 26, 2, -23 },
  { 4974, 18, 23, 26, 4, -23 },
  { 5026, 20, 23, 26, 3, -23 },
  { 5084, 19, 32, 26, 4, -23 },
  { 5160, 19, 32, 26, 3, -23 },
  { 5236, 17, 23, 26, 5, -23 },
  { 5285, 19, 23, 26, 3, -23 },
  { 5340, 17, 29, 26, 4, -29 },
  { 5402, 18, 23, 26, 4, -23 },
  { 5454, 23, 23, 26, 1, -23 },
  { 5521, 25, 23, 26, 0, -23 },
  { 5593, 22, 23, 26, 2, -23 },
  { 5657, 23, 32, 26, 1, -23 },
  { 5749, 19, 23, 26, 3, -23 },
  { 5804, 17, 40, 26, 5, -31 },
  { 5889, 4, 40, 26, 11, -31 },
  { 5909, 18, 40, 26, 3, -31 },
  { 5999, 22, 5, 26, 2, -17 },
};

const GFXfont LiberationMono_Regular43pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular43pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular43pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _LIBERATIONMONO_REGULAR43PT7B_H_
