#ifndef _LIBERATIONMONO_REGULAR25PT7B_H_
#define _LIBERATIONMONO_REGULAR25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x69, 0x20, 0x3F, 0xE3, 0xF1, 0xD8, 0xCC, 0x66,
  0x33, 0x19, 0x8C, 0xC6, 0x0C, 0x30, 0x61, 0x02, 0x08, 0x10, 0x40, 0x86,
  0x7F, 0xFC, 0x61, 0x02, 0x08, 0x10, 0xC0, 0x86, 0x3F, 0xFE, 0x41, 0x02,
  0x08, 0x10, 0xC1, 0x86, 0x0C, 0x20, 0x02, 0x00, 0x10, 0x07, 0xF0, 0xFF,
  0xE7, 0x27, 0x31, 0x1D, 0x88, 0x0E, 0x40, 0x3F, 0x80, 0x7F, 0x00, 0xBC,
  0x04, 0x70, 0x21, 0x81, 0x0F, 0x08, 0x7C, 0x47, 0x7F, 0xF0, 0xFE, 0x00,
  0x80, 0x04, 0x00, 0x7C, 0x0C, 0x88, 0x33, 0x18, 0x46, 0x31, 0x8C, 0x66,
  0x18, 0xD8, 0x11, 0x20, 0x3E, 0xC0, 0x03, 0x7C, 0x04, 0x88, 0x1B, 0x18,
  0x66, 0x31, 0x8C, 0x62, 0x18, 0xCC, 0x11, 0x30, 0x3E, 0x0F, 0x80, 0xFE,
  0x0E, 0x30, 0x61, 0x83, 0x0C, 0x09, 0xC0, 0x78, 0x07, 0x86, 0x6C, 0x36,
  0x31, 0xB1, 0xD9, 0x87, 0xCC, 0x1C, 0x70, 0xF1, 0xFF, 0xE7, 0xC7, 0xFF,
  0xFF, 0xD2, 0x0C, 0x38, 0x61, 0x83, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x06,
  0x0C, 0x1C, 0x38, 0x30, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x83, 0x00, 0xE0,
  0xE0, 0xC0, 0xC1, 0x83, 0x83, 0x06, 0x0E, 0x1C, 0x18, 0x30, 0xE1, 0xC3,
  0x86, 0x0C, 0x38, 0x60, 0xC3, 0x0E, 0x38, 0x00, 0x08, 0x04, 0x32, 0x7D,
  0x73, 0xE0, 0xE0, 0xD8, 0x6C, 0x22, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x7F, 0xFF, 0xFF, 0xE0, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x39, 0xCC, 0xE6, 0x31, 0x18, 0xFF, 0xFC, 0xFF, 0xF0,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x00, 0x1F, 0x0F, 0xF9, 0xC7, 0x70, 0x7C,
  0x07, 0x80, 0xF3, 0x9E, 0x73, 0xCE, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x0E,
  0xE3, 0x9F, 0xE0, 0xF8, 0x06, 0x00, 0xE0, 0x3E, 0x0F, 0x60, 0xC6, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0x1F, 0x0F, 0xF9, 0xC3, 0xF0, 0x7C, 0x06, 0x00,
  0xC0, 0x30, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x3F,
  0xFF, 0xFF, 0x1F, 0x0F, 0xF9, 0xC3, 0xF0, 0x3C, 0x06, 0x01, 0xC0, 0x70,
  0x7C, 0x0F, 0x80, 0x1C, 0x01, 0xE0, 0x3C, 0x07, 0xC1, 0xDF, 0xF0, 0xFC,
  0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x05, 0x80, 0x6C, 0x06, 0x60, 0x63, 0x03,
  0x18, 0x30, 0xC3, 0x06, 0x18, 0x31, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x03,
  0x00, 0x18, 0x7F, 0xCF, 0xFB, 0x80, 0x70, 0x0C, 0x01, 0xBE, 0x3F, 0xF7,
  0x0F, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3C, 0x07, 0xC3, 0xDF, 0xF1, 0xF8,
  0x0F, 0x87, 0xF9, 0xC3, 0x30, 0x3C, 0x01, 0x9F, 0x37, 0xF7, 0x87, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x36, 0x06, 0xE1, 0xCF, 0xF0, 0xF8, 0xFF, 0xFF,
  0xFC, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0x0F, 0xFB, 0x83,
  0xE0, 0x7C, 0x07, 0x81, 0xD8, 0x31, 0xFC, 0x3F, 0x9C, 0x1F, 0x01, 0xE0,
  0x3C, 0x07, 0xC1, 0xDF, 0xF1, 0xFC, 0x1F, 0x0F, 0xF3, 0x87, 0x60, 0x7C,
  0x07, 0x80, 0xF0, 0x1F, 0x0F, 0x7F, 0x67, 0xCC, 0x01, 0x80, 0x7C, 0x0D,
  0xC3, 0x9F, 0xE1, 0xF8, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x38, 0xE3,
  0x8E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x31, 0xC6, 0x18, 0x63, 0x00,
  0x00, 0x18, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x03, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x60, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x1F, 0x83, 0xFE,
  0x70, 0x7E, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0xC0, 0x61,
  0x83, 0x03, 0x18, 0x04, 0x40, 0x1B, 0x1D, 0xAC, 0xCE, 0xA6, 0x3A, 0x98,
  0xCA, 0x43, 0x39, 0x0C, 0xAC, 0x32, 0xB0, 0xCA, 0xC2, 0x29, 0x19, 0xB6,
  0xE4, 0xCE, 0xE1, 0x00, 0x06, 0x02, 0x0C, 0x18, 0x0F, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x1B, 0x00, 0x36, 0x00, 0xEE, 0x01, 0x8C, 0x03, 0x18, 0x0E,
  0x38, 0x18, 0x30, 0x30, 0x60, 0xFF, 0xE1, 0xFF, 0xC7, 0x01, 0xCC, 0x01,
  0x98, 0x03, 0x70, 0x07, 0xFF, 0x0F, 0xFC, 0xC0, 0xEC, 0x06, 0xC0, 0x6C,
  0x0E, 0xC1, 0xCF, 0xF8, 0xFF, 0xCC, 0x0E, 0xC0, 0x7C, 0x03, 0xC0, 0x7C,
  0x0F, 0xFF, 0xEF, 0xF8, 0x0F, 0x81, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x27,
  0x03, 0x9C, 0x38, 0x7F, 0x81, 0xF8, 0xFE, 0x0F, 0xF8, 0xC1, 0xCC, 0x0E,
  0xC0, 0x6C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x6C, 0x06,
  0xC0, 0xEC, 0x1C, 0xFF, 0x8F, 0xE0, 0xFF, 0xEF, 0xFE, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFC, 0xFF, 0xCC, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x0F, 0x83, 0xFE, 0x38, 0x77, 0x03, 0x60, 0x36,
  0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xFE, 0x1F, 0x60, 0x36, 0x03, 0x70, 0x33,
  0x83, 0x1F, 0xF0, 0xFC, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F, 0xFF, 0xFF,
  0x0F, 0xC3, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0F, 0x83, 0xE1, 0xDC, 0x77, 0xF8, 0x7C, 0xC0, 0x76, 0x07, 0x30,
  0x71, 0x87, 0x0C, 0x70, 0x67, 0x03, 0x30, 0x1B, 0x80, 0xFE, 0x07, 0x38,
  0x30, 0xE1, 0x83, 0x8C, 0x1C, 0x60, 0x73, 0x01, 0xD8, 0x07, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xE0, 0xFC, 0x1E, 0x83, 0xF8, 0xFF,
  0x1F, 0xB2, 0xF6, 0xDE, 0xDB, 0xCE, 0x79, 0xCF, 0x39, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3D, 0x87, 0xB0,
  0xF3, 0x1E, 0x63, 0xC6, 0x78, 0xCF, 0x0D, 0xE1, 0xBC, 0x1F, 0x83, 0xF0,
  0x7E, 0x07, 0x0F, 0x81, 0xFF, 0x1E, 0x38, 0xE0, 0xE6, 0x03, 0x70, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x67, 0x07, 0x1C,
  0x70, 0xFF, 0x81, 0xF0, 0xFF, 0x8F, 0xFC, 0xC0, 0xEC, 0x06, 0xC0, 0x7C,
  0x07, 0xC0, 0x6C, 0x0E, 0xFF, 0xCF, 0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x0F, 0x81, 0xFF, 0x1E, 0x38, 0xE0, 0xE6, 0x03,
  0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x67,
  0x07, 0x1C, 0x70, 0xFF, 0x81, 0xF0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0xF0, 0x07, 0x80, 0xFF, 0x8F, 0xFE, 0xC0, 0xEC, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xEF, 0xFC, 0xFF, 0x8C, 0x30, 0xC3, 0x8C, 0x18, 0xC1, 0xCC, 0x0E,
  0xC0, 0x6C, 0x07, 0x1F, 0xC1, 0xFF, 0x1C, 0x1C, 0xC0, 0x66, 0x00, 0x38,
  0x00, 0xF0, 0x03, 0xF8, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x7E, 0x03,
  0xB8, 0x38, 0xFF, 0xC3, 0xF8, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0xC1, 0xDF, 0xF1, 0xFC, 0xE0, 0x0E, 0xC0, 0x19, 0x80, 0x73, 0x80,
  0xE3, 0x01, 0x87, 0x07, 0x06, 0x0C, 0x0C, 0x18, 0x1C, 0x70, 0x18, 0xC0,
  0x31, 0x80, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xE0, 0x01, 0xC0, 0xC0,
  0x07, 0xC0, 0x1F, 0x80, 0x3B, 0x00, 0x66, 0x00, 0xCC, 0x71, 0x98, 0xE3,
  0x31, 0x46, 0x66, 0xCC, 0x6D, 0xB0, 0xDB, 0x61, 0xA2, 0xC3, 0xC7, 0x87,
  0x8F, 0x0F, 0x1E, 0x1C, 0x1C, 0x70, 0x1C, 0x60, 0x30, 0x60, 0xC0, 0xE3,
  0x80, 0xC6, 0x00, 0xD8, 0x01, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0D, 0x80,
  0x3B, 0x80, 0x63, 0x01, 0x83, 0x07, 0x07, 0x1C, 0x07, 0x30, 0x06, 0x60,
  0x0C, 0xE0, 0x38, 0xE0, 0xE0, 0xC1, 0x81, 0xC7, 0x01, 0x8C, 0x01, 0xB0,
  0x03, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x7F, 0xFB, 0xFF, 0xC0, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x1F, 0xFF, 0x80, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0xFF, 0xFC,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x80, 0x0E, 0x01, 0x40, 0x6C, 0x0D,
  0x83, 0x18, 0x63, 0x18, 0x23, 0x06, 0x60, 0xD8, 0x0F, 0x01, 0x80, 0xFF,
  0xFE, 0xE3, 0x86, 0x3F, 0x07, 0xF8, 0xE1, 0xC0, 0x0C, 0x00, 0xC3, 0xFC,
  0x7F, 0xCE, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0xCE, 0x3C, 0xFE, 0xF7, 0xC7,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0xF9, 0xBF, 0xBC, 0x3F, 0x07, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x86, 0xDF, 0xD9,
  0xF0, 0x1F, 0x0F, 0xF9, 0xC3, 0xF0, 0x3C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x81, 0xB8, 0x77, 0xFC, 0x3E, 0x00, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x33, 0xE6, 0xFE, 0xF8, 0x7F, 0x07, 0xC0, 0xF8, 0x1F, 0x01,
  0xE0, 0x3C, 0x0F, 0x81, 0xF8, 0x3F, 0x0F, 0x7F, 0x67, 0xCC, 0x1F, 0x0F,
  0xF9, 0xC7, 0x70, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x03,
  0x81, 0xB8, 0x77, 0xFC, 0x3E, 0x00, 0x07, 0xE3, 0xFC, 0x70, 0x0C, 0x0F,
  0xFF, 0xFF, 0xC6, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x3E, 0x6F, 0xEF, 0x87, 0xF0,
  0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0xF7,
  0xF6, 0x7C, 0xC0, 0x1B, 0x07, 0x71, 0xC7, 0xF8, 0x7C, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0xF9, 0xBF, 0xBC, 0x37, 0x07, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0C, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF,
  0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x3F, 0xF9, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x1D, 0x83,
  0x30, 0xC6, 0x30, 0xCE, 0x1B, 0x83, 0xE0, 0x7E, 0x0C, 0xE1, 0x8E, 0x30,
  0xC6, 0x1C, 0xC1, 0xD8, 0x18, 0x7E, 0x07, 0xE0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xDC, 0xF7, 0xF7, 0xB9,
  0xCF, 0xCE, 0x3E, 0x71, 0xE3, 0x8F, 0x1C, 0x78, 0xE3, 0xC7, 0x1E, 0x38,
  0xF1, 0xC7, 0x8E, 0x3C, 0x71, 0xE3, 0x8C, 0xCF, 0x9B, 0xFB, 0xC3, 0x70,
  0x7E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xC0, 0x1F, 0x0F, 0xF9, 0xC7, 0x70, 0x7C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0xB8, 0xE7, 0xFC, 0x3E, 0x00, 0xCF,
  0x9B, 0xFB, 0xC3, 0xF0, 0x7E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xE0, 0x7C,
  0x0F, 0x83, 0xF8, 0x7D, 0xFD, 0x9F, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x00, 0x3E, 0x6F, 0xEF, 0x87, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E,
  0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0xF7, 0xF6, 0x7C, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0xC7, 0xF3, 0xFF, 0x81, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x00, 0x1F,
  0x8F, 0xF9, 0x83, 0xB0, 0x06, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xE0,
  0x0F, 0x01, 0xF0, 0x77, 0xFC, 0x7E, 0x00, 0x18, 0x06, 0x01, 0x83, 0xFF,
  0xFF, 0xCE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x7F, 0x0F, 0xC0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x83, 0xB0, 0xF7, 0xF6, 0x7C,
  0xC0, 0xC0, 0x3F, 0x01, 0xD8, 0x0C, 0xE0, 0xE3, 0x06, 0x18, 0x30, 0xE3,
  0x83, 0x18, 0x18, 0xC0, 0xEC, 0x03, 0x60, 0x1B, 0x00, 0x70, 0x03, 0x80,
  0xE0, 0x0F, 0xC0, 0x1D, 0x80, 0x33, 0x00, 0x66, 0x38, 0xCC, 0x51, 0x98,
  0xA3, 0x3B, 0x6E, 0x36, 0xD8, 0x68, 0xB0, 0xF1, 0xE1, 0xE3, 0xC3, 0x83,
  0x87, 0x07, 0x00, 0x60, 0x33, 0x83, 0x0C, 0x38, 0x31, 0x80, 0xD8, 0x07,
  0xC0, 0x1C, 0x00, 0xE0, 0x0D, 0x80, 0xEE, 0x06, 0x30, 0x60, 0xC7, 0x07,
  0x70, 0x18, 0xC0, 0x1F, 0x01, 0xD8, 0x0C, 0xE0, 0xE3, 0x06, 0x18, 0x30,
  0x63, 0x83, 0x18, 0x0D, 0xC0, 0x6C, 0x03, 0x60, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0C, 0x03, 0xE0, 0x1C, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0,
  0x70, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xC3, 0xF1, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0E, 0x0F, 0x03, 0xC0, 0x38, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0xF0, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x3F, 0x00, 0xE0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x3C, 0x0F, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x3F, 0x0F, 0x80,
  0x7C, 0x0F, 0xF8, 0xF1, 0xFE, 0x03, 0xE0,
};

const GFXglyph LiberationMono_Regular25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 16, 15, 6, -16 },
  { 7, 9, 8, 15, 3, -18 },
  { 16, 13, 16, 15, 1, -16 },
  { 42, 13, 20, 15, 1, -18 },
  { 75, 15, 16, 15, 0, -16 },
  { 105, 13, 16, 15, 1, -16 },
  { 131, 3, 8, 15, 6, -18 },
  { 134, 7, 23, 15, 4, -18 },
  { 155, 7, 23, 15, 4, -18 },
  { 176, 9, 9, 15, 3, -18 },
  { 187, 13, 12, 15, 1, -14 },
  { 207, 5, 8, 15, 3, -4 },
  { 212, 7, 2, 15, 4, -8 },
  { 214, 3, 4, 15, 6, -4 },
  { 216, 13, 18, 15, 1, -18 },
  { 246, 11, 16, 15, 2, -16 },
  { 268, 12, 16, 15, 2, -16 },
  { 292, 11, 16, 15, 2, -16 },
  { 314, 11, 16, 15, 2, -16 },
  { 336, 13, 16, 15, 1, -16 },
  { 362, 11, 16, 15, 2, -16 },
  { 384, 11, 16, 15, 2, -16 },
  { 406, 11, 16, 15, 2, -16 },
  { 428, 11, 16, 15, 2, -16 },
  { 450, 11, 16, 15, 2, -16 },
  { 472, 3, 14, 15, 6, -14 },
  { 478, 6, 18, 15, 4, -14 },
  { 492, 13, 13, 15, 1, -15 },
  { 514, 13, 8, 15, 1, -12 },
  { 527, 13, 13, 15, 1, -15 },
  { 549, 12, 16, 15, 1, -16 },
  { 573, 14, 21, 15, 1, -18 },
  { 610, 15, 16, 15, 0, -16 },
  { 640, 12, 16, 15, 2, -16 },
  { 664, 13, 16, 15, 1, -16 },
  { 690, 12, 16, 15, 2, -16 },
  { 714, 12, 16, 15, 2, -16 },
  { 738, 11, 16, 15, 2, -16 },
  { 760, 12, 16, 15, 1, -16 },
  { 784, 11, 16, 15, 2, -16 },
  { 806, 11, 16, 15, 2, -16 },
  { 828, 10, 16, 15, 2, -16 },
  { 848, 13, 16, 15, 2, -16 },
  { 874, 10, 16, 15, 3, -16 },
  { 894, 11, 16, 15, 2, -16 },
  { 916, 11, 16, 15, 2, -16 },
  { 938, 13, 16, 15, 1, -16 },
  { 964, 12, 16, 15, 2, -16 },
  { 988, 13, 21, 15, 1, -16 },
  { 1023, 12, 16, 15, 2, -16 },
  { 1047, 13, 16, 15, 1, -16 },
  { 1073, 13, 16, 15, 1, -16 },
  { 1099, 11, 16, 15, 2, -16 },
  { 1121, 15, 16, 15, 0, -16 },
  { 1151, 15, 16, 15, 0, -16 },
  { 1181, 15, 16, 15, 0, -16 },
  { 1211, 15, 16, 15, 0, -16 },
  { 1241, 13, 16, 15, 1, -16 },
  { 1267, 7, 23, 15, 5, -18 },
  { 1288, 13, 18, 15, 1, -18 },
  { 1318, 7, 23, 15, 3, -18 },
  { 1339, 11, 11, 15, 2, -16 },
  { 1355, 15, 1, 15, 0, 2 },
  { 1357, 5, 3, 15, 5, -18 },
  { 1359, 12, 14, 15, 2, -14 },
  { 1380, 11, 18, 15, 2, -18 },
  { 1405, 11, 14, 15, 2, -14 },
  { 1425, 11, 18, 15, 2, -18 },
  { 1450, 11, 14, 15, 2, -14 },
  { 1470, 11, 18, 15, 2, -18 },
  { 1495, 11, 19, 15, 2, -14 },
  { 1522, 11, 18, 15, 2, -18 },
  { 1547, 12, 18, 15, 2, -18 },
  { 1574, 9, 23, 15, 1, -18 },
  { 1600, 11, 18, 15, 3, -18 },
  { 1625, 12, 18, 15, 2, -18 },
  { 1652, 13, 14, 15, 1, -14 },
  { 1675, 11, 14, 15, 2, -14 },
  { 1695, 11, 14, 15, 2, -14 },
  { 1715, 11, 19, 15, 2, -14 },
  { 1742, 11, 19, 15, 2, -14 },
  { 1769, 10, 14, 15, 3, -14 },
  { 1787, 11, 14, 15, 2, -14 },
  { 1807, 10, 17, 15, 2, -17 },
  { 1829, 11, 14, 15, 2, -14 },
  { 1849, 13, 14, 15, 1, -14 },
  { 1872, 15, 14, 15, 0, -14 },
  { 1899, 13, 14, 15, 1, -14 },
  { 1922, 13, 19, 15, 1, -14 },
  { 1953, 11, 14, 15, 2, -14 },
  { 1973, 10, 23, 15, 3, -18 },
  { 2002, 3, 23, 15, 6, -18 },
  { 2011, 10, 23, 15, 2, -18 },
  { 2040, 13, 4, 15, 1, -11 },
};

const GFXfont LiberationMono_Regular25pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular25pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular25pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _LIBERATIONMONO_REGULAR25PT7B_H_
