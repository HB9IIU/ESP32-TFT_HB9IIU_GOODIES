#ifndef _LIBERATIONMONO_REGULAR11PT7B_H_
#define _LIBERATIONMONO_REGULAR11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0x55, 0x50, 0x24, 0xA7, 0xD2, 0xFD, 0x25, 0x00, 0x11, 0xE5,
  0x54, 0x38, 0x5D, 0x5E, 0x10, 0xE5, 0x53, 0xA0, 0x82, 0xCA, 0x53, 0x00,
  0x39, 0x23, 0x19, 0x9A, 0x27, 0x40, 0xE0, 0x4A, 0x49, 0x24, 0x48, 0x89,
  0x12, 0x4A, 0x50, 0x2B, 0x66, 0x50, 0x21, 0x3E, 0x42, 0x00, 0x69, 0x40,
  0xE0, 0xC0, 0x08, 0x84, 0x42, 0x22, 0x10, 0x74, 0xE3, 0x58, 0xCD, 0xC0,
  0x27, 0x08, 0x42, 0x13, 0xE0, 0x74, 0x42, 0x26, 0x43, 0xE0, 0x74, 0x42,
  0xE0, 0xC7, 0xC0, 0x11, 0x95, 0x2F, 0x88, 0x40, 0xF4, 0x3C, 0x10, 0xC7,
  0xC0, 0x74, 0x61, 0xE8, 0xC5, 0xC0, 0xF8, 0x84, 0x42, 0x21, 0x00, 0x74,
  0x62, 0xE8, 0xC7, 0xC0, 0xF4, 0x63, 0xF0, 0xC9, 0xC0, 0xCC, 0x50, 0x7A,
  0x1F, 0x21, 0xC1, 0x80, 0xF8, 0x3E, 0x83, 0x82, 0xE8, 0x00, 0x79, 0x10,
  0x46, 0x10, 0x02, 0x00, 0x39, 0x14, 0x6F, 0xAF, 0x3B, 0xE0, 0x44, 0xE0,
  0x10, 0x50, 0xA2, 0x47, 0xC8, 0xA1, 0x00, 0xF4, 0x63, 0xE8, 0xC7, 0xC0,
  0x74, 0x61, 0x08, 0x45, 0xC0, 0xF4, 0xE3, 0x18, 0xCF, 0xC0, 0xFC, 0x21,
  0xE8, 0x43, 0xE0, 0xFC, 0x21, 0xF8, 0x42, 0x00, 0x74, 0x61, 0x78, 0xC5,
  0xC0, 0x8C, 0x63, 0xF8, 0xC6, 0x20, 0xF9, 0x08, 0x42, 0x13, 0xE0, 0x31,
  0x11, 0x19, 0x70, 0x8A, 0x4A, 0x38, 0x92, 0x48, 0x80, 0x84, 0x21, 0x08,
  0x43, 0xE0, 0x8E, 0xF7, 0xDA, 0xC6, 0x20, 0x8E, 0x73, 0x5A, 0xCE, 0x60,
  0x74, 0xE3, 0x18, 0xCD, 0xC0, 0xF4, 0x63, 0xE8, 0x42, 0x00, 0x74, 0xE3,
  0x18, 0xCD, 0xC4, 0x18, 0xF4, 0x63, 0xEB, 0x4A, 0x20, 0x79, 0x14, 0x0E,
  0x05, 0x17, 0x80, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x00, 0x8C, 0x63, 0x18,
  0xC7, 0xC0, 0x84, 0x89, 0x12, 0x42, 0x86, 0x04, 0x00, 0x83, 0x2A, 0x53,
  0xA6, 0xCD, 0x93, 0x00, 0x45, 0xA3, 0x04, 0x29, 0x24, 0x40, 0x45, 0x22,
  0x8C, 0x10, 0x41, 0x00, 0x7C, 0x21, 0x84, 0x21, 0x0F, 0xC0, 0xF2, 0x49,
  0x24, 0x9C, 0x84, 0x10, 0x42, 0x08, 0x41, 0xE4, 0x92, 0x49, 0x3C, 0x22,
  0x95, 0x28, 0x80, 0xFE, 0xD0, 0xF0, 0xBD, 0x29, 0x74, 0x84, 0x3D, 0x18,
  0xC6, 0x3E, 0x74, 0x61, 0x08, 0xB8, 0x08, 0x7B, 0x38, 0xC6, 0x7D, 0x74,
  0x7F, 0x08, 0xB8, 0x3A, 0x3E, 0x84, 0x21, 0x08, 0xEC, 0xE3, 0x19, 0xF4,
  0x7E, 0x84, 0x3D, 0x38, 0xC6, 0x31, 0x20, 0x38, 0x42, 0x10, 0x9F, 0x23,
  0x92, 0x49, 0x3C, 0x84, 0x25, 0x6A, 0x72, 0x51, 0xE1, 0x08, 0x42, 0x10,
  0x9F, 0xDD, 0x6B, 0x5A, 0xD4, 0xF4, 0xE3, 0x18, 0xC4, 0x74, 0x63, 0x19,
  0xB8, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0xEC, 0xE3, 0x19, 0xF4, 0x21, 0xBA,
  0x10, 0x84, 0x20, 0x74, 0x78, 0x28, 0xB8, 0x44, 0xF4, 0x44, 0x47, 0x8C,
  0x63, 0x19, 0xF4, 0x45, 0x14, 0x8A, 0x30, 0x40, 0x86, 0x19, 0x5D, 0x6D,
  0x30, 0x44, 0xA3, 0x0C, 0x29, 0x10, 0x45, 0x12, 0x8A, 0x10, 0x42, 0x18,
  0xF8, 0x88, 0x88, 0x7C, 0x39, 0x08, 0x4C, 0x30, 0x84, 0x21, 0xC0, 0xFF,
  0xC0, 0xE2, 0x22, 0x12, 0x22, 0x2C, 0xC1, 0xC0,
};

const GFXglyph LiberationMono_Regular11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 7, 7, 3, -7 },
  { 2, 4, 3, 7, 1, -8 },
  { 4, 6, 7, 7, 0, -7 },
  { 10, 6, 9, 7, 0, -8 },
  { 17, 7, 7, 7, 0, -7 },
  { 24, 6, 7, 7, 0, -7 },
  { 30, 1, 3, 7, 3, -8 },
  { 31, 3, 10, 7, 2, -8 },
  { 35, 3, 10, 7, 2, -8 },
  { 39, 4, 5, 7, 1, -8 },
  { 42, 5, 5, 7, 1, -6 },
  { 46, 3, 4, 7, 1, -2 },
  { 48, 3, 1, 7, 2, -4 },
  { 49, 1, 2, 7, 3, -2 },
  { 50, 5, 8, 7, 1, -8 },
  { 55, 5, 7, 7, 1, -7 },
  { 60, 5, 7, 7, 1, -7 },
  { 65, 5, 7, 7, 1, -7 },
  { 70, 5, 7, 7, 1, -7 },
  { 75, 5, 7, 7, 1, -7 },
  { 80, 5, 7, 7, 1, -7 },
  { 85, 5, 7, 7, 1, -7 },
  { 90, 5, 7, 7, 1, -7 },
  { 95, 5, 7, 7, 1, -7 },
  { 100, 5, 7, 7, 1, -7 },
  { 105, 1, 6, 7, 3, -6 },
  { 106, 2, 8, 7, 2, -6 },
  { 108, 5, 5, 7, 1, -6 },
  { 112, 5, 3, 7, 1, -5 },
  { 114, 5, 5, 7, 1, -6 },
  { 118, 6, 7, 7, 0, -7 },
  { 124, 6, 10, 7, 0, -8 },
  { 132, 7, 7, 7, 0, -7 },
  { 139, 5, 7, 7, 1, -7 },
  { 144, 5, 7, 7, 1, -7 },
  { 149, 5, 7, 7, 1, -7 },
  { 154, 5, 7, 7, 1, -7 },
  { 159, 5, 7, 7, 1, -7 },
  { 164, 5, 7, 7, 1, -7 },
  { 169, 5, 7, 7, 1, -7 },
  { 174, 5, 7, 7, 1, -7 },
  { 179, 4, 7, 7, 1, -7 },
  { 183, 6, 7, 7, 1, -7 },
  { 189, 5, 7, 7, 1, -7 },
  { 194, 5, 7, 7, 1, -7 },
  { 199, 5, 7, 7, 1, -7 },
  { 204, 5, 7, 7, 1, -7 },
  { 209, 5, 7, 7, 1, -7 },
  { 214, 5, 9, 7, 1, -7 },
  { 220, 5, 7, 7, 1, -7 },
  { 225, 6, 7, 7, 0, -7 },
  { 231, 6, 7, 7, 0, -7 },
  { 237, 5, 7, 7, 1, -7 },
  { 242, 7, 7, 7, 0, -7 },
  { 249, 7, 7, 7, 0, -7 },
  { 256, 6, 7, 7, 0, -7 },
  { 262, 6, 7, 7, 0, -7 },
  { 268, 6, 7, 7, 0, -7 },
  { 274, 3, 10, 7, 2, -8 },
  { 278, 5, 8, 7, 1, -8 },
  { 283, 3, 10, 7, 1, -8 },
  { 287, 5, 5, 7, 1, -7 },
  { 291, 7, 1, 7, 0, 1 },
  { 292, 2, 2, 7, 2, -9 },
  { 293, 5, 6, 7, 1, -6 },
  { 297, 5, 8, 7, 1, -8 },
  { 302, 5, 6, 7, 1, -6 },
  { 306, 5, 8, 7, 1, -8 },
  { 311, 5, 6, 7, 1, -6 },
  { 315, 5, 8, 7, 1, -8 },
  { 320, 5, 8, 7, 1, -6 },
  { 325, 5, 8, 7, 1, -8 },
  { 330, 5, 8, 7, 1, -8 },
  { 335, 3, 10, 7, 1, -8 },
  { 339, 5, 8, 7, 1, -8 },
  { 344, 5, 8, 7, 1, -8 },
  { 349, 5, 6, 7, 1, -6 },
  { 353, 5, 6, 7, 1, -6 },
  { 357, 5, 6, 7, 1, -6 },
  { 361, 5, 8, 7, 1, -6 },
  { 366, 5, 8, 7, 1, -6 },
  { 371, 5, 6, 7, 1, -6 },
  { 375, 5, 6, 7, 1, -6 },
  { 379, 4, 8, 7, 1, -8 },
  { 383, 5, 6, 7, 1, -6 },
  { 387, 6, 6, 7, 0, -6 },
  { 392, 6, 6, 7, 0, -6 },
  { 397, 6, 6, 7, 0, -6 },
  { 402, 6, 8, 7, 0, -6 },
  { 408, 5, 6, 7, 1, -6 },
  { 412, 5, 10, 7, 1, -8 },
  { 419, 1, 10, 7, 3, -8 },
  { 421, 4, 10, 7, 1, -8 },
  { 426, 5, 2, 7, 1, -5 },
};

const GFXfont LiberationMono_Regular11pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular11pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular11pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _LIBERATIONMONO_REGULAR11PT7B_H_
