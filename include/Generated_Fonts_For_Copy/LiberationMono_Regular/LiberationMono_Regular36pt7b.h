#ifndef _LIBERATIONMONO_REGULAR36PT7B_H_
#define _LIBERATIONMONO_REGULAR36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x00, 0xEE,
  0xEE, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0xF0, 0xEE, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE0, 0xEE, 0x0E, 0x60, 0xE0, 0x01, 0x81, 0x80, 0x30, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC3, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x18, 0x03, 0x03, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0x01,
  0x80, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x20, 0x30, 0x0C, 0x06,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0xFE,
  0x01, 0xFF, 0xF0, 0x78, 0xCF, 0x0E, 0x18, 0xF3, 0xC3, 0x0E, 0x70, 0x61,
  0xCE, 0x0C, 0x00, 0xE1, 0x80, 0x1C, 0x30, 0x01, 0xE6, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x63, 0xC0, 0x0C, 0x3C, 0x01, 0x83,
  0x80, 0x30, 0x76, 0x06, 0x0F, 0xE0, 0xC1, 0xDC, 0x18, 0x3B, 0xC3, 0x0F,
  0x3C, 0x67, 0xC3, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0x00, 0x71, 0xFE, 0x01, 0x87, 0x18, 0x0E, 0x38,
  0x70, 0x70, 0xE1, 0xC1, 0x83, 0x87, 0x0E, 0x0E, 0x1C, 0x70, 0x38, 0x71,
  0x80, 0xE1, 0xCC, 0x01, 0xCE, 0x70, 0x07, 0xF9, 0x80, 0x07, 0x8C, 0x00,
  0x00, 0x73, 0xE0, 0x03, 0x9F, 0xC0, 0x0C, 0xE3, 0x80, 0x73, 0x06, 0x03,
  0x8C, 0x1C, 0x0C, 0x30, 0x70, 0x70, 0xC1, 0xC3, 0x83, 0x07, 0x0C, 0x0C,
  0x18, 0x70, 0x38, 0xE3, 0x80, 0x7F, 0x0C, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x7F, 0xC0, 0x0F, 0x0E, 0x00, 0xE0, 0xE0, 0x0C, 0x06, 0x00, 0xC0, 0x60,
  0x0C, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x78, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x18, 0x3F, 0x81, 0xC7, 0x1C, 0x18, 0xF1, 0xC3, 0x8E, 0x0E,
  0x38, 0xE0, 0x73, 0x0E, 0x07, 0xF0, 0xE0, 0x3F, 0x0E, 0x01, 0xE0, 0xF0,
  0x1F, 0x07, 0x87, 0xFD, 0x3F, 0xF3, 0xF0, 0xFC, 0x0F, 0xFF, 0xFF, 0xEE,
  0xEE, 0xEE, 0x60, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0x81,
  0xC0, 0xF0, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x86, 0x17, 0x37, 0xBF,
  0xFC, 0x7F, 0x00, 0xE0, 0x0F, 0x80, 0x6E, 0x07, 0x38, 0x70, 0xC1, 0x04,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x7C, 0xF1, 0xE7, 0x8F, 0x1C,
  0x38, 0xE1, 0xC3, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0x07, 0x87, 0x01, 0xE7, 0x80, 0x73, 0x80, 0x3D,
  0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x78, 0xFC, 0x3C,
  0x7E, 0x1E, 0x3F, 0x0F, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0x70, 0x03, 0xB8,
  0x01, 0xDC, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE0, 0xF0, 0xF0, 0x3F, 0xF0,
  0x07, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0xDE,
  0x07, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x3C, 0x70,
  0x0E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0x87, 0x87,
  0x01, 0xE7, 0x80, 0x73, 0x80, 0x3D, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x0F, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77,
  0x80, 0x79, 0xE0, 0x78, 0x7F, 0xF8, 0x0F, 0xF0, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x39, 0xC0,
  0x0C, 0x70, 0x07, 0x1C, 0x03, 0x87, 0x00, 0xC1, 0xC0, 0x70, 0x70, 0x38,
  0x1C, 0x0C, 0x07, 0x07, 0x01, 0xC3, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x3F, 0xFF, 0x1F, 0xFF, 0x8E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0xFC, 0x1D,
  0xFF, 0x0F, 0x83, 0xE7, 0x80, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0xF7, 0x80, 0xF1, 0xE0,
  0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x1C, 0x3C, 0x38,
  0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE3,
  0xF0, 0xEF, 0xFC, 0xFC, 0x3E, 0xF0, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x38, 0x0E, 0x3C,
  0x3C, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x8F,
  0x00, 0xE7, 0x00, 0x73, 0x80, 0x3D, 0xC0, 0x1E, 0xE0, 0x0E, 0x38, 0x07,
  0x1E, 0x0F, 0x03, 0xFF, 0x01, 0xFF, 0x83, 0xC1, 0xE3, 0xC0, 0x39, 0xC0,
  0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0xF7,
  0x80, 0x71, 0xE0, 0xF8, 0x7F, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xFE,
  0x0F, 0x07, 0x87, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1F, 0xE0,
  0x07, 0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xEE, 0x00, 0xF3, 0x80, 0xF9,
  0xE0, 0xDC, 0x7F, 0xCE, 0x0F, 0xC7, 0x00, 0x03, 0x80, 0x03, 0x9C, 0x01,
  0xCF, 0x01, 0xE3, 0x80, 0xE1, 0xE1, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x38, 0x70, 0x70, 0x60, 0x60, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0xCF, 0x83, 0xEF, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0x07, 0x80, 0xE0, 0x18, 0x1C,
  0x00, 0xC3, 0x80, 0x0E, 0x30, 0x00, 0x67, 0x0F, 0x36, 0x61, 0xFB, 0x66,
  0x38, 0xB3, 0xE7, 0x0F, 0x3E, 0x60, 0x63, 0xC6, 0x06, 0x3C, 0xE0, 0x63,
  0xCE, 0x0E, 0x3C, 0xC0, 0xE3, 0xCC, 0x0C, 0x3C, 0xC0, 0xC7, 0xCC, 0x0C,
  0x6C, 0xC1, 0xC6, 0xCE, 0x1C, 0xEC, 0x63, 0xCC, 0xE7, 0xEF, 0x86, 0x3C,
  0x70, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x81, 0xC0, 0x38, 0x1E,
  0x0F, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x70,
  0x78, 0x01, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x38, 0x0F, 0x00, 0xE0, 0x1C,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x0F, 0x0E,
  0x00, 0x1C, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xE7, 0x00, 0x03, 0xBC, 0x00,
  0x0E, 0xFF, 0xE0, 0x7F, 0xFE, 0x38, 0x0F, 0x9C, 0x01, 0xCE, 0x00, 0xF7,
  0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x1E, 0x3F, 0xFC,
  0x1F, 0xFF, 0x0E, 0x01, 0xE7, 0x00, 0x3B, 0x80, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x77, 0x00, 0xFB,
  0xFF, 0xF1, 0xFF, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xE1, 0xF0, 0xF0,
  0x1C, 0x78, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x33, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0x1C, 0x00, 0x77, 0x80, 0x3C, 0xE0,
  0x0E, 0x3C, 0x07, 0x07, 0x83, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xC0,
  0x7F, 0xF8, 0x38, 0x1E, 0x1C, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x7B, 0x80,
  0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03,
  0xB8, 0x03, 0xDC, 0x01, 0xCE, 0x01, 0xC7, 0x03, 0xC3, 0xFF, 0xC1, 0xFF,
  0x80, 0xFF, 0xFF, 0x7F, 0xFF, 0xB8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x87, 0x87, 0x80,
  0xE7, 0x80, 0x7B, 0x80, 0x1D, 0xC0, 0x0D, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x01, 0xDE, 0x00, 0xE7, 0x00, 0x73, 0xC0,
  0x38, 0xF0, 0x7C, 0x3F, 0xFC, 0x07, 0xF0, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x7F, 0x01, 0xDC, 0x07,
  0x78, 0x38, 0xF1, 0xE1, 0xFF, 0x03, 0xF0, 0xE0, 0x07, 0x9C, 0x01, 0xE3,
  0x80, 0x78, 0x70, 0x1E, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x3C, 0x07,
  0x0F, 0x00, 0xE3, 0xC0, 0x1C, 0xF0, 0x03, 0xBE, 0x00, 0x77, 0xC0, 0x0F,
  0xFC, 0x01, 0xF3, 0xC0, 0x3C, 0x7C, 0x07, 0x07, 0x80, 0xE0, 0x78, 0x1C,
  0x07, 0x83, 0x80, 0xF8, 0x70, 0x0F, 0x0E, 0x00, 0xF1, 0xC0, 0x0F, 0x38,
  0x01, 0xE7, 0x00, 0x1E, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xBF, 0xC0, 0xDF,
  0x70, 0xFF, 0xB8, 0x7F, 0xDC, 0x37, 0xE7, 0x3B, 0xF3, 0x99, 0xF8, 0xDC,
  0xFC, 0x7E, 0x7E, 0x3E, 0x3F, 0x0F, 0x1F, 0x87, 0x8F, 0xC3, 0x87, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xEE, 0x07, 0xEE, 0x07, 0xE7, 0x07, 0xE7, 0x07,
  0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE1, 0xC7, 0xE1, 0xC7, 0xE0, 0xE7,
  0xE0, 0xE7, 0xE0, 0x77, 0xE0, 0x77, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xE1, 0xE0, 0xE0,
  0x3C, 0x78, 0x07, 0x1C, 0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xBC, 0x00, 0xE7, 0x00, 0x79, 0xE0,
  0x1C, 0x38, 0x0F, 0x07, 0x87, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xF0,
  0x7F, 0xFE, 0x38, 0x07, 0x9C, 0x01, 0xEE, 0x00, 0x77, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0xDC, 0x07, 0xCF,
  0xFF, 0xC7, 0xFF, 0x83, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xE1, 0xE0, 0xE0, 0x3C, 0x78, 0x07,
  0x1C, 0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xBC, 0x00, 0xE7, 0x00, 0x79, 0xE0, 0x1C, 0x38, 0x0F,
  0x0F, 0x87, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0E, 0x01, 0xE3, 0x80, 0x3C, 0xE0, 0x07, 0x38, 0x01,
  0xEE, 0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x07, 0x38, 0x03, 0xCE, 0x01, 0xE3,
  0xFF, 0xF0, 0xFF, 0xE0, 0x38, 0x38, 0x0E, 0x0F, 0x03, 0x81, 0xC0, 0xE0,
  0x78, 0x38, 0x0F, 0x0E, 0x01, 0xC3, 0x80, 0x78, 0xE0, 0x0F, 0x38, 0x03,
  0xCE, 0x00, 0x7B, 0x80, 0x0E, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x78, 0x3E,
  0x1E, 0x01, 0xE3, 0x80, 0x3C, 0x70, 0x03, 0x8E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xEE, 0x00, 0x3D,
  0xC0, 0x07, 0xBC, 0x00, 0xE7, 0x80, 0x3C, 0x7C, 0x0F, 0x07, 0xFF, 0xC0,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x70, 0x03, 0xB8,
  0x01, 0xDC, 0x01, 0xEE, 0x00, 0xE7, 0x80, 0x71, 0xE0, 0xF0, 0x7F, 0xF0,
  0x0F, 0xE0, 0xF0, 0x00, 0x3B, 0x80, 0x03, 0xDE, 0x00, 0x1C, 0xF0, 0x00,
  0xE3, 0x80, 0x0F, 0x1E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x3C, 0x1E,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0x00, 0x70, 0x38,
  0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8E, 0x00, 0x0E,
  0x70, 0x00, 0x73, 0x80, 0x03, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00,
  0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x07,
  0x9C, 0x1E, 0x1C, 0x70, 0x78, 0x71, 0xE1, 0xE1, 0xC3, 0x8F, 0x87, 0x0E,
  0x3F, 0x1C, 0x38, 0xDC, 0x70, 0xE3, 0x31, 0xC3, 0x9C, 0xCE, 0x0E, 0x73,
  0xB8, 0x19, 0x8E, 0xE0, 0x66, 0x1B, 0x81, 0xF8, 0x6E, 0x07, 0xE1, 0xB8,
  0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x70,
  0x01, 0xE7, 0x80, 0x1C, 0x3C, 0x03, 0xC1, 0xC0, 0x78, 0x1E, 0x07, 0x00,
  0xE0, 0xF0, 0x07, 0x1E, 0x00, 0x79, 0xC0, 0x03, 0xBC, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xBC,
  0x00, 0x79, 0xC0, 0x07, 0x0E, 0x00, 0xE0, 0xF0, 0x1E, 0x07, 0x01, 0xC0,
  0x78, 0x3C, 0x03, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xEF, 0x00, 0x0F, 0xF0,
  0x00, 0xF7, 0x00, 0x1E, 0x78, 0x01, 0xC3, 0x80, 0x3C, 0x3C, 0x03, 0x81,
  0xC0, 0x78, 0x0E, 0x07, 0x00, 0xF0, 0xE0, 0x07, 0x1E, 0x00, 0x79, 0xC0,
  0x03, 0xBC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF,
  0xFF, 0xC0, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xDC, 0x00, 0x6E, 0x00,
  0x73, 0x00, 0x31, 0xC0, 0x38, 0x60, 0x18, 0x38, 0x1C, 0x1C, 0x0E, 0x07,
  0x06, 0x03, 0x87, 0x00, 0xC3, 0x00, 0x73, 0x80, 0x19, 0xC0, 0x0E, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x78, 0x3C, 0x0E, 0x06,
  0x07, 0xF0, 0x07, 0xFF, 0x03, 0xC1, 0xE1, 0xE0, 0x38, 0x70, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0xFF, 0x0F, 0xFF, 0xC7, 0xC0,
  0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x5C,
  0x78, 0x67, 0x0F, 0xF1, 0xF1, 0xF8, 0x3C, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xF0, 0xE7,
  0xFC, 0xEC, 0x3E, 0xF8, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0E, 0xF8, 0x0E, 0xEC, 0x3C, 0xE7, 0xFC, 0xE3, 0xF0, 0x03,
  0xF0, 0x07, 0xFE, 0x0F, 0x07, 0x87, 0x00, 0xE7, 0x00, 0x7B, 0x80, 0x3D,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x1D, 0xE0, 0x1E, 0x70, 0x0E, 0x3C, 0x1E, 0x07,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x07, 0xC7, 0x1F, 0xF7, 0x3C, 0x1F,
  0x78, 0x0F, 0x70, 0x0F, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0F,
  0x78, 0x0F, 0x3C, 0x3F, 0x1F, 0xF7, 0x0F, 0xC7, 0x03, 0xF0, 0x07, 0xFE,
  0x0F, 0x87, 0x87, 0x01, 0xE7, 0x80, 0x73, 0x80, 0x3D, 0xC0, 0x0F, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x0C, 0x70, 0x0E, 0x1E, 0x0F, 0x07, 0xFF, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x8F, 0x3F,
  0xEE, 0x78, 0x7E, 0x70, 0x1E, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1E, 0xF0, 0x1E, 0x78, 0x7E, 0x3F, 0xEE, 0x1F, 0x8E, 0x00,
  0x0E, 0x00, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x1F, 0xF8, 0x07,
  0xE0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0xF8, 0xE7, 0xFD, 0xD8, 0x3F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x3F,
  0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x3A, 0x07,
  0x9F, 0xF8, 0xFF, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0x78,
  0xE0, 0xF0, 0xE0, 0xE0, 0xE1, 0xC0, 0xE3, 0x80, 0xE7, 0x00, 0xEF, 0x00,
  0xFF, 0x80, 0xFB, 0x80, 0xF1, 0xC0, 0xE1, 0xE0, 0xE0, 0xF0, 0xE0, 0x70,
  0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x0E, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xCF, 0x0F, 0x37, 0xE7, 0xED,
  0x1B, 0x3B, 0xC7, 0x8F, 0xE1, 0xE1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87,
  0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1,
  0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E,
  0x1C, 0x1C, 0xE1, 0xF1, 0xCF, 0xFB, 0xB0, 0x7F, 0xC0, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x38, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0x87, 0x87, 0x01, 0xE7, 0x80,
  0x73, 0x80, 0x3D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x3D, 0xE0, 0x1C, 0x70, 0x1E,
  0x3C, 0x1E, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0xE3, 0xF0, 0xE7, 0xFC, 0xEC,
  0x1E, 0xF8, 0x0E, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0E, 0xF8, 0x0E, 0xEC, 0x1E, 0xE7, 0xFC, 0xE3, 0xF0, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07,
  0xC7, 0x1F, 0xF7, 0x3C, 0x1F, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x07, 0x70,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70,
  0x07, 0x70, 0x07, 0x70, 0x0F, 0x78, 0x0F, 0x3C, 0x3F, 0x1F, 0xF7, 0x07,
  0xC7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0xE0, 0xFD, 0xCF, 0xF7, 0x7F, 0xDD, 0xC0, 0x7E, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x0F, 0xE0, 0x3F, 0xF8, 0x78, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x00, 0x70, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x78, 0x1E, 0x3F,
  0xFC, 0x0F, 0xF0, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x1F, 0xFF, 0xBF, 0xFF, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x43, 0xFF, 0x81, 0xFE,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x3E, 0x3F, 0xEE,
  0x1F, 0x87, 0xF0, 0x00, 0xEE, 0x00, 0x3D, 0xE0, 0x07, 0x1C, 0x01, 0xE3,
  0x80, 0x3C, 0x78, 0x07, 0x07, 0x01, 0xE0, 0xF0, 0x38, 0x0E, 0x0F, 0x01,
  0xC1, 0xC0, 0x3C, 0x38, 0x03, 0x8F, 0x00, 0x79, 0xC0, 0x07, 0x38, 0x00,
  0xEE, 0x00, 0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00,
  0x07, 0x38, 0x3C, 0x39, 0xE1, 0xE1, 0xC7, 0x1F, 0x0E, 0x38, 0xDC, 0x71,
  0xC6, 0xE3, 0x8E, 0x73, 0x38, 0x73, 0x99, 0xC3, 0x98, 0xEE, 0x0D, 0xC3,
  0x70, 0x7E, 0x1B, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x03,
  0x80, 0xF0, 0xF0, 0x03, 0x9E, 0x01, 0xC3, 0x80, 0xF0, 0x70, 0x78, 0x1E,
  0x1C, 0x03, 0x8E, 0x00, 0x77, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0x38, 0x03, 0x8F, 0x01, 0xC1, 0xE0,
  0xF0, 0x38, 0x38, 0x07, 0x1C, 0x01, 0xEE, 0x00, 0x3C, 0xF0, 0x00, 0xEE,
  0x00, 0x3D, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x38, 0x38, 0x07, 0x07,
  0x00, 0xE0, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC1, 0xC0, 0x1C, 0x38, 0x03,
  0x86, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFE, 0x07, 0xFC, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x3C, 0x1F,
  0xFC, 0x00, 0xFC,
};

const GFXglyph LiberationMono_Regular36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 4, 24, 22, 9, -24 },
  { 13, 12, 11, 22, 5, -26 },
  { 30, 19, 24, 22, 1, -24 },
  { 87, 19, 30, 22, 1, -27 },
  { 159, 22, 24, 22, 0, -24 },
  { 225, 20, 24, 22, 1, -24 },
  { 285, 4, 11, 22, 9, -26 },
  { 291, 10, 33, 22, 6, -26 },
  { 333, 10, 33, 22, 6, -26 },
  { 375, 13, 13, 22, 4, -26 },
  { 397, 18, 18, 22, 2, -21 },
  { 438, 7, 12, 22, 5, -5 },
  { 449, 10, 3, 22, 6, -11 },
  { 453, 4, 5, 22, 9, -5 },
  { 456, 18, 26, 22, 2, -26 },
  { 515, 17, 24, 22, 2, -24 },
  { 566, 17, 24, 22, 3, -24 },
  { 617, 16, 24, 22, 3, -24 },
  { 665, 17, 24, 22, 2, -24 },
  { 716, 18, 24, 22, 2, -24 },
  { 770, 17, 24, 22, 2, -24 },
  { 821, 16, 24, 22, 3, -24 },
  { 869, 16, 24, 22, 3, -24 },
  { 917, 17, 24, 22, 2, -24 },
  { 968, 17, 24, 22, 2, -24 },
  { 1019, 4, 19, 22, 9, -19 },
  { 1029, 8, 26, 22, 6, -19 },
  { 1055, 18, 18, 22, 2, -21 },
  { 1096, 18, 11, 22, 2, -18 },
  { 1121, 18, 18, 22, 2, -21 },
  { 1162, 17, 24, 22, 2, -24 },
  { 1213, 20, 31, 22, 1, -26 },
  { 1291, 22, 24, 22, 0, -24 },
  { 1357, 17, 24, 22, 3, -24 },
  { 1408, 18, 24, 22, 2, -24 },
  { 1462, 17, 24, 22, 3, -24 },
  { 1513, 17, 24, 22, 3, -24 },
  { 1564, 16, 24, 22, 3, -24 },
  { 1612, 17, 24, 22, 2, -24 },
  { 1663, 16, 24, 22, 3, -24 },
  { 1711, 14, 24, 22, 4, -24 },
  { 1753, 14, 24, 22, 3, -24 },
  { 1795, 19, 24, 22, 3, -24 },
  { 1852, 15, 24, 22, 4, -24 },
  { 1897, 17, 24, 22, 2, -24 },
  { 1948, 16, 24, 22, 3, -24 },
  { 1996, 18, 24, 22, 2, -24 },
  { 2050, 17, 24, 22, 3, -24 },
  { 2101, 18, 31, 22, 2, -24 },
  { 2171, 18, 24, 22, 3, -24 },
  { 2225, 19, 24, 22, 1, -24 },
  { 2282, 19, 24, 22, 1, -24 },
  { 2339, 17, 24, 22, 2, -24 },
  { 2390, 21, 24, 22, 0, -24 },
  { 2453, 22, 24, 22, 0, -24 },
  { 2519, 20, 24, 22, 1, -24 },
  { 2579, 20, 24, 22, 1, -24 },
  { 2639, 19, 24, 22, 1, -24 },
  { 2696, 10, 33, 22, 7, -26 },
  { 2738, 18, 26, 22, 2, -26 },
  { 2797, 9, 33, 22, 5, -26 },
  { 2835, 17, 16, 22, 2, -24 },
  { 2869, 22, 2, 22, 0, 2 },
  { 2875, 8, 5, 22, 7, -26 },
  { 2880, 18, 19, 22, 2, -19 },
  { 2923, 16, 26, 22, 3, -26 },
  { 2975, 17, 19, 22, 2, -19 },
  { 3016, 16, 26, 22, 2, -26 },
  { 3068, 17, 19, 22, 2, -19 },
  { 3109, 17, 26, 22, 2, -26 },
  { 3165, 16, 26, 22, 3, -19 },
  { 3217, 15, 26, 22, 3, -26 },
  { 3266, 17, 26, 22, 3, -26 },
  { 3322, 13, 33, 22, 2, -26 },
  { 3376, 16, 26, 22, 4, -26 },
  { 3428, 18, 26, 22, 2, -26 },
  { 3487, 18, 19, 22, 2, -19 },
  { 3530, 15, 19, 22, 3, -19 },
  { 3566, 17, 19, 22, 2, -19 },
  { 3607, 16, 26, 22, 3, -19 },
  { 3659, 16, 26, 22, 2, -19 },
  { 3711, 14, 19, 22, 4, -19 },
  { 3745, 16, 19, 22, 3, -19 },
  { 3783, 15, 24, 22, 3, -24 },
  { 3828, 16, 19, 22, 3, -19 },
  { 3866, 19, 19, 22, 1, -19 },
  { 3912, 21, 19, 22, 0, -19 },
  { 3962, 18, 19, 22, 2, -19 },
  { 4005, 19, 26, 22, 1, -19 },
  { 4067, 16, 19, 22, 3, -19 },
  { 4105, 15, 33, 22, 4, -26 },
  { 4167, 3, 33, 22, 9, -26 },
  { 4180, 15, 33, 22, 3, -26 },
  { 4242, 18, 4, 22, 2, -14 },
};

const GFXfont LiberationMono_Regular36pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular36pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular36pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _LIBERATIONMONO_REGULAR36PT7B_H_
