#ifndef _LIBERATIONMONO_REGULAR60PT7B_H_
#define _LIBERATIONMONO_REGULAR60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01,
  0xE0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0x80, 0x1E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xE3, 0xC7, 0xF8, 0x1F,
  0x83, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0xFC, 0x3E, 0x03, 0xC0, 0x7C, 0x3E,
  0x03, 0xC0, 0x7E, 0x3E, 0x03, 0xC0, 0x30, 0x3E, 0x03, 0xC0, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F,
  0xC3, 0xC0, 0x00, 0x0F, 0xFB, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xC7, 0xF8, 0x00, 0x03, 0xC1, 0xFC, 0x00,
  0x03, 0xC0, 0x7E, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x1F, 0x18, 0x03, 0xC0, 0x1F, 0xF8,
  0x03, 0xC0, 0x1F, 0xFC, 0x03, 0xC0, 0x3F, 0x7C, 0x03, 0xC0, 0x3E, 0x7E,
  0x03, 0xC0, 0x3E, 0x7F, 0x03, 0xC0, 0x7E, 0x3F, 0x83, 0xC0, 0xFC, 0x1F,
  0xE3, 0xC7, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C,
  0x3F, 0xFE, 0x00, 0x0F, 0x87, 0xC3, 0xE0, 0x00, 0xF0, 0x78, 0x1F, 0x00,
  0x1E, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x3C, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x81, 0xE0, 0x0F, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x0F, 0x83,
  0xC0, 0x0F, 0x80, 0xF0, 0x78, 0x00, 0x78, 0x0F, 0x0F, 0x80, 0x07, 0x81,
  0xF0, 0xF0, 0x00, 0x7C, 0x3E, 0x1E, 0x00, 0x03, 0xFF, 0xE3, 0xE0, 0x00,
  0x1F, 0xFC, 0x3C, 0x00, 0x00, 0x7F, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xFE, 0x00, 0x00,
  0x3C, 0x3F, 0xF8, 0x00, 0x07, 0xC7, 0xFF, 0xC0, 0x00, 0x78, 0x7C, 0x3E,
  0x00, 0x0F, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0xF0, 0x1E, 0x00, 0x1E, 0x1F,
  0x01, 0xF0, 0x03, 0xC1, 0xF0, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0xF0, 0x07,
  0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x0F,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x1F, 0x07, 0xC0, 0x0F,
  0x01, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x0F, 0x00, 0x07, 0xC3, 0xE1, 0xF0,
  0x00, 0x7F, 0xFC, 0x1E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x0F, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0x00, 0x1F, 0xF8, 0x00,
  0xF0, 0x0F, 0xFE, 0x00, 0x3C, 0x07, 0xE7, 0xC0, 0x1F, 0x03, 0xF1, 0xF8,
  0x07, 0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x1F, 0x01,
  0xF8, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xC0, 0xF8,
  0x01, 0xF9, 0xF0, 0x3E, 0x00, 0x3F, 0x78, 0x0F, 0x80, 0x07, 0xFE, 0x03,
  0xE0, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x07, 0xF0,
  0x07, 0xE0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0x8F, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x06, 0x07, 0x81, 0x9F, 0x1E, 0x3E,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x87,
  0x80, 0x3E, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0x80, 0xF0, 0x02, 0x01, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x7C,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F,
  0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x07,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0xFC, 0x00, 0xFF, 0xC7, 0xE0, 0x07,
  0xF8, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x01,
  0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x01,
  0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x3F, 0x80,
  0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x7C, 0x7F, 0xFC,
  0x07, 0xDF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x7F,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF7, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x81, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0x83, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0x00, 0x7C, 0x3F, 0xFC,
  0x07, 0xCF, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0x8F, 0xFF, 0x07, 0xFC, 0xFF,
  0xC0, 0x1F, 0xCF, 0xF0, 0x00, 0x7E, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x3E, 0xFE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7E, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x7E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0x83, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC3,
  0xFC, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0x03, 0xF8,
  0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E, 0xFC,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFF, 0x3F, 0x80,
  0x3D, 0xF1, 0xFE, 0x0F, 0xDF, 0x0F, 0xFF, 0xF9, 0xF0, 0x7F, 0xFF, 0x3F,
  0x03, 0xFF, 0xC3, 0xE0, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC1, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x3F,
  0x00, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x00, 0xFE,
  0x7F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0xF0, 0x78, 0x07, 0xC0, 0x1E, 0x1E, 0x07, 0xFC, 0xF7, 0x8F, 0x03,
  0xFF, 0x39, 0xE3, 0xC1, 0xF0, 0xEE, 0x38, 0xF0, 0x78, 0x1B, 0x8E, 0x38,
  0x3C, 0x07, 0xE3, 0xDE, 0x1E, 0x01, 0xF8, 0xF7, 0x87, 0x80, 0x3C, 0x3D,
  0xE1, 0xE0, 0x0F, 0x0F, 0x70, 0xF0, 0x03, 0xC3, 0xDC, 0x3C, 0x00, 0xF0,
  0xFF, 0x0F, 0x00, 0x7C, 0x3F, 0xC7, 0xC0, 0x1E, 0x0F, 0xF1, 0xE0, 0x07,
  0x83, 0xFC, 0x78, 0x01, 0xE0, 0xFF, 0x1E, 0x00, 0x78, 0x3B, 0xC7, 0x80,
  0x1E, 0x0E, 0xF1, 0xE0, 0x0F, 0x03, 0xBC, 0x78, 0x03, 0xC1, 0xEF, 0x1E,
  0x00, 0xF0, 0x7B, 0xC7, 0x80, 0x7C, 0x1C, 0x71, 0xE0, 0x1F, 0x07, 0x1C,
  0x3C, 0x0F, 0xC3, 0xC7, 0x8F, 0x07, 0x70, 0xE1, 0xE3, 0xE3, 0x9C, 0x78,
  0x78, 0x7F, 0xE7, 0xFC, 0x0E, 0x0F, 0xF1, 0xFE, 0x03, 0xC1, 0xF0, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7C, 0x00, 0x7F, 0xC3, 0xE0, 0x00,
  0x7F, 0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E,
  0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xFC, 0x7C,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xF0, 0xF8, 0x00,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC3, 0xE0, 0x00, 0xFF, 0x1F,
  0x00, 0x01, 0xFC, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x7F, 0xBE, 0x00, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0x81,
  0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x10, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x83, 0xF0, 0x00, 0x07, 0x8F, 0xC0, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x3F, 0xF0,
  0xF8, 0x00, 0xFF, 0x8F, 0x80, 0x03, 0xF8, 0xF8, 0x00, 0x1F, 0xCF, 0x80,
  0x00, 0xFC, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC,
  0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xFC, 0xF8, 0x00, 0x3F, 0x8F, 0x80,
  0x07, 0xF0, 0xF8, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x3F, 0x80,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x30, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFB,
  0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x3E,
  0x1F, 0xC0, 0x03, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x1C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0xC1, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x3F, 0x87, 0xC0, 0x00, 0xFE, 0x0F, 0x80, 0x03, 0xF8, 0x1F, 0x00,
  0x0F, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0xC0, 0x07, 0xC0, 0x7F,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF3, 0xF8, 0x00,
  0x03, 0xE7, 0xF8, 0x00, 0x07, 0xDF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xE0, 0x0F, 0xE0, 0x07,
  0xC0, 0x0F, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0xC0, 0x3E,
  0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x3F, 0x83, 0xE0, 0x00, 0x3F, 0x87, 0xC0, 0x00, 0x3F, 0x8F, 0x80,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0x7F, 0x7C, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xF7, 0x80, 0x1E, 0xFF, 0x7C, 0x01, 0xEF, 0xF7,
  0xC0, 0x3E, 0xFF, 0x3C, 0x03, 0xDF, 0xF3, 0xE0, 0x3D, 0xFF, 0x3E, 0x07,
  0xDF, 0xF1, 0xE0, 0x79, 0xFF, 0x1F, 0x07, 0x9F, 0xF1, 0xF0, 0xF9, 0xFF,
  0x0F, 0x0F, 0x1F, 0xF0, 0xF8, 0xF1, 0xFF, 0x0F, 0x9F, 0x1F, 0xF0, 0x79,
  0xE1, 0xFF, 0x07, 0xDE, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x1F,
  0xF0, 0x3F, 0xC1, 0xFF, 0x01, 0xF8, 0x1F, 0xF0, 0x1F, 0x81, 0xFF, 0x01,
  0xF8, 0x1F, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xDF, 0x00, 0x1F, 0xF7, 0xC0, 0x07, 0xFE, 0xF8, 0x01, 0xFF,
  0xBE, 0x00, 0x7F, 0xE7, 0xC0, 0x1F, 0xF9, 0xF0, 0x07, 0xFE, 0x7C, 0x01,
  0xFF, 0x8F, 0x80, 0x7F, 0xE3, 0xE0, 0x1F, 0xF8, 0x7C, 0x07, 0xFE, 0x1F,
  0x01, 0xFF, 0x83, 0xE0, 0x7F, 0xE0, 0xF8, 0x1F, 0xF8, 0x1F, 0x07, 0xFE,
  0x07, 0xC1, 0xFF, 0x80, 0xF8, 0x7F, 0xE0, 0x3E, 0x1F, 0xF8, 0x0F, 0x87,
  0xFE, 0x01, 0xF1, 0xFF, 0x80, 0x7C, 0x7F, 0xE0, 0x0F, 0x9F, 0xF8, 0x03,
  0xE7, 0xFE, 0x00, 0x7D, 0xFF, 0x80, 0x1F, 0x7F, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFB, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E,
  0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0x80, 0x07, 0xFC,
  0xF8, 0x00, 0x1F, 0xEF, 0x80, 0x00, 0xFE, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0xFE, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x0F,
  0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7E, 0x3F,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7C, 0x00, 0x1F, 0xE3,
  0xE0, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x0F, 0xE7, 0xC0, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x7C,
  0x00, 0x7F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x3F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F,
  0xCF, 0x80, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xF8,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC7,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xFF,
  0x00, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xC3, 0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x80, 0x7C, 0x3E, 0x01, 0xF8, 0x07, 0xC3, 0xF0, 0x1F,
  0xC0, 0x7C, 0x1F, 0x03, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0xC0, 0xF8, 0x1F,
  0x03, 0xFC, 0x0F, 0x81, 0xF0, 0x7D, 0xE0, 0xF8, 0x1F, 0x07, 0x9E, 0x0F,
  0x81, 0xF0, 0x79, 0xE0, 0xF8, 0x1F, 0x07, 0x9E, 0x0F, 0x80, 0xF8, 0xF9,
  0xF0, 0xF0, 0x0F, 0x8F, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0xF1, 0xF0, 0x0F,
  0x8F, 0x0F, 0x1F, 0x00, 0xF9, 0xF0, 0xF9, 0xF0, 0x0F, 0x9E, 0x07, 0x9F,
  0x00, 0x79, 0xE0, 0x79, 0xE0, 0x07, 0x9E, 0x07, 0x9E, 0x00, 0x7B, 0xE0,
  0x3D, 0xE0, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x3D, 0xE0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x7C, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF0,
  0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3E, 0x78,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xE0, 0x0F,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x3E, 0x07, 0xF0, 0x00, 0xF8, 0x3F,
  0x80, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xE0, 0xFE, 0x01, 0xEF,
  0xC1, 0xFC, 0x0F, 0xBF, 0x87, 0xFF, 0xFC, 0x7F, 0xCF, 0xFF, 0xE1, 0xFF,
  0x1F, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x3F, 0xFC,
  0x0F, 0xCF, 0xFF, 0xE1, 0xFB, 0xFF, 0xFE, 0x3F, 0xF8, 0x1F, 0xC7, 0xFC,
  0x01, 0xFC, 0xFF, 0x00, 0x1F, 0x9F, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x3F,
  0x7F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFB, 0xF8, 0x00, 0x1F, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0xFD, 0xFE, 0x00, 0x3F, 0x3F, 0xE0, 0x0F, 0xE7, 0xFF, 0x03, 0xF8, 0xFD,
  0xFF, 0xFE, 0x1F, 0x9F, 0xFF, 0x83, 0xE1, 0xFF, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0x81, 0xF8, 0x01, 0xFC, 0x3F, 0x00,
  0x0F, 0xE3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xF8,
  0x1F, 0x81, 0xFF, 0xE3, 0xF0, 0xFF, 0xFE, 0x7E, 0x3F, 0xFF, 0xEF, 0xC7,
  0xF0, 0x3F, 0xF9, 0xFC, 0x01, 0xFF, 0x3F, 0x00, 0x1F, 0xEF, 0xC0, 0x01,
  0xFD, 0xF8, 0x00, 0x3F, 0xBE, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xBF, 0x00,
  0x07, 0xF7, 0xE0, 0x01, 0xFE, 0x7E, 0x00, 0x3F, 0xCF, 0xC0, 0x0F, 0xF8,
  0xFE, 0x07, 0xFF, 0x1F, 0xFF, 0xF7, 0xE1, 0xFF, 0xFC, 0x7C, 0x0F, 0xFF,
  0x0F, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x30,
  0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC0, 0xFE,
  0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x7C, 0x3F, 0xFF, 0x8F, 0x8F, 0xFF, 0xF9,
  0xF1, 0xFC, 0x0F, 0xBE, 0x7F, 0x00, 0x77, 0xCF, 0xC0, 0x07, 0xFB, 0xF0,
  0x00, 0xFF, 0x7E, 0x00, 0x0F, 0xEF, 0x80, 0x01, 0xFD, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF,
  0xC0, 0x03, 0xFC, 0xFC, 0x00, 0x7F, 0x9F, 0x80, 0x1F, 0xF3, 0xFC, 0x0F,
  0x7E, 0x3F, 0xFF, 0xEF, 0xC3, 0xFF, 0xF9, 0xF8, 0x3F, 0xFC, 0x3F, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFE,
  0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0xFF, 0xF0, 0xFC, 0xFF,
  0xFE, 0x3F, 0x7F, 0xFF, 0xCF, 0xFE, 0x07, 0xF3, 0xEE, 0x00, 0xFE, 0xFF,
  0x00, 0x1F, 0xBF, 0x80, 0x03, 0xEF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xCE, 0x00, 0xFE, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC3,
  0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87,
  0xE0, 0x03, 0xE3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x8F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x3E,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3F,
  0x3E, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x07, 0xC3, 0xC7,
  0xF8, 0x7F, 0xCF, 0x3F, 0xE3, 0xFF, 0x3D, 0xFF, 0xCF, 0xFE, 0xF7, 0x1F,
  0x71, 0xFB, 0xD8, 0x3D, 0x83, 0xEF, 0xC0, 0xFE, 0x0F, 0xFF, 0x03, 0xF0,
  0x1F, 0xFC, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x01, 0xFF, 0x80, 0x7C, 0x07,
  0xFE, 0x01, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x1E, 0x01, 0xFF,
  0x80, 0x78, 0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x7F, 0xE0,
  0x1E, 0x01, 0xFF, 0x80, 0x78, 0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x07,
  0x80, 0x7F, 0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x78, 0x07, 0xFE, 0x01, 0xE0,
  0x1F, 0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x78, 0x07,
  0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x01, 0xFF,
  0x80, 0x78, 0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x7C, 0x00,
  0x0F, 0xE0, 0x3E, 0x0F, 0xFF, 0x0F, 0x8F, 0xFF, 0xE3, 0xE7, 0xFF, 0xFC,
  0xFB, 0xE0, 0x7F, 0x3E, 0xE0, 0x0F, 0xEF, 0xF0, 0x01, 0xFB, 0xF8, 0x00,
  0x3E, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x1F, 0x0F, 0xFF, 0x03, 0xF3, 0xFF, 0xF8, 0x7E, 0xFF, 0xFF, 0x8F,
  0xDE, 0x07, 0xF1, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xE7, 0xF8, 0x00,
  0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7E,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3E, 0xFE, 0x00, 0x07, 0xDF, 0xC0,
  0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x80, 0x0F, 0xCF, 0xF8, 0x03, 0xF9,
  0xFF, 0xC0, 0xFE, 0x3F, 0x7F, 0xFF, 0x87, 0xE7, 0xFF, 0xE0, 0xFC, 0x7F,
  0xF8, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xE0, 0x7F, 0xF8,
  0xFC, 0x3F, 0xFF, 0x9F, 0x8F, 0xFF, 0xFB, 0xF1, 0xFC, 0x0F, 0xFE, 0x7F,
  0x00, 0x7F, 0xCF, 0xC0, 0x07, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F,
  0xEF, 0x80, 0x01, 0xFD, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00,
  0x7F, 0x9F, 0x80, 0x0F, 0xF3, 0xF8, 0x03, 0xFE, 0x3F, 0x81, 0xEF, 0xC7,
  0xFF, 0xFD, 0xF8, 0x7F, 0xFF, 0x3F, 0x03, 0xFF, 0xC7, 0xE0, 0x1F, 0xC0,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0x7C,
  0x7F, 0xFF, 0x7C, 0xFF, 0xFF, 0x7C, 0xFC, 0x01, 0x7D, 0xF0, 0x00, 0x7D,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0x80, 0x07,
  0xE3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xCE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3E,
  0x7E, 0x00, 0x1F, 0x9F, 0xE0, 0x1F, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xDF, 0x00, 0x07, 0xF7,
  0xE0, 0x03, 0xFD, 0xF8, 0x01, 0xDF, 0x3F, 0x81, 0xF7, 0xCF, 0xFF, 0xF9,
  0xF1, 0xFF, 0xFC, 0x7C, 0x3F, 0xFE, 0x1F, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F,
  0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0xFC,
  0x03, 0xE7, 0xC0, 0x3F, 0x01, 0xF8, 0xF8, 0x1F, 0xE0, 0x7C, 0x3E, 0x07,
  0xF8, 0x1F, 0x0F, 0x81, 0xFE, 0x07, 0xC3, 0xE0, 0xF3, 0xC1, 0xF0, 0xF8,
  0x3C, 0xF0, 0x7C, 0x3E, 0x0F, 0x3C, 0x1F, 0x07, 0x87, 0xCF, 0x0F, 0x81,
  0xF1, 0xE1, 0xE3, 0xE0, 0x7C, 0x78, 0x78, 0xF8, 0x1F, 0x3E, 0x1E, 0x3E,
  0x07, 0xCF, 0x03, 0xCF, 0x81, 0xF3, 0xC0, 0xF3, 0xC0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x0F, 0x78, 0x07, 0x7C, 0x03, 0xDE, 0x01, 0xFF, 0x00, 0xF7, 0x80,
  0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x7C,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F,
  0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x7E, 0x3E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00,
};

const GFXglyph LiberationMono_Regular60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 6, 40, 36, 15, -40 },
  { 31, 20, 19, 36, 8, -43 },
  { 79, 32, 40, 36, 2, -40 },
  { 239, 32, 49, 36, 2, -44 },
  { 435, 36, 42, 36, 0, -41 },
  { 624, 34, 41, 36, 1, -40 },
  { 799, 6, 19, 36, 15, -43 },
  { 814, 16, 55, 36, 10, -43 },
  { 924, 16, 55, 36, 10, -43 },
  { 1034, 22, 21, 36, 7, -43 },
  { 1092, 30, 30, 36, 3, -35 },
  { 1205, 12, 19, 36, 8, -9 },
  { 1234, 16, 5, 36, 10, -18 },
  { 1244, 6, 9, 36, 15, -9 },
  { 1251, 30, 44, 36, 3, -43 },
  { 1416, 28, 42, 36, 4, -41 },
  { 1563, 29, 40, 36, 4, -40 },
  { 1708, 28, 41, 36, 4, -41 },
  { 1852, 28, 42, 36, 4, -41 },
  { 1999, 30, 40, 36, 3, -40 },
  { 2149, 28, 41, 36, 4, -40 },
  { 2293, 28, 42, 36, 4, -41 },
  { 2440, 26, 40, 36, 5, -40 },
  { 2570, 28, 42, 36, 4, -41 },
  { 2717, 28, 42, 36, 4, -41 },
  { 2864, 6, 32, 36, 15, -32 },
  { 2888, 13, 42, 36, 10, -32 },
  { 2957, 30, 30, 36, 3, -35 },
  { 3070, 30, 19, 36, 3, -29 },
  { 3142, 30, 30, 36, 3, -35 },
  { 3255, 28, 41, 36, 3, -41 },
  { 3399, 34, 50, 36, 1, -43 },
  { 3612, 36, 40, 36, 0, -40 },
  { 3792, 29, 40, 36, 5, -40 },
  { 3937, 30, 42, 36, 3, -41 },
  { 4095, 28, 40, 36, 5, -40 },
  { 4235, 28, 40, 36, 5, -40 },
  { 4375, 26, 40, 36, 6, -40 },
  { 4505, 29, 42, 36, 3, -41 },
  { 4658, 26, 40, 36, 5, -40 },
  { 4788, 24, 40, 36, 6, -40 },
  { 4908, 24, 41, 36, 5, -40 },
  { 5031, 31, 40, 36, 5, -40 },
  { 5186, 25, 40, 36, 7, -40 },
  { 5311, 28, 40, 36, 4, -40 },
  { 5451, 26, 40, 36, 5, -40 },
  { 5581, 30, 42, 36, 3, -41 },
  { 5739, 28, 40, 36, 5, -40 },
  { 5879, 30, 52, 36, 3, -41 },
  { 6074, 29, 40, 36, 5, -40 },
  { 6219, 31, 42, 36, 2, -41 },
  { 6382, 32, 40, 36, 2, -40 },
  { 6542, 28, 41, 36, 4, -40 },
  { 6686, 36, 40, 36, 0, -40 },
  { 6866, 36, 40, 36, 0, -40 },
  { 7046, 34, 40, 36, 1, -40 },
  { 7216, 34, 40, 36, 1, -40 },
  { 7386, 32, 40, 36, 2, -40 },
  { 7546, 16, 55, 36, 12, -43 },
  { 7656, 30, 44, 36, 3, -43 },
  { 7821, 16, 55, 36, 8, -43 },
  { 7931, 28, 27, 36, 4, -40 },
  { 8026, 36, 3, 36, 0, 4 },
  { 8040, 12, 8, 36, 12, -43 },
  { 8052, 30, 34, 36, 4, -33 },
  { 8180, 27, 44, 36, 5, -43 },
  { 8329, 28, 34, 36, 4, -33 },
  { 8448, 27, 44, 36, 4, -43 },
  { 8597, 28, 34, 36, 4, -33 },
  { 8716, 28, 43, 36, 4, -43 },
  { 8867, 27, 45, 36, 4, -33 },
  { 9019, 26, 43, 36, 5, -43 },
  { 9159, 29, 43, 36, 4, -43 },
  { 9315, 22, 55, 36, 3, -43 },
  { 9467, 26, 43, 36, 7, -43 },
  { 9607, 29, 43, 36, 4, -43 },
  { 9763, 30, 33, 36, 3, -33 },
  { 9887, 26, 33, 36, 5, -33 },
  { 9995, 28, 34, 36, 4, -33 },
  { 10114, 27, 45, 36, 5, -33 },
  { 10266, 27, 45, 36, 4, -33 },
  { 10418, 24, 33, 36, 7, -33 },
  { 10517, 26, 34, 36, 5, -33 },
  { 10628, 24, 41, 36, 6, -40 },
  { 10751, 26, 33, 36, 5, -32 },
  { 10859, 32, 32, 36, 2, -32 },
  { 10987, 34, 32, 36, 1, -32 },
  { 11123, 30, 32, 36, 3, -32 },
  { 11243, 32, 44, 36, 2, -32 },
  { 11419, 27, 32, 36, 4, -32 },
  { 11527, 24, 55, 36, 7, -43 },
  { 11692, 4, 55, 36, 16, -43 },
  { 11720, 24, 55, 36, 5, -43 },
  { 11885, 30, 7, 36, 3, -23 },
};

const GFXfont LiberationMono_Regular60pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular60pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular60pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _LIBERATIONMONO_REGULAR60PT7B_H_
