#ifndef _LIBERATIONMONO_REGULAR41PT7B_H_
#define _LIBERATIONMONO_REGULAR41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x00,
  0x0F, 0xFF, 0xF0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x07,
  0x00, 0x00, 0xC0, 0x70, 0x03, 0x01, 0xC0, 0x0C, 0x06, 0x00, 0x70, 0x18,
  0x01, 0x80, 0x60, 0x06, 0x03, 0x80, 0x18, 0x0C, 0x00, 0xE0, 0x30, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x30, 0x1C, 0x00, 0xC0, 0x60, 0x07, 0x01,
  0x80, 0x1C, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0xE0, 0x06, 0x03, 0x03,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x83, 0x01, 0xC0, 0x0C, 0x06, 0x00, 0x30,
  0x18, 0x01, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x18, 0x0E, 0x00, 0x60, 0x30,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC3, 0xF3, 0x9F, 0x0F,
  0x0E, 0x1E, 0x38, 0x38, 0x78, 0xE0, 0xE0, 0xE3, 0x83, 0x80, 0x0E, 0x0E,
  0x00, 0x3C, 0x38, 0x00, 0x7C, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0x8F, 0x80, 0x0E, 0x1E, 0x00,
  0x38, 0x3C, 0x00, 0xE0, 0xF7, 0x03, 0x81, 0xFC, 0x0E, 0x0F, 0x78, 0x38,
  0x3D, 0xF0, 0xE1, 0xE3, 0xE3, 0x9F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x1F,
  0x00, 0x0E, 0x1F, 0xE0, 0x0E, 0x1C, 0x78, 0x0E, 0x1C, 0x1C, 0x07, 0x0E,
  0x0E, 0x07, 0x07, 0x07, 0x07, 0x03, 0x81, 0x83, 0x81, 0xC0, 0xC3, 0x80,
  0xE0, 0xE3, 0x80, 0x70, 0x71, 0xC0, 0x18, 0x39, 0xC0, 0x0E, 0x3D, 0xC0,
  0x03, 0xFC, 0xC0, 0x00, 0xF8, 0xE7, 0xE0, 0x00, 0xE7, 0xF8, 0x00, 0xE7,
  0x1E, 0x00, 0x73, 0x87, 0x00, 0x73, 0x83, 0x80, 0x71, 0xC0, 0xE0, 0x38,
  0xE0, 0x70, 0x38, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x07, 0x0E, 0x1C, 0x03, 0x8F, 0x0C, 0x00, 0xFF, 0x0E, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3C, 0x3C, 0x00,
  0xF0, 0x3C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x07,
  0x0F, 0x00, 0x0E, 0x7C, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x06, 0x07, 0xF8, 0x0E, 0x1E, 0x78, 0x1C, 0x38, 0x78, 0x38, 0xF0, 0x70,
  0xF1, 0xC0, 0xF1, 0xC3, 0x80, 0xF3, 0x87, 0x00, 0xFE, 0x0E, 0x00, 0xFC,
  0x1E, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x3E, 0x0F, 0xF9, 0x3F, 0xFF, 0xFE,
  0x3F, 0xF9, 0xFC, 0x1F, 0x80, 0xF0, 0xFF, 0xBD, 0xEF, 0x7B, 0xCE, 0x73,
  0x9C, 0xE7, 0x00, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0x80,
  0xF0, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x04, 0x38,
  0xDF, 0x6F, 0xBF, 0xFF, 0x87, 0xE0, 0x07, 0xC0, 0x1D, 0x80, 0x73, 0x80,
  0xE3, 0x83, 0x87, 0x82, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0x8F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x1C, 0x0C,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xF0, 0x7C,
  0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x0E, 0x78, 0x00,
  0xF7, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x0F, 0x8F, 0xF0, 0xF8, 0xFF, 0x0F,
  0x8F, 0xF0, 0xF8, 0xF7, 0x0F, 0x8F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x0E, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xC1,
  0xF0, 0x7C, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0x78, 0x0F, 0xE7,
  0x80, 0xFC, 0x78, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFE, 0x1F, 0x07, 0xC7, 0x80, 0x7C, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x07, 0xC7, 0x80, 0x7C, 0xE0,
  0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0x83, 0xFF,
  0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3B, 0xC0, 0x03, 0x9E, 0x00, 0x3C,
  0xF0, 0x01, 0xC7, 0x80, 0x1C, 0x3C, 0x01, 0xC1, 0xE0, 0x0E, 0x0F, 0x00,
  0xE0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x00, 0xF0, 0x70, 0x07,
  0x87, 0x80, 0x3C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x3F, 0x01, 0xDF, 0xF8, 0x3F, 0xFF, 0xCF, 0xC0, 0xF9, 0xF0, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xBE, 0x01, 0xF3, 0xE0, 0x7C,
  0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0x87, 0xC3, 0xC0, 0x3C, 0x70, 0x07, 0x9E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x3F, 0x03, 0xCF, 0xFC, 0x7F, 0xFF,
  0xCF, 0xE0, 0xFD, 0xF8, 0x07, 0xBE, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07,
  0x8F, 0x00, 0xF1, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x3E, 0x07, 0xC7,
  0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0x70, 0x03, 0xCF,
  0x00, 0x70, 0xF0, 0x3E, 0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFE, 0x0F,
  0x03, 0xE3, 0xC0, 0x1E, 0xF0, 0x01, 0xDE, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xF3, 0xE0, 0x7E, 0x3F,
  0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0x80, 0x79, 0xE0, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0x0E, 0xF0, 0x01, 0xDC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3E, 0xF0, 0x0F, 0xDF, 0x83, 0xF9, 0xFF, 0xEF, 0x1F, 0xF9, 0xE0,
  0xFC, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3D, 0xE0, 0x0F, 0x1E,
  0x03, 0xE3, 0xE0, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0x87, 0xC3,
  0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xFF,
  0xFF, 0x1F, 0x03, 0xE7, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0x07, 0x80, 0x38, 0x07, 0x80, 0xE0,
  0x07, 0x03, 0x80, 0x07, 0x06, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x30, 0x3C,
  0xFC, 0xE1, 0xFD, 0x99, 0xC7, 0x1B, 0x33, 0x0E, 0x1E, 0x7E, 0x38, 0x3C,
  0xFC, 0x60, 0x79, 0xF9, 0xC0, 0xE3, 0xF3, 0x81, 0xC7, 0xE7, 0x03, 0x8F,
  0x8C, 0x07, 0x1F, 0x18, 0x0E, 0x3E, 0x30, 0x18, 0x6C, 0x60, 0x30, 0xD8,
  0xC0, 0xE1, 0xB9, 0x81, 0xC3, 0x73, 0x07, 0x8E, 0xE7, 0x0F, 0x18, 0xCE,
  0x36, 0x71, 0x8F, 0xCF, 0xC3, 0x8F, 0x0F, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x08, 0x0F, 0x00, 0x78, 0x0F, 0x03, 0xE0, 0x07, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x3C, 0x00, 0x03,
  0x8E, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0xF0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x07, 0x80,
  0x1C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x38, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0x00, 0xFC, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x01, 0xCF, 0x00,
  0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x0F, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xEF, 0x00, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3E, 0x0F, 0xC3,
  0xE0, 0x1E, 0x1E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x08, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x18, 0xF0, 0x00, 0xF7, 0xC0, 0x07, 0x1E, 0x00, 0x78, 0xF8,
  0x07, 0x83, 0xF0, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x03, 0xF0, 0xF0, 0x0F,
  0x8F, 0x00, 0x7C, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x01, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC1, 0xF0, 0x7C,
  0x3E, 0x01, 0xE3, 0xC0, 0x1F, 0x78, 0x00, 0xF7, 0x80, 0x0C, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x00, 0xF3, 0xC0, 0x0F, 0x3E, 0x00, 0xF1,
  0xF8, 0x3F, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF8, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xE0, 0xF0, 0x01, 0xF3, 0xC0, 0x0F, 0x8F, 0x00, 0x7C, 0x3C,
  0x01, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x1E,
  0x00, 0xF0, 0xF8, 0x03, 0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x00,
  0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xEF, 0x00, 0x3F, 0x3E, 0x00, 0xF8,
  0x7C, 0x03, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x0F,
  0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0xF0, 0x01, 0xF3,
  0xC0, 0x03, 0xCF, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1D, 0xFB, 0x83, 0xBF, 0x70, 0x77, 0xEF,
  0x1C, 0xFC, 0xE3, 0x9F, 0x9C, 0xF3, 0xF3, 0xDC, 0x7E, 0x3B, 0x8F, 0xC7,
  0x61, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xE0, 0xFC, 0x1C, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0x80, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFB, 0x80, 0x7E, 0xF0,
  0x1F, 0xDC, 0x07, 0xF7, 0x81, 0xFC, 0xE0, 0x7F, 0x3C, 0x1F, 0xC7, 0x07,
  0xF1, 0xC1, 0xFC, 0x38, 0x7F, 0x0E, 0x1F, 0xC3, 0xC7, 0xF0, 0x71, 0xFC,
  0x1E, 0x7F, 0x03, 0x9F, 0xC0, 0xF7, 0xF0, 0x1D, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7C, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x3E, 0x0F, 0x83, 0xC0, 0x3E, 0x3E,
  0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x07,
  0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0x9E, 0x00, 0x3C,
  0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x3E, 0x00, 0xF0, 0xF8, 0x0F, 0x83, 0xE0,
  0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x78, 0x07, 0xEF, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x1F, 0xBF, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF,
  0xF8, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x3E, 0x0F,
  0x83, 0xC0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x00, 0x1E, 0xF8,
  0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x3E, 0x00, 0xF0,
  0xF8, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x1E, 0x78,
  0x00, 0xF3, 0xC0, 0x03, 0x9E, 0x00, 0x1C, 0xF0, 0x01, 0xE7, 0x80, 0x0F,
  0x3C, 0x00, 0xF9, 0xE0, 0x0F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF,
  0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81,
  0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x1F, 0x1E, 0x00,
  0x78, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0xBC, 0x00, 0x3C, 0x03, 0xFE, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7C, 0x0F, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0x79, 0xE0, 0x03, 0x8F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0xC0, 0x7C,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0x9E,
  0x01, 0xF3, 0xE0, 0x7C, 0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x07, 0x80, 0xF0, 0x07, 0x80, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0xC1, 0xE0,
  0x03, 0xC1, 0xC0, 0x01, 0xC3, 0xC0, 0x01, 0xE3, 0x80, 0x01, 0xE3, 0x80,
  0x00, 0xE7, 0x80, 0x00, 0xF7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0x78, 0x3C,
  0x0E, 0x3C, 0x1E, 0x07, 0x0E, 0x0F, 0x87, 0x87, 0x07, 0xC3, 0xC3, 0x87,
  0x61, 0xE1, 0xE3, 0xB8, 0xE0, 0xF1, 0xDC, 0x70, 0x78, 0xCE, 0x38, 0x1C,
  0xE7, 0x1C, 0x0E, 0x71, 0xCE, 0x07, 0x38, 0xE7, 0x03, 0x98, 0x77, 0x81,
  0xDC, 0x1B, 0x80, 0xEE, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x03, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3C, 0x00, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x1E,
  0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x00,
  0x03, 0xDE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEF, 0x00, 0x07,
  0x8E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x1C, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x7C, 0x78, 0x00, 0x78, 0xF0, 0x00,
  0x7B, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x01,
  0xE1, 0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78,
  0x03, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xDC, 0x00, 0x73, 0x80, 0x0E, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x38, 0x70,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70,
  0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xC1, 0xF0, 0x78, 0x07,
  0x87, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x7F,
  0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xFC, 0x07, 0x8F, 0x00, 0x78, 0xF0,
  0x07, 0x8E, 0x00, 0x78, 0xE0, 0x0F, 0x8F, 0x01, 0xB8, 0xF8, 0x3B, 0xCF,
  0xFF, 0x3F, 0x7F, 0xE3, 0xF1, 0xF8, 0x1F, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE1, 0xF8, 0x39, 0xFF, 0x8E, 0xFF, 0xF3, 0xB0, 0x7C, 0xF8, 0x07,
  0xBC, 0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0E, 0xF0, 0x07, 0xBE, 0x01, 0xEF, 0xC1, 0xF3, 0xBF, 0xFC, 0xE7, 0xFE,
  0x38, 0x7E, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x07,
  0xC7, 0x80, 0x3C, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x0F, 0x78, 0x03, 0xCF, 0x00, 0x78, 0xF8, 0x3E,
  0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x07, 0xE3, 0xC7, 0xFE, 0xF3, 0xFF, 0xFD, 0xF0, 0x7F, 0x78,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xDE, 0x03, 0xF7, 0xC1, 0xFC, 0xFF, 0xEF, 0x1F,
  0xF3, 0xC3, 0xF8, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F,
  0x07, 0xC7, 0x80, 0x7C, 0xE0, 0x07, 0xBC, 0x00, 0x77, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x01, 0x8F, 0x00, 0x78, 0xF8,
  0x3F, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE1, 0xC7,
  0xFC, 0x73, 0xFF, 0xBD, 0xF0, 0x7F, 0x78, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xDE,
  0x03, 0xF7, 0xC1, 0xFC, 0xFF, 0xEF, 0x1F, 0xF3, 0xC3, 0xF0, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x78, 0xF8, 0x3E,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE1, 0xF8, 0x73, 0xFF, 0x3B, 0xFF, 0xDD, 0xC3, 0xEF, 0x80, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF4, 0x07, 0xEF, 0xFF, 0x9F,
  0xFE, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x0F,
  0xB8, 0x07, 0xCE, 0x01, 0xE3, 0x80, 0xF0, 0xE0, 0x78, 0x38, 0x3C, 0x0E,
  0x1E, 0x03, 0x8F, 0x00, 0xE7, 0x80, 0x3B, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0xFB, 0xE0, 0x3C, 0x78, 0x0E, 0x0F, 0x03, 0x81, 0xE0, 0xE0, 0x78,
  0x38, 0x0F, 0x0E, 0x01, 0xE3, 0x80, 0x7C, 0xE0, 0x0F, 0x38, 0x01, 0xE0,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE7, 0xC3, 0xC7, 0x7E, 0x3F, 0x3B, 0xFB, 0xFD, 0xF1, 0xD9, 0xEF, 0x0F,
  0x87, 0x78, 0x78, 0x3B, 0xC1, 0xC1, 0xDE, 0x0E, 0x0E, 0xF0, 0x70, 0x7F,
  0x03, 0x83, 0xF8, 0x1C, 0x1F, 0xC0, 0xE0, 0xFE, 0x07, 0x07, 0xF0, 0x38,
  0x3F, 0x81, 0xC1, 0xFC, 0x0E, 0x0F, 0xE0, 0x70, 0x7F, 0x03, 0x83, 0xF8,
  0x1C, 0x1F, 0xC0, 0xE0, 0xFE, 0x07, 0x07, 0xF0, 0x38, 0x3C, 0xE1, 0xF8,
  0x73, 0xFF, 0x3B, 0xFF, 0xDD, 0xC3, 0xEF, 0x80, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3C, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x07, 0xC7, 0x80, 0x7D, 0xF0, 0x07, 0xBC,
  0x00, 0x77, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0xF8, 0xF8, 0x3E, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x07,
  0xF0, 0x00, 0xE1, 0xF8, 0x39, 0xFF, 0x8E, 0xFF, 0xF3, 0xB0, 0x7C, 0xF8,
  0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0E, 0xF0, 0x07, 0xBE, 0x01, 0xEF, 0xC1, 0xF3, 0xBF, 0xFC, 0xE7,
  0xFE, 0x38, 0x7E, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0xE3, 0xC7, 0xFE, 0xF3, 0xFF, 0xBD, 0xF0, 0x7F, 0x78, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xDE, 0x03, 0xF7, 0xC1, 0xFC, 0xFF, 0xEF, 0x1F, 0xF3, 0xC1,
  0xF8, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0xE0, 0x7F,
  0xF1, 0xFF, 0xF3, 0xFF, 0x77, 0x80, 0x76, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF,
  0xF0, 0xF0, 0x3E, 0x78, 0x03, 0x9E, 0x00, 0xF7, 0x80, 0x01, 0xE0, 0x00,
  0x3F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x70, 0x01, 0xDC, 0x00, 0xF7, 0xC0,
  0x78, 0xFF, 0xFE, 0x1F, 0xFF, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x01, 0x0F, 0xFF,
  0x07, 0xFF, 0x03, 0xFE, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x0E, 0xEF, 0xFE, 0x73, 0xFE,
  0x38, 0xFE, 0x1C, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0xF0, 0x70, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0xF0,
  0x07, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x3C, 0x70, 0x00, 0xF3, 0xC0, 0x01,
  0xCF, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x38, 0x3C,
  0x0E, 0x38, 0x3E, 0x1E, 0x38, 0x3E, 0x1E, 0x38, 0x76, 0x1E, 0x3C, 0x77,
  0x1C, 0x3C, 0x67, 0x1C, 0x3C, 0xE7, 0x1C, 0x1C, 0xE3, 0x3C, 0x1C, 0xE3,
  0xBC, 0x1D, 0xC3, 0xBC, 0x1D, 0xC1, 0xB8, 0x1D, 0xC1, 0xF8, 0x0D, 0x81,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x78, 0x00,
  0xF3, 0xC0, 0x0F, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x78, 0x07,
  0x87, 0x80, 0x1E, 0x38, 0x00, 0x73, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xEE, 0x00, 0x1E,
  0x78, 0x00, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x00, 0xF0,
  0x78, 0x03, 0xC7, 0x80, 0x0F, 0x78, 0x00, 0x78, 0x70, 0x00, 0x3D, 0xE0,
  0x00, 0xF7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0x70, 0x03,
  0xC1, 0xE0, 0x0F, 0x03, 0x80, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00,
  0x70, 0x3C, 0x01, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x0F, 0x1E, 0x00, 0x1C,
  0x70, 0x00, 0x71, 0xC0, 0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x7F,
  0xE0, 0x3F, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0xE0, 0x00, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xC0,
};

const GFXglyph LiberationMono_Regular41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 4, 27, 25, 10, -27 },
  { 15, 13, 13, 25, 6, -30 },
  { 37, 22, 27, 25, 1, -27 },
  { 112, 22, 33, 25, 1, -30 },
  { 203, 25, 27, 25, 0, -27 },
  { 288, 23, 27, 25, 1, -27 },
  { 366, 5, 13, 25, 10, -30 },
  { 375, 11, 39, 25, 7, -30 },
  { 429, 11, 39, 25, 7, -30 },
  { 483, 15, 14, 25, 5, -30 },
  { 510, 20, 21, 25, 2, -24 },
  { 563, 9, 13, 25, 5, -6 },
  { 578, 11, 3, 25, 7, -13 },
  { 583, 5, 6, 25, 10, -6 },
  { 587, 20, 30, 25, 2, -30 },
  { 662, 20, 27, 25, 2, -27 },
  { 730, 20, 27, 25, 3, -27 },
  { 798, 19, 27, 25, 3, -27 },
  { 863, 19, 27, 25, 3, -27 },
  { 928, 21, 27, 25, 2, -27 },
  { 999, 19, 27, 25, 3, -27 },
  { 1064, 19, 27, 25, 3, -27 },
  { 1129, 18, 27, 25, 3, -27 },
  { 1190, 19, 27, 25, 3, -27 },
  { 1255, 19, 27, 25, 3, -27 },
  { 1320, 5, 22, 25, 10, -22 },
  { 1334, 9, 29, 25, 7, -22 },
  { 1367, 20, 21, 25, 2, -24 },
  { 1420, 20, 13, 25, 2, -20 },
  { 1453, 20, 21, 25, 2, -24 },
  { 1506, 19, 27, 25, 2, -27 },
  { 1571, 23, 35, 25, 1, -30 },
  { 1672, 25, 27, 25, 0, -27 },
  { 1757, 20, 27, 25, 3, -27 },
  { 1825, 21, 27, 25, 2, -27 },
  { 1896, 20, 27, 25, 3, -27 },
  { 1964, 19, 27, 25, 3, -27 },
  { 2029, 18, 27, 25, 4, -27 },
  { 2090, 20, 27, 25, 2, -27 },
  { 2158, 18, 27, 25, 3, -27 },
  { 2219, 17, 27, 25, 4, -27 },
  { 2277, 16, 27, 25, 4, -27 },
  { 2331, 22, 27, 25, 3, -27 },
  { 2406, 17, 27, 25, 5, -27 },
  { 2464, 19, 27, 25, 3, -27 },
  { 2529, 18, 27, 25, 3, -27 },
  { 2590, 21, 27, 25, 2, -27 },
  { 2661, 19, 27, 25, 3, -27 },
  { 2726, 21, 35, 25, 2, -27 },
  { 2818, 21, 27, 25, 3, -27 },
  { 2889, 21, 27, 25, 2, -27 },
  { 2960, 21, 27, 25, 2, -27 },
  { 3031, 19, 27, 25, 3, -27 },
  { 3096, 24, 27, 25, 0, -27 },
  { 3177, 25, 27, 25, 0, -27 },
  { 3262, 23, 27, 25, 1, -27 },
  { 3340, 23, 27, 25, 1, -27 },
  { 3418, 22, 27, 25, 1, -27 },
  { 3493, 11, 39, 25, 8, -30 },
  { 3547, 20, 30, 25, 2, -30 },
  { 3622, 11, 39, 25, 5, -30 },
  { 3676, 19, 18, 25, 3, -27 },
  { 3719, 25, 2, 25, 0, 2 },
  { 3726, 9, 5, 25, 8, -29 },
  { 3732, 20, 22, 25, 3, -22 },
  { 3787, 18, 30, 25, 4, -30 },
  { 3855, 19, 22, 25, 3, -22 },
  { 3908, 18, 30, 25, 3, -30 },
  { 3976, 19, 22, 25, 3, -22 },
  { 4029, 19, 30, 25, 3, -30 },
  { 4101, 18, 31, 25, 3, -22 },
  { 4171, 17, 30, 25, 4, -30 },
  { 4235, 20, 30, 25, 3, -30 },
  { 4310, 15, 39, 25, 2, -30 },
  { 4384, 18, 30, 25, 5, -30 },
  { 4452, 19, 30, 25, 3, -30 },
  { 4524, 21, 22, 25, 2, -22 },
  { 4582, 17, 22, 25, 4, -22 },
  { 4629, 19, 22, 25, 3, -22 },
  { 4682, 18, 31, 25, 4, -22 },
  { 4752, 18, 31, 25, 3, -22 },
  { 4822, 16, 22, 25, 5, -22 },
  { 4866, 18, 22, 25, 3, -22 },
  { 4916, 16, 28, 25, 4, -28 },
  { 4972, 17, 22, 25, 4, -22 },
  { 5019, 22, 22, 25, 1, -22 },
  { 5080, 24, 22, 25, 0, -22 },
  { 5146, 21, 22, 25, 2, -22 },
  { 5204, 22, 31, 25, 1, -22 },
  { 5290, 18, 22, 25, 3, -22 },
  { 5340, 16, 39, 25, 5, -30 },
  { 5418, 3, 39, 25, 11, -30 },
  { 5433, 17, 39, 25, 3, -30 },
  { 5516, 20, 5, 25, 2, -16 },
};

const GFXfont LiberationMono_Regular41pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular41pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular41pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _LIBERATIONMONO_REGULAR41PT7B_H_
