#ifndef _LIBERATIONMONO_REGULAR44PT7B_H_
#define _LIBERATIONMONO_REGULAR44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x70,
  0x00, 0x0F, 0xFF, 0xF0, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xC0, 0xF7, 0x03, 0xDC,
  0x0F, 0x70, 0x3D, 0xC0, 0xF0, 0x00, 0x60, 0x18, 0x00, 0xE0, 0x18, 0x00,
  0xE0, 0x38, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x01,
  0xC0, 0x30, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x70, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0E, 0x01, 0x80, 0x0E, 0x03, 0x80, 0x0C,
  0x03, 0x80, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x1C,
  0x07, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x1F, 0x1C, 0xFC, 0x3E, 0x1C, 0x3C, 0x3C, 0x1C, 0x3C, 0x3C,
  0x1C, 0x1E, 0x38, 0x1C, 0x1C, 0x3C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x1E,
  0x1C, 0x00, 0x1F, 0x9C, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1C, 0x7C, 0x00, 0x1C, 0x1E, 0x00,
  0x1C, 0x1E, 0x00, 0x1C, 0x0F, 0x30, 0x1C, 0x0F, 0x70, 0x1C, 0x0F, 0x78,
  0x1C, 0x0F, 0x7C, 0x1C, 0x1E, 0x3C, 0x1C, 0x3E, 0x3F, 0x1C, 0x7C, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x07, 0x0F, 0xF0, 0x01, 0xC7,
  0x8E, 0x00, 0xE1, 0xC1, 0xC0, 0x70, 0xE0, 0x70, 0x1C, 0x38, 0x1C, 0x0E,
  0x0E, 0x07, 0x07, 0x03, 0x81, 0xC3, 0xC0, 0xE0, 0x70, 0xE0, 0x38, 0x1C,
  0x70, 0x0E, 0x07, 0x3C, 0x01, 0xC1, 0xCE, 0x00, 0x78, 0xE7, 0x00, 0x0F,
  0xF3, 0x80, 0x01, 0xF8, 0xE7, 0xE0, 0x00, 0x73, 0xFE, 0x00, 0x39, 0xE3,
  0x80, 0x0E, 0x70, 0x70, 0x07, 0x3C, 0x1C, 0x03, 0x8E, 0x07, 0x01, 0xE3,
  0x81, 0xC0, 0x70, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x07,
  0x03, 0xC1, 0xC3, 0x80, 0x70, 0x71, 0xC0, 0x1E, 0x38, 0x70, 0x03, 0xFC,
  0x38, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0xC3, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x07, 0x01, 0xE0, 0x07, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x07, 0xBF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x18, 0x1F, 0xE0,
  0x1C, 0x3C, 0xF0, 0x3C, 0x78, 0x70, 0x38, 0x70, 0x78, 0x38, 0xF0, 0x3C,
  0x78, 0xF0, 0x1C, 0x70, 0xF0, 0x1E, 0x70, 0xF0, 0x0F, 0xF0, 0xF0, 0x07,
  0xE0, 0xF0, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x7C, 0x0F, 0xFC, 0x3F, 0xFF,
  0x7F, 0x1F, 0xFE, 0x3F, 0x07, 0xF0, 0x0F, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xE7, 0x38, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x61, 0xC2, 0x79, 0x9F, 0xFF, 0xFF, 0x1F, 0xF8,
  0x03, 0xC0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x3C, 0x3C,
  0x08, 0x10, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x1F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0x78, 0x38, 0x3C,
  0x1C, 0x0E, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7E, 0x0F, 0x83, 0xC0, 0x3E, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xDE,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x1D, 0xE0, 0x00,
  0xFF, 0x0F, 0x87, 0xF8, 0x7C, 0x3F, 0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0xF0,
  0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1D, 0xE0, 0x01, 0xEF, 0x00, 0x0F,
  0x38, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x03, 0xE1, 0xF8,
  0x3E, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0xFB, 0xC0, 0x7F,
  0x9E, 0x03, 0xF8, 0xF0, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xF0,
  0x7E, 0x7C, 0x01, 0xE7, 0x80, 0x1F, 0x78, 0x00, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7C, 0x0F, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xFB, 0xC0, 0x03, 0xDE, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x7C, 0x01, 0xF1, 0xF0, 0x3F,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xEF, 0x00, 0x07, 0xBC, 0x00, 0x3C, 0xF0, 0x00, 0xE3, 0xC0, 0x07, 0x0F,
  0x00, 0x3C, 0x3C, 0x00, 0xE0, 0xF0, 0x07, 0x03, 0xC0, 0x3C, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x00, 0xF0, 0x38, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x00,
  0x3C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x3F, 0x00, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x3F, 0x03, 0xF1, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDF, 0x00, 0x3E, 0x7C, 0x03, 0xE3, 0xF0,
  0x3F, 0x0F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0x0F, 0x81, 0xE0, 0x1E, 0x1E,
  0x00, 0xF0, 0xF0, 0x03, 0x8F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x3F, 0x81, 0xE7, 0xFF, 0x0F, 0x7F, 0xFC, 0x7F, 0x83, 0xF3, 0xF0,
  0x07, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x1E,
  0xF0, 0x00, 0xF7, 0x80, 0x07, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xC7, 0x80,
  0x1E, 0x3E, 0x01, 0xE0, 0xF8, 0x3F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0,
  0x7C, 0x0F, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00,
  0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x7C, 0x0F, 0x81,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xC0, 0xF8, 0x78, 0x01,
  0xE3, 0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78,
  0x00, 0x7B, 0xC0, 0x03, 0xDF, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xF0, 0x3F,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0xFC, 0x7C, 0x03, 0xC7, 0x80, 0x1E,
  0xF8, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xF3, 0xE0,
  0xFF, 0x1F, 0xFE, 0xF0, 0xFF, 0xCF, 0x03, 0xF0, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x70, 0x01, 0xE7, 0x80, 0x3C, 0x7C, 0x07, 0xC3,
  0xE0, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xE1,
  0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x03, 0x81,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF8, 0x7E,
  0x07, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x70, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x38, 0x1E, 0x77,
  0x1C, 0x3F, 0xBB, 0x9C, 0x38, 0xDD, 0xCE, 0x38, 0x3C, 0x67, 0x1C, 0x1E,
  0x33, 0x1C, 0x07, 0x1B, 0x8E, 0x03, 0x8F, 0xC7, 0x01, 0xC7, 0xE7, 0x01,
  0xC3, 0xF3, 0x80, 0xE1, 0xB9, 0xC0, 0x70, 0xDC, 0xE0, 0x38, 0x6E, 0x70,
  0x1C, 0x37, 0x38, 0x0E, 0x3B, 0x9C, 0x0E, 0x1D, 0xCE, 0x07, 0x0C, 0xE7,
  0x07, 0x86, 0x71, 0x83, 0xC7, 0x38, 0xE3, 0x67, 0x0E, 0x3F, 0x3F, 0x07,
  0x0F, 0x0F, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x10, 0x0F, 0x00, 0x1C, 0x03, 0xE0, 0x7E, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x3E, 0x01, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xCF, 0x80,
  0x0F, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x1E,
  0x3E, 0x01, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x3E,
  0x00, 0xFC, 0xF8, 0x00, 0xF3, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1E,
  0xF8, 0x00, 0xFB, 0xE0, 0x0F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFC,
  0x1F, 0x81, 0xF0, 0x0F, 0x07, 0xC0, 0x0F, 0x0F, 0x00, 0x1F, 0x3E, 0x00,
  0x1E, 0x78, 0x00, 0x30, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x01, 0x0F, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1F, 0x00, 0x3C, 0x1F,
  0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xF0, 0x3F,
  0x8F, 0x80, 0x7E, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1E, 0xF8,
  0x00, 0xF7, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x7C, 0x00, 0x7B,
  0xE0, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0xFE, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x1F, 0x00, 0xF8, 0xF8,
  0x01, 0xE3, 0xC0, 0x07, 0xDF, 0x00, 0x0C, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFD, 0xE0, 0x00, 0xF7, 0x80,
  0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0xCF, 0x80, 0x0F, 0x1F, 0x00, 0x7C, 0x3E, 0x07, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF7, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0x1F, 0x78, 0x0F, 0x3F, 0x0F, 0x8F, 0xFF, 0x83, 0xFF, 0x80,
  0x7F, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F,
  0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0xCF, 0x80,
  0x0F, 0xBE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFE, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8,
  0x01, 0xF1, 0xF0, 0x01, 0xF3, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xEF, 0x80,
  0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F,
  0xF7, 0x01, 0xFF, 0xB8, 0x1D, 0xFD, 0xE0, 0xEF, 0xE7, 0x07, 0x7F, 0x38,
  0x73, 0xF9, 0xE3, 0x9F, 0xC7, 0x1C, 0xFE, 0x39, 0xC7, 0xF1, 0xEE, 0x3F,
  0x87, 0x71, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7F, 0x07, 0xC3, 0xF8, 0x3C,
  0x1F, 0xC0, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0x80, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xF7, 0x00, 0xFF, 0x78, 0x0F,
  0xF3, 0x80, 0xFF, 0x3C, 0x0F, 0xF3, 0xC0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0,
  0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x07, 0x0F, 0xF0, 0x78, 0xFF, 0x03,
  0x8F, 0xF0, 0x3C, 0xFF, 0x01, 0xCF, 0xF0, 0x1E, 0xFF, 0x00, 0xEF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xE0, 0xF8, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xE7, 0xC0, 0x07,
  0x9E, 0x00, 0x1E, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x1F,
  0x78, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x3E,
  0x01, 0xF0, 0x7E, 0x0F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xF0, 0x0F, 0xCF,
  0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x7C,
  0x00, 0xFB, 0xE0, 0x1F, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xE0, 0xF8, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC7, 0xC0,
  0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00,
  0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0x8F, 0x00, 0x3C,
  0x3E, 0x01, 0xF0, 0x7E, 0x0F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3E, 0x00, 0xFC, 0xF8,
  0x00, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF8, 0x00,
  0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x7C, 0xF8, 0x03, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xF8, 0x3C, 0x03, 0xE0,
  0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F,
  0x0F, 0x80, 0x3C, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xE3, 0xE0, 0x07, 0xCF,
  0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x3C, 0x00, 0xF9, 0xF0, 0x01,
  0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xDE,
  0x00, 0x1F, 0x7C, 0x00, 0x78, 0xFC, 0x07, 0xE1, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xE3, 0xE0, 0x7E, 0x3F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x03, 0xC0,
  0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x01,
  0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xF1,
  0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x07, 0x81,
  0xE3, 0x81, 0xF0, 0x78, 0xF0, 0x7C, 0x1E, 0x3C, 0x3F, 0x07, 0x0F, 0x0F,
  0xC1, 0xC3, 0xC3, 0xB8, 0x70, 0xF0, 0xEE, 0x3C, 0x1C, 0x73, 0x8F, 0x07,
  0x1C, 0xE3, 0xC1, 0xC7, 0x1C, 0xF0, 0x7B, 0xC7, 0x38, 0x1E, 0xE1, 0xCE,
  0x07, 0xB8, 0x73, 0x80, 0xEE, 0x0E, 0xE0, 0x3B, 0x83, 0xB8, 0x0F, 0xC0,
  0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x00, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x07, 0x87, 0xC0, 0x03, 0xE3, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x3D,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x79, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x80,
  0x3C, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x1E,
  0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0x87, 0x80, 0x07, 0x81, 0xE0,
  0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x0F, 0x03, 0xE0, 0x07,
  0xC1, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xB8, 0x00,
  0x39, 0xC0, 0x01, 0xCF, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xE0, 0x0F, 0x07,
  0x00, 0x70, 0x38, 0x07, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x3C, 0x1C,
  0x00, 0xE0, 0xE0, 0x07, 0x8F, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0x80, 0x03,
  0xB8, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF8, 0x0F, 0x83, 0xF0, 0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7E, 0x01, 0xC3, 0xE0, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x7E, 0x3C, 0x03, 0x78,
  0xFC, 0x3D, 0xE1, 0xFF, 0xE7, 0xF3, 0xFF, 0x0F, 0xC7, 0xF0, 0x1F, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0xFC, 0x1E, 0x7F, 0xE3, 0xDF,
  0xFE, 0x7F, 0x07, 0xEF, 0xC0, 0x3D, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xEF, 0xE0, 0xFD, 0xEF, 0xFF, 0x3C, 0xFF,
  0xC7, 0x87, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xF0,
  0x7E, 0x3C, 0x01, 0xE7, 0x80, 0x1F, 0x78, 0x00, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF7, 0x80, 0x0F,
  0x78, 0x01, 0xF7, 0xC0, 0x1E, 0x3F, 0x07, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x07,
  0xF0, 0xE1, 0xFF, 0xCE, 0x3F, 0xFE, 0xE3, 0xE0, 0xEE, 0x7C, 0x03, 0xE7,
  0x80, 0x3E, 0x78, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0xC0,
  0x7E, 0x3E, 0x0E, 0xE3, 0xFF, 0xCE, 0x1F, 0xF8, 0xE0, 0x7F, 0x0E, 0x01,
  0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7E, 0x0F, 0x83, 0xC0, 0x3E,
  0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x07, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x30, 0x78, 0x03, 0xE3, 0xF0, 0x3E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xE0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xF0, 0xF0, 0xFF, 0x8F, 0x1F, 0xFC, 0xF3, 0xE0, 0xEF,
  0x7C, 0x07, 0xF7, 0x80, 0x3F, 0x78, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0x80, 0x1F, 0x78,
  0x03, 0xF7, 0xC0, 0x7F, 0x3E, 0x0E, 0xF3, 0xFF, 0xCF, 0x1F, 0xF8, 0xF0,
  0x7E, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE3, 0xC0, 0x1E,
  0x3C, 0x03, 0xE3, 0xF0, 0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0xFC, 0x1E, 0x7F,
  0xE3, 0xDF, 0xFE, 0x7F, 0x87, 0xEF, 0xC0, 0x3D, 0xF0, 0x07, 0xBE, 0x00,
  0xF7, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xFC,
  0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xD0, 0x1F, 0xBF, 0xFE, 0x7F, 0xF8, 0x7F, 0x80, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x3C,
  0x78, 0x0F, 0x8F, 0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x3E, 0x07, 0x87, 0x80,
  0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xDE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01,
  0xFB, 0xE0, 0x3E, 0x3C, 0x07, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x83,
  0xC0, 0x78, 0x78, 0x0F, 0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x3C, 0x00, 0xF7,
  0x80, 0x1F, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xC1, 0xF3, 0x9F, 0x8F, 0xEE, 0xFF, 0x7F, 0xBB, 0x3D,
  0x9F, 0xF8, 0x7C, 0x3F, 0xE1, 0xF0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x07,
  0xF0, 0x78, 0x1F, 0xC1, 0xE0, 0x7F, 0x07, 0x81, 0xFC, 0x1E, 0x07, 0xF0,
  0x78, 0x1F, 0xC1, 0xE0, 0x7F, 0x07, 0x81, 0xFC, 0x1E, 0x07, 0xF0, 0x78,
  0x1F, 0xC1, 0xE0, 0x7F, 0x07, 0x81, 0xFC, 0x1E, 0x07, 0xF0, 0x78, 0x1F,
  0xC1, 0xE0, 0x7F, 0x07, 0x81, 0xFC, 0x1E, 0x07, 0xF0, 0xFC, 0x1E, 0x7F,
  0xE3, 0xDF, 0xFE, 0x7F, 0x87, 0xEF, 0xC0, 0x3D, 0xF0, 0x07, 0xBE, 0x00,
  0xF7, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xF0, 0x7E, 0x0F, 0x87, 0xC0, 0x3E, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xDE,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0,
  0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x78, 0xF8, 0x07, 0xC3, 0xF0, 0x7C,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0xF0, 0xFC, 0x1E, 0x7F,
  0xE3, 0xDF, 0xFE, 0x7F, 0x07, 0xEF, 0xC0, 0x3D, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xEF, 0xE0, 0xFD, 0xEF, 0xFF,
  0x3C, 0xFF, 0xC7, 0x87, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0xF1, 0xFF, 0xCE, 0x3F, 0xFE, 0xE3, 0xE0,
  0xEE, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x1E,
  0x78, 0x03, 0xE7, 0xC0, 0x7E, 0x3E, 0x0E, 0xE3, 0xFF, 0xCE, 0x1F, 0xF8,
  0xE0, 0x7F, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0xF0, 0x3F, 0xB8, 0x7F, 0xDC, 0x7F, 0xEF, 0x7F, 0xF7, 0xBC,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x3E, 0x03, 0xC7, 0x80, 0x3C, 0xE0, 0x03, 0x9C, 0x00, 0x03, 0x80, 0x00,
  0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x01, 0xEF, 0x80, 0x7C, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0,
  0x3F, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x83, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x04, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xC0, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xF7, 0xC1, 0xDE,
  0xFF, 0xF3, 0xCF, 0xFC, 0x78, 0x7F, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00,
  0x1E, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x7C, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC3,
  0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xE3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7,
  0x80, 0x00, 0xE7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x9E,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0xE0, 0x78, 0x1E, 0x3C, 0x1F, 0x07,
  0x8F, 0x0F, 0xC1, 0xC3, 0xC3, 0xF0, 0xF0, 0xF0, 0xEE, 0x3C, 0x1C, 0x73,
  0x8F, 0x07, 0x1C, 0xE3, 0xC1, 0xC7, 0x1C, 0xF0, 0x7B, 0x87, 0x38, 0x1E,
  0xE1, 0xCE, 0x07, 0xB8, 0x37, 0x81, 0xEC, 0x0F, 0xE0, 0x3F, 0x03, 0xF8,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x78, 0x00, 0x79, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x07, 0x80, 0x78,
  0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0x78, 0x78, 0x00, 0xF3, 0xC0, 0x01,
  0xEF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0x87, 0x80,
  0x1E, 0x1F, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0xF0,
  0x03, 0xE7, 0x80, 0x07, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0xF0, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1,
  0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xE7, 0x80, 0x00, 0xF7,
  0x80, 0x00, 0x77, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x07, 0xF0,
};

const GFXglyph LiberationMono_Regular44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 4, 29, 26, 11, -29 },
  { 16, 14, 14, 26, 6, -32 },
  { 41, 24, 29, 26, 1, -29 },
  { 128, 24, 35, 26, 1, -32 },
  { 233, 26, 29, 26, 0, -29 },
  { 328, 24, 29, 26, 1, -29 },
  { 415, 5, 14, 26, 11, -32 },
  { 424, 12, 41, 26, 7, -32 },
  { 486, 12, 41, 26, 7, -32 },
  { 548, 16, 15, 26, 5, -32 },
  { 578, 22, 21, 26, 2, -25 },
  { 636, 9, 14, 26, 6, -6 },
  { 652, 12, 3, 26, 7, -13 },
  { 657, 5, 6, 26, 11, -6 },
  { 661, 22, 32, 26, 2, -32 },
  { 749, 21, 29, 26, 3, -29 },
  { 826, 21, 29, 26, 3, -29 },
  { 903, 20, 29, 26, 3, -29 },
  { 976, 21, 29, 26, 3, -29 },
  { 1053, 22, 29, 26, 2, -29 },
  { 1133, 21, 29, 26, 3, -29 },
  { 1210, 21, 29, 26, 3, -29 },
  { 1287, 20, 29, 26, 3, -29 },
  { 1360, 21, 29, 26, 3, -29 },
  { 1437, 20, 29, 26, 3, -29 },
  { 1510, 5, 24, 26, 11, -24 },
  { 1525, 9, 32, 26, 8, -24 },
  { 1561, 22, 23, 26, 2, -26 },
  { 1625, 22, 15, 26, 2, -22 },
  { 1667, 22, 23, 26, 2, -26 },
  { 1731, 21, 29, 26, 2, -29 },
  { 1808, 25, 38, 26, 1, -32 },
  { 1927, 26, 29, 26, 0, -29 },
  { 2022, 22, 29, 26, 3, -29 },
  { 2102, 23, 29, 26, 2, -29 },
  { 2186, 21, 29, 26, 3, -29 },
  { 2263, 21, 29, 26, 3, -29 },
  { 2340, 19, 29, 26, 4, -29 },
  { 2409, 22, 29, 26, 2, -29 },
  { 2489, 20, 29, 26, 3, -29 },
  { 2562, 18, 29, 26, 4, -29 },
  { 2628, 17, 29, 26, 4, -29 },
  { 2690, 23, 29, 26, 3, -29 },
  { 2774, 19, 29, 26, 5, -29 },
  { 2843, 21, 29, 26, 3, -29 },
  { 2920, 20, 29, 26, 3, -29 },
  { 2993, 22, 29, 26, 2, -29 },
  { 3073, 21, 29, 26, 3, -29 },
  { 3150, 22, 37, 26, 2, -29 },
  { 3252, 22, 29, 26, 3, -29 },
  { 3332, 22, 29, 26, 2, -29 },
  { 3412, 23, 29, 26, 2, -29 },
  { 3496, 20, 29, 26, 3, -29 },
  { 3569, 26, 29, 26, 0, -29 },
  { 3664, 26, 29, 26, 0, -29 },
  { 3759, 25, 29, 26, 1, -29 },
  { 3850, 25, 29, 26, 1, -29 },
  { 3941, 23, 29, 26, 2, -29 },
  { 4025, 12, 41, 26, 9, -32 },
  { 4087, 22, 32, 26, 2, -32 },
  { 4175, 12, 41, 26, 6, -32 },
  { 4237, 21, 19, 26, 3, -29 },
  { 4287, 26, 2, 26, 0, 3 },
  { 4294, 9, 6, 26, 9, -32 },
  { 4301, 22, 24, 26, 3, -24 },
  { 4367, 19, 32, 26, 4, -32 },
  { 4443, 20, 24, 26, 3, -24 },
  { 4503, 20, 32, 26, 3, -32 },
  { 4583, 21, 24, 26, 3, -24 },
  { 4646, 21, 32, 26, 3, -32 },
  { 4730, 20, 33, 26, 3, -24 },
  { 4813, 19, 32, 26, 4, -32 },
  { 4889, 21, 32, 26, 3, -32 },
  { 4973, 15, 41, 26, 3, -32 },
  { 5050, 19, 32, 26, 5, -32 },
  { 5126, 21, 32, 26, 3, -32 },
  { 5210, 22, 24, 26, 2, -24 },
  { 5276, 19, 24, 26, 4, -24 },
  { 5333, 21, 24, 26, 3, -24 },
  { 5396, 19, 33, 26, 4, -24 },
  { 5475, 20, 33, 26, 3, -24 },
  { 5558, 17, 24, 26, 5, -24 },
  { 5609, 19, 24, 26, 4, -24 },
  { 5666, 18, 30, 26, 4, -30 },
  { 5734, 19, 24, 26, 4, -24 },
  { 5791, 24, 24, 26, 1, -24 },
  { 5863, 26, 24, 26, 0, -24 },
  { 5941, 22, 24, 26, 2, -24 },
  { 6007, 24, 33, 26, 1, -24 },
  { 6106, 20, 24, 26, 3, -24 },
  { 6166, 18, 41, 26, 5, -32 },
  { 6259, 4, 41, 26, 11, -32 },
  { 6280, 18, 41, 26, 4, -32 },
  { 6373, 22, 5, 26, 2, -17 },
};

const GFXfont LiberationMono_Regular44pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular44pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular44pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _LIBERATIONMONO_REGULAR44PT7B_H_
