#ifndef _LIBERATIONMONO_REGULAR24PT7B_H_
#define _LIBERATIONMONO_REGULAR24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xE3, 0xE3, 0xE3, 0xE3, 0x63, 0x63, 0x43,
  0x0C, 0x20, 0x41, 0x02, 0x18, 0x10, 0x81, 0x84, 0x7F, 0xFC, 0x43, 0x02,
  0x18, 0x10, 0x81, 0x84, 0x3F, 0xFC, 0x43, 0x02, 0x18, 0x30, 0x81, 0x84,
  0x08, 0x20, 0x02, 0x00, 0x20, 0x1F, 0xC7, 0xFE, 0x62, 0x76, 0x23, 0x62,
  0x07, 0x20, 0x3F, 0x00, 0xFC, 0x02, 0xF0, 0x23, 0x02, 0x30, 0x23, 0xC2,
  0x3E, 0x27, 0x7F, 0xE1, 0xFC, 0x02, 0x00, 0x20, 0x78, 0x1B, 0x30, 0x6C,
  0x63, 0x31, 0x98, 0xC6, 0x43, 0x1B, 0x04, 0xD8, 0x1E, 0x40, 0x03, 0x78,
  0x1B, 0x30, 0x4C, 0x43, 0x21, 0x18, 0x84, 0x43, 0x13, 0x0C, 0xD8, 0x1E,
  0x07, 0x80, 0x3F, 0x81, 0x86, 0x06, 0x18, 0x18, 0x40, 0x66, 0x00, 0xF0,
  0x0F, 0x06, 0x76, 0x11, 0x8C, 0xC6, 0x33, 0x30, 0x68, 0x60, 0xE1, 0xC3,
  0xC7, 0xFB, 0xC7, 0xC7, 0xDB, 0x6D, 0xB0, 0x0C, 0x63, 0x8C, 0x71, 0x86,
  0x38, 0xC3, 0x0C, 0x30, 0xC3, 0x0E, 0x18, 0x61, 0xC3, 0x0E, 0x18, 0x30,
  0xE1, 0x83, 0x0E, 0x18, 0x60, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x18, 0x63, 0x8C, 0x63, 0x80, 0x18, 0x18, 0xC9, 0xFF, 0x18, 0x3C, 0x26,
  0x62, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x39, 0x9C, 0xE6, 0x33, 0x18,
  0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x00, 0x0F, 0x83, 0xFC, 0x30, 0xE6, 0x06,
  0x60, 0x76, 0x03, 0xE7, 0x3E, 0x73, 0xE7, 0x3E, 0x03, 0x60, 0x36, 0x07,
  0x60, 0x63, 0x0E, 0x3F, 0xC0, 0xF8, 0x06, 0x01, 0xC0, 0xF8, 0x7B, 0x0C,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x3F, 0xFF, 0xFF, 0x1F, 0x0F, 0xF1, 0x87, 0x60, 0x6C, 0x0C, 0x01,
  0x80, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0xC0, 0x3F,
  0xFF, 0xFF, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0xF8, 0x0F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x60, 0x77, 0x06, 0x3F,
  0xE1, 0xF8, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x6C, 0x04, 0xC0, 0xCC, 0x18,
  0xC1, 0x0C, 0x30, 0xC6, 0x0C, 0x40, 0xCF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00,
  0xC0, 0x0C, 0x7F, 0xE7, 0xFE, 0x60, 0x06, 0x00, 0x60, 0x06, 0xF8, 0x7F,
  0xC7, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x60, 0x77, 0x0E, 0x3F,
  0xC1, 0xF8, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x6C, 0x01, 0x9E, 0x3F, 0xF7,
  0x8E, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x0E, 0xE3, 0x8F, 0xE0, 0xF8,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0x0F,
  0xF3, 0x87, 0x60, 0x6C, 0x0D, 0x81, 0x98, 0x71, 0xFC, 0x3F, 0x9C, 0x3B,
  0x03, 0xE0, 0x3C, 0x0F, 0xC1, 0x9F, 0xF1, 0xF8, 0x3F, 0x0F, 0xF3, 0x87,
  0x60, 0x6C, 0x0D, 0x81, 0xF0, 0x3F, 0x0F, 0x7F, 0x67, 0xDC, 0x03, 0x80,
  0x6C, 0x1D, 0xC3, 0x1F, 0xE1, 0xF0, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x39,
  0xCE, 0x70, 0x00, 0x00, 0x01, 0xCE, 0xE7, 0x31, 0x98, 0xC0, 0x00, 0x10,
  0x0F, 0x03, 0xE1, 0xF0, 0xFC, 0x0E, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0x00, 0x70, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x0C, 0x00, 0x1F, 0x83,
  0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x70, 0x06, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0F, 0x80,
  0xC3, 0x0C, 0x08, 0xC0, 0x64, 0x75, 0x66, 0xEF, 0x63, 0x72, 0x1B, 0x90,
  0xDD, 0x86, 0xEC, 0x27, 0x61, 0x3B, 0x19, 0x58, 0xCA, 0x4A, 0xD9, 0x9C,
  0x40, 0x03, 0x01, 0x0C, 0x30, 0x3F, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xB0, 0x0C, 0xC0, 0x33, 0x80, 0xC6, 0x06, 0x18, 0x18, 0x70, 0xE0,
  0xC3, 0xFF, 0x0F, 0xFE, 0x70, 0x19, 0x80, 0x66, 0x00, 0xF8, 0x03, 0xFF,
  0x0F, 0xFC, 0xC1, 0xCC, 0x0E, 0xC0, 0xEC, 0x0C, 0xC1, 0xCF, 0xF8, 0xFF,
  0xCC, 0x0E, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xFF, 0xCF, 0xF8, 0x0F,
  0x83, 0xFC, 0x38, 0xE7, 0x07, 0x60, 0x2E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x06, 0x03, 0x70, 0x33, 0x86, 0x1F, 0xE0, 0xF8, 0xFE,
  0x1F, 0xF3, 0x0F, 0x60, 0x6C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7C, 0x0D, 0x87, 0xBF, 0xE7, 0xF0, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xFE, 0xFF, 0xD8, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDC, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x0F, 0x83, 0xFC, 0x78, 0xE7, 0x07, 0x60,
  0x2E, 0x00, 0xE0, 0x0E, 0x00, 0xE3, 0xFE, 0x3F, 0x60, 0x36, 0x03, 0x70,
  0x33, 0x87, 0x1F, 0xF0, 0xF8, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x0F,
  0xC3, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1F, 0x07, 0xE1, 0x98, 0xE7, 0xF0, 0x78, 0xC0, 0xEC, 0x0C, 0xC1, 0x8C,
  0x30, 0xC7, 0x0C, 0xE0, 0xDC, 0x0D, 0xC0, 0xFE, 0x0E, 0x70, 0xC3, 0x0C,
  0x38, 0xC1, 0xCC, 0x0E, 0xC0, 0x6C, 0x07, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F, 0x87, 0xD8, 0xFB, 0x17, 0x66, 0xE6,
  0xDC, 0xD3, 0x9E, 0x71, 0xCE, 0x31, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x7D, 0x8F, 0xB1, 0xF6, 0x3E, 0x67,
  0xCC, 0xF8, 0xDF, 0x1B, 0xE1, 0xBC, 0x37, 0x83, 0xF0, 0x7E, 0x07, 0x0F,
  0x83, 0xFC, 0x70, 0xE6, 0x06, 0x60, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x36, 0x07, 0x60, 0x67, 0x0E, 0x3F, 0xC0, 0xF8, 0xFF,
  0x1F, 0xFB, 0x07, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x0E, 0xFF, 0xDF,
  0xE3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x0F, 0x83, 0xFC,
  0x70, 0xE6, 0x06, 0x60, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x36, 0x07, 0x60, 0x67, 0x0E, 0x3F, 0xC0, 0xF8, 0x03, 0x00, 0x30,
  0x03, 0x80, 0x1F, 0x00, 0xF0, 0xFF, 0x8F, 0xFC, 0xC0, 0xEC, 0x06, 0xC0,
  0x6C, 0x06, 0xC0, 0xEF, 0xFC, 0xFF, 0x0C, 0x70, 0xC3, 0x0C, 0x38, 0xC1,
  0xCC, 0x0C, 0xC0, 0xEC, 0x06, 0x1F, 0x83, 0xFE, 0x70, 0x66, 0x07, 0x60,
  0x06, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0x3C, 0x03, 0xE0,
  0x37, 0x07, 0x7F, 0xE1, 0xF8, 0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0D, 0xC3, 0x9F, 0xE1, 0xF8, 0xE0, 0x0D, 0x80, 0x76, 0x01, 0x9C, 0x06,
  0x30, 0x38, 0xC0, 0xC1, 0x83, 0x06, 0x1C, 0x18, 0x60, 0x31, 0x80, 0xCC,
  0x03, 0x30, 0x06, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x8C, 0x76, 0x39, 0x99, 0xE6, 0x66,
  0x99, 0x9A, 0x63, 0x4D, 0x8F, 0x36, 0x3C, 0x50, 0xF1, 0x43, 0x87, 0x0E,
  0x1C, 0x70, 0x18, 0xC0, 0xE1, 0x87, 0x07, 0x18, 0x0C, 0xE0, 0x1B, 0x00,
  0x78, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0xCC, 0x07, 0x18, 0x18, 0x70,
  0xC0, 0xC7, 0x01, 0x98, 0x07, 0x60, 0x1D, 0xC0, 0x63, 0x03, 0x06, 0x1C,
  0x1C, 0x60, 0x33, 0x80, 0x6C, 0x01, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x7F, 0xF3, 0xFF,
  0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F,
  0xFF, 0xC0, 0x0E, 0x03, 0xC0, 0x68, 0x09, 0x83, 0x30, 0x63, 0x18, 0x63,
  0x04, 0x40, 0xD8, 0x1B, 0x01, 0x80, 0xFF, 0xFC, 0xE3, 0x04, 0x1F, 0x81,
  0xFE, 0x1C, 0x30, 0x01, 0xC0, 0x06, 0x0F, 0xF1, 0xFF, 0x8E, 0x0C, 0x60,
  0xE7, 0x07, 0x18, 0x78, 0xFE, 0xF3, 0xE7, 0x80, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0xF1, 0xBF, 0xBC, 0x77, 0x06, 0xE0, 0xF8, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0xC1, 0xBC, 0x76, 0xFC, 0xCF, 0x00, 0x1F, 0x0F, 0xF3, 0x87,
  0x60, 0x7C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x1F, 0x87, 0x3F,
  0xC1, 0xF0, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x3E, 0xDF, 0xFE, 0x1F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1D, 0xFF, 0x3C, 0xC0,
  0x1F, 0x0F, 0xF3, 0x87, 0x60, 0x6C, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xC0,
  0x18, 0x1B, 0x87, 0x3F, 0xC1, 0xF0, 0x0F, 0xE3, 0xFC, 0x60, 0x0C, 0x0F,
  0xFF, 0xFF, 0xC6, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x3C, 0xDF, 0xFE, 0x1F, 0x07, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7E, 0x1D, 0xFF, 0x3C, 0xC0, 0x30,
  0x0D, 0x87, 0x7F, 0x8F, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCF, 0x37,
  0xFF, 0x1F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xC0, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x87,
  0xFF, 0xFF, 0xE0, 0x03, 0x81, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xE0, 0x6F, 0xF3, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC1, 0xB0, 0xEC,
  0x73, 0x38, 0xDC, 0x36, 0x0F, 0x83, 0xB0, 0xCE, 0x31, 0xCC, 0x33, 0x06,
  0xC1, 0xC0, 0x7E, 0x0F, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x87, 0xFF,
  0xFF, 0xE0, 0xDC, 0xEF, 0xFF, 0xE7, 0x3E, 0x63, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x30, 0xCF, 0xB7,
  0xFF, 0x1F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xC0, 0x1F, 0x0F, 0xF3, 0x87, 0x60, 0x6C, 0x0F, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x1B, 0x87, 0x3F, 0xC1, 0xF0, 0xCF, 0x1B, 0xFB,
  0xC7, 0x70, 0x6E, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xFC, 0x1B, 0xC7,
  0x6F, 0xEC, 0xF1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x3E, 0xDF,
  0xFE, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7E, 0x1D,
  0xFF, 0x3C, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xC7, 0xEF, 0xF6,
  0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00,
  0x1F, 0x1F, 0xF6, 0x0F, 0x00, 0x60, 0x1F, 0x01, 0xF8, 0x0F, 0x00, 0xF0,
  0x3E, 0x0D, 0xFF, 0x3F, 0x00, 0x10, 0x04, 0x03, 0x03, 0xFE, 0xFF, 0x8C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xFC,
  0x3F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3E, 0x1D, 0xFF, 0x3E, 0xC0, 0xC0, 0x37, 0x01, 0x98, 0x1C, 0xC0,
  0xC3, 0x06, 0x18, 0x60, 0xE3, 0x03, 0x38, 0x19, 0x80, 0x6C, 0x03, 0xC0,
  0x1E, 0x00, 0x70, 0x00, 0xC0, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x03, 0x63,
  0x19, 0x8E, 0x66, 0x69, 0x99, 0xA6, 0x34, 0xD8, 0xF3, 0x63, 0xC5, 0x0E,
  0x1C, 0x38, 0x70, 0x60, 0x77, 0x06, 0x30, 0xC1, 0x98, 0x0D, 0x80, 0xF0,
  0x07, 0x00, 0xF0, 0x1D, 0x81, 0x9C, 0x30, 0xC6, 0x06, 0xE0, 0x30, 0xC0,
  0x37, 0x01, 0x98, 0x1C, 0xC0, 0xC3, 0x06, 0x18, 0x60, 0x63, 0x03, 0x18,
  0x19, 0x80, 0x6C, 0x03, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x03,
  0x80, 0x78, 0x03, 0x80, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0x01, 0xC0, 0x70,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x7F, 0xFF, 0xFE, 0x0F,
  0x8F, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x38, 0x1C,
  0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xF8, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3F, 0x00, 0xC0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x3C, 0x0F, 0x07, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0xFC, 0x3E, 0x00, 0x78, 0x0F,
  0xF1, 0xC7, 0xF0, 0x1E,
};

const GFXglyph LiberationMono_Regular24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 2, 16, 14, 6, -16 },
  { 5, 8, 7, 14, 3, -17 },
  { 12, 13, 16, 14, 1, -16 },
  { 38, 12, 20, 14, 1, -18 },
  { 68, 14, 16, 14, 0, -16 },
  { 96, 14, 16, 14, 0, -16 },
  { 124, 3, 7, 14, 6, -17 },
  { 127, 6, 22, 14, 4, -17 },
  { 144, 6, 22, 14, 4, -17 },
  { 161, 8, 8, 14, 3, -17 },
  { 169, 12, 12, 14, 1, -14 },
  { 187, 5, 8, 14, 3, -4 },
  { 192, 6, 2, 14, 4, -7 },
  { 194, 3, 4, 14, 6, -4 },
  { 196, 12, 17, 14, 1, -17 },
  { 222, 12, 16, 14, 1, -16 },
  { 246, 11, 16, 14, 2, -16 },
  { 268, 11, 16, 14, 2, -16 },
  { 290, 12, 16, 14, 1, -16 },
  { 314, 12, 16, 14, 1, -16 },
  { 338, 12, 16, 14, 1, -16 },
  { 362, 11, 16, 14, 2, -16 },
  { 384, 11, 16, 14, 2, -16 },
  { 406, 11, 16, 14, 2, -16 },
  { 428, 11, 16, 14, 2, -16 },
  { 450, 3, 13, 14, 6, -13 },
  { 455, 5, 17, 14, 4, -13 },
  { 466, 12, 12, 14, 1, -14 },
  { 484, 12, 8, 14, 1, -12 },
  { 496, 12, 12, 14, 1, -14 },
  { 514, 12, 16, 14, 1, -16 },
  { 538, 13, 20, 14, 1, -17 },
  { 571, 14, 16, 14, 0, -16 },
  { 599, 12, 16, 14, 2, -16 },
  { 623, 12, 16, 14, 1, -16 },
  { 647, 11, 16, 14, 2, -16 },
  { 669, 11, 16, 14, 2, -16 },
  { 691, 11, 16, 14, 2, -16 },
  { 713, 12, 16, 14, 1, -16 },
  { 737, 11, 16, 14, 2, -16 },
  { 759, 10, 16, 14, 2, -16 },
  { 779, 10, 16, 14, 2, -16 },
  { 799, 12, 16, 14, 2, -16 },
  { 823, 10, 16, 14, 3, -16 },
  { 843, 11, 16, 14, 2, -16 },
  { 865, 11, 16, 14, 2, -16 },
  { 887, 12, 16, 14, 1, -16 },
  { 911, 11, 16, 14, 2, -16 },
  { 933, 12, 21, 14, 1, -16 },
  { 965, 12, 16, 14, 2, -16 },
  { 989, 12, 16, 14, 1, -16 },
  { 1013, 13, 16, 14, 1, -16 },
  { 1039, 11, 16, 14, 2, -16 },
  { 1061, 14, 16, 14, 0, -16 },
  { 1089, 14, 16, 14, 0, -16 },
  { 1117, 14, 16, 14, 0, -16 },
  { 1145, 14, 16, 14, 0, -16 },
  { 1173, 13, 16, 14, 1, -16 },
  { 1199, 6, 22, 14, 5, -17 },
  { 1216, 12, 17, 14, 1, -17 },
  { 1242, 7, 22, 14, 3, -17 },
  { 1262, 11, 11, 14, 2, -16 },
  { 1278, 14, 1, 14, 0, 1 },
  { 1280, 5, 3, 14, 5, -17 },
  { 1282, 13, 13, 14, 1, -13 },
  { 1304, 11, 17, 14, 2, -17 },
  { 1328, 11, 13, 14, 2, -13 },
  { 1346, 10, 17, 14, 2, -17 },
  { 1368, 11, 13, 14, 2, -13 },
  { 1386, 11, 17, 14, 2, -17 },
  { 1410, 10, 18, 14, 2, -13 },
  { 1433, 10, 17, 14, 2, -17 },
  { 1455, 11, 17, 14, 2, -17 },
  { 1479, 9, 22, 14, 1, -17 },
  { 1504, 10, 17, 14, 3, -17 },
  { 1526, 11, 17, 14, 2, -17 },
  { 1550, 12, 13, 14, 1, -13 },
  { 1570, 10, 13, 14, 2, -13 },
  { 1587, 11, 13, 14, 2, -13 },
  { 1605, 11, 18, 14, 2, -13 },
  { 1630, 10, 18, 14, 2, -13 },
  { 1653, 9, 13, 14, 3, -13 },
  { 1668, 10, 13, 14, 2, -13 },
  { 1685, 10, 16, 14, 2, -16 },
  { 1705, 10, 13, 14, 2, -13 },
  { 1722, 13, 13, 14, 1, -13 },
  { 1744, 14, 13, 14, 0, -13 },
  { 1767, 12, 13, 14, 1, -13 },
  { 1787, 13, 18, 14, 1, -13 },
  { 1817, 11, 13, 14, 2, -13 },
  { 1835, 9, 22, 14, 3, -17 },
  { 1860, 2, 22, 14, 6, -17 },
  { 1866, 10, 22, 14, 2, -17 },
  { 1894, 12, 4, 14, 1, -10 },
};

const GFXfont LiberationMono_Regular24pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular24pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular24pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _LIBERATIONMONO_REGULAR24PT7B_H_
