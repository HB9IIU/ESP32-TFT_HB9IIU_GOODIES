#ifndef _LIBERATIONMONO_REGULAR16PT7B_H_
#define _LIBERATIONMONO_REGULAR16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xA8, 0x3C, 0xCE, 0x73, 0x9C, 0x80, 0x11, 0x08, 0x84, 0x4F,
  0xF1, 0x21, 0x10, 0x89, 0xFF, 0x22, 0x12, 0x11, 0x00, 0x10, 0x7C, 0xD2,
  0x93, 0x90, 0x50, 0x3C, 0x16, 0x11, 0x91, 0xD3, 0x7E, 0x10, 0x70, 0xA4,
  0x49, 0x22, 0x48, 0x74, 0x02, 0x00, 0xB8, 0x53, 0x24, 0xC9, 0x24, 0x38,
  0x1C, 0x19, 0x08, 0x84, 0xC1, 0x83, 0x89, 0x25, 0x92, 0xC6, 0x23, 0x8F,
  0x60, 0xFE, 0x80, 0x36, 0x4C, 0xC8, 0x88, 0x88, 0xCC, 0x46, 0x30, 0xC4,
  0x62, 0x33, 0x33, 0x33, 0x32, 0x64, 0xC0, 0x22, 0x8E, 0x8C, 0x31, 0x44,
  0x80, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x6D, 0x40, 0xF0, 0xF0,
  0x02, 0x02, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0,
  0x3C, 0x46, 0xC2, 0xC2, 0x83, 0x9B, 0x9B, 0xC2, 0xC2, 0x46, 0x3C, 0x18,
  0x38, 0xC8, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x3C, 0x8F,
  0x08, 0x10, 0x61, 0x86, 0x18, 0x61, 0x83, 0xF8, 0x3C, 0x46, 0xC2, 0x02,
  0x06, 0x18, 0x06, 0x03, 0xC3, 0xC6, 0x3C, 0x0C, 0x0C, 0x14, 0x34, 0x24,
  0x44, 0x84, 0xFF, 0x04, 0x04, 0x04, 0x7E, 0x40, 0x40, 0xC0, 0xFC, 0xC6,
  0x02, 0x03, 0xC2, 0xC6, 0x3C, 0x3C, 0x62, 0x40, 0xC0, 0xFC, 0xC6, 0xC2,
  0xC3, 0x42, 0x66, 0x3C, 0xFE, 0x04, 0x10, 0x60, 0x83, 0x04, 0x08, 0x30,
  0x60, 0xC0, 0x38, 0x46, 0xC2, 0xC2, 0x46, 0x38, 0x46, 0xC3, 0xC2, 0x42,
  0x3C, 0x3C, 0x46, 0xC2, 0xC2, 0xC2, 0x46, 0x3A, 0x02, 0x02, 0xC4, 0x78,
  0xF0, 0x03, 0xC0, 0x6C, 0x00, 0x03, 0x5A, 0x00, 0x03, 0x0C, 0x70, 0x80,
  0x70, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0x0E,
  0x70, 0x80, 0x3D, 0x8E, 0x08, 0x10, 0xC3, 0x04, 0x00, 0x00, 0x60, 0xC0,
  0x1E, 0x10, 0x88, 0x29, 0xB5, 0x2A, 0x96, 0x8B, 0x45, 0xA2, 0xD3, 0x59,
  0xAB, 0x64, 0x01, 0x08, 0x78, 0x0C, 0x07, 0x01, 0x60, 0x48, 0x32, 0x08,
  0xC2, 0x31, 0xFC, 0x41, 0x90, 0x2C, 0x08, 0xFC, 0xC6, 0xC2, 0xC2, 0xC6,
  0xFC, 0xC2, 0xC3, 0xC3, 0xC3, 0xFC, 0x3C, 0x66, 0xC3, 0xC0, 0x80, 0x80,
  0x80, 0xC0, 0xC3, 0x62, 0x3C, 0xF8, 0xC6, 0xC2, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC2, 0xC6, 0xF8, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x08, 0x00,
  0x3C, 0x66, 0xC3, 0xC0, 0x80, 0x8F, 0x83, 0xC3, 0xC3, 0x63, 0x3C, 0xC3,
  0x87, 0x0E, 0x1C, 0x3F, 0xF0, 0xE1, 0xC3, 0x87, 0x08, 0xFC, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xC0, 0x1E, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0xC6, 0x88, 0xE0, 0xC3, 0x63, 0x33, 0x19, 0x0D, 0x07, 0xC3, 0x21,
  0x88, 0xC6, 0x61, 0xB0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x03, 0xF8, 0xC3, 0xC7, 0xA7, 0xA7, 0xAB, 0x9B, 0x9B, 0x83, 0x83,
  0x83, 0x83, 0xC3, 0x47, 0x8F, 0x1D, 0x3A, 0x72, 0xE5, 0xCF, 0x8F, 0x18,
  0x3C, 0x46, 0xC2, 0xC3, 0x83, 0x83, 0x83, 0xC3, 0xC2, 0x46, 0x3C, 0xFC,
  0xC2, 0xC3, 0xC3, 0xC2, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3C, 0x46,
  0xC2, 0xC3, 0x83, 0x83, 0x83, 0xC3, 0xC2, 0x46, 0x3C, 0x18, 0x0C, 0x07,
  0xFC, 0xC2, 0xC3, 0xC3, 0xC2, 0xFC, 0xC8, 0xCC, 0xC6, 0xC2, 0xC3, 0x7C,
  0xC6, 0xC3, 0xC0, 0x70, 0x3E, 0x06, 0x03, 0x83, 0xC2, 0x7C, 0xFF, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC2, 0x8C, 0xF0, 0xC0, 0x90, 0x66, 0x19, 0x84,
  0x23, 0x0C, 0xC3, 0x20, 0x58, 0x14, 0x07, 0x00, 0xC0, 0xC0, 0xF0, 0x2C,
  0x09, 0x32, 0x4C, 0x93, 0x65, 0x59, 0x5C, 0x53, 0x1C, 0xC2, 0x30, 0x61,
  0x91, 0x8C, 0x82, 0xC0, 0xC0, 0x60, 0x70, 0x24, 0x23, 0x30, 0x90, 0x60,
  0x41, 0xB0, 0x88, 0xC6, 0x41, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0xFF, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x60, 0x40, 0xC0, 0xFF,
  0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0xF1, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0xF0, 0x18, 0x28, 0x2C, 0x24, 0x44, 0x42, 0x82, 0xFF,
  0xC0, 0xCC, 0x80, 0x7C, 0xC6, 0x06, 0x06, 0x7E, 0xC6, 0x86, 0xCE, 0x73,
  0xC0, 0xC0, 0xC0, 0xDC, 0xE6, 0xC2, 0xC2, 0xC3, 0xC2, 0xC2, 0xE6, 0xDC,
  0x3C, 0x87, 0x06, 0x0C, 0x18, 0x30, 0x21, 0x3C, 0x02, 0x04, 0x0B, 0xD4,
  0x78, 0x70, 0xE1, 0xC3, 0x8D, 0x1B, 0xD0, 0x3C, 0x46, 0xC2, 0xC2, 0xFF,
  0xC0, 0xC0, 0x42, 0x3C, 0x1F, 0x30, 0x30, 0xFE, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x7A, 0x8F, 0x1E, 0x1C, 0x38, 0x71, 0xA3, 0x7A,
  0x05, 0x19, 0xE0, 0xC1, 0x83, 0x06, 0xEE, 0x78, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x10, 0x18, 0x18, 0x00, 0x78, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0x0C, 0x30, 0x1F, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x08,
  0x2F, 0x00, 0x81, 0x02, 0x04, 0x28, 0x92, 0x2C, 0x78, 0x91, 0x32, 0x34,
  0x20, 0x78, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0xB6, 0xDB, 0x9B, 0x93, 0x93, 0x93, 0x93, 0x93, 0x93, 0xDD, 0xCF,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC2, 0x3C, 0x46, 0xC2, 0xC3, 0xC3, 0xC3,
  0xC2, 0x46, 0x3C, 0xDC, 0xE6, 0xC2, 0xC2, 0xC3, 0xC2, 0xC2, 0xE6, 0xDC,
  0xC0, 0xC0, 0xC0, 0x7A, 0x8F, 0x0E, 0x1C, 0x38, 0x71, 0xA3, 0x7A, 0x04,
  0x08, 0x10, 0x9F, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x3C, 0x85, 0x03,
  0x03, 0xC0, 0xC0, 0xE1, 0x7C, 0x20, 0x43, 0xF9, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x78, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xA3, 0x7A, 0x83,
  0xC2, 0xC2, 0x46, 0x64, 0x2C, 0x2C, 0x38, 0x18, 0xC0, 0xE0, 0x50, 0x29,
  0x94, 0xDA, 0xAD, 0x4C, 0xE6, 0x23, 0x00, 0xC2, 0x46, 0x2C, 0x38, 0x18,
  0x38, 0x64, 0x46, 0xC3, 0x83, 0xC2, 0x42, 0x46, 0x64, 0x24, 0x28, 0x18,
  0x18, 0x10, 0x30, 0xE0, 0xFE, 0x0C, 0x30, 0x41, 0x06, 0x18, 0x20, 0xFE,
  0x1C, 0xC2, 0x08, 0x20, 0x86, 0x20, 0x60, 0x82, 0x08, 0x20, 0xC1, 0xC0,
  0xFF, 0xFE, 0xF0, 0x30, 0x60, 0xC1, 0x83, 0x02, 0x03, 0x08, 0x30, 0x60,
  0xC1, 0x83, 0x3C, 0x00, 0xF1, 0x0F,
};

const GFXglyph LiberationMono_Regular16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 11, 10, 4, -11 },
  { 4, 5, 5, 10, 2, -12 },
  { 8, 9, 11, 10, 0, -11 },
  { 21, 8, 13, 10, 1, -12 },
  { 34, 10, 11, 10, 0, -11 },
  { 48, 9, 11, 10, 0, -11 },
  { 61, 2, 5, 10, 4, -12 },
  { 63, 4, 15, 10, 3, -12 },
  { 71, 4, 15, 10, 3, -12 },
  { 79, 6, 7, 10, 2, -12 },
  { 85, 8, 7, 10, 1, -9 },
  { 92, 3, 4, 10, 2, -2 },
  { 94, 4, 1, 10, 3, -5 },
  { 95, 2, 2, 10, 4, -2 },
  { 96, 8, 12, 10, 1, -12 },
  { 108, 8, 11, 10, 1, -11 },
  { 119, 8, 11, 10, 1, -11 },
  { 130, 7, 11, 10, 1, -11 },
  { 140, 8, 11, 10, 1, -11 },
  { 151, 8, 11, 10, 1, -11 },
  { 162, 8, 11, 10, 1, -11 },
  { 173, 8, 11, 10, 1, -11 },
  { 184, 7, 11, 10, 1, -11 },
  { 194, 8, 11, 10, 1, -11 },
  { 205, 8, 11, 10, 1, -11 },
  { 216, 2, 9, 10, 4, -9 },
  { 219, 3, 11, 10, 3, -9 },
  { 224, 8, 7, 10, 1, -9 },
  { 231, 8, 4, 10, 1, -7 },
  { 235, 8, 7, 10, 1, -9 },
  { 242, 7, 11, 10, 1, -11 },
  { 252, 9, 15, 10, 0, -12 },
  { 269, 10, 11, 10, 0, -11 },
  { 283, 8, 11, 10, 1, -11 },
  { 294, 8, 11, 10, 1, -11 },
  { 305, 8, 11, 10, 1, -11 },
  { 316, 8, 11, 10, 1, -11 },
  { 327, 6, 11, 10, 2, -11 },
  { 336, 8, 11, 10, 1, -11 },
  { 347, 7, 11, 10, 1, -11 },
  { 357, 6, 11, 10, 2, -11 },
  { 366, 7, 11, 10, 1, -11 },
  { 376, 9, 11, 10, 1, -11 },
  { 389, 7, 11, 10, 2, -11 },
  { 399, 8, 11, 10, 1, -11 },
  { 410, 7, 11, 10, 1, -11 },
  { 420, 8, 11, 10, 1, -11 },
  { 431, 8, 11, 10, 1, -11 },
  { 442, 8, 14, 10, 1, -11 },
  { 456, 8, 11, 10, 1, -11 },
  { 467, 8, 11, 10, 1, -11 },
  { 478, 8, 11, 10, 1, -11 },
  { 489, 7, 11, 10, 1, -11 },
  { 499, 10, 11, 10, 0, -11 },
  { 513, 10, 11, 10, 0, -11 },
  { 527, 9, 11, 10, 0, -11 },
  { 540, 9, 11, 10, 0, -11 },
  { 553, 8, 11, 10, 1, -11 },
  { 564, 4, 15, 10, 3, -12 },
  { 572, 8, 12, 10, 1, -12 },
  { 584, 4, 15, 10, 2, -12 },
  { 592, 8, 7, 10, 1, -11 },
  { 599, 10, 1, 10, 0, 1 },
  { 601, 3, 3, 10, 3, -13 },
  { 603, 8, 9, 10, 1, -9 },
  { 612, 8, 12, 10, 1, -12 },
  { 624, 7, 9, 10, 1, -9 },
  { 632, 7, 12, 10, 1, -12 },
  { 643, 8, 9, 10, 1, -9 },
  { 652, 8, 12, 10, 1, -12 },
  { 664, 7, 12, 10, 1, -9 },
  { 675, 7, 12, 10, 1, -12 },
  { 686, 8, 12, 10, 1, -12 },
  { 698, 6, 15, 10, 1, -12 },
  { 710, 7, 12, 10, 2, -12 },
  { 721, 8, 12, 10, 1, -12 },
  { 733, 8, 9, 10, 1, -9 },
  { 742, 7, 9, 10, 1, -9 },
  { 750, 8, 9, 10, 1, -9 },
  { 759, 8, 12, 10, 1, -9 },
  { 771, 7, 12, 10, 1, -9 },
  { 782, 6, 9, 10, 2, -9 },
  { 789, 7, 9, 10, 1, -9 },
  { 797, 7, 11, 10, 1, -11 },
  { 807, 7, 9, 10, 1, -9 },
  { 815, 8, 9, 10, 1, -9 },
  { 824, 9, 9, 10, 0, -9 },
  { 835, 8, 9, 10, 1, -9 },
  { 844, 8, 12, 10, 1, -9 },
  { 856, 7, 9, 10, 1, -9 },
  { 864, 6, 15, 10, 2, -12 },
  { 876, 1, 15, 10, 4, -12 },
  { 878, 7, 15, 10, 1, -12 },
  { 892, 8, 2, 10, 1, -6 },
};

const GFXfont LiberationMono_Regular16pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular16pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular16pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _LIBERATIONMONO_REGULAR16PT7B_H_
