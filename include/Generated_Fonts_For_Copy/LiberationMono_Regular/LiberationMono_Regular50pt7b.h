#ifndef _LIBERATIONMONO_REGULAR50PT7B_H_
#define _LIBERATIONMONO_REGULAR50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0x70, 0x1E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x1C,
  0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x18,
  0x03, 0x80, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x38, 0x00,
  0x70, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x0F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x38, 0x03, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x70,
  0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x00, 0x70, 0x00, 0xE0,
  0x0E, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFC, 0x39, 0xFC, 0x7E, 0x0E, 0x1F, 0x1F,
  0x03, 0x83, 0xE7, 0x80, 0xE0, 0x79, 0xE0, 0x38, 0x1C, 0x7C, 0x0E, 0x00,
  0x0F, 0x03, 0x80, 0x03, 0xE0, 0xE0, 0x00, 0x7F, 0x38, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0x8F, 0xE0, 0x00, 0xE0, 0xF8, 0x00, 0x38, 0x1F,
  0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80, 0xF3, 0x00, 0xE0, 0x3F, 0xC0, 0x38,
  0x0F, 0xF8, 0x0E, 0x07, 0xFE, 0x03, 0x81, 0xF7, 0xE0, 0xE0, 0xF9, 0xFE,
  0x38, 0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0xFF, 0xC0, 0x03, 0x87,
  0xFF, 0x80, 0x1C, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x3C, 0x07, 0x83, 0xC0,
  0xF0, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0x3C,
  0x1C, 0x03, 0xC0, 0xF0, 0xF0, 0x0F, 0x03, 0xC7, 0x80, 0x3C, 0x0F, 0x1C,
  0x00, 0x70, 0x38, 0xF0, 0x01, 0xE1, 0xE7, 0x80, 0x07, 0xFF, 0x1C, 0x00,
  0x0F, 0xFC, 0xF0, 0x00, 0x0F, 0xC7, 0x8F, 0xC0, 0x00, 0x1C, 0xFF, 0xC0,
  0x00, 0xE7, 0xFF, 0x80, 0x07, 0x9E, 0x1E, 0x00, 0x3C, 0xF0, 0x3C, 0x00,
  0xE3, 0xC0, 0xF0, 0x07, 0x8F, 0x03, 0xC0, 0x3C, 0x3C, 0x0F, 0x00, 0xE0,
  0xF0, 0x3C, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x3C,
  0x0F, 0x07, 0x80, 0x70, 0x38, 0x3C, 0x01, 0xE1, 0xE0, 0xE0, 0x03, 0xFF,
  0x07, 0x00, 0x0F, 0xFC, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC0,
  0x78, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xC0,
  0x07, 0x80, 0x38, 0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x3C,
  0x3F, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x20, 0x0F, 0xF0, 0x07, 0x81, 0xF7, 0x80, 0x78, 0x3E,
  0x78, 0x07, 0x87, 0xC3, 0xC0, 0x70, 0x78, 0x3E, 0x0F, 0x07, 0x81, 0xF0,
  0xF0, 0xF0, 0x0F, 0x0E, 0x0F, 0x00, 0xF9, 0xE0, 0xF0, 0x07, 0xDE, 0x0F,
  0x00, 0x3F, 0xC0, 0xF0, 0x01, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0x78, 0x00,
  0xFC, 0x07, 0xC0, 0x1F, 0xE0, 0x3F, 0x07, 0xFF, 0xB1, 0xFF, 0xFC, 0xFF,
  0x0F, 0xFF, 0x07, 0xF0, 0x3F, 0xC0, 0x1E, 0xFF, 0xFF, 0xFF, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x78, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x40, 0xC0,
  0x9C, 0x30, 0xEF, 0xCD, 0xFD, 0xFF, 0xFE, 0x0F, 0xFC, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0x38, 0x03, 0x87, 0x01, 0xE1, 0xE0, 0x70,
  0x38, 0x0C, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0x81, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F,
  0xF0, 0x7E, 0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xDE, 0x00,
  0xFF, 0x9E, 0x00, 0xFF, 0x1E, 0x00, 0xFC, 0x1E, 0x00, 0xE0, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x03, 0xF9, 0xF0,
  0x03, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x81, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0xF1,
  0xF0, 0x00, 0xE1, 0xF0, 0x01, 0xE1, 0xF0, 0x03, 0xC1, 0xF0, 0x03, 0x81,
  0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x1C, 0x01,
  0xF0, 0x3C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x70, 0x01, 0xF0, 0xF0, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x7F, 0x00, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0x01, 0xFC, 0x7C, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0x3F, 0x81,
  0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x81, 0xF8, 0x3F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x1F, 0x3E, 0x00, 0x38,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x83, 0xF8, 0x0F,
  0x1F, 0xFC, 0x1E, 0x7F, 0xFE, 0x3D, 0xFF, 0xFC, 0x7F, 0xC1, 0xFC, 0xFE,
  0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x78, 0x00,
  0x3C, 0xF8, 0x00, 0x79, 0xF0, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xF8, 0x3F,
  0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x81,
  0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x3F, 0x81, 0xFC, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x78, 0x00,
  0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7F, 0x80, 0xFC, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0x83,
  0xF8, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x78, 0x00,
  0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x3F, 0x81,
  0xFF, 0x1F, 0xFF, 0xDE, 0x0F, 0xFF, 0x9E, 0x07, 0xFF, 0x1E, 0x01, 0xFC,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3F, 0x03,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x87,
  0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x3F, 0x80, 0xFE, 0x3E, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C,
  0x1E, 0x00, 0x01, 0xE1, 0xC0, 0xF8, 0x0E, 0x38, 0x1F, 0xCE, 0xE3, 0x83,
  0xFE, 0xEE, 0x78, 0x78, 0xEC, 0x77, 0x0F, 0x07, 0xC7, 0x70, 0xE0, 0x3C,
  0x77, 0x1E, 0x03, 0xC7, 0x71, 0xC0, 0x3C, 0x7F, 0x1C, 0x03, 0x87, 0xE3,
  0xC0, 0x38, 0x7E, 0x38, 0x03, 0x87, 0xE3, 0x80, 0x78, 0x7E, 0x38, 0x07,
  0x87, 0xE3, 0x80, 0x70, 0x7E, 0x38, 0x07, 0x07, 0xE3, 0x80, 0x70, 0xEE,
  0x38, 0x0F, 0x0E, 0xE3, 0x80, 0xF0, 0xEE, 0x38, 0x1F, 0x0E, 0xF3, 0xC1,
  0xF1, 0xC7, 0x1E, 0x77, 0x3C, 0x71, 0xFF, 0x7F, 0x87, 0x0F, 0xE3, 0xF0,
  0x38, 0x78, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x20, 0x1E, 0x00, 0x07, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x03,
  0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF1,
  0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x7C, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xF8, 0x03, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xFC,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3E, 0xF8, 0x01, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x03,
  0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x04, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x04,
  0x3E, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x03,
  0xF0, 0xF8, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x80, 0xFF, 0x1F, 0x00,
  0x7F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xE0,
  0x03, 0xE7, 0xC0, 0x1F, 0xCF, 0x80, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xC0, 0xFC,
  0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x08,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x38, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1E, 0x7E, 0x03,
  0xE3, 0xF0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F,
  0xC0, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC3, 0xE0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xDF, 0x00, 0x0F,
  0xF7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x03, 0xE0,
  0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x3E, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F,
  0xC0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xF7, 0x00,
  0xEF, 0xF7, 0x81, 0xEF, 0xF7, 0x81, 0xEF, 0xF3, 0xC1, 0xCF, 0xF3, 0xC3,
  0xCF, 0xF3, 0xC3, 0xCF, 0xF1, 0xE3, 0x8F, 0xF1, 0xE7, 0x8F, 0xF1, 0xE7,
  0x8F, 0xF0, 0xF7, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E,
  0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFD, 0xE0, 0x0F, 0xF7, 0x80, 0x3F, 0xCF, 0x00, 0xFF, 0x3C,
  0x03, 0xFC, 0x78, 0x0F, 0xF1, 0xE0, 0x3F, 0xC7, 0xC0, 0xFF, 0x0F, 0x03,
  0xFC, 0x3E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x03, 0xC3, 0xFC,
  0x0F, 0x0F, 0xF0, 0x1E, 0x3F, 0xC0, 0x78, 0xFF, 0x00, 0xF3, 0xFC, 0x03,
  0xCF, 0xF0, 0x0F, 0xBF, 0xC0, 0x1E, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xE0, 0x00,
  0x3E, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0x8F,
  0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xFC, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xCF, 0x80, 0x3F, 0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0x7C,
  0x00, 0x7E, 0xF8, 0x03, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0x9F, 0x00, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x3E, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F,
  0x80, 0x1F, 0xC7, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9F, 0x00, 0x07,
  0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x07, 0xF1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xCE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7B, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xE3, 0xF8, 0x07, 0xF0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00,
  0x1E, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF3, 0xE0, 0x07,
  0xC7, 0xE0, 0x3F, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xE0, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9F, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x78, 0x0F,
  0x0F, 0x03, 0xF0, 0x3C, 0x3C, 0x0F, 0xC0, 0xF0, 0xF0, 0x3F, 0x03, 0xC3,
  0xC0, 0xFC, 0x0F, 0x0F, 0x87, 0xF8, 0x7C, 0x1E, 0x1E, 0xE1, 0xE0, 0x78,
  0x73, 0x87, 0x81, 0xE1, 0xCE, 0x1E, 0x07, 0x8F, 0x3C, 0x78, 0x1E, 0x3C,
  0xF1, 0xE0, 0x78, 0xE1, 0xC7, 0x80, 0xE3, 0x87, 0x1E, 0x03, 0xDE, 0x1E,
  0xF0, 0x0F, 0x78, 0x3B, 0xC0, 0x3D, 0xC0, 0xEF, 0x00, 0xF7, 0x03, 0xBC,
  0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7C,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xC0, 0x3C, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x00,
  0xF0, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xE7, 0x00,
  0x01, 0xE7, 0x80, 0x01, 0xC3, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0x83, 0xC0,
  0x07, 0x81, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x38,
  0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x0F, 0x01, 0xF0,
  0x07, 0xC1, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFE, 0x01, 0xE0, 0xFC, 0x00, 0xF0, 0x7C, 0x00, 0x78,
  0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xF0, 0xF8, 0x06, 0xF8, 0x7E, 0x0F,
  0x7C, 0x1F, 0xFF, 0x1F, 0xC7, 0xFF, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x7E, 0x01, 0xE3, 0xFF, 0x03, 0xDF, 0xFF, 0x07, 0xB8, 0x3F,
  0x0F, 0xE0, 0x1F, 0x1F, 0x80, 0x1E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xEF,
  0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0,
  0x00, 0x7D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x80,
  0x0F, 0x9F, 0x00, 0x1F, 0x7F, 0x00, 0x7C, 0xFE, 0x00, 0xF9, 0xFF, 0x07,
  0xE3, 0xEF, 0xFF, 0x87, 0xCF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x0F, 0xC1, 0xF0, 0x07,
  0xC7, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xCF, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x81, 0xF8, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xF8, 0x78,
  0x1F, 0xFC, 0xF0, 0x7F, 0xFD, 0xE1, 0xF8, 0x3B, 0xC7, 0xC0, 0x1F, 0x8F,
  0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xBE, 0x00,
  0x0F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x79, 0xE0, 0x00,
  0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F,
  0x1E, 0x00, 0x7E, 0x3E, 0x01, 0xFC, 0x3F, 0x07, 0x78, 0x7F, 0xFE, 0xF8,
  0x3F, 0xF1, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x18,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0xC1, 0xFC, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x7C,
  0x3F, 0xFE, 0xF8, 0xFC, 0x1D, 0xF3, 0xE0, 0x1F, 0xE7, 0xC0, 0x1F, 0xDF,
  0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0,
  0x00, 0xFB, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00,
  0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xE7, 0x80, 0x1F, 0xCF, 0x80, 0x7F,
  0x8F, 0xC1, 0xDF, 0x1F, 0xFF, 0x3E, 0x1F, 0xFC, 0x7C, 0x0F, 0xE0, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x0F, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x83, 0xF8, 0x3C, 0x7F, 0xF1, 0xE7, 0xFF,
  0xCF, 0x70, 0x7E, 0x7F, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x1E, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xA0, 0x1F, 0xDF,
  0xFF, 0xCF, 0xFF, 0x83, 0xFF, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x7D, 0xE0,
  0x07, 0xCF, 0x00, 0x7E, 0x78, 0x03, 0xE3, 0xC0, 0x3E, 0x1E, 0x03, 0xE0,
  0xF0, 0x3E, 0x07, 0x83, 0xE0, 0x3C, 0x3E, 0x01, 0xE3, 0xE0, 0x0F, 0x3E,
  0x00, 0x7B, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFE, 0xF8, 0x07,
  0xC7, 0xC0, 0x3C, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xF0, 0x78, 0x0F,
  0xC3, 0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0xF0, 0x03, 0xE7, 0x80, 0x1F, 0xBC,
  0x00, 0x7D, 0xE0, 0x01, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x3C, 0x79, 0xFC, 0x7F, 0xBD,
  0xFF, 0x7F, 0xCE, 0xC7, 0xB1, 0xF7, 0xC3, 0xF0, 0x7B, 0xE0, 0xF8, 0x3D,
  0xE0, 0x7C, 0x1E, 0xF0, 0x3C, 0x0F, 0x78, 0x1E, 0x07, 0xBC, 0x0F, 0x03,
  0xDE, 0x07, 0x81, 0xEF, 0x03, 0xC0, 0xF7, 0x81, 0xE0, 0x7B, 0xC0, 0xF0,
  0x3D, 0xE0, 0x78, 0x1E, 0xF0, 0x3C, 0x0F, 0x78, 0x1E, 0x07, 0xBC, 0x0F,
  0x03, 0xDE, 0x07, 0x81, 0xEF, 0x03, 0xC0, 0xF7, 0x81, 0xE0, 0x7B, 0xC0,
  0xF0, 0x3D, 0xE0, 0x78, 0x1E, 0xF0, 0x3C, 0x0F, 0x78, 0x1E, 0x07, 0xBC,
  0x0F, 0x03, 0xDE, 0x07, 0x81, 0xE0, 0x00, 0x3F, 0x83, 0xE3, 0xFF, 0x8F,
  0x9F, 0xFF, 0x3E, 0xE0, 0xFC, 0xFF, 0x00, 0xFB, 0xF8, 0x03, 0xE7, 0xC0,
  0x07, 0x9F, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07,
  0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE,
  0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00,
  0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F,
  0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x01,
  0xF1, 0xFF, 0x83, 0xE7, 0xFF, 0xC7, 0xDC, 0x1F, 0x8F, 0xF0, 0x0F, 0x9F,
  0xC0, 0x0F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0xF0,
  0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x00,
  0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F,
  0x9F, 0x80, 0x1E, 0x3F, 0x00, 0x7C, 0x7F, 0x83, 0xF0, 0xF7, 0xFF, 0xC1,
  0xE7, 0xFF, 0x03, 0xC3, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x3E, 0x0F,
  0xFE, 0x7C, 0x3F, 0xFE, 0xF8, 0xFC, 0x1D, 0xF3, 0xE0, 0x1F, 0xE7, 0x80,
  0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x07,
  0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x79,
  0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x8F,
  0x00, 0x3F, 0x1F, 0x00, 0xFE, 0x1F, 0x83, 0xBC, 0x3F, 0xFE, 0x78, 0x1F,
  0xF8, 0xF0, 0x0F, 0xC1, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x9F, 0xFF, 0x7B, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xC0, 0x7C, 0x3C, 0x00, 0xF9, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0x9E, 0x00, 0x3E, 0x7E, 0x01, 0xF0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x30, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xEF, 0x81, 0xDF,
  0x7F, 0xFE, 0xF9, 0xFF, 0xC3, 0xC3, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0x8F, 0x03,
  0xF0, 0x3C, 0x78, 0x1F, 0x81, 0xE3, 0xC0, 0xFC, 0x0F, 0x1E, 0x07, 0xE0,
  0xF8, 0xF8, 0x7F, 0x87, 0x83, 0xC3, 0x9C, 0x3C, 0x1E, 0x1C, 0xE1, 0xE0,
  0xF1, 0xE7, 0x8F, 0x07, 0x8E, 0x1C, 0x78, 0x3C, 0x70, 0xE7, 0xC0, 0xE7,
  0x87, 0xBC, 0x07, 0xB8, 0x1D, 0xE0, 0x3D, 0xC0, 0xEF, 0x01, 0xFE, 0x07,
  0x78, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x03,
  0xE0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x3E, 0x3C, 0x00,
  0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x1F,
  0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x07, 0x80, 0x78, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x83,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x03,
  0xFC,
};

const GFXglyph LiberationMono_Regular50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 4, 33, 30, 13, -33 },
  { 18, 16, 16, 30, 7, -36 },
  { 50, 27, 33, 30, 1, -33 },
  { 162, 26, 40, 30, 2, -36 },
  { 292, 30, 33, 30, 0, -33 },
  { 416, 28, 34, 30, 1, -33 },
  { 535, 6, 16, 30, 12, -36 },
  { 547, 14, 46, 30, 8, -36 },
  { 628, 14, 46, 30, 8, -36 },
  { 709, 18, 17, 30, 6, -36 },
  { 748, 24, 24, 30, 3, -28 },
  { 820, 11, 16, 30, 6, -7 },
  { 842, 14, 4, 30, 8, -15 },
  { 849, 6, 7, 30, 12, -7 },
  { 855, 24, 36, 30, 3, -36 },
  { 963, 24, 33, 30, 3, -33 },
  { 1062, 24, 33, 30, 4, -33 },
  { 1161, 22, 33, 30, 4, -33 },
  { 1252, 24, 33, 30, 3, -33 },
  { 1351, 24, 33, 30, 3, -33 },
  { 1450, 24, 33, 30, 3, -33 },
  { 1549, 23, 33, 30, 4, -33 },
  { 1644, 22, 33, 30, 4, -33 },
  { 1735, 24, 33, 30, 3, -33 },
  { 1834, 24, 33, 30, 3, -33 },
  { 1933, 6, 26, 30, 12, -26 },
  { 1953, 10, 35, 30, 9, -26 },
  { 1997, 24, 25, 30, 3, -29 },
  { 2072, 24, 17, 30, 3, -25 },
  { 2123, 24, 25, 30, 3, -29 },
  { 2198, 24, 34, 30, 2, -34 },
  { 2300, 28, 42, 30, 1, -36 },
  { 2447, 30, 33, 30, 0, -33 },
  { 2571, 24, 33, 30, 4, -33 },
  { 2670, 25, 35, 30, 3, -34 },
  { 2780, 23, 33, 30, 4, -33 },
  { 2875, 23, 33, 30, 4, -33 },
  { 2970, 21, 33, 30, 5, -33 },
  { 3057, 24, 35, 30, 3, -34 },
  { 3162, 22, 33, 30, 4, -33 },
  { 3253, 20, 33, 30, 5, -33 },
  { 3336, 20, 34, 30, 4, -33 },
  { 3421, 26, 33, 30, 4, -33 },
  { 3529, 21, 33, 30, 6, -33 },
  { 3616, 24, 33, 30, 3, -33 },
  { 3715, 22, 33, 30, 4, -33 },
  { 3806, 25, 35, 30, 2, -34 },
  { 3916, 23, 33, 30, 4, -33 },
  { 4011, 26, 43, 30, 2, -34 },
  { 4151, 25, 33, 30, 4, -33 },
  { 4255, 26, 35, 30, 2, -34 },
  { 4369, 26, 33, 30, 2, -33 },
  { 4477, 23, 34, 30, 3, -33 },
  { 4575, 30, 33, 30, 0, -33 },
  { 4699, 30, 33, 30, 0, -33 },
  { 4823, 28, 33, 30, 1, -33 },
  { 4939, 28, 33, 30, 1, -33 },
  { 5055, 26, 33, 30, 2, -33 },
  { 5163, 13, 46, 30, 10, -36 },
  { 5238, 24, 36, 30, 3, -36 },
  { 5346, 13, 46, 30, 7, -36 },
  { 5421, 24, 22, 30, 3, -33 },
  { 5487, 30, 2, 30, 0, 3 },
  { 5495, 10, 6, 30, 10, -35 },
  { 5503, 25, 28, 30, 3, -27 },
  { 5591, 23, 37, 30, 4, -36 },
  { 5698, 23, 28, 30, 3, -27 },
  { 5779, 23, 37, 30, 3, -36 },
  { 5886, 24, 28, 30, 3, -27 },
  { 5970, 24, 36, 30, 3, -36 },
  { 6078, 23, 37, 30, 3, -27 },
  { 6185, 21, 36, 30, 5, -36 },
  { 6280, 24, 36, 30, 3, -36 },
  { 6388, 17, 46, 30, 3, -36 },
  { 6486, 21, 36, 30, 6, -36 },
  { 6581, 24, 36, 30, 3, -36 },
  { 6689, 25, 27, 30, 2, -27 },
  { 6774, 22, 27, 30, 4, -27 },
  { 6849, 24, 28, 30, 3, -27 },
  { 6933, 23, 37, 30, 4, -27 },
  { 7040, 23, 37, 30, 3, -27 },
  { 7147, 20, 27, 30, 6, -27 },
  { 7215, 22, 28, 30, 4, -27 },
  { 7292, 20, 34, 30, 5, -33 },
  { 7377, 21, 27, 30, 5, -26 },
  { 7448, 26, 26, 30, 2, -26 },
  { 7533, 29, 26, 30, 1, -26 },
  { 7628, 26, 26, 30, 2, -26 },
  { 7713, 26, 36, 30, 2, -26 },
  { 7830, 22, 26, 30, 4, -26 },
  { 7902, 20, 46, 30, 6, -36 },
  { 8017, 4, 46, 30, 13, -36 },
  { 8040, 20, 46, 30, 4, -36 },
  { 8155, 24, 6, 30, 3, -20 },
};

const GFXfont LiberationMono_Regular50pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular50pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular50pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _LIBERATIONMONO_REGULAR50PT7B_H_
