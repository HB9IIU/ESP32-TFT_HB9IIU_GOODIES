#ifndef _LIBERATIONMONO_REGULAR65PT7B_H_
#define _LIBERATIONMONO_REGULAR65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular65pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x1E, 0x3F,
  0xE0, 0x7F, 0x03, 0xC1, 0xFC, 0x1F, 0xC0, 0x78, 0x1F, 0xC3, 0xF0, 0x0F,
  0x01, 0xF8, 0x7E, 0x01, 0xE0, 0x3F, 0x0F, 0xC0, 0x3C, 0x03, 0x81, 0xF8,
  0x07, 0x80, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0x7E, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x00, 0xFF, 0xCF, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0xFF, 0x80, 0x00, 0x0F, 0x07, 0xF8,
  0x00, 0x01, 0xE0, 0x3F, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x07, 0x80,
  0x7E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x70, 0x03,
  0xC0, 0x1F, 0x7E, 0x00, 0x78, 0x03, 0xEF, 0xC0, 0x0F, 0x00, 0x7C, 0xFC,
  0x01, 0xE0, 0x1F, 0x9F, 0x80, 0x3C, 0x03, 0xF1, 0xF8, 0x07, 0x80, 0xFE,
  0x3F, 0xC0, 0xF0, 0x3F, 0x83, 0xFE, 0x1E, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xE0, 0xFF, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x00, 0x1F,
  0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0xF8, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x1F,
  0x01, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x03, 0xC0, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x03, 0xC1, 0xF0, 0x00, 0x7C,
  0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x0F, 0x00, 0x00, 0xFF, 0xFC, 0x3E,
  0x00, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xE1, 0xFF, 0xE0,
  0x00, 0x0F, 0x87, 0xFF, 0xE0, 0x00, 0x1E, 0x1F, 0x87, 0xC0, 0x00, 0x7C,
  0x3E, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x07, 0x80, 0x03, 0xC1, 0xF0, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x00, 0x78,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x03, 0xE0,
  0x7C, 0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x7C, 0x00, 0x07, 0xFF, 0xE0, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x00, 0x00,
  0x7D, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0x3E, 0x03, 0xF9, 0xF0, 0x01, 0xF0,
  0x1F, 0x87, 0xC0, 0x1F, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x3C, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x3E,
  0x00, 0x7E, 0x1F, 0x03, 0xF0, 0x01, 0xF1, 0xF0, 0x1F, 0x80, 0x0F, 0xCF,
  0x80, 0xFC, 0x00, 0x3F, 0x7C, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0x00,
  0x03, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFC, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x7F, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x18, 0x0E, 0x01, 0x3C, 0x1C, 0x1E, 0xFE, 0x38, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x80, 0x0F, 0x8F, 0x80, 0x3E,
  0x0F, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xC0, 0x3C, 0x00, 0x80,
  0x20, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x3F,
  0x81, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x81, 0xFC,
  0x0F, 0xFF, 0x03, 0xF8, 0x1F, 0xFE, 0x07, 0xF0, 0x3F, 0xFC, 0x0F, 0xE0,
  0x7F, 0xF8, 0x1F, 0xC0, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFD,
  0xF8, 0x00, 0xFF, 0xE3, 0xF0, 0x01, 0xFF, 0x87, 0xE0, 0x03, 0xF8, 0x0F,
  0xC0, 0x07, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x1F, 0xF0, 0x1F, 0xF0, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFE, 0x7E,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x07, 0xFC, 0x00, 0x3E, 0x3F, 0xFE, 0x00, 0x7D, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0xF8,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x03, 0xF0, 0xFF,
  0xF8, 0x0F, 0xCF, 0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0xF0, 0xFB, 0xFF, 0xFF,
  0xE3, 0xEF, 0xC0, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFE,
  0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xFE, 0x1F,
  0xF0, 0x3F, 0x7C, 0x1F, 0xFF, 0xFE, 0xF8, 0x1F, 0xFF, 0xF9, 0xF0, 0x1F,
  0xFF, 0xE3, 0xE0, 0x1F, 0xFF, 0x0F, 0xC0, 0x07, 0xF8, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0xF0, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0xFF, 0x1E, 0xF8, 0x78, 0x0F,
  0xFC, 0xF3, 0xC3, 0xC0, 0xF8, 0xF7, 0x9E, 0x3C, 0x0F, 0x03, 0xB8, 0xF1,
  0xE0, 0xF8, 0x0F, 0xC7, 0x8F, 0x07, 0x80, 0x7E, 0x1C, 0xF8, 0x78, 0x03,
  0xF0, 0xF7, 0x83, 0xC0, 0x0F, 0x87, 0xBC, 0x3E, 0x00, 0x7C, 0x3D, 0xE1,
  0xE0, 0x03, 0xC1, 0xEF, 0x0F, 0x00, 0x1E, 0x0F, 0x78, 0x78, 0x01, 0xF0,
  0x7B, 0xC7, 0xC0, 0x0F, 0x83, 0xDE, 0x3E, 0x00, 0x7C, 0x1F, 0xE1, 0xE0,
  0x03, 0xC0, 0xFF, 0x0F, 0x00, 0x1E, 0x07, 0x78, 0x78, 0x00, 0xF0, 0x3B,
  0xC3, 0xC0, 0x0F, 0x83, 0xDE, 0x1E, 0x00, 0x7C, 0x1E, 0xF0, 0xF0, 0x03,
  0xC0, 0xF7, 0x87, 0x80, 0x1E, 0x07, 0x9E, 0x3C, 0x01, 0xF0, 0x38, 0xF1,
  0xE0, 0x0F, 0x81, 0xC7, 0x8F, 0x00, 0x7C, 0x1E, 0x3C, 0x7C, 0x07, 0xE0,
  0xF1, 0xE1, 0xE0, 0x77, 0x0F, 0x0F, 0x0F, 0x03, 0xB8, 0x78, 0x7C, 0x7C,
  0x79, 0xC7, 0x81, 0xE1, 0xFF, 0x8F, 0xF8, 0x0F, 0x07, 0xF8, 0x7F, 0x80,
  0x7C, 0x1F, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x80, 0x07,
  0xC0, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00,
  0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0x20, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x10, 0x7E, 0x00, 0x00, 0x1E, 0x7F, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xFC,
  0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x3F, 0xF8, 0x3F, 0x00, 0x0F,
  0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xFC, 0x1F, 0x80, 0x1F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x03, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xFE,
  0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x38, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xF3, 0xFC, 0x03, 0xF8, 0xFF,
  0x07, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x00, 0xFD, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xBF, 0x80, 0x00,
  0xFF, 0xC7, 0xF0, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7F,
  0x3F, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFD, 0xE0, 0x03, 0xDF, 0xFB, 0xE0, 0x07, 0xBF, 0xF7, 0xC0,
  0x1F, 0x7F, 0xE7, 0xC0, 0x3C, 0xFF, 0xCF, 0x80, 0xF9, 0xFF, 0x9F, 0x01,
  0xF3, 0xFF, 0x1F, 0x03, 0xC7, 0xFE, 0x3E, 0x0F, 0x8F, 0xFC, 0x7C, 0x1F,
  0x1F, 0xF8, 0x7C, 0x3C, 0x3F, 0xF0, 0xF8, 0xF8, 0x7F, 0xE1, 0xF1, 0xF0,
  0xFF, 0xC1, 0xF3, 0xC1, 0xFF, 0x83, 0xEF, 0x83, 0xFF, 0x03, 0xDF, 0x07,
  0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xC0, 0x7F, 0xE0, 0x3F, 0x80, 0xFF, 0xC0, 0x3E, 0x01, 0xFF,
  0x80, 0x7C, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF8, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFB, 0xE0, 0x01, 0xFF, 0xDF, 0x80, 0x0F, 0xFE, 0x7C,
  0x00, 0x7F, 0xF3, 0xF0, 0x03, 0xFF, 0x8F, 0x80, 0x1F, 0xFC, 0x7C, 0x00,
  0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0x8F, 0x80, 0x3F, 0xFC, 0x7E, 0x01, 0xFF,
  0xE1, 0xF0, 0x0F, 0xFF, 0x0F, 0xC0, 0x7F, 0xF8, 0x3E, 0x03, 0xFF, 0xC1,
  0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0x80, 0xF8,
  0x3F, 0xFC, 0x07, 0xE1, 0xFF, 0xE0, 0x1F, 0x0F, 0xFF, 0x00, 0xF8, 0x7F,
  0xF8, 0x07, 0xE3, 0xFF, 0xC0, 0x1F, 0x1F, 0xFE, 0x00, 0xFC, 0xFF, 0xF0,
  0x03, 0xE7, 0xFF, 0x80, 0x1F, 0xBF, 0xFC, 0x00, 0x7C, 0xFF, 0xE0, 0x03,
  0xF7, 0xFF, 0x00, 0x0F, 0xBF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F,
  0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F,
  0x80, 0x07, 0xFE, 0x3F, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x7F, 0x9F, 0x80, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFE,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x01, 0xC0, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x0C, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7E, 0x3F, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00,
  0x1F, 0x87, 0xE0, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x1F,
  0x80, 0x7F, 0x00, 0xFC, 0x1F, 0x00, 0xFE, 0x01, 0xF0, 0x3E, 0x01, 0xFE,
  0x03, 0xE0, 0x7C, 0x07, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0x78, 0x0F, 0x81,
  0xF8, 0x1E, 0xF0, 0x3F, 0x03, 0xF0, 0x7D, 0xF0, 0x7E, 0x03, 0xE0, 0xFB,
  0xE0, 0xFC, 0x07, 0xC1, 0xE3, 0xC1, 0xF0, 0x0F, 0x83, 0xC7, 0x83, 0xE0,
  0x1F, 0x0F, 0x8F, 0x87, 0xC0, 0x3E, 0x1F, 0x1F, 0x0F, 0x80, 0x7E, 0x3C,
  0x1E, 0x1F, 0x00, 0xFC, 0x78, 0x3C, 0x7E, 0x00, 0xF9, 0xF0, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0xF9, 0xF0, 0x03, 0xE7, 0x80, 0xF3, 0xE0, 0x07, 0xCF,
  0x01, 0xE7, 0xC0, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x07, 0xDF,
  0x00, 0x1E, 0xF0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x0F, 0x78, 0x00, 0x7B,
  0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x01,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1E,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x01, 0xFE, 0x0F, 0xC0, 0x01, 0xFF, 0x03, 0xF0, 0x01,
  0xFF, 0x81, 0xFC, 0x01, 0xEF, 0xC0, 0xFF, 0x03, 0xE3, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F,
  0x80, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0xFF, 0x00, 0x7E, 0x1F, 0xFE, 0x03, 0xF3, 0xFF, 0xFC, 0x1F, 0xBF, 0xFF,
  0xF0, 0xFD, 0xF0, 0x7F, 0xC7, 0xFE, 0x00, 0xFE, 0x3F, 0xE0, 0x03, 0xF9,
  0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0xFC, 0xFF, 0x00, 0x07, 0xE7, 0xF8, 0x00, 0x7F, 0x3E,
  0xE0, 0x07, 0xF1, 0xF7, 0xC0, 0xFF, 0x0F, 0x9F, 0xFF, 0xF8, 0x7C, 0x7F,
  0xFF, 0x83, 0xE1, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0x80,
  0xFF, 0xF0, 0xFC, 0x1F, 0xFF, 0xE7, 0xE1, 0xFF, 0xFF, 0xBF, 0x1F, 0xE0,
  0x3F, 0xF8, 0xFE, 0x00, 0x7F, 0xCF, 0xE0, 0x01, 0xFE, 0x7E, 0x00, 0x0F,
  0xF3, 0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x7F, 0x3F, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0xC7, 0xF0, 0x07, 0xBE,
  0x3F, 0xC0, 0xF9, 0xF0, 0xFF, 0xFF, 0xCF, 0x83, 0xFF, 0xFC, 0x7C, 0x0F,
  0xFF, 0x83, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x81,
  0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0x01, 0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0x83, 0xF8,
  0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x20, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x1F,
  0x0F, 0xFF, 0xF1, 0xF1, 0xFF, 0xFF, 0x9F, 0x3F, 0xE0, 0xF9, 0xF3, 0xF8,
  0x03, 0xDF, 0x7F, 0x00, 0x1F, 0xF7, 0xE0, 0x00, 0xFF, 0x7E, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x1D, 0xF3, 0xF8,
  0x03, 0xDF, 0x3F, 0xC0, 0xF9, 0xF1, 0xFF, 0xFF, 0x1F, 0x0F, 0xFF, 0xE1,
  0xF0, 0x7F, 0xFC, 0x1F, 0x00, 0xFF, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0xF0, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC1,
  0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xFF,
  0x01, 0xF8, 0x7F, 0xFC, 0x3F, 0x1F, 0xFF, 0xC7, 0xEF, 0xFF, 0xFC, 0xF9,
  0xF0, 0x3F, 0xDF, 0x78, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x70, 0x07, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0x80,
  0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x3F,
  0x81, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFB, 0xF0, 0x00,
  0xFF, 0x9F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFE, 0x7E,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7E,
  0x01, 0xF8, 0x7C, 0x7F, 0x83, 0xFE, 0x3E, 0x7F, 0xE3, 0xFF, 0x9F, 0x7F,
  0xF3, 0xFF, 0xCF, 0xB8, 0xFD, 0xC7, 0xF7, 0xF8, 0x3F, 0xC1, 0xFB, 0xF8,
  0x1F, 0xE0, 0x7D, 0xFC, 0x0F, 0xE0, 0x3E, 0xFC, 0x03, 0xF0, 0x1F, 0xFE,
  0x01, 0xF8, 0x0F, 0xFF, 0x00, 0xF8, 0x07, 0xFF, 0x80, 0x7C, 0x03, 0xFF,
  0xC0, 0x3E, 0x01, 0xFF, 0xE0, 0x1F, 0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x7F,
  0xF8, 0x07, 0xC0, 0x3F, 0xFC, 0x03, 0xE0, 0x1F, 0xFE, 0x01, 0xF0, 0x0F,
  0xFF, 0x00, 0xF8, 0x07, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0xC0, 0x3E, 0x01,
  0xFF, 0xE0, 0x1F, 0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x7F, 0xF8, 0x07, 0xC0,
  0x3F, 0xFC, 0x03, 0xE0, 0x1F, 0xFE, 0x01, 0xF0, 0x0F, 0xFF, 0x00, 0xF8,
  0x07, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0xE0, 0x1F,
  0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x7F, 0xF8, 0x07, 0xC0, 0x3F, 0xFC, 0x03,
  0xE0, 0x1F, 0xFE, 0x01, 0xF0, 0x0F, 0xFF, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x1F, 0x07, 0xFF, 0xC3, 0xE1, 0xFF, 0xFC, 0x7C, 0xFF, 0xFF,
  0xCF, 0x9F, 0x03, 0xFD, 0xF7, 0x80, 0x3F, 0xBF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xC1, 0xFF,
  0xE0, 0x3E, 0x3F, 0xFF, 0xC1, 0xF3, 0xFF, 0xFF, 0x0F, 0x9F, 0x03, 0xFC,
  0x7F, 0xE0, 0x0F, 0xE3, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFC, 0xFE,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xCF,
  0xF0, 0x00, 0x7E, 0x7F, 0x80, 0x07, 0xF3, 0xFE, 0x00, 0x7F, 0x1F, 0xFC,
  0x07, 0xF0, 0xFD, 0xFF, 0xFF, 0x87, 0xE7, 0xFF, 0xF8, 0x3F, 0x0F, 0xFF,
  0x01, 0xF8, 0x1F, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0xF8, 0x0F, 0xFF, 0x07, 0xC1, 0xFF, 0xFE, 0x3E, 0x1F,
  0xFF, 0xFB, 0xF1, 0xFE, 0x03, 0xFF, 0x8F, 0xE0, 0x07, 0xFC, 0xFE, 0x00,
  0x1F, 0xE7, 0xE0, 0x00, 0xFF, 0x3F, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x07,
  0xFC, 0x7F, 0x00, 0x7F, 0xE3, 0xFC, 0x0F, 0xBF, 0x0F, 0xFF, 0xF9, 0xF8,
  0x3F, 0xFF, 0x8F, 0xC0, 0x7F, 0xF8, 0x7E, 0x00, 0xFF, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFB, 0xE7, 0xF0,
  0x05, 0xF3, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE,
  0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7E, 0x3E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC6, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xF0, 0x07, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x77, 0xDF,
  0xE0, 0x3C, 0xF9, 0xFF, 0xFF, 0x9F, 0x1F, 0xFF, 0xE3, 0xE1, 0xFF, 0xF0,
  0x7C, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x03, 0xF3, 0xF0, 0x0F, 0xE0, 0x1F, 0x9F, 0x80, 0x7F, 0x00,
  0xF8, 0x7C, 0x03, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0xE0, 0x3E, 0x1F, 0x01,
  0xEF, 0x03, 0xF0, 0xFC, 0x0F, 0x78, 0x1F, 0x87, 0xE0, 0xFB, 0xE0, 0xFC,
  0x3F, 0x07, 0x8F, 0x07, 0xC0, 0xF8, 0x3C, 0x78, 0x3E, 0x07, 0xC3, 0xE3,
  0xC1, 0xF0, 0x3E, 0x1F, 0x1F, 0x1F, 0x81, 0xF0, 0xF0, 0x78, 0xFC, 0x0F,
  0xCF, 0x83, 0xC7, 0xE0, 0x3E, 0x7C, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x79,
  0xF0, 0x0F, 0x9E, 0x03, 0xCF, 0x80, 0x7D, 0xF0, 0x1F, 0x7C, 0x03, 0xEF,
  0x00, 0x7B, 0xE0, 0x1F, 0x78, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xDF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
};

const GFXglyph LiberationMono_Regular65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 7, 43, 39, 16, -43 },
  { 39, 21, 20, 39, 9, -47 },
  { 92, 35, 43, 39, 2, -43 },
  { 281, 35, 52, 39, 2, -47 },
  { 509, 39, 45, 39, 0, -44 },
  { 729, 37, 44, 39, 1, -43 },
  { 933, 7, 20, 39, 16, -47 },
  { 951, 17, 60, 39, 11, -47 },
  { 1079, 17, 60, 39, 11, -47 },
  { 1207, 23, 23, 39, 8, -47 },
  { 1274, 31, 33, 39, 4, -38 },
  { 1402, 14, 21, 39, 8, -9 },
  { 1439, 17, 5, 39, 11, -20 },
  { 1450, 7, 9, 39, 16, -9 },
  { 1458, 31, 48, 39, 4, -47 },
  { 1644, 31, 45, 39, 4, -44 },
  { 1819, 31, 43, 39, 5, -43 },
  { 1986, 29, 44, 39, 5, -44 },
  { 2146, 31, 45, 39, 4, -44 },
  { 2321, 33, 43, 39, 3, -43 },
  { 2499, 31, 44, 39, 4, -43 },
  { 2670, 30, 45, 39, 5, -44 },
  { 2839, 29, 43, 39, 5, -43 },
  { 2995, 31, 45, 39, 4, -44 },
  { 3170, 31, 45, 39, 4, -44 },
  { 3345, 7, 34, 39, 16, -34 },
  { 3375, 14, 46, 39, 11, -34 },
  { 3456, 31, 33, 39, 4, -38 },
  { 3584, 31, 21, 39, 4, -32 },
  { 3666, 31, 33, 39, 4, -38 },
  { 3794, 31, 44, 39, 3, -44 },
  { 3965, 37, 56, 39, 1, -47 },
  { 4224, 39, 43, 39, 0, -43 },
  { 4434, 32, 43, 39, 5, -43 },
  { 4606, 32, 45, 39, 4, -44 },
  { 4786, 31, 43, 39, 5, -43 },
  { 4953, 31, 43, 39, 5, -43 },
  { 5120, 28, 43, 39, 6, -43 },
  { 5271, 31, 45, 39, 4, -44 },
  { 5446, 29, 43, 39, 5, -43 },
  { 5602, 27, 43, 39, 6, -43 },
  { 5748, 25, 44, 39, 6, -43 },
  { 5886, 34, 43, 39, 5, -43 },
  { 6069, 27, 43, 39, 8, -43 },
  { 6215, 31, 43, 39, 4, -43 },
  { 6382, 29, 43, 39, 5, -43 },
  { 6538, 33, 45, 39, 3, -44 },
  { 6724, 31, 43, 39, 5, -43 },
  { 6891, 33, 56, 39, 3, -44 },
  { 7122, 32, 43, 39, 5, -43 },
  { 7294, 34, 45, 39, 2, -44 },
  { 7486, 35, 43, 39, 2, -43 },
  { 7675, 30, 44, 39, 4, -43 },
  { 7840, 39, 43, 39, 0, -43 },
  { 8050, 39, 43, 39, 0, -43 },
  { 8260, 37, 43, 39, 1, -43 },
  { 8459, 37, 43, 39, 1, -43 },
  { 8658, 35, 43, 39, 2, -43 },
  { 8847, 17, 60, 39, 13, -47 },
  { 8975, 31, 48, 39, 4, -47 },
  { 9161, 17, 60, 39, 9, -47 },
  { 9289, 31, 29, 39, 4, -43 },
  { 9402, 39, 3, 39, 0, 4 },
  { 9417, 13, 8, 39, 13, -46 },
  { 9430, 33, 36, 39, 4, -35 },
  { 9579, 29, 48, 39, 6, -47 },
  { 9753, 30, 36, 39, 4, -35 },
  { 9888, 29, 48, 39, 4, -47 },
  { 10062, 31, 36, 39, 4, -35 },
  { 10202, 31, 47, 39, 4, -47 },
  { 10385, 28, 48, 39, 5, -35 },
  { 10553, 27, 47, 39, 6, -47 },
  { 10712, 31, 47, 39, 5, -47 },
  { 10895, 23, 60, 39, 4, -47 },
  { 11068, 29, 47, 39, 7, -47 },
  { 11239, 31, 47, 39, 4, -47 },
  { 11422, 33, 35, 39, 3, -35 },
  { 11567, 27, 35, 39, 6, -35 },
  { 11686, 31, 36, 39, 4, -35 },
  { 11826, 29, 48, 39, 6, -35 },
  { 12000, 29, 48, 39, 4, -35 },
  { 12174, 25, 35, 39, 8, -35 },
  { 12284, 29, 36, 39, 5, -35 },
  { 12415, 26, 44, 39, 6, -43 },
  { 12558, 27, 35, 39, 6, -34 },
  { 12677, 35, 34, 39, 2, -34 },
  { 12826, 37, 34, 39, 1, -34 },
  { 12984, 33, 34, 39, 3, -34 },
  { 13125, 35, 47, 39, 2, -34 },
  { 13331, 29, 34, 39, 5, -34 },
  { 13455, 27, 60, 39, 7, -47 },
  { 13658, 5, 60, 39, 17, -47 },
  { 13696, 27, 60, 39, 5, -47 },
  { 13899, 33, 8, 39, 3, -26 },
};

const GFXfont LiberationMono_Regular65pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular65pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular65pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _LIBERATIONMONO_REGULAR65PT7B_H_
