#ifndef _LIBERATIONMONO_REGULAR31PT7B_H_
#define _LIBERATIONMONO_REGULAR31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0x80, 0x1F, 0xF0, 0xF1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xD8, 0x76, 0x1D, 0x87, 0x60, 0xD8, 0x30, 0x02, 0x06,
  0x01, 0x02, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x40, 0xC3, 0xFF, 0xFD, 0xFF,
  0xFE, 0x18, 0x30, 0x0C, 0x18, 0x04, 0x0C, 0x02, 0x04, 0x03, 0x06, 0x0F,
  0xFF, 0xF7, 0xFF, 0xF8, 0x40, 0xC0, 0x20, 0x40, 0x30, 0x60, 0x18, 0x30,
  0x0C, 0x18, 0x04, 0x0C, 0x00, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xF0, 0x3F,
  0xFC, 0x39, 0x9E, 0x71, 0x87, 0x71, 0x87, 0x71, 0x80, 0x71, 0x80, 0x3D,
  0x80, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xBE, 0x01, 0x8F, 0x01, 0x87, 0x01,
  0x83, 0x01, 0x83, 0xE1, 0x83, 0xE1, 0x87, 0x79, 0x8E, 0x3F, 0xFC, 0x0F,
  0xF0, 0x01, 0x80, 0x01, 0x80, 0x3E, 0x01, 0x8F, 0xE0, 0x63, 0x8C, 0x1C,
  0x61, 0xC3, 0x0C, 0x38, 0xC1, 0x87, 0x38, 0x30, 0xE6, 0x07, 0x19, 0x80,
  0x7F, 0x60, 0x07, 0xCC, 0x00, 0x03, 0x3E, 0x00, 0xCF, 0xE0, 0x3B, 0x8C,
  0x06, 0x61, 0xC1, 0x8C, 0x38, 0x71, 0x87, 0x0C, 0x30, 0xC3, 0x07, 0x18,
  0xC0, 0x7F, 0x18, 0x07, 0x80, 0x03, 0xE0, 0x07, 0xF8, 0x07, 0x0E, 0x03,
  0x03, 0x01, 0x81, 0x80, 0xC1, 0xC0, 0x71, 0xC0, 0x1F, 0xC0, 0x0F, 0x80,
  0x1F, 0x03, 0x1D, 0xC1, 0x9C, 0x61, 0xCE, 0x38, 0xC6, 0x0E, 0x63, 0x03,
  0xF1, 0x80, 0xF0, 0xE0, 0x38, 0x78, 0x7F, 0x1F, 0xFB, 0xE3, 0xF0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xD8, 0x07, 0x0E, 0x0E, 0x1C, 0x18, 0x38, 0x30, 0x70,
  0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70,
  0x70, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0E, 0x0E, 0x07, 0xE0, 0x70, 0x38,
  0x18, 0x1C, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x03, 0x03, 0x03,
  0x03, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x18, 0x38,
  0x70, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x66, 0x2F, 0xFE, 0x7F, 0x03, 0x80,
  0xD8, 0x33, 0x0E, 0x30, 0x84, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x3C, 0xF3, 0x8E,
  0x71, 0xC6, 0x18, 0xE3, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xE1, 0xE3,
  0x80, 0xC6, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0x70, 0x07, 0xE3, 0x8F, 0xC7,
  0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x00, 0xFC, 0x01, 0xB8, 0x07, 0x30, 0x0E,
  0x70, 0x38, 0x70, 0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x7F, 0x07, 0xEE, 0x0F, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0,
  0x7F, 0xC3, 0x83, 0x9C, 0x07, 0x70, 0x1F, 0x80, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F,
  0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x01, 0xDC, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x78, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xB8,
  0x03, 0xF0, 0x07, 0x70, 0x1C, 0xF0, 0x78, 0xFF, 0xE0, 0x7F, 0x00, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x37, 0x00, 0xEE, 0x03, 0x9C,
  0x06, 0x38, 0x18, 0x70, 0x70, 0xE1, 0xC1, 0xC3, 0x03, 0x8C, 0x07, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x7F, 0xF8, 0xFF, 0xF1, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x33, 0xF0, 0x6F, 0xF0, 0xF0, 0xF1, 0xC0, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x0E, 0xE0, 0x1C, 0xF0, 0xF0, 0xFF,
  0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xF0, 0xE1, 0xC0, 0xE7, 0x01,
  0xCE, 0x00, 0x18, 0x00, 0x71, 0xF0, 0xEF, 0xF9, 0xF0, 0x73, 0xC0, 0x77,
  0x00, 0xEE, 0x00, 0xEC, 0x01, 0xD8, 0x03, 0xB8, 0x0E, 0x30, 0x1C, 0x78,
  0x70, 0x7F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x7F, 0xE1, 0xE0, 0xE3, 0x80, 0xE6,
  0x01, 0xCC, 0x03, 0x9C, 0x07, 0x1C, 0x1C, 0x1F, 0xF0, 0x3F, 0xE1, 0xE0,
  0xE3, 0x80, 0xEE, 0x00, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x0E, 0xF0, 0x1C,
  0xF0, 0x78, 0xFF, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x9C,
  0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0x77,
  0x87, 0xCF, 0xFB, 0x0F, 0x8C, 0x00, 0x70, 0x01, 0xD8, 0x06, 0x70, 0x39,
  0xE1, 0xC3, 0xFE, 0x03, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE7,
  0x8F, 0x1C, 0x38, 0xE1, 0xC3, 0x06, 0x18, 0x00, 0x00, 0x02, 0x00, 0x3C,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x38, 0x00, 0x40,
  0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xF0, 0x73, 0x80, 0x77, 0x00, 0xFC, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x03, 0xF0, 0x03, 0xFC, 0x07, 0x87, 0x03, 0x00, 0xC3,
  0x00, 0x33, 0x80, 0x19, 0x87, 0x3C, 0xC7, 0xDB, 0xC6, 0x29, 0xE7, 0x0C,
  0xF3, 0x06, 0x79, 0x83, 0x3D, 0xC1, 0x9E, 0xC1, 0x8F, 0x60, 0xC7, 0xB0,
  0x63, 0xD8, 0x31, 0x6C, 0x39, 0xB3, 0x3C, 0xD9, 0xF7, 0xCC, 0x71, 0xC3,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x08, 0x1C, 0x1E, 0x07, 0xFC, 0x01, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xD8, 0x00, 0x3B,
  0x80, 0x06, 0x70, 0x01, 0xC6, 0x00, 0x30, 0xE0, 0x0E, 0x0C, 0x01, 0xC1,
  0xC0, 0x30, 0x38, 0x0E, 0x03, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x0E, 0x00,
  0xE1, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x07, 0x70, 0x00,
  0xE0, 0xFF, 0xE1, 0xFF, 0xF3, 0x80, 0xF7, 0x00, 0xEE, 0x01, 0xDC, 0x03,
  0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x79, 0xFF, 0xC3, 0xFF, 0xE7, 0x01, 0xEE,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0xFF,
  0xF7, 0xFF, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xF0, 0xE3, 0x80, 0xE7, 0x00,
  0xFC, 0x01, 0xB8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x01, 0x38, 0x07, 0x70, 0x1C, 0x78,
  0x78, 0x7F, 0xE0, 0x3F, 0x00, 0xFF, 0x81, 0xFF, 0xC3, 0x83, 0xE7, 0x01,
  0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0x70, 0x0E, 0xE0,
  0x39, 0xC0, 0xF3, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xF9,
  0xFF, 0xF3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE3,
  0x80, 0xE7, 0x01, 0xDC, 0x01, 0xB8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x87, 0xFF, 0x0F, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xB8, 0x07,
  0x70, 0x0E, 0x78, 0x3C, 0x7F, 0xF0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xE7, 0x0E, 0x3F, 0xC1, 0xF8, 0xE0, 0x0E,
  0x70, 0x0E, 0x38, 0x0E, 0x1C, 0x0E, 0x0E, 0x0E, 0x07, 0x0E, 0x03, 0x8F,
  0x01, 0xCF, 0x00, 0xE7, 0x00, 0x77, 0xC0, 0x3F, 0xE0, 0x1F, 0x38, 0x0F,
  0x1E, 0x07, 0x07, 0x83, 0x81, 0xC1, 0xC0, 0x70, 0xE0, 0x3C, 0x70, 0x0F,
  0x38, 0x03, 0x9C, 0x00, 0xE0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFE, 0xC1, 0xFD, 0x87, 0xFB,
  0x8D, 0xF3, 0x1B, 0xE7, 0x77, 0xCE, 0xCF, 0x8D, 0x9F, 0x1E, 0x3E, 0x1C,
  0x7C, 0x38, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x70, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC,
  0x0F, 0xB0, 0x3E, 0xE0, 0xF9, 0x83, 0xE7, 0x0F, 0x8C, 0x3E, 0x38, 0xF8,
  0x63, 0xE1, 0xCF, 0x83, 0x3E, 0x0E, 0xF8, 0x1B, 0xE0, 0x7F, 0x81, 0xFE,
  0x03, 0xF8, 0x0F, 0x0F, 0xC0, 0x3F, 0xE0, 0xE1, 0xE3, 0x81, 0xEE, 0x01,
  0xDC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0x78, 0x0E, 0x70, 0x3C, 0x70,
  0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0xFF, 0xE1, 0xFF, 0xF3, 0x80, 0xF7, 0x00,
  0xEE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0x7B,
  0xFF, 0xE7, 0xFF, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xE1,
  0xE3, 0x81, 0xEE, 0x01, 0xDC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0x78,
  0x0E, 0x70, 0x3C, 0x70, 0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x7C, 0xFF, 0xE0, 0xFF, 0xF8,
  0xE0, 0x3C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C,
  0xE0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0xF0,
  0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E,
  0x07, 0xF0, 0x1F, 0xFC, 0x3C, 0x1E, 0x70, 0x0E, 0x70, 0x07, 0x70, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x3C, 0x1E,
  0x1F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0x70, 0x1D, 0xE0, 0xE3, 0xFF, 0x03, 0xF8, 0xE0, 0x01, 0xDC, 0x00, 0x77,
  0x00, 0x3D, 0xC0, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xC1, 0xC0, 0x70, 0x70,
  0x1C, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xC0, 0x18, 0x70, 0x07, 0x1C,
  0x01, 0xC6, 0x00, 0x33, 0x80, 0x0E, 0xE0, 0x03, 0xB0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x80, 0x07, 0x30,
  0x00, 0xE6, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x38, 0x73, 0x87, 0x0C, 0x71,
  0xE1, 0x86, 0x36, 0x30, 0xC6, 0xCE, 0x19, 0xD9, 0xC3, 0xB3, 0x38, 0x76,
  0x76, 0x0E, 0xC6, 0xC1, 0xF8, 0xD8, 0x1E, 0x1B, 0x03, 0xC1, 0xE0, 0x78,
  0x3C, 0x0E, 0x07, 0x80, 0x70, 0x07, 0x38, 0x07, 0x0E, 0x03, 0x83, 0x83,
  0x81, 0xC3, 0x80, 0x71, 0xC0, 0x1D, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x71, 0xC0, 0x70, 0xE0,
  0x38, 0x38, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x01, 0xDC, 0x00, 0x70, 0xE0,
  0x03, 0xB8, 0x03, 0x9C, 0x03, 0x87, 0x01, 0xC1, 0xC1, 0xC0, 0xE1, 0xC0,
  0x38, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0xFF,
  0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0xFF, 0xFF, 0x03, 0x80, 0x0F, 0x00, 0x1B, 0x00, 0x76, 0x00,
  0xCE, 0x03, 0x8C, 0x06, 0x18, 0x0C, 0x18, 0x38, 0x30, 0x60, 0x71, 0xC0,
  0x63, 0x00, 0xE6, 0x00, 0xDC, 0x01, 0x80, 0xFF, 0xFF, 0xE0, 0xF0, 0xE0,
  0x60, 0x60, 0x0F, 0xC0, 0x3F, 0xF0, 0x78, 0x70, 0x70, 0x38, 0x70, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x0F, 0xF8, 0x3F, 0xF8, 0x78, 0x38, 0xE0, 0x38,
  0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x78, 0xF0, 0xDC, 0x7F, 0x9F, 0x3E, 0x0F,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x7C,
  0x3B, 0xFC, 0xF8, 0x73, 0xC0, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x1B, 0x80,
  0x6E, 0x01, 0xF8, 0x06, 0xE0, 0x1B, 0x80, 0xEE, 0x03, 0xBC, 0x0E, 0xD8,
  0x73, 0x7F, 0x8C, 0x7C, 0x00, 0x0F, 0xE0, 0x7F, 0xC3, 0x83, 0x9C, 0x07,
  0x60, 0x1F, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x1D, 0xC0, 0x73, 0x83, 0x87, 0xFC, 0x0F, 0xC0, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xF9, 0xCF,
  0xF7, 0x78, 0x7D, 0xC0, 0xF6, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xDC, 0x0F, 0x78, 0x7C,
  0xFF, 0x71, 0xF9, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0xE1, 0xE3, 0x80, 0xE6,
  0x01, 0xDC, 0x03, 0xB8, 0x03, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x8E, 0x03, 0x8E, 0x0E, 0x0F, 0xF8, 0x0F, 0xC0,
  0x01, 0xFE, 0x0F, 0xFC, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x3F,
  0xFF, 0x7F, 0xFE, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0F, 0x9C, 0xFF, 0x77,
  0x87, 0xDC, 0x0F, 0x60, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0x60, 0x3D, 0xC0, 0xF7, 0x87, 0xCF, 0xF7,
  0x1F, 0x9C, 0x00, 0x70, 0x01, 0xDC, 0x0E, 0x38, 0x78, 0xFF, 0xC0, 0xFC,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9F,
  0x1D, 0xFE, 0xD8, 0x77, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x0F,
  0x7F, 0xCF, 0xE0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x01, 0xD8, 0x1C, 0xC1, 0xC6, 0x1E, 0x30, 0xE1, 0x8E, 0x0C, 0xE0,
  0x6E, 0x03, 0xF8, 0x1E, 0xE0, 0xC7, 0x06, 0x1C, 0x30, 0x71, 0x83, 0xCC,
  0x0E, 0x60, 0x3B, 0x01, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x6F, 0x1C, 0x6F, 0xBE, 0x73, 0xE7, 0x71, 0xC7, 0x61, 0xC7, 0x61,
  0xC7, 0x61, 0xC7, 0x61, 0xC7, 0x61, 0xC7, 0x61, 0xC7, 0x61, 0xC7, 0x61,
  0xC7, 0x61, 0xC7, 0x61, 0xC7, 0x61, 0xC7, 0x61, 0xC7, 0x61, 0xC7, 0xC7,
  0xC6, 0x7F, 0xB6, 0x1D, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x3F, 0xE0, 0xE1, 0xE3, 0x80, 0xE6, 0x01,
  0xDC, 0x03, 0xB8, 0x03, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x37,
  0x00, 0xE6, 0x01, 0xCE, 0x03, 0x8E, 0x1E, 0x0F, 0xF8, 0x0F, 0xC0, 0xC7,
  0xC3, 0x3F, 0xCD, 0x87, 0x3C, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x01, 0xB8,
  0x06, 0xE0, 0x1F, 0x80, 0x6E, 0x01, 0xB8, 0x0E, 0xE0, 0x3B, 0xC0, 0xEF,
  0x87, 0x3F, 0xF8, 0xE7, 0xC3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x0F, 0x9C, 0xFF, 0x77, 0x87, 0xDC, 0x0F, 0x60,
  0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0x60, 0x3D, 0xC0, 0xF7, 0x87, 0xCF, 0xF7, 0x1F, 0x9C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xC3, 0xFE, 0x7F,
  0xEF, 0xFF, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1F,
  0xC3, 0xFF, 0x1C, 0x1D, 0xC0, 0x7E, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0xC1, 0xCF,
  0xFC, 0x1F, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xFF, 0x07, 0xF0, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0xC3, 0xEF,
  0xF7, 0x3F, 0x38, 0xE0, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC3,
  0x80, 0xE1, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x38, 0x1C, 0x38, 0x07, 0x1C,
  0x03, 0x8C, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x3B, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0x76, 0x00, 0x1D, 0xC0,
  0x07, 0x70, 0x01, 0xDC, 0x38, 0x67, 0x1E, 0x18, 0xC7, 0xCE, 0x31, 0xB3,
  0x8C, 0xEC, 0xE3, 0xB3, 0x38, 0xEC, 0x6C, 0x3F, 0x1B, 0x07, 0x86, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0F, 0x00, 0x70, 0x0E, 0x38, 0x0E, 0x18,
  0x1C, 0x1C, 0x38, 0x0E, 0x38, 0x06, 0x70, 0x07, 0xE0, 0x03, 0xC0, 0x01,
  0xC0, 0x03, 0xE0, 0x07, 0x60, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x1C, 0x38,
  0x1C, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xC6,
  0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x60, 0x70, 0x70, 0x38, 0x30, 0x0C, 0x38,
  0x07, 0x1C, 0x01, 0x9C, 0x00, 0xEE, 0x00, 0x36, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xF8, 0x1F, 0xC1, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x7C, 0x03, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x07, 0xF0, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC,
  0x0F, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x3C, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x0F, 0xE0, 0xFC, 0x00, 0x7C, 0x01, 0xFF, 0x0E, 0x0F,
  0xF8, 0x03, 0xE0,
};

const GFXglyph LiberationMono_Regular31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 3, 20, 19, 8, -20 },
  { 9, 10, 10, 19, 4, -23 },
  { 22, 17, 20, 19, 1, -20 },
  { 65, 16, 24, 19, 1, -22 },
  { 113, 19, 20, 19, 0, -20 },
  { 161, 17, 20, 19, 1, -20 },
  { 204, 3, 10, 19, 8, -23 },
  { 208, 8, 29, 19, 5, -23 },
  { 237, 8, 29, 19, 5, -23 },
  { 266, 11, 11, 19, 4, -23 },
  { 282, 15, 14, 19, 2, -17 },
  { 309, 6, 10, 19, 4, -5 },
  { 317, 9, 2, 19, 5, -9 },
  { 320, 3, 5, 19, 8, -5 },
  { 322, 15, 23, 19, 2, -23 },
  { 366, 15, 20, 19, 2, -20 },
  { 404, 15, 20, 19, 2, -20 },
  { 442, 14, 20, 19, 2, -20 },
  { 477, 15, 20, 19, 2, -20 },
  { 515, 15, 20, 19, 2, -20 },
  { 553, 15, 20, 19, 2, -20 },
  { 591, 15, 20, 19, 2, -20 },
  { 629, 14, 20, 19, 2, -20 },
  { 664, 15, 20, 19, 2, -20 },
  { 702, 14, 20, 19, 2, -20 },
  { 737, 3, 17, 19, 8, -17 },
  { 744, 7, 22, 19, 5, -17 },
  { 764, 15, 16, 19, 2, -18 },
  { 794, 15, 9, 19, 2, -14 },
  { 811, 15, 16, 19, 2, -18 },
  { 841, 15, 20, 19, 1, -20 },
  { 879, 17, 27, 19, 1, -23 },
  { 937, 19, 20, 19, 0, -20 },
  { 985, 15, 20, 19, 2, -20 },
  { 1023, 15, 20, 19, 2, -20 },
  { 1061, 15, 20, 19, 2, -20 },
  { 1099, 15, 20, 19, 2, -20 },
  { 1137, 13, 20, 19, 3, -20 },
  { 1170, 15, 20, 19, 2, -20 },
  { 1208, 14, 20, 19, 2, -20 },
  { 1243, 13, 20, 19, 3, -20 },
  { 1276, 12, 20, 19, 3, -20 },
  { 1306, 17, 20, 19, 2, -20 },
  { 1349, 13, 20, 19, 4, -20 },
  { 1382, 15, 20, 19, 2, -20 },
  { 1420, 14, 20, 19, 2, -20 },
  { 1455, 15, 20, 19, 2, -20 },
  { 1493, 15, 20, 19, 2, -20 },
  { 1531, 15, 26, 19, 2, -20 },
  { 1580, 16, 20, 19, 2, -20 },
  { 1620, 16, 20, 19, 1, -20 },
  { 1660, 16, 20, 19, 1, -20 },
  { 1700, 14, 20, 19, 2, -20 },
  { 1735, 18, 20, 19, 0, -20 },
  { 1780, 19, 20, 19, 0, -20 },
  { 1828, 17, 20, 19, 1, -20 },
  { 1871, 17, 20, 19, 1, -20 },
  { 1914, 16, 20, 19, 1, -20 },
  { 1954, 8, 29, 19, 6, -23 },
  { 1983, 15, 23, 19, 2, -23 },
  { 2027, 8, 29, 19, 4, -23 },
  { 2056, 15, 14, 19, 2, -20 },
  { 2083, 19, 1, 19, 0, 2 },
  { 2086, 7, 4, 19, 6, -22 },
  { 2090, 16, 17, 19, 2, -17 },
  { 2124, 14, 23, 19, 3, -23 },
  { 2165, 14, 17, 19, 2, -17 },
  { 2195, 14, 23, 19, 2, -23 },
  { 2236, 15, 17, 19, 2, -17 },
  { 2268, 15, 23, 19, 2, -23 },
  { 2312, 14, 23, 19, 2, -17 },
  { 2353, 13, 23, 19, 3, -23 },
  { 2391, 15, 23, 19, 2, -23 },
  { 2435, 11, 29, 19, 2, -23 },
  { 2475, 13, 23, 19, 4, -23 },
  { 2513, 15, 23, 19, 2, -23 },
  { 2557, 16, 17, 19, 1, -17 },
  { 2591, 13, 17, 19, 3, -17 },
  { 2619, 15, 17, 19, 2, -17 },
  { 2651, 14, 23, 19, 3, -17 },
  { 2692, 14, 23, 19, 2, -17 },
  { 2733, 12, 17, 19, 4, -17 },
  { 2759, 13, 17, 19, 3, -17 },
  { 2787, 12, 21, 19, 3, -21 },
  { 2819, 13, 17, 19, 3, -17 },
  { 2847, 17, 17, 19, 1, -17 },
  { 2884, 18, 17, 19, 0, -17 },
  { 2923, 16, 17, 19, 1, -17 },
  { 2957, 17, 23, 19, 1, -17 },
  { 3006, 14, 17, 19, 2, -17 },
  { 3036, 13, 29, 19, 3, -23 },
  { 3084, 3, 29, 19, 8, -23 },
  { 3095, 12, 29, 19, 3, -23 },
  { 3139, 15, 4, 19, 2, -12 },
};

const GFXfont LiberationMono_Regular31pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular31pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular31pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _LIBERATIONMONO_REGULAR31PT7B_H_
