#ifndef _LIBERATIONMONO_REGULAR62PT7B_H_
#define _LIBERATIONMONO_REGULAR62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0xFB, 0xEF, 0xBE, 0xF8, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x00,
  0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x7C, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x03,
  0x80, 0x0F, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0xF0, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x1C, 0x07,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xE0, 0x03, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x01, 0xE0,
  0x03, 0x80, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF1, 0xE7,
  0xF8, 0x0F, 0xC0, 0xF0, 0xFE, 0x0F, 0xC0, 0x78, 0x1F, 0x87, 0xE0, 0x3C,
  0x0F, 0xC3, 0xE0, 0x1E, 0x03, 0xE1, 0xF0, 0x0F, 0x01, 0xF8, 0xF8, 0x07,
  0x80, 0xE0, 0x7C, 0x03, 0xC0, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x00, 0xFF,
  0x9E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x78, 0xFF, 0x00, 0x00, 0x3C, 0x1F, 0xC0, 0x00, 0x1E, 0x07, 0xF0,
  0x00, 0x0F, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x3F,
  0x00, 0x01, 0xE0, 0x0F, 0x8C, 0x00, 0xF0, 0x07, 0xFF, 0x00, 0x78, 0x03,
  0xFF, 0x80, 0x3C, 0x03, 0xF7, 0xC0, 0x1E, 0x01, 0xFB, 0xF0, 0x0F, 0x00,
  0xF8, 0xFC, 0x07, 0x80, 0xFC, 0x7F, 0x03, 0xC1, 0xFC, 0x1F, 0xF1, 0xE3,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0x0F, 0xFF, 0x80, 0x01, 0xF0, 0xFC, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0xF0,
  0x00, 0xF8, 0x3C, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x1E, 0x00, 0x78, 0x1F,
  0x00, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x80,
  0x78, 0x1E, 0x00, 0x7C, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0x3E, 0x1F, 0x00,
  0x0F, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0xF8,
  0xF8, 0x00, 0x0F, 0xFF, 0x8F, 0x80, 0x00, 0x3F, 0xF8, 0x78, 0x00, 0x00,
  0x7F, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC1,
  0xFC, 0x00, 0x00, 0x3C, 0x3F, 0xF8, 0x00, 0x03, 0xE3, 0xFF, 0xE0, 0x00,
  0x1E, 0x3F, 0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x3C, 0x00, 0x1F, 0x1F, 0x01,
  0xF0, 0x00, 0xF0, 0xF8, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x3C, 0x00, 0xF8,
  0x3C, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x78, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0x7C, 0x1E,
  0x00, 0x1F, 0x03, 0xC1, 0xE0, 0x00, 0xFC, 0x3E, 0x1F, 0x00, 0x03, 0xFF,
  0xE0, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x00,
  0x3C, 0x1F, 0xC0, 0x00, 0x07, 0xDF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x0C, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x1F, 0xFE, 0x00, 0x3C, 0x07, 0xE7,
  0xE0, 0x0F, 0x81, 0xF8, 0x7C, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x3C, 0x0F,
  0xC0, 0xFC, 0x07, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x3E, 0x00, 0xF8, 0x3E,
  0x0F, 0xC0, 0x1F, 0x8F, 0x81, 0xF0, 0x01, 0xF9, 0xF0, 0x3E, 0x00, 0x1F,
  0xBC, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0x80,
  0x03, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x07, 0xF8, 0x03,
  0xF0, 0x03, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xBF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0xBF, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x04, 0x07, 0x01, 0x3E, 0x1C,
  0x3E, 0xFE, 0x73, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x01, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0xC0, 0x07,
  0x8F, 0x00, 0x3E, 0x1E, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x10, 0x04, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF8, 0x3F,
  0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F,
  0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x07, 0xF0, 0x3F, 0xF0, 0x3F, 0x81,
  0xFF, 0x81, 0xFC, 0x0F, 0xFC, 0x0F, 0xE0, 0x7F, 0xE0, 0x7F, 0x03, 0xFF,
  0x03, 0xF8, 0x1F, 0xF8, 0x1F, 0xC0, 0xFF, 0xC0, 0xFE, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xBF, 0x00, 0x3F, 0xFC, 0xFC, 0x00, 0xFF, 0xE3, 0xF0, 0x03, 0xFC, 0x0F,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7E,
  0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x07,
  0xF8, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0,
  0x0F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC3, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC1, 0xFE, 0x00, 0x3E, 0x3F, 0xFC, 0x03,
  0xF7, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x87, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF9, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xF0, 0x7F,
  0x80, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x00, 0x7C, 0x3F,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x30, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0xFE, 0x00, 0xF8, 0x7F, 0xFC, 0x0F, 0x8F, 0xFF, 0xE0, 0xFB, 0xFF,
  0xFF, 0x0F, 0xBE, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xCF, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x7C,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0x03, 0xF0, 0x01, 0xFC,
  0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x1F,
  0xC0, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x3F, 0x9F, 0x80, 0x03, 0xFC, 0xFC, 0x00, 0x3F, 0xE3, 0xF8, 0x03, 0xFF,
  0x1F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFF, 0xEF, 0xC1, 0xFF, 0xFE, 0x7E, 0x03,
  0xFF, 0xC3, 0xE0, 0x07, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3F,
  0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x83, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0xFE, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03,
  0xC1, 0xF0, 0x0F, 0x80, 0x3C, 0x3C, 0x07, 0xF8, 0xF7, 0x87, 0x81, 0xFF,
  0x9C, 0xF1, 0xE0, 0x7C, 0x7B, 0x8E, 0x3C, 0x1F, 0x07, 0xF1, 0xE7, 0x83,
  0xC0, 0x7E, 0x3D, 0xE0, 0xF0, 0x0F, 0xC7, 0xBC, 0x1E, 0x01, 0xF0, 0xF7,
  0x87, 0x80, 0x3E, 0x1E, 0xF0, 0xF0, 0x07, 0xC3, 0xDE, 0x3E, 0x00, 0xF8,
  0x7B, 0xC7, 0x80, 0x1F, 0x0F, 0x70, 0xF0, 0x03, 0xC1, 0xFE, 0x1E, 0x00,
  0x78, 0x3F, 0xC3, 0xC0, 0x0F, 0x07, 0xF8, 0x78, 0x01, 0xE0, 0xFF, 0x1F,
  0x00, 0x3C, 0x1F, 0xE3, 0xC0, 0x0F, 0x03, 0xBC, 0x78, 0x01, 0xE0, 0x77,
  0x8F, 0x00, 0x3C, 0x0E, 0xF1, 0xF0, 0x07, 0x83, 0xDE, 0x1E, 0x01, 0xF0,
  0x79, 0xC3, 0xC0, 0x3E, 0x0E, 0x3C, 0x78, 0x0F, 0xC3, 0xC7, 0x8F, 0x01,
  0xF0, 0x78, 0xF1, 0xF0, 0x7F, 0x1E, 0x1E, 0x1F, 0x1C, 0xE3, 0x83, 0xC3,
  0xFF, 0x1F, 0xF0, 0x3C, 0x3F, 0xC3, 0xFC, 0x07, 0x81, 0xF0, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x10, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0x01,
  0xFF, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC0, 0x03, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x7F, 0xBF, 0x00, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x60, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x10, 0x3F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00,
  0x3E, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x01,
  0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x7E,
  0x01, 0xFF, 0xC3, 0xF0, 0x01, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xE1,
  0xF8, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xDF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFE, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x18, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x7E, 0x00, 0xFF, 0xFD, 0xF8, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x01, 0xF7, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x07, 0xC7, 0xF0, 0x00,
  0x1F, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x70, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xC7, 0xF0, 0x0F,
  0xE3, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFD, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xDF, 0xC0, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFB,
  0xC0, 0x1F, 0xFF, 0xDF, 0x00, 0xF7, 0xFE, 0xF8, 0x07, 0xBF, 0xF3, 0xC0,
  0x7D, 0xFF, 0x9F, 0x03, 0xCF, 0xFC, 0xF8, 0x3E, 0x7F, 0xE3, 0xC1, 0xF3,
  0xFF, 0x1F, 0x0F, 0x1F, 0xF8, 0xF8, 0xF8, 0xFF, 0xC3, 0xC7, 0xC7, 0xFE,
  0x1F, 0x3C, 0x3F, 0xF0, 0xF9, 0xE1, 0xFF, 0x83, 0xDE, 0x0F, 0xFC, 0x1F,
  0xF0, 0x7F, 0xE0, 0x7F, 0x83, 0xFF, 0x03, 0xF8, 0x1F, 0xF8, 0x1F, 0xC0,
  0xFF, 0xC0, 0x7E, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0x7C, 0x00, 0x7F, 0xEF, 0x80, 0x0F,
  0xFC, 0xF8, 0x01, 0xFF, 0x9F, 0x00, 0x3F, 0xF1, 0xF0, 0x07, 0xFE, 0x3E,
  0x00, 0xFF, 0xC3, 0xE0, 0x1F, 0xF8, 0x7C, 0x03, 0xFF, 0x07, 0xC0, 0x7F,
  0xE0, 0xF8, 0x0F, 0xFC, 0x1F, 0x81, 0xFF, 0x81, 0xF0, 0x3F, 0xF0, 0x3F,
  0x07, 0xFE, 0x03, 0xE0, 0xFF, 0xC0, 0x7C, 0x1F, 0xF8, 0x07, 0xC3, 0xFF,
  0x00, 0xF8, 0x7F, 0xE0, 0x0F, 0x8F, 0xFC, 0x01, 0xF1, 0xFF, 0x80, 0x1F,
  0x3F, 0xF0, 0x03, 0xE7, 0xFE, 0x00, 0x7E, 0xFF, 0xC0, 0x07, 0xDF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0x81, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7E,
  0x00, 0x3F, 0xF3, 0xF0, 0x00, 0x3F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xCF, 0xC0, 0x07, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x03,
  0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x81, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x03,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0x80, 0x07, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0,
  0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x70, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x1C,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0xC0, 0x01, 0xFE, 0x1F,
  0xF0, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC3,
  0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x80, 0x7C, 0x1F, 0x01,
  0xFC, 0x07, 0xE0, 0xF8, 0x0F, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0x81, 0xF0,
  0x3E, 0x07, 0xBC, 0x0F, 0x81, 0xF0, 0x3D, 0xE0, 0x7C, 0x0F, 0xC1, 0xEF,
  0x83, 0xE0, 0x3E, 0x1F, 0x3C, 0x1F, 0x01, 0xF0, 0xF1, 0xE0, 0xF8, 0x0F,
  0x87, 0x8F, 0x0F, 0x80, 0x7C, 0x3C, 0x7C, 0x7C, 0x03, 0xE3, 0xE1, 0xE3,
  0xE0, 0x1F, 0x1E, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0x78, 0xF8, 0x03, 0xC7,
  0x83, 0xE7, 0xC0, 0x1F, 0x7C, 0x0F, 0x3C, 0x00, 0xFB, 0xC0, 0x79, 0xE0,
  0x07, 0xDE, 0x03, 0xCF, 0x00, 0x3E, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x3E,
  0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0x03, 0xF8, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFE, 0x0F, 0xC0, 0x07, 0xFC,
  0x0F, 0xC0, 0x1E, 0xFC, 0x1F, 0xC0, 0xF9, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF,
  0x3F, 0xFF, 0x83, 0xFE, 0x1F, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0xFF, 0x00, 0x7C, 0x3F, 0xFC, 0x07, 0xC7, 0xFF,
  0xE0, 0x7C, 0xFF, 0xFF, 0x07, 0xDF, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xC7,
  0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F,
  0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x7F, 0x00, 0x07, 0xC7, 0xF8, 0x00, 0xFC, 0x7F, 0xC0, 0x1F, 0xC7,
  0xDE, 0x07, 0xF8, 0x7D, 0xFF, 0xFF, 0x0F, 0xCF, 0xFF, 0xE0, 0xFC, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0x03, 0xFF, 0xE3, 0xF0, 0x7F, 0xFF,
  0x3F, 0x0F, 0xFF, 0xFB, 0xF1, 0xFE, 0x07, 0xFF, 0x3F, 0x80, 0x1F, 0xF3,
  0xF0, 0x00, 0xFF, 0x3E, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00,
  0x07, 0xF7, 0xC0, 0x00, 0x7F, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7C,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x7F, 0x7E, 0x00, 0x0F, 0xF3, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x3F, 0xF1,
  0xFE, 0x07, 0xBF, 0x0F, 0xFF, 0xFB, 0xF0, 0x7F, 0xFF, 0x3F, 0x03, 0xFF,
  0xC3, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x7E, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x60, 0x7E, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xFC, 0x1F, 0x07, 0xFF, 0xF1, 0xF0, 0xFF, 0xFF, 0xBF, 0x1F, 0xE0,
  0xFB, 0xF3, 0xF8, 0x03, 0xFF, 0x3F, 0x00, 0x1F, 0xF3, 0xF0, 0x00, 0xFF,
  0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xC0,
  0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xF3, 0xF0, 0x01, 0xFF, 0x3F, 0x80,
  0x3F, 0xF1, 0xFE, 0x0F, 0xBF, 0x1F, 0xFF, 0xF3, 0xF0, 0xFF, 0xFE, 0x3F,
  0x03, 0xFF, 0xC3, 0xF0, 0x0F, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC1, 0xFC, 0x00, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7F, 0x80, 0xF8, 0x7F, 0xF8, 0x3E,
  0x3F, 0xFF, 0x8F, 0x9F, 0xFF, 0xF3, 0xEF, 0x81, 0xFC, 0xFF, 0x80, 0x3F,
  0xBF, 0xC0, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x60, 0x0F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xEF, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x81, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7F,
  0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xE1, 0xF3, 0xFC, 0x1F, 0xF3, 0xEF,
  0xFC, 0x7F, 0xE7, 0xDF, 0xF9, 0xFF, 0xEF, 0xF1, 0xFB, 0x8F, 0xDF, 0xC1,
  0xFE, 0x0F, 0xBF, 0x81, 0xF8, 0x1F, 0xFE, 0x03, 0xF0, 0x1F, 0xFC, 0x07,
  0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0x00, 0xFF, 0xC0, 0x3E,
  0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0,
  0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80,
  0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03,
  0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F,
  0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFF,
  0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE,
  0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0,
  0x0F, 0x80, 0x7C, 0x00, 0x07, 0xF0, 0x1F, 0x87, 0xFF, 0xC1, 0xF1, 0xFF,
  0xFC, 0x3E, 0x7F, 0xFF, 0xC7, 0xDF, 0x03, 0xF8, 0xFF, 0x80, 0x3F, 0x9F,
  0xE0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0xF8,
  0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F,
  0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xBE, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0x3F,
  0x80, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xC3, 0xFF, 0xC0,
  0x7C, 0x7F, 0xFF, 0x07, 0xCF, 0xFF, 0xF0, 0x7D, 0xF0, 0x3F, 0x87, 0xFC,
  0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0x7C,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7F, 0x80, 0x0F, 0xC7, 0xFC,
  0x01, 0xFC, 0x7D, 0xF0, 0x3F, 0x87, 0xDF, 0xFF, 0xF0, 0x7C, 0xFF, 0xFE,
  0x07, 0xC3, 0xFF, 0xC0, 0x7C, 0x0F, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x3F, 0x07, 0xFF, 0xF3,
  0xF0, 0xFF, 0xFF, 0xBF, 0x1F, 0xE0, 0x7B, 0xF3, 0xF8, 0x01, 0xFF, 0x3F,
  0x00, 0x0F, 0xF3, 0xF0, 0x00, 0xFF, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x7F, 0x7C, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x3F, 0x7C, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0xFF, 0x3F, 0x00, 0x1F, 0xF3, 0xF8, 0x03, 0xFF, 0x1F,
  0xE0, 0xFB, 0xF0, 0xFF, 0xFF, 0x3F, 0x07, 0xFF, 0xE3, 0xF0, 0x3F, 0xFC,
  0x3F, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xDF, 0x07, 0xFF, 0xEF, 0x87, 0xFF, 0xF7,
  0xC7, 0xFF, 0xFB, 0xF7, 0xF0, 0x05, 0xFB, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81,
  0xFC, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7C,
  0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x0E, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x77, 0xDF, 0xC0,
  0x79, 0xF7, 0xFF, 0xFE, 0x7C, 0xFF, 0xFF, 0x1F, 0x0F, 0xFF, 0x07, 0xC0,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x07,
  0xC7, 0xC0, 0x1F, 0x80, 0x7C, 0x7E, 0x03, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F,
  0x80, 0xFC, 0x3E, 0x03, 0xFC, 0x0F, 0x83, 0xE0, 0x7B, 0xC0, 0xF8, 0x3E,
  0x07, 0xBC, 0x0F, 0x83, 0xE0, 0x7B, 0xE0, 0xF8, 0x3F, 0x0F, 0x1E, 0x0F,
  0x81, 0xF0, 0xF1, 0xE1, 0xF8, 0x1F, 0x0F, 0x1E, 0x1F, 0x01, 0xF1, 0xF0,
  0xF1, 0xF0, 0x1F, 0x1E, 0x0F, 0x1F, 0x01, 0xF1, 0xE0, 0xF1, 0xF0, 0x1F,
  0x3E, 0x0F, 0x9F, 0x00, 0xF3, 0xC0, 0x79, 0xE0, 0x0F, 0xBC, 0x07, 0xBE,
  0x00, 0xFB, 0xC0, 0x7B, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x1F, 0xBE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x03,
  0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xF0,
};

const GFXglyph LiberationMono_Regular62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 6, 41, 37, 16, -41 },
  { 32, 21, 19, 37, 8, -45 },
  { 82, 33, 41, 37, 2, -41 },
  { 252, 33, 50, 37, 2, -45 },
  { 459, 37, 43, 37, 0, -42 },
  { 658, 35, 42, 37, 1, -41 },
  { 842, 7, 19, 37, 15, -45 },
  { 859, 17, 58, 37, 10, -45 },
  { 983, 17, 58, 37, 10, -45 },
  { 1107, 22, 22, 37, 8, -45 },
  { 1168, 30, 30, 37, 4, -36 },
  { 1281, 13, 20, 37, 8, -9 },
  { 1314, 17, 5, 37, 10, -19 },
  { 1325, 7, 9, 37, 15, -9 },
  { 1333, 31, 46, 37, 3, -45 },
  { 1512, 29, 43, 37, 4, -42 },
  { 1668, 30, 41, 37, 4, -41 },
  { 1822, 29, 42, 37, 4, -42 },
  { 1975, 29, 43, 37, 4, -42 },
  { 2131, 31, 41, 37, 3, -41 },
  { 2290, 29, 42, 37, 4, -41 },
  { 2443, 28, 43, 37, 5, -42 },
  { 2594, 27, 41, 37, 5, -41 },
  { 2733, 29, 43, 37, 4, -42 },
  { 2889, 29, 43, 37, 4, -42 },
  { 3045, 7, 33, 37, 15, -33 },
  { 3074, 13, 44, 37, 11, -33 },
  { 3146, 30, 31, 37, 4, -36 },
  { 3263, 30, 20, 37, 4, -30 },
  { 3338, 30, 31, 37, 4, -36 },
  { 3455, 29, 42, 37, 3, -42 },
  { 3608, 35, 54, 37, 1, -45 },
  { 3845, 37, 41, 37, 0, -41 },
  { 4035, 30, 41, 37, 5, -41 },
  { 4189, 32, 43, 37, 3, -42 },
  { 4361, 29, 41, 37, 5, -41 },
  { 4510, 29, 41, 37, 5, -41 },
  { 4659, 27, 41, 37, 6, -41 },
  { 4798, 30, 43, 37, 3, -42 },
  { 4960, 27, 41, 37, 5, -41 },
  { 5099, 25, 41, 37, 6, -41 },
  { 5228, 25, 42, 37, 5, -41 },
  { 5360, 32, 41, 37, 5, -41 },
  { 5524, 26, 41, 37, 7, -41 },
  { 5658, 29, 41, 37, 4, -41 },
  { 5807, 27, 41, 37, 5, -41 },
  { 5946, 31, 43, 37, 3, -42 },
  { 6113, 29, 41, 37, 5, -41 },
  { 6262, 31, 54, 37, 3, -42 },
  { 6472, 31, 41, 37, 5, -41 },
  { 6631, 32, 43, 37, 2, -42 },
  { 6803, 33, 41, 37, 2, -41 },
  { 6973, 29, 42, 37, 4, -41 },
  { 7126, 37, 41, 37, 0, -41 },
  { 7316, 37, 41, 37, 0, -41 },
  { 7506, 35, 41, 37, 1, -41 },
  { 7686, 35, 41, 37, 1, -41 },
  { 7866, 33, 41, 37, 2, -41 },
  { 8036, 17, 58, 37, 12, -45 },
  { 8160, 31, 46, 37, 3, -45 },
  { 8339, 17, 58, 37, 8, -45 },
  { 8463, 29, 27, 37, 4, -41 },
  { 8561, 37, 3, 37, 0, 4 },
  { 8575, 13, 8, 37, 12, -44 },
  { 8588, 31, 35, 37, 4, -34 },
  { 8724, 28, 46, 37, 5, -45 },
  { 8885, 29, 35, 37, 4, -34 },
  { 9012, 28, 46, 37, 4, -45 },
  { 9173, 29, 35, 37, 4, -34 },
  { 9300, 29, 45, 37, 4, -45 },
  { 9464, 28, 47, 37, 4, -34 },
  { 9629, 26, 45, 37, 6, -45 },
  { 9776, 30, 45, 37, 4, -45 },
  { 9945, 21, 58, 37, 4, -45 },
  { 10098, 27, 45, 37, 7, -45 },
  { 10250, 30, 45, 37, 4, -45 },
  { 10419, 31, 34, 37, 3, -34 },
  { 10551, 27, 34, 37, 5, -34 },
  { 10666, 29, 35, 37, 4, -34 },
  { 10793, 28, 47, 37, 5, -34 },
  { 10958, 28, 47, 37, 4, -34 },
  { 11123, 25, 34, 37, 7, -34 },
  { 11230, 27, 35, 37, 5, -34 },
  { 11349, 25, 43, 37, 6, -42 },
  { 11484, 26, 34, 37, 6, -33 },
  { 11595, 33, 33, 37, 2, -33 },
  { 11732, 36, 33, 37, 1, -33 },
  { 11881, 31, 33, 37, 3, -33 },
  { 12009, 33, 46, 37, 2, -33 },
  { 12199, 28, 33, 37, 4, -33 },
  { 12315, 25, 58, 37, 7, -45 },
  { 12497, 5, 58, 37, 16, -45 },
  { 12534, 25, 58, 37, 5, -45 },
  { 12716, 31, 8, 37, 3, -25 },
};

const GFXfont LiberationMono_Regular62pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular62pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular62pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _LIBERATIONMONO_REGULAR62PT7B_H_
