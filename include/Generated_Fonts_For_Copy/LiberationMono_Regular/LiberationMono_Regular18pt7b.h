#ifndef _LIBERATIONMONO_REGULAR18PT7B_H_
#define _LIBERATIONMONO_REGULAR18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x30, 0xCD, 0x34, 0x51, 0x45, 0x10, 0x08, 0x82, 0x20, 0x88,
  0x44, 0x7F, 0xC4, 0x41, 0x13, 0xFF, 0x22, 0x08, 0x82, 0x20, 0x88, 0x08,
  0x04, 0x0F, 0x99, 0x6C, 0x9E, 0x41, 0xA0, 0x78, 0x0B, 0x04, 0xC2, 0x31,
  0x3C, 0x9B, 0xF0, 0x20, 0x10, 0x70, 0x5B, 0x12, 0x24, 0x45, 0x8D, 0xA0,
  0xE8, 0x03, 0x70, 0x53, 0x12, 0x66, 0x4C, 0x89, 0xA0, 0xE0, 0x1E, 0x04,
  0x43, 0x10, 0xCC, 0x1E, 0x0E, 0x26, 0x89, 0x32, 0xC7, 0xB0, 0xC6, 0x38,
  0xF3, 0xF5, 0x50, 0x11, 0x98, 0xC4, 0x63, 0x18, 0xC6, 0x31, 0x84, 0x31,
  0x86, 0x10, 0xC3, 0x08, 0x61, 0x08, 0x63, 0x18, 0xC6, 0x21, 0x18, 0x8C,
  0xC0, 0x10, 0x23, 0x53, 0xC3, 0x85, 0x12, 0x00, 0x08, 0x04, 0x02, 0x01,
  0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x36, 0x64, 0x4C, 0xF8, 0xFC,
  0x01, 0x81, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x30, 0x18, 0x18,
  0x08, 0x0C, 0x00, 0x3E, 0x31, 0x90, 0x58, 0x2C, 0x1E, 0xCF, 0x67, 0x83,
  0xC1, 0x20, 0x98, 0xC7, 0x80, 0x0C, 0x0E, 0x3B, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x1F, 0xF0, 0x3E, 0x31, 0xB0, 0x40, 0x20,
  0x30, 0x18, 0x18, 0x38, 0x30, 0x30, 0x10, 0x1F, 0xF0, 0x3E, 0x31, 0xB0,
  0x40, 0x20, 0x30, 0xE0, 0x0C, 0x02, 0x01, 0xE0, 0xD8, 0xC7, 0xC0, 0x06,
  0x07, 0x02, 0x82, 0x43, 0x21, 0x11, 0x09, 0x84, 0xFF, 0x81, 0x00, 0x80,
  0x40, 0x7F, 0x20, 0x10, 0x08, 0x05, 0xE3, 0x18, 0x04, 0x03, 0x01, 0xE0,
  0x98, 0xC7, 0xC0, 0x1E, 0x11, 0x90, 0x48, 0x0D, 0xE7, 0x1B, 0x05, 0x83,
  0x41, 0xA0, 0x98, 0xC3, 0xC0, 0xFF, 0x01, 0x02, 0x06, 0x04, 0x0C, 0x08,
  0x18, 0x18, 0x10, 0x10, 0x10, 0x3E, 0x31, 0xB0, 0x48, 0x26, 0x30, 0xE1,
  0x8D, 0x82, 0xC1, 0xE0, 0x98, 0xC7, 0xC0, 0x3C, 0x31, 0xB0, 0xD8, 0x2C,
  0x16, 0x0D, 0x8E, 0x7A, 0x01, 0x21, 0x98, 0x87, 0x80, 0xFC, 0x03, 0xF0,
  0x66, 0x60, 0x00, 0x07, 0x66, 0x4C, 0x80, 0x00, 0x83, 0x87, 0x0C, 0x08,
  0x03, 0x00, 0x70, 0x0E, 0x00, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x80, 0x30, 0x06, 0x00, 0xE0, 0x08, 0x38, 0x60, 0xC0, 0x80, 0x00, 0x3E,
  0x63, 0xC1, 0xC1, 0x03, 0x06, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x0F,
  0x0C, 0x22, 0x05, 0x01, 0x4E, 0xD6, 0x5D, 0x17, 0xC5, 0xF3, 0x74, 0x95,
  0xD9, 0x00, 0x60, 0x0C, 0x21, 0xF0, 0x0E, 0x01, 0xC0, 0x28, 0x0D, 0x81,
  0x10, 0x62, 0x0C, 0x61, 0xFC, 0x60, 0xC8, 0x19, 0x01, 0x60, 0x30, 0xFE,
  0x61, 0xB0, 0x58, 0x2C, 0x37, 0xE3, 0x0D, 0x83, 0xC1, 0xE0, 0xF0, 0x7F,
  0xC0, 0x3E, 0x31, 0x90, 0x58, 0x2C, 0x06, 0x03, 0x01, 0x80, 0xC1, 0xA0,
  0xD8, 0xC3, 0xC0, 0xFC, 0x63, 0xB0, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE1, 0xB1, 0x9F, 0x80, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x07, 0xFB,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x1F, 0xF0, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3E, 0x31, 0x90, 0x78, 0x0C,
  0x06, 0x03, 0x3F, 0x83, 0xC1, 0xA0, 0xD8, 0x67, 0xC0, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xFF, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xFE, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x47, 0xF0, 0x3E, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x87, 0x8F, 0x33, 0xC0, 0xC1, 0xB0, 0xCC, 0x63, 0x30,
  0xD8, 0x36, 0x0E, 0xC3, 0x30, 0xC6, 0x30, 0xCC, 0x1B, 0x06, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC3, 0xF1,
  0xF8, 0xFE, 0xFF, 0x5E, 0xAF, 0x77, 0x93, 0xC1, 0xE0, 0xF0, 0x78, 0x30,
  0xE1, 0xE1, 0xF1, 0xF1, 0xD1, 0xD9, 0xC9, 0xCD, 0xC5, 0xC7, 0xC3, 0xC3,
  0x3E, 0x31, 0xB0, 0x58, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xA0, 0x98,
  0xC7, 0xC0, 0xFE, 0x61, 0xB0, 0x78, 0x3C, 0x1E, 0x1B, 0xF9, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x00, 0x3E, 0x31, 0xB0, 0x58, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0x98, 0xC7, 0xC0, 0xC0, 0x30, 0x0E, 0xFE, 0x60, 0xF0,
  0x78, 0x3C, 0x37, 0xF3, 0x31, 0x8C, 0xC2, 0x61, 0xB0, 0x58, 0x30, 0x3E,
  0x31, 0xB0, 0x78, 0x06, 0x01, 0xE0, 0x1C, 0x03, 0x01, 0xC0, 0xF0, 0xC7,
  0xC0, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0x60, 0x98, 0xC7, 0xC0, 0xC0, 0x68, 0x19, 0x83, 0x30, 0x42, 0x18,
  0x63, 0x0C, 0x40, 0x98, 0x1B, 0x01, 0x40, 0x38, 0x06, 0x00, 0xC0, 0x78,
  0x0F, 0x01, 0x20, 0x24, 0x44, 0x9D, 0x92, 0xB3, 0x56, 0x7A, 0x8E, 0x70,
  0xC6, 0x18, 0xC0, 0x60, 0xC8, 0x63, 0x10, 0x6C, 0x0E, 0x03, 0x00, 0xE0,
  0x68, 0x13, 0x0C, 0x66, 0x09, 0x03, 0x40, 0xD8, 0x33, 0x18, 0xC4, 0x1B,
  0x03, 0x80, 0xE0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0xFF, 0x81, 0x80,
  0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x20, 0x30, 0x30, 0x1F, 0xF0, 0xF8,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC0, 0x20, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x18, 0xF8,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xF8, 0x18, 0x0A,
  0x0D, 0x04, 0xC2, 0x23, 0x19, 0x05, 0x82, 0xFF, 0xE0, 0xC8, 0x80, 0x3C,
  0x31, 0x10, 0xC0, 0x63, 0xF3, 0x1B, 0x0D, 0x86, 0xC7, 0x3C, 0xC0, 0x80,
  0x80, 0x80, 0xBC, 0xC6, 0xC2, 0x82, 0x83, 0x83, 0x82, 0xC2, 0xC6, 0xBC,
  0x3E, 0x31, 0x90, 0x58, 0x0C, 0x06, 0x03, 0x00, 0x82, 0x63, 0x1F, 0x00,
  0x01, 0x01, 0x01, 0x3D, 0x63, 0x43, 0xC3, 0xC1, 0xC1, 0xC3, 0xC3, 0x65,
  0x3D, 0x3E, 0x31, 0x90, 0x58, 0x3F, 0xFE, 0x03, 0x00, 0x82, 0x63, 0x1F,
  0x00, 0x0F, 0x88, 0x04, 0x1F, 0xE1, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x3D, 0x65, 0x43, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3,
  0x65, 0x39, 0x01, 0x63, 0x63, 0x3E, 0x81, 0x02, 0x05, 0xEC, 0x78, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x0C, 0x06, 0x00, 0x0F, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xF8, 0x04, 0x10, 0x1F,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x43, 0xF8, 0xC0, 0xC0,
  0xC0, 0xC6, 0xC4, 0xC8, 0xD8, 0xF0, 0xF8, 0xC8, 0xCC, 0xC6, 0xC3, 0x78,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x0F, 0xF8, 0xB3, 0x6E, 0xF2, 0x71, 0x38, 0x9C, 0x4E, 0x27, 0x13, 0x89,
  0xC4, 0xC0, 0xBD, 0x8F, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x3E,
  0x31, 0x90, 0x58, 0x3C, 0x1E, 0x0F, 0x06, 0x82, 0x63, 0x1F, 0x00, 0xBC,
  0xC6, 0xC2, 0x82, 0x83, 0x83, 0x82, 0xC2, 0xC6, 0xBC, 0x80, 0x80, 0x80,
  0x80, 0x3D, 0x63, 0x43, 0xC3, 0xC1, 0xC1, 0xC3, 0x43, 0x65, 0x3D, 0x01,
  0x01, 0x01, 0x01, 0xDF, 0xA1, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80,
  0x3E, 0x63, 0x41, 0x60, 0x3C, 0x0F, 0x01, 0x41, 0x63, 0x3E, 0x20, 0xC3,
  0xFB, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81, 0xF0, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC3, 0xC6, 0xF4, 0xC1, 0xE0, 0xD0, 0x4C, 0x66, 0x21,
  0x30, 0xD8, 0x68, 0x1C, 0x0C, 0x00, 0xC0, 0x78, 0x09, 0x01, 0x26, 0x24,
  0xAC, 0xD5, 0x9E, 0xB3, 0x9C, 0x31, 0x86, 0x30, 0xC1, 0x31, 0x89, 0x86,
  0x81, 0xC0, 0xE0, 0xD0, 0x4C, 0x63, 0x60, 0xC0, 0x81, 0xE0, 0xD0, 0x4C,
  0x66, 0x21, 0x10, 0xD8, 0x28, 0x1C, 0x04, 0x02, 0x03, 0x03, 0x07, 0x00,
  0x7F, 0x03, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x60, 0x40, 0xFF, 0x1E, 0x20,
  0xC1, 0x83, 0x06, 0x0C, 0x10, 0xC0, 0x40, 0xC1, 0x83, 0x06, 0x0C, 0x08,
  0x1E, 0xFF, 0xFF, 0x80, 0xF0, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0C,
  0x03, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xF0, 0xF8, 0x87, 0xC0,
};

const GFXglyph LiberationMono_Regular18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 1, 12, 11, 5, -12 },
  { 3, 6, 6, 11, 2, -13 },
  { 8, 10, 12, 11, 0, -12 },
  { 23, 9, 16, 11, 1, -14 },
  { 41, 11, 12, 11, 0, -12 },
  { 58, 10, 12, 11, 0, -12 },
  { 73, 2, 6, 11, 4, -13 },
  { 75, 5, 17, 11, 3, -13 },
  { 86, 5, 17, 11, 3, -13 },
  { 97, 7, 7, 11, 2, -13 },
  { 104, 9, 9, 11, 1, -11 },
  { 115, 4, 6, 11, 2, -3 },
  { 118, 5, 1, 11, 3, -5 },
  { 119, 2, 3, 11, 4, -3 },
  { 120, 9, 13, 11, 1, -13 },
  { 135, 9, 12, 11, 1, -12 },
  { 149, 9, 12, 11, 1, -12 },
  { 163, 9, 12, 11, 1, -12 },
  { 177, 9, 12, 11, 1, -12 },
  { 191, 9, 12, 11, 1, -12 },
  { 205, 9, 12, 11, 1, -12 },
  { 219, 9, 12, 11, 1, -12 },
  { 233, 8, 12, 11, 1, -12 },
  { 245, 9, 12, 11, 1, -12 },
  { 259, 9, 12, 11, 1, -12 },
  { 273, 2, 10, 11, 4, -10 },
  { 276, 4, 13, 11, 3, -10 },
  { 283, 9, 9, 11, 1, -11 },
  { 294, 9, 5, 11, 1, -9 },
  { 300, 9, 9, 11, 1, -11 },
  { 311, 8, 12, 11, 1, -12 },
  { 323, 10, 15, 11, 0, -13 },
  { 342, 11, 12, 11, 0, -12 },
  { 359, 9, 12, 11, 1, -12 },
  { 373, 9, 12, 11, 1, -12 },
  { 387, 9, 12, 11, 1, -12 },
  { 401, 9, 12, 11, 1, -12 },
  { 415, 8, 12, 11, 2, -12 },
  { 427, 9, 12, 11, 1, -12 },
  { 441, 8, 12, 11, 1, -12 },
  { 453, 7, 12, 11, 2, -12 },
  { 464, 7, 12, 11, 2, -12 },
  { 475, 10, 12, 11, 1, -12 },
  { 490, 8, 12, 11, 2, -12 },
  { 502, 9, 12, 11, 1, -12 },
  { 516, 8, 12, 11, 1, -12 },
  { 528, 9, 12, 11, 1, -12 },
  { 542, 9, 12, 11, 1, -12 },
  { 556, 9, 15, 11, 1, -12 },
  { 573, 9, 12, 11, 1, -12 },
  { 587, 9, 12, 11, 1, -12 },
  { 601, 9, 12, 11, 1, -12 },
  { 615, 9, 12, 11, 1, -12 },
  { 629, 11, 12, 11, 0, -12 },
  { 646, 11, 12, 11, 0, -12 },
  { 663, 10, 12, 11, 0, -12 },
  { 678, 10, 12, 11, 0, -12 },
  { 693, 9, 12, 11, 1, -12 },
  { 707, 4, 17, 11, 4, -13 },
  { 716, 9, 13, 11, 1, -13 },
  { 731, 5, 17, 11, 2, -13 },
  { 742, 9, 8, 11, 1, -12 },
  { 751, 11, 1, 11, 0, 1 },
  { 753, 3, 3, 11, 4, -14 },
  { 755, 9, 10, 11, 1, -10 },
  { 767, 8, 13, 11, 2, -13 },
  { 780, 9, 10, 11, 1, -10 },
  { 792, 8, 13, 11, 1, -13 },
  { 805, 9, 10, 11, 1, -10 },
  { 817, 9, 13, 11, 1, -13 },
  { 832, 8, 14, 11, 1, -10 },
  { 846, 7, 13, 11, 2, -13 },
  { 858, 9, 13, 11, 1, -13 },
  { 873, 6, 17, 11, 1, -13 },
  { 886, 8, 13, 11, 2, -13 },
  { 899, 9, 13, 11, 1, -13 },
  { 914, 9, 10, 11, 1, -10 },
  { 926, 7, 10, 11, 2, -10 },
  { 935, 9, 10, 11, 1, -10 },
  { 947, 8, 14, 11, 2, -10 },
  { 961, 8, 14, 11, 1, -10 },
  { 975, 7, 10, 11, 2, -10 },
  { 984, 8, 10, 11, 1, -10 },
  { 994, 7, 12, 11, 2, -12 },
  { 1005, 7, 10, 11, 2, -10 },
  { 1014, 9, 10, 11, 1, -10 },
  { 1026, 11, 10, 11, 0, -10 },
  { 1040, 9, 10, 11, 1, -10 },
  { 1052, 9, 14, 11, 1, -10 },
  { 1068, 8, 10, 11, 1, -10 },
  { 1078, 7, 17, 11, 2, -13 },
  { 1093, 1, 17, 11, 5, -13 },
  { 1096, 8, 17, 11, 1, -13 },
  { 1113, 9, 2, 11, 1, -7 },
};

const GFXfont LiberationMono_Regular18pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular18pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular18pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _LIBERATIONMONO_REGULAR18PT7B_H_
