#ifndef _LIBERATIONMONO_REGULAR57PT7B_H_
#define _LIBERATIONMONO_REGULAR57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDE,
  0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x00,
  0xE0, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70,
  0x03, 0x80, 0x01, 0xC0, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x70, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xE3, 0x8F,
  0xE0, 0xFC, 0x0E, 0x0F, 0xC3, 0xE0, 0x38, 0x1F, 0x0F, 0x80, 0xE0, 0x7E,
  0x3E, 0x03, 0x80, 0xF8, 0xF0, 0x0E, 0x03, 0x83, 0xC0, 0x38, 0x00, 0x0F,
  0x80, 0xE0, 0x00, 0x3E, 0x03, 0x80, 0x00, 0xFC, 0x0E, 0x00, 0x01, 0xF8,
  0x38, 0x00, 0x03, 0xFC, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0E, 0x3F, 0xC0, 0x00, 0x38, 0x3F, 0x80, 0x00, 0xE0, 0x3E,
  0x00, 0x03, 0x80, 0xFC, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x38, 0x07, 0xCE,
  0x00, 0xE0, 0x1F, 0xF8, 0x03, 0x80, 0x7F, 0xE0, 0x0E, 0x01, 0xF7, 0xC0,
  0x38, 0x0F, 0xDF, 0x80, 0xE0, 0x3E, 0x3F, 0x03, 0x81, 0xF8, 0xFF, 0x0E,
  0x3F, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xC3, 0xFF, 0xC0, 0x01, 0xE1, 0xF0, 0xF8, 0x00,
  0xF0, 0x78, 0x1E, 0x00, 0x3C, 0x3E, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0xF0,
  0x0F, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xF0,
  0x0F, 0x0F, 0x00, 0x3E, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE1, 0xE0, 0x01,
  0xF0, 0xF8, 0xF0, 0x00, 0x3F, 0xFC, 0x7C, 0x00, 0x07, 0xFE, 0x1E, 0x00,
  0x00, 0x7E, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x7F, 0x00, 0x00, 0x78, 0x7F, 0xE0, 0x00, 0x1E,
  0x3F, 0xFC, 0x00, 0x0F, 0x1F, 0x0F, 0x80, 0x07, 0x87, 0x81, 0xE0, 0x01,
  0xE1, 0xE0, 0x3C, 0x00, 0xF0, 0xF8, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xC0,
  0x1E, 0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x80, 0xF0, 0x78, 0x01, 0xE0,
  0x3C, 0x3E, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x87, 0x80, 0x03,
  0xFF, 0xC3, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0,
  0x0F, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0,
  0x0F, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x01, 0xE0,
  0x7E, 0x00, 0x01, 0xE1, 0xFC, 0x00, 0x00, 0xF7, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x40, 0x07, 0xFC,
  0x00, 0x78, 0x0F, 0xFE, 0x00, 0xF8, 0x1F, 0xBE, 0x00, 0xF0, 0x3E, 0x1F,
  0x00, 0xF0, 0x3E, 0x0F, 0x00, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x78, 0x07,
  0xC1, 0xE0, 0xF8, 0x03, 0xE1, 0xE0, 0xF8, 0x03, 0xE3, 0xE0, 0xF8, 0x01,
  0xF3, 0xC0, 0xF8, 0x00, 0xFF, 0xC0, 0xF8, 0x00, 0xFF, 0x80, 0xF8, 0x00,
  0x7F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x7F, 0xC0, 0x3F, 0x81, 0xFF, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF, 0x0F, 0xFF,
  0xF1, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE0,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x04, 0x0F, 0x02, 0x78, 0x70, 0xFF, 0xE7, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0xC0, 0x07, 0x9E, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0x78, 0x1E,
  0x07, 0x80, 0x40, 0x20, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x1F,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0x7C, 0x1F,
  0x83, 0xFF, 0xC1, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xC1, 0xF8, 0x1F,
  0xFC, 0x1F, 0x81, 0xFF, 0xC1, 0xF8, 0x1F, 0x7C, 0x1F, 0x81, 0xF7, 0xC0,
  0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xEF, 0x80, 0x3F, 0xF9, 0xF0, 0x07, 0xFE, 0x3E,
  0x00, 0xFF, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0x0F,
  0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0x9F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3E, 0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7E,
  0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x3E,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x78, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x03,
  0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00,
  0x3E, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x03, 0xE7, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x3F, 0x00,
  0x1F, 0xC7, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xF0, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x1F,
  0x80, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0E,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x07, 0xF0, 0x07, 0xC3, 0xFF, 0xC0,
  0xF9, 0xFF, 0xFC, 0x1F, 0x7F, 0xFF, 0xC3, 0xEF, 0x83, 0xFC, 0x7F, 0xC0,
  0x1F, 0xCF, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F,
  0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x01, 0xF9,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE3, 0xE0,
  0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F,
  0xC3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xDF, 0x00, 0x03, 0xE7, 0xF0, 0x01, 0xF8, 0xFF, 0x01, 0xFC, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xC1, 0xFE, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0xFD, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x1F, 0xF3, 0xFC,
  0x0F, 0xFC, 0x7F, 0xFF, 0xDF, 0x0F, 0xFF, 0xE7, 0xC0, 0xFF, 0xE1, 0xF0,
  0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x80,
  0x0F, 0x83, 0xF0, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F,
  0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x81, 0xFC, 0x07, 0xF8, 0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF3, 0xE0,
  0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFC, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x03, 0xE0, 0x1E, 0x3C,
  0x07, 0xF1, 0xCE, 0x3C, 0x1F, 0xF9, 0xCE, 0x38, 0x1E, 0x1F, 0xCF, 0x38,
  0x3C, 0x0F, 0xCF, 0x78, 0x78, 0x0F, 0x87, 0x78, 0x78, 0x0F, 0x87, 0x78,
  0xF0, 0x07, 0x87, 0x70, 0xF0, 0x07, 0x87, 0x70, 0xE0, 0x0F, 0x87, 0xF1,
  0xE0, 0x0F, 0x07, 0xF1, 0xE0, 0x0F, 0x07, 0xF1, 0xE0, 0x0F, 0x07, 0xF1,
  0xE0, 0x0F, 0x07, 0xF1, 0xE0, 0x0F, 0x0F, 0xF1, 0xC0, 0x0E, 0x0F, 0xF1,
  0xC0, 0x1E, 0x0E, 0xF1, 0xC0, 0x1E, 0x0E, 0xF1, 0xE0, 0x1E, 0x0E, 0xF1,
  0xE0, 0x3E, 0x1E, 0xF1, 0xE0, 0x3E, 0x1C, 0x71, 0xE0, 0x7C, 0x1C, 0x70,
  0xE0, 0x6C, 0x3C, 0x78, 0xF1, 0xEE, 0x78, 0x78, 0xFF, 0xCF, 0xF0, 0x78,
  0x7F, 0x8F, 0xE0, 0x38, 0x1E, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x60, 0x07, 0x80, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0x80,
  0x1F, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC,
  0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x7C, 0x00,
  0x0F, 0xCF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x87,
  0xC0, 0x0F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x0F, 0x80, 0x0F, 0xF1, 0xF0, 0x00, 0x3F, 0x3E,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x1F,
  0xDF, 0x00, 0x0F, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x03, 0xF8,
  0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x3F,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x1F, 0x80, 0x00, 0x60, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x0C, 0x3F, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xF8, 0x07, 0xFC, 0x3E,
  0x00, 0x7F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF3,
  0xE0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x3E, 0x01, 0xFF, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x3E, 0x7E, 0x00, 0x01, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x3E,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x38, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07,
  0xDF, 0x00, 0x3F, 0x7E, 0x00, 0xF9, 0xFC, 0x07, 0xE3, 0xF8, 0x3F, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xF8,
  0x00, 0x0F, 0xE7, 0xC0, 0x00, 0xFE, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x7E, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0,
  0x1F, 0x00, 0x7F, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x3E,
  0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x3F,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF9, 0xF8, 0x00,
  0x07, 0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFB, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0xFE,
  0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x7F, 0x03,
  0xE0, 0x01, 0xFC, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF9, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xBC,
  0x01, 0xDF, 0xF7, 0x80, 0x7B, 0xFE, 0xF8, 0x0F, 0x7F, 0xCF, 0x03, 0xEF,
  0xF9, 0xE0, 0x79, 0xFF, 0x3E, 0x0F, 0x3F, 0xE3, 0xC3, 0xE7, 0xFC, 0x78,
  0x78, 0xFF, 0x8F, 0x8F, 0x1F, 0xF0, 0xF3, 0xC3, 0xFE, 0x1E, 0x78, 0x7F,
  0xC3, 0xEF, 0x0F, 0xF8, 0x3D, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0x7F,
  0x07, 0xFC, 0x0F, 0xC0, 0xFF, 0x81, 0xF8, 0x1F, 0xF0, 0x1F, 0x03, 0xFE,
  0x03, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xF7, 0xC0, 0x0F,
  0xFB, 0xE0, 0x07, 0xFC, 0xF0, 0x03, 0xFE, 0x7C, 0x01, 0xFF, 0x1E, 0x00,
  0xFF, 0x8F, 0x80, 0x7F, 0xC3, 0xC0, 0x3F, 0xE1, 0xF0, 0x1F, 0xF0, 0x78,
  0x0F, 0xF8, 0x3E, 0x07, 0xFC, 0x1F, 0x03, 0xFE, 0x07, 0xC1, 0xFF, 0x03,
  0xE0, 0xFF, 0x80, 0xF8, 0x7F, 0xC0, 0x7C, 0x3F, 0xE0, 0x1E, 0x1F, 0xF0,
  0x0F, 0x8F, 0xF8, 0x03, 0xC7, 0xFC, 0x01, 0xF3, 0xFE, 0x00, 0xF9, 0xFF,
  0x00, 0x3E, 0xFF, 0x80, 0x1F, 0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x07,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0xFF, 0x3E, 0x00, 0x0F, 0xEF, 0x80,
  0x01, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xBE, 0x00,
  0x0F, 0xCF, 0x80, 0x1F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xFC, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0xFF, 0x0F, 0x80, 0x03, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0xFC, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x8F, 0x80, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xF8,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07,
  0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFE, 0x01, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0E, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x8C, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x0F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC3, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0xFC, 0x07, 0xC3, 0xE0,
  0x3F, 0x01, 0xF0, 0xF8, 0x0F, 0xE0, 0x7C, 0x1E, 0x07, 0xF8, 0x1F, 0x07,
  0xC1, 0xFE, 0x07, 0x81, 0xF0, 0x7F, 0x81, 0xE0, 0x7C, 0x1E, 0xF0, 0xF8,
  0x1F, 0x0F, 0x3C, 0x3E, 0x07, 0xC3, 0xCF, 0x0F, 0x81, 0xF0, 0xF3, 0xC3,
  0xE0, 0x3C, 0x3C, 0x78, 0xF8, 0x0F, 0x1E, 0x1E, 0x3C, 0x03, 0xE7, 0x87,
  0x8F, 0x00, 0xF9, 0xE1, 0xE3, 0xC0, 0x3E, 0x78, 0x3C, 0xF0, 0x0F, 0xBC,
  0x0F, 0x7C, 0x01, 0xEF, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x77, 0x80, 0x1E,
  0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x03,
  0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x07,
  0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x83,
  0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFC,
  0x01, 0xF0, 0xFE, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8,
  0x00, 0x7F, 0x0F, 0x80, 0x0F, 0xF0, 0xFC, 0x01, 0xDF, 0x0F, 0xE0, 0x7D,
  0xF8, 0x7F, 0xFF, 0x9F, 0xF3, 0xFF, 0xF0, 0xFF, 0x1F, 0xFE, 0x0F, 0xF0,
  0x7F, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x07,
  0xF0, 0x1F, 0x0F, 0xFE, 0x0F, 0x9F, 0xFF, 0x87, 0xDF, 0xFF, 0xE3, 0xEF,
  0x03, 0xF9, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xBF,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xBF, 0x80, 0x07, 0xDF, 0xC0, 0x07, 0xEF, 0xF0, 0x07, 0xE7, 0xFE,
  0x07, 0xF3, 0xEF, 0xFF, 0xF1, 0xF3, 0xFF, 0xF0, 0xF8, 0xFF, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x07, 0xE3, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0xCF, 0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7F, 0x83, 0xE0, 0xFF, 0xF1,
  0xF0, 0xFF, 0xFC, 0xF8, 0xFF, 0xFF, 0x7C, 0xFE, 0x07, 0xFE, 0x7E, 0x00,
  0xFF, 0x7E, 0x00, 0x3F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x0F,
  0xEF, 0xC0, 0x07, 0xF3, 0xF0, 0x07, 0xF9, 0xFC, 0x0F, 0x7C, 0x7F, 0xFF,
  0xBE, 0x1F, 0xFF, 0x9F, 0x07, 0xFF, 0x8F, 0x80, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF9, 0xF0, 0x00,
  0x3E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x06, 0x0F, 0xC0, 0x03, 0xF3,
  0xF8, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xC7, 0xC3, 0xFF, 0xF3, 0xE3,
  0xFF, 0xFD, 0xF3, 0xFC, 0x1F, 0xF9, 0xF8, 0x03, 0xFD, 0xF8, 0x00, 0xFE,
  0xF8, 0x00, 0x7F, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFD, 0xF0,
  0x00, 0x7E, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0xCF,
  0xE0, 0x7B, 0xE3, 0xFF, 0xFD, 0xF1, 0xFF, 0xFC, 0xF8, 0x3F, 0xF8, 0x7C,
  0x07, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE3, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xF0, 0xFC, 0x01,
  0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x1F, 0xC0, 0xF8, 0x7F, 0xF0, 0xF9, 0xFF, 0xFC, 0xFB, 0xFF, 0xFC, 0xFB,
  0xC0, 0xFE, 0xFF, 0x80, 0x7E, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0xE0, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01,
  0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F,
  0x80, 0xF8, 0x3F, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0xFC, 0x00, 0xF9, 0xF8,
  0x00, 0xFB, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0x8F, 0x3F, 0xC3, 0xFC, 0xF7, 0xFE, 0x7F,
  0xEF, 0x7F, 0xEF, 0xFE, 0xFE, 0x3E, 0xE3, 0xFF, 0xC1, 0xFC, 0x1F, 0xFC,
  0x1F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8,
  0x0F, 0xF8, 0x0F, 0x80, 0xFF, 0x80, 0xF8, 0x0F, 0xF8, 0x0F, 0x00, 0xFF,
  0x80, 0xF0, 0x0F, 0xF8, 0x0F, 0x00, 0xFF, 0x80, 0xF0, 0x0F, 0xF8, 0x0F,
  0x00, 0xFF, 0x80, 0xF0, 0x0F, 0xF8, 0x0F, 0x00, 0xFF, 0x80, 0xF0, 0x0F,
  0xF8, 0x0F, 0x00, 0xFF, 0x80, 0xF0, 0x0F, 0xF8, 0x0F, 0x00, 0xFF, 0x80,
  0xF0, 0x0F, 0xF8, 0x0F, 0x00, 0xFF, 0x80, 0xF0, 0x0F, 0xF8, 0x0F, 0x00,
  0xFF, 0x80, 0xF0, 0x0F, 0xF8, 0x0F, 0x00, 0xFF, 0x80, 0xF0, 0x0F, 0xF8,
  0x0F, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0xF8, 0x7F, 0xF8, 0xF9, 0xFF, 0xFC,
  0xFB, 0xFF, 0xFC, 0xFB, 0xC0, 0xFE, 0xFF, 0x80, 0x7E, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0xBF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x7C, 0x3F, 0xF8, 0x3E, 0x7F, 0xFE, 0x1F, 0x7F, 0xFF,
  0x8F, 0xBC, 0x0F, 0xE7, 0xF8, 0x03, 0xFB, 0xF8, 0x00, 0xFD, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x7F, 0x00, 0x1F, 0xBF, 0xC0, 0x1F,
  0x9F, 0x78, 0x1F, 0xCF, 0xBF, 0xFF, 0xC7, 0xCF, 0xFF, 0xC3, 0xE3, 0xFF,
  0xC1, 0xF0, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0x83, 0xFF, 0xC7, 0xC3, 0xFF, 0xF3,
  0xE3, 0xFF, 0xFD, 0xF3, 0xF8, 0x1F, 0xF9, 0xF8, 0x03, 0xFD, 0xF8, 0x00,
  0xFE, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0xCF, 0xC0, 0x1F, 0xE7, 0xF0, 0x3D, 0xF1, 0xFF, 0xFE, 0xF8, 0x7F, 0xFE,
  0x7C, 0x1F, 0xFE, 0x3E, 0x03, 0xFC, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFD, 0xF7, 0xE0, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xE3,
  0xF0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xCF, 0xE0, 0x1F, 0xC7,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x18, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x7F,
  0x03, 0xFF, 0x3F, 0xFF, 0xDF, 0x3F, 0xFF, 0x8F, 0x0F, 0xFF, 0x0F, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xE0,
  0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3D, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x07, 0xE0, 0x3E, 0x3E, 0x03, 0xF0, 0x1F,
  0x1F, 0x01, 0xFC, 0x0F, 0x87, 0x81, 0xFE, 0x07, 0xC3, 0xC0, 0xFF, 0x03,
  0xC1, 0xF0, 0x73, 0x83, 0xE0, 0xF8, 0x79, 0xE1, 0xF0, 0x7C, 0x3C, 0xF0,
  0xF8, 0x3E, 0x1E, 0x38, 0x7C, 0x0F, 0x1E, 0x1E, 0x3E, 0x07, 0x8F, 0x0F,
  0x1E, 0x03, 0xC7, 0x87, 0x8F, 0x01, 0xF7, 0x81, 0xEF, 0x80, 0xFB, 0xC0,
  0xF7, 0xC0, 0x7D, 0xE0, 0x7B, 0xE0, 0x1E, 0xE0, 0x1D, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0xF8,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0,
  0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x80,
};

const GFXglyph LiberationMono_Regular57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 6, 38, 34, 14, -38 },
  { 30, 18, 18, 34, 8, -41 },
  { 71, 31, 38, 34, 1, -38 },
  { 219, 30, 46, 34, 2, -42 },
  { 392, 34, 40, 34, 0, -39 },
  { 562, 32, 39, 34, 1, -38 },
  { 718, 6, 18, 34, 14, -41 },
  { 732, 15, 53, 34, 10, -41 },
  { 832, 16, 53, 34, 9, -41 },
  { 938, 20, 20, 34, 7, -41 },
  { 988, 28, 28, 34, 3, -33 },
  { 1086, 12, 18, 34, 7, -8 },
  { 1113, 16, 4, 34, 9, -17 },
  { 1121, 6, 8, 34, 14, -8 },
  { 1127, 28, 42, 34, 3, -41 },
  { 1274, 28, 40, 34, 3, -39 },
  { 1414, 27, 38, 34, 4, -38 },
  { 1543, 26, 39, 34, 4, -39 },
  { 1670, 27, 40, 34, 4, -39 },
  { 1805, 28, 38, 34, 3, -38 },
  { 1938, 27, 39, 34, 4, -38 },
  { 2070, 27, 40, 34, 4, -39 },
  { 2205, 26, 38, 34, 4, -38 },
  { 2329, 26, 40, 34, 4, -39 },
  { 2459, 26, 40, 34, 4, -39 },
  { 2589, 6, 30, 34, 14, -30 },
  { 2612, 12, 40, 34, 10, -30 },
  { 2672, 28, 29, 34, 3, -33 },
  { 2774, 28, 18, 34, 3, -28 },
  { 2837, 28, 29, 34, 3, -33 },
  { 2939, 27, 39, 34, 3, -39 },
  { 3071, 32, 49, 34, 1, -41 },
  { 3267, 34, 38, 34, 0, -38 },
  { 3429, 27, 38, 34, 5, -38 },
  { 3558, 29, 40, 34, 3, -39 },
  { 3703, 26, 38, 34, 5, -38 },
  { 3827, 26, 38, 34, 5, -38 },
  { 3951, 25, 38, 34, 5, -38 },
  { 4070, 28, 40, 34, 3, -39 },
  { 4210, 25, 38, 34, 5, -38 },
  { 4329, 23, 38, 34, 6, -38 },
  { 4439, 22, 39, 34, 5, -38 },
  { 4547, 29, 38, 34, 5, -38 },
  { 4685, 24, 38, 34, 7, -38 },
  { 4799, 27, 38, 34, 4, -38 },
  { 4928, 25, 38, 34, 5, -38 },
  { 5047, 28, 40, 34, 3, -39 },
  { 5187, 26, 38, 34, 5, -38 },
  { 5311, 29, 50, 34, 3, -39 },
  { 5493, 28, 38, 34, 5, -38 },
  { 5626, 29, 40, 34, 2, -39 },
  { 5771, 30, 38, 34, 2, -38 },
  { 5914, 26, 39, 34, 4, -38 },
  { 6041, 34, 38, 34, 0, -38 },
  { 6203, 34, 38, 34, 0, -38 },
  { 6365, 32, 38, 34, 1, -38 },
  { 6517, 32, 38, 34, 1, -38 },
  { 6669, 30, 38, 34, 2, -38 },
  { 6812, 16, 53, 34, 11, -41 },
  { 6918, 28, 42, 34, 3, -41 },
  { 7065, 15, 53, 34, 8, -41 },
  { 7165, 26, 25, 34, 4, -38 },
  { 7247, 34, 3, 34, 0, 3 },
  { 7260, 12, 7, 34, 11, -40 },
  { 7271, 28, 32, 34, 4, -31 },
  { 7383, 25, 42, 34, 5, -41 },
  { 7515, 26, 32, 34, 4, -31 },
  { 7619, 25, 42, 34, 4, -41 },
  { 7751, 26, 32, 34, 4, -31 },
  { 7855, 27, 41, 34, 4, -41 },
  { 7994, 25, 43, 34, 4, -31 },
  { 8129, 24, 41, 34, 5, -41 },
  { 8252, 27, 41, 34, 4, -41 },
  { 8391, 20, 53, 34, 3, -41 },
  { 8524, 24, 41, 34, 7, -41 },
  { 8647, 27, 41, 34, 4, -41 },
  { 8786, 28, 31, 34, 3, -31 },
  { 8895, 24, 31, 34, 5, -31 },
  { 8988, 27, 32, 34, 4, -31 },
  { 9096, 25, 43, 34, 5, -31 },
  { 9231, 25, 43, 34, 4, -31 },
  { 9366, 22, 31, 34, 7, -31 },
  { 9452, 25, 32, 34, 5, -31 },
  { 9552, 23, 39, 34, 5, -38 },
  { 9665, 24, 31, 34, 5, -30 },
  { 9758, 30, 30, 34, 2, -30 },
  { 9871, 33, 30, 34, 1, -30 },
  { 9995, 29, 30, 34, 3, -30 },
  { 10104, 30, 42, 34, 2, -30 },
  { 10262, 26, 30, 34, 4, -30 },
  { 10360, 24, 53, 34, 6, -41 },
  { 10519, 4, 53, 34, 15, -41 },
  { 10546, 23, 53, 34, 5, -41 },
  { 10699, 28, 7, 34, 3, -22 },
};

const GFXfont LiberationMono_Regular57pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular57pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular57pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _LIBERATIONMONO_REGULAR57PT7B_H_
