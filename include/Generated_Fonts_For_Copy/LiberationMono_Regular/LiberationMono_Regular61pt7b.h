#ifndef _LIBERATIONMONO_REGULAR61PT7B_H_
#define _LIBERATIONMONO_REGULAR61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03,
  0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0,
  0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xE7, 0xC0, 0x1E, 0x7C,
  0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x38, 0x07, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x78, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xE1, 0xC7, 0xF8, 0x1F, 0x81, 0xC1, 0xFC, 0x3F, 0x01, 0xC0, 0xFC,
  0x3E, 0x01, 0xC0, 0x7E, 0x3E, 0x01, 0xC0, 0x7E, 0x3E, 0x01, 0xC0, 0x3E,
  0x3E, 0x01, 0xC0, 0x38, 0x3E, 0x01, 0xC0, 0x00, 0x3F, 0x01, 0xC0, 0x00,
  0x1F, 0x81, 0xC0, 0x00, 0x1F, 0xC1, 0xC0, 0x00, 0x0F, 0xF9, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xC7, 0xFC,
  0x00, 0x01, 0xC0, 0xFC, 0x00, 0x01, 0xC0, 0x7E, 0x00, 0x01, 0xC0, 0x3E,
  0x00, 0x01, 0xC0, 0x1F, 0x00, 0x01, 0xC0, 0x1F, 0x00, 0x01, 0xC0, 0x1F,
  0x18, 0x01, 0xC0, 0x1F, 0xF8, 0x01, 0xC0, 0x1F, 0xFC, 0x01, 0xC0, 0x1F,
  0x7C, 0x01, 0xC0, 0x1F, 0x7E, 0x01, 0xC0, 0x3F, 0x3F, 0x01, 0xC0, 0x7E,
  0x3F, 0x81, 0xC0, 0xFE, 0x1F, 0xE1, 0xC3, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1E, 0x0F, 0xFF, 0x80, 0x01, 0xE0, 0xFC, 0x3E,
  0x00, 0x1F, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0x0F, 0x03,
  0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xE0,
  0x0F, 0x03, 0xC0, 0x0F, 0x80, 0x78, 0x3C, 0x00, 0x7C, 0x07, 0xC3, 0xE0,
  0x01, 0xE0, 0x3C, 0x1E, 0x00, 0x0F, 0x81, 0xE1, 0xE0, 0x00, 0x7E, 0x1F,
  0x1F, 0x00, 0x01, 0xFF, 0xF0, 0xF0, 0x00, 0x07, 0xFF, 0x0F, 0x00, 0x00,
  0x0F, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x81, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0xF0, 0x00,
  0x03, 0xC3, 0xFF, 0xE0, 0x00, 0x3C, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xE0,
  0x7C, 0x00, 0x1E, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x1F,
  0x07, 0x80, 0x78, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x78, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x03,
  0xC0, 0x03, 0xC0, 0xF8, 0x3C, 0x00, 0x1F, 0x0F, 0x83, 0xE0, 0x00, 0x7F,
  0xF8, 0x1E, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F,
  0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0x00, 0x1F, 0xF8, 0x00, 0xF8,
  0x0F, 0xFF, 0x00, 0x3E, 0x07, 0xE7, 0xC0, 0x0F, 0x03, 0xF0, 0xF8, 0x03,
  0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF8,
  0x1E, 0x07, 0xC0, 0x3F, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0xF8, 0x00,
  0xF8, 0xF0, 0x3E, 0x00, 0x3F, 0x7C, 0x0F, 0x80, 0x07, 0xFE, 0x03, 0xE0,
  0x00, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFC, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE0, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x02,
  0x03, 0x81, 0x9F, 0x0E, 0x3E, 0x7F, 0xBF, 0xFD, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3E, 0xF0,
  0x00, 0xF3, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x0F, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0x70, 0x02, 0x01, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0,
  0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0xFE, 0x0F, 0xFE, 0x07, 0xF0, 0x7F,
  0xF0, 0x3F, 0x83, 0xFF, 0x81, 0xFC, 0x1F, 0xFC, 0x0F, 0xE0, 0xFF, 0xE0,
  0x7F, 0x07, 0xFF, 0x03, 0xF8, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0x7E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xBE, 0x00, 0x3F, 0xFC, 0xF8, 0x00, 0xFF, 0xC3, 0xE0, 0x03, 0xFC, 0x0F,
  0x80, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xC3,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x03, 0xE0, 0x01, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xFC, 0x00,
  0x7E, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFD, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xFC, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x3F,
  0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0x83,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x81, 0xFE, 0x00, 0x7C, 0x3F, 0xFC, 0x03, 0xE7, 0xFF, 0xF8,
  0x1F, 0x7F, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0x87, 0xFC, 0x00, 0xFE, 0x7F,
  0xC0, 0x03, 0xF3, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x1F,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC,
  0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0x01, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xF0, 0x1F,
  0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x03,
  0xF8, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x1F,
  0xF1, 0xFE, 0x07, 0xDF, 0x0F, 0xFF, 0xF9, 0xF0, 0x7F, 0xFF, 0x1F, 0x01,
  0xFF, 0xE1, 0xF0, 0x07, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x1C, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x80,
  0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x1F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E, 0x7E,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x03,
  0xE0, 0x1E, 0x1E, 0x03, 0xFC, 0x73, 0x87, 0x01, 0xFF, 0xBC, 0xF3, 0xC0,
  0xF0, 0xEF, 0x3C, 0xF0, 0x78, 0x1B, 0xCF, 0x38, 0x3C, 0x07, 0xE3, 0xDE,
  0x0F, 0x00, 0xF8, 0x77, 0x87, 0x80, 0x3E, 0x1D, 0xE1, 0xE0, 0x0F, 0x87,
  0x78, 0xF8, 0x03, 0xE1, 0xDC, 0x3C, 0x00, 0xF0, 0x77, 0x0F, 0x00, 0x3C,
  0x1F, 0xC3, 0xC0, 0x0F, 0x07, 0xF0, 0xF0, 0x03, 0xC1, 0xFC, 0x78, 0x01,
  0xF0, 0x7F, 0x1E, 0x00, 0x78, 0x1F, 0xC7, 0x80, 0x1E, 0x0F, 0xF1, 0xE0,
  0x07, 0x83, 0xFC, 0x78, 0x01, 0xE0, 0xFF, 0x1E, 0x00, 0xF8, 0x3B, 0xC7,
  0x80, 0x3C, 0x0E, 0x70, 0xE0, 0x0F, 0x07, 0x9C, 0x3C, 0x07, 0xC1, 0xE7,
  0x8F, 0x03, 0xF0, 0x71, 0xE3, 0xC0, 0xDC, 0x3C, 0x78, 0x78, 0xF7, 0x1E,
  0x1E, 0x1F, 0xF9, 0xFF, 0x03, 0xC3, 0xFC, 0x3F, 0x80, 0xF0, 0x7C, 0x07,
  0xC0, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x40, 0x07, 0x80, 0x00, 0x38, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7E,
  0x00, 0x3F, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC3, 0xF0, 0x00, 0xFF, 0x9F, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xFD,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xE3, 0xF8, 0x00, 0x03, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x06, 0x0F, 0xC0, 0x00, 0x0F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7E, 0x01, 0xFF, 0x83, 0xF0,
  0x01, 0xFE, 0x1F, 0x80, 0x07, 0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x7F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3E, 0xFC,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x3F,
  0x87, 0xE0, 0x03, 0xFC, 0x3F, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0x10, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x7E, 0x00, 0xFF, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC,
  0x7E, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x07,
  0xF8, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x1C, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F,
  0x3F, 0x00, 0x7E, 0x3F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFD, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xDF, 0xC0,
  0x00, 0xFF, 0x9F, 0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFB, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xDF, 0xFF, 0xC0, 0x1E, 0xFF, 0xDF, 0x01, 0xF7, 0xFE,
  0xF8, 0x0F, 0x3F, 0xF7, 0xC0, 0x79, 0xFF, 0x9F, 0x07, 0xCF, 0xFC, 0xF8,
  0x3C, 0x7F, 0xE3, 0xC1, 0xE3, 0xFF, 0x1F, 0x1F, 0x1F, 0xF8, 0xF8, 0xF0,
  0xFF, 0xC3, 0xC7, 0x87, 0xFE, 0x1F, 0x7C, 0x3F, 0xF0, 0xFB, 0xC1, 0xFF,
  0x83, 0xDE, 0x0F, 0xFC, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0x03, 0xFF, 0x03,
  0xF8, 0x1F, 0xF8, 0x1F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x7C, 0x00, 0x7F, 0xEF, 0x80,
  0x0F, 0xFC, 0xF8, 0x01, 0xFF, 0x9F, 0x00, 0x3F, 0xF1, 0xF0, 0x07, 0xFE,
  0x3E, 0x00, 0xFF, 0xC3, 0xE0, 0x1F, 0xF8, 0x7C, 0x03, 0xFF, 0x0F, 0xC0,
  0x7F, 0xE0, 0xF8, 0x0F, 0xFC, 0x1F, 0x81, 0xFF, 0x81, 0xF0, 0x3F, 0xF0,
  0x3E, 0x07, 0xFE, 0x03, 0xE0, 0xFF, 0xC0, 0x7C, 0x1F, 0xF8, 0x07, 0xC3,
  0xFF, 0x00, 0xF8, 0x7F, 0xE0, 0x0F, 0x8F, 0xFC, 0x01, 0xF1, 0xFF, 0x80,
  0x1F, 0x3F, 0xF0, 0x03, 0xE7, 0xFE, 0x00, 0x7E, 0xFF, 0xC0, 0x07, 0xDF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFE,
  0x07, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7F,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xCF, 0xC0, 0x07, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xEF, 0xC0, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x7F, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0xFF, 0x8F, 0xC0, 0x00, 0xFF, 0x3F, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0,
  0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x70, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x1C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0xC0,
  0x01, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xFC, 0x03, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0xFC,
  0x07, 0xF0, 0x1F, 0x07, 0xE0, 0x3F, 0x80, 0xF8, 0x1F, 0x01, 0xFC, 0x07,
  0xC0, 0xF8, 0x1F, 0xE0, 0x3E, 0x07, 0xC0, 0xF7, 0x81, 0xF0, 0x3E, 0x07,
  0xBC, 0x0F, 0x81, 0xF0, 0x7D, 0xE0, 0xF8, 0x0F, 0x83, 0xCF, 0x87, 0xC0,
  0x3E, 0x1E, 0x3C, 0x3E, 0x01, 0xF0, 0xF1, 0xE1, 0xF0, 0x0F, 0x8F, 0x8F,
  0x0F, 0x80, 0x7C, 0x78, 0x7C, 0x7C, 0x03, 0xE3, 0xC1, 0xE3, 0xC0, 0x1F,
  0x1E, 0x0F, 0x1E, 0x00, 0xF9, 0xF0, 0x79, 0xF0, 0x03, 0xCF, 0x03, 0xEF,
  0x80, 0x1E, 0x78, 0x0F, 0x7C, 0x00, 0xFB, 0xC0, 0x7B, 0xE0, 0x07, 0xFE,
  0x03, 0xDF, 0x00, 0x3F, 0xE0, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3C, 0xF8, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xE0, 0x3E,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFC,
  0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0xFF, 0x07, 0xE0, 0x03, 0xBE, 0x0F, 0xE0, 0x0F, 0x7C, 0x0F,
  0xE0, 0x7C, 0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0x1F,
  0xFF, 0x03, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x07,
  0xC3, 0xFF, 0xC0, 0xF9, 0xFF, 0xFC, 0x1F, 0x7F, 0xFF, 0xC3, 0xEF, 0x03,
  0xFC, 0x7F, 0xC0, 0x1F, 0x8F, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7D,
  0xFE, 0x00, 0x1F, 0xBF, 0xC0, 0x03, 0xF7, 0xFC, 0x00, 0xFC, 0xFF, 0xE0,
  0x7F, 0x9F, 0xBF, 0xFF, 0xE3, 0xF3, 0xFF, 0xF8, 0x7E, 0x3F, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xC1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x3E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x03, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x7F, 0x81, 0xF0, 0x3F, 0xFC, 0x3E, 0x0F, 0xFF,
  0xE7, 0xC3, 0xFF, 0xFC, 0xF8, 0xFE, 0x07, 0xDF, 0x3F, 0x80, 0x3F, 0xE7,
  0xE0, 0x03, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xC0, 0x00,
  0x7E, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F,
  0xBE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xCF, 0xC0,
  0x07, 0xF9, 0xFC, 0x01, 0xDF, 0x1F, 0xC0, 0xFB, 0xE3, 0xFF, 0xFE, 0x7C,
  0x3F, 0xFF, 0x8F, 0x81, 0xFF, 0xE1, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0C, 0x0F, 0xC0, 0x00, 0xFC,
  0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x7C, 0x1F, 0xFF, 0x8F, 0x87, 0xFF, 0xF9, 0xF1, 0xFE, 0x0F, 0xBE, 0x7F,
  0x00, 0x7F, 0xCF, 0xC0, 0x07, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFC, 0xFC, 0x00,
  0x7F, 0x9F, 0xC0, 0x1D, 0xF1, 0xFC, 0x0F, 0xBE, 0x3F, 0xFF, 0xE7, 0xC3,
  0xFF, 0xF8, 0xF8, 0x3F, 0xFE, 0x1F, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x1E,
  0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x1F,
  0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xFC, 0x0F, 0x87, 0xFF, 0x87, 0xCF,
  0xFF, 0xE3, 0xEF, 0xFF, 0xF9, 0xF7, 0x81, 0xFE, 0xFF, 0x80, 0x3F, 0x7F,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0xE0, 0x0F, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x1F,
  0x87, 0xC0, 0x07, 0xE0, 0xF8, 0x01, 0xFC, 0x1F, 0x00, 0x3F, 0x03, 0xE0,
  0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x3F, 0x00,
  0x3E, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x3F,
  0x00, 0x03, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0x7E, 0x00, 0x3F, 0xCF, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x0F,
  0xC0, 0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x0F,
  0x80, 0x1F, 0x81, 0xF0, 0x03, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x03,
  0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x7E, 0x7C,
  0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x07, 0xE3, 0xC7,
  0xF8, 0x3F, 0xCF, 0x3F, 0xF1, 0xFF, 0xBE, 0xFF, 0xCF, 0xFE, 0xFF, 0x1F,
  0xF8, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xE0, 0xFE, 0x07, 0xFF, 0x03, 0xF8,
  0x1F, 0xFC, 0x07, 0xC0, 0x7F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0x7C, 0x07,
  0xFE, 0x01, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x1F, 0x01, 0xFF,
  0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xE0,
  0x1F, 0x01, 0xFF, 0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF0, 0x1F, 0xF8, 0x07,
  0xC0, 0x7F, 0xE0, 0x1F, 0x01, 0xFF, 0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF0,
  0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x1F, 0x01, 0xFF, 0x80, 0x7C, 0x07,
  0xFE, 0x01, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x1F, 0x01, 0xFF,
  0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x7C, 0x00,
  0x0F, 0xF0, 0x3E, 0x0F, 0xFF, 0x0F, 0x8F, 0xFF, 0xE3, 0xF7, 0xFF, 0xFC,
  0xFD, 0xE0, 0x7F, 0xBF, 0xF0, 0x07, 0xEF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0x87, 0xFF, 0x83, 0xF3, 0xFF,
  0xF8, 0x7E, 0xFF, 0xFF, 0x8F, 0xDE, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0x3F,
  0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x80,
  0x07, 0xE7, 0xF8, 0x01, 0xF8, 0xFF, 0xC0, 0xFF, 0x1F, 0x7F, 0xFF, 0xC3,
  0xE7, 0xFF, 0xF0, 0x7C, 0x7F, 0xFC, 0x0F, 0x81, 0xFE, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xE0, 0x7F, 0xF8, 0x7C, 0x1F, 0xFF,
  0x8F, 0x87, 0xFF, 0xF9, 0xF1, 0xFC, 0x0F, 0xBE, 0x7F, 0x00, 0x7F, 0xCF,
  0xC0, 0x07, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0x80, 0x00,
  0xFD, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F,
  0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x9F, 0x80,
  0x0F, 0xF3, 0xF8, 0x03, 0xBE, 0x3F, 0x81, 0xF7, 0xC7, 0xFF, 0xFC, 0xF8,
  0x7F, 0xFF, 0x1F, 0x03, 0xFF, 0xC3, 0xE0, 0x1F, 0xE0, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x7C, 0x3F, 0xFF,
  0x7C, 0x7F, 0xFF, 0x7C, 0x7F, 0xFF, 0x7C, 0xFE, 0x00, 0x7E, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x7E,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE7, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFC, 0xFF, 0x00, 0x7F, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x07, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xF8, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xF7, 0xF0, 0x1E, 0xFB, 0xFF,
  0xFE, 0x7C, 0xFF, 0xFE, 0x3E, 0x3F, 0xFE, 0x1F, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0xE0, 0x3E,
  0x1F, 0x01, 0xFC, 0x07, 0xC3, 0xE0, 0x7F, 0x80, 0xF8, 0x7C, 0x0F, 0x78,
  0x3F, 0x0F, 0x81, 0xEF, 0x07, 0xC1, 0xF0, 0x79, 0xE0, 0xF8, 0x3E, 0x0F,
  0x3E, 0x1F, 0x03, 0xE1, 0xE3, 0xC3, 0xE0, 0x7C, 0x7C, 0x78, 0x7C, 0x0F,
  0x8F, 0x0F, 0x1F, 0x81, 0xF1, 0xE0, 0xF3, 0xE0, 0x3E, 0x7C, 0x1E, 0x7C,
  0x07, 0xCF, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x3D, 0xF0, 0x0F, 0x7C, 0x07,
  0xBE, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0x3F, 0xE0, 0x0E, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xF8,
};

const GFXglyph LiberationMono_Regular61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 6, 40, 37, 15, -40 },
  { 31, 20, 19, 37, 8, -44 },
  { 79, 33, 40, 37, 2, -40 },
  { 244, 32, 49, 37, 2, -44 },
  { 440, 37, 42, 37, 0, -41 },
  { 635, 34, 41, 37, 1, -40 },
  { 810, 7, 19, 37, 15, -44 },
  { 827, 17, 57, 37, 10, -44 },
  { 949, 16, 57, 37, 10, -44 },
  { 1063, 22, 21, 37, 7, -44 },
  { 1121, 30, 30, 37, 3, -35 },
  { 1234, 13, 20, 37, 8, -9 },
  { 1267, 17, 5, 37, 10, -19 },
  { 1278, 7, 9, 37, 15, -9 },
  { 1286, 30, 45, 37, 3, -44 },
  { 1455, 29, 42, 37, 4, -41 },
  { 1608, 30, 40, 37, 4, -40 },
  { 1758, 28, 41, 37, 4, -41 },
  { 1902, 29, 42, 37, 4, -41 },
  { 2055, 31, 40, 37, 3, -40 },
  { 2210, 29, 41, 37, 4, -40 },
  { 2359, 29, 42, 37, 4, -41 },
  { 2512, 27, 40, 37, 5, -40 },
  { 2647, 29, 42, 37, 4, -41 },
  { 2800, 28, 42, 37, 4, -41 },
  { 2947, 7, 32, 37, 15, -32 },
  { 2975, 13, 43, 37, 10, -32 },
  { 3045, 30, 31, 37, 3, -36 },
  { 3162, 30, 20, 37, 3, -30 },
  { 3237, 30, 31, 37, 3, -36 },
  { 3354, 29, 41, 37, 3, -41 },
  { 3503, 34, 51, 37, 1, -44 },
  { 3720, 37, 40, 37, 0, -40 },
  { 3905, 29, 40, 37, 5, -40 },
  { 4050, 31, 42, 37, 3, -41 },
  { 4213, 29, 40, 37, 5, -40 },
  { 4358, 28, 40, 37, 5, -40 },
  { 4498, 26, 40, 37, 6, -40 },
  { 4628, 30, 42, 37, 3, -41 },
  { 4786, 27, 40, 37, 5, -40 },
  { 4921, 25, 40, 37, 6, -40 },
  { 5046, 24, 41, 37, 5, -40 },
  { 5169, 32, 40, 37, 5, -40 },
  { 5329, 26, 40, 37, 7, -40 },
  { 5459, 29, 40, 37, 4, -40 },
  { 5604, 27, 40, 37, 5, -40 },
  { 5739, 31, 42, 37, 3, -41 },
  { 5902, 28, 40, 37, 5, -40 },
  { 6042, 31, 53, 37, 3, -41 },
  { 6248, 30, 40, 37, 5, -40 },
  { 6398, 32, 42, 37, 2, -41 },
  { 6566, 32, 40, 37, 2, -40 },
  { 6726, 28, 41, 37, 4, -40 },
  { 6870, 36, 40, 37, 0, -40 },
  { 7050, 37, 40, 37, 0, -40 },
  { 7235, 35, 40, 37, 1, -40 },
  { 7410, 35, 40, 37, 1, -40 },
  { 7585, 32, 40, 37, 2, -40 },
  { 7745, 17, 57, 37, 12, -44 },
  { 7867, 30, 45, 37, 3, -44 },
  { 8036, 16, 57, 37, 8, -44 },
  { 8150, 29, 27, 37, 4, -40 },
  { 8248, 37, 3, 37, 0, 4 },
  { 8262, 13, 8, 37, 12, -44 },
  { 8275, 31, 34, 37, 4, -33 },
  { 8407, 27, 45, 37, 5, -44 },
  { 8559, 28, 34, 37, 4, -33 },
  { 8678, 27, 45, 37, 4, -44 },
  { 8830, 29, 34, 37, 4, -33 },
  { 8954, 29, 44, 37, 4, -44 },
  { 9114, 27, 46, 37, 4, -33 },
  { 9270, 25, 44, 37, 6, -44 },
  { 9408, 30, 44, 37, 4, -44 },
  { 9573, 22, 57, 37, 3, -44 },
  { 9730, 27, 44, 37, 7, -44 },
  { 9879, 29, 44, 37, 4, -44 },
  { 10039, 30, 33, 37, 3, -33 },
  { 10163, 26, 33, 37, 5, -33 },
  { 10271, 29, 34, 37, 4, -33 },
  { 10395, 27, 46, 37, 5, -33 },
  { 10551, 27, 46, 37, 4, -33 },
  { 10707, 24, 33, 37, 7, -33 },
  { 10806, 27, 34, 37, 5, -33 },
  { 10921, 24, 41, 37, 6, -40 },
  { 11044, 25, 33, 37, 6, -32 },
  { 11148, 33, 32, 37, 2, -32 },
  { 11280, 35, 32, 37, 1, -32 },
  { 11420, 31, 32, 37, 3, -32 },
  { 11544, 33, 45, 37, 2, -32 },
  { 11730, 28, 32, 37, 4, -32 },
  { 11842, 25, 57, 37, 7, -44 },
  { 12021, 5, 57, 37, 16, -44 },
  { 12057, 25, 57, 37, 5, -44 },
  { 12236, 30, 8, 37, 3, -24 },
};

const GFXfont LiberationMono_Regular61pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular61pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular61pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _LIBERATIONMONO_REGULAR61PT7B_H_
