#ifndef _LIBERATIONMONO_REGULAR42PT7B_H_
#define _LIBERATIONMONO_REGULAR42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7E, 0x03,
  0x80, 0x00, 0xE0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x01, 0xC0, 0x06, 0x03,
  0x80, 0x1C, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x70,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x0C, 0x03, 0x00, 0x18, 0x0E, 0x00,
  0x30, 0x1C, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x06,
  0x01, 0x81, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x60, 0x18, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0xE0, 0x03, 0x01, 0xC0, 0x0E, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x0F, 0xCE, 0x7E, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x3C,
  0x70, 0x70, 0x70, 0xE0, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x03,
  0xF7, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0xE3, 0xE0, 0x01, 0xC1, 0xE0, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x80, 0x0E, 0x07, 0x98, 0x1C, 0x0F, 0x70, 0x38, 0x1C, 0xF0, 0x70,
  0x79, 0xF0, 0xE0, 0xF1, 0xF9, 0xC7, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x1F, 0x80, 0x0E, 0x1F, 0xE0, 0x07, 0x1C, 0x38, 0x07, 0x1E, 0x1C, 0x07,
  0x0E, 0x07, 0x03, 0x87, 0x03, 0x83, 0x83, 0x81, 0xC3, 0x81, 0xC0, 0xE1,
  0xC0, 0xE0, 0x71, 0xC0, 0x70, 0x79, 0xC0, 0x1C, 0x39, 0xE0, 0x0E, 0x3C,
  0xE0, 0x03, 0xFC, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x00, 0x71, 0xF0, 0x00,
  0x73, 0xFE, 0x00, 0x73, 0xC7, 0x00, 0x39, 0xC1, 0xC0, 0x38, 0xE0, 0xE0,
  0x38, 0xF0, 0x70, 0x1C, 0x70, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x0E, 0x0E,
  0x0E, 0x07, 0x07, 0x0E, 0x03, 0x83, 0x8E, 0x01, 0xE3, 0x87, 0x00, 0x7F,
  0x87, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x01, 0xE0, 0x07, 0x07, 0x80, 0x0E, 0x3E, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x03, 0x03, 0xF8, 0x07, 0x0F, 0x78, 0x0E, 0x3C,
  0x70, 0x38, 0x70, 0x70, 0x71, 0xE0, 0xF0, 0xE3, 0x80, 0xF3, 0x87, 0x00,
  0xF7, 0x0E, 0x01, 0xFE, 0x1E, 0x01, 0xF8, 0x3C, 0x01, 0xF0, 0x7C, 0x03,
  0xF0, 0x7C, 0x1F, 0xF8, 0x7F, 0xFD, 0xFC, 0x7F, 0xF1, 0xF8, 0x3F, 0x80,
  0xF0, 0xFF, 0xFE, 0xF7, 0xBD, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x01, 0xE0,
  0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x04, 0x38, 0x5F, 0x77, 0xFF, 0xFF, 0x8F,
  0xF8, 0x03, 0x80, 0x0F, 0x80, 0x3B, 0x80, 0xE3, 0x81, 0xC7, 0x07, 0x07,
  0x02, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x8F, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x0E,
  0x07, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x03, 0xE0, 0xF8, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0x70, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x1F,
  0x0F, 0xE1, 0xF0, 0xFE, 0x1F, 0x0F, 0xE1, 0xF0, 0xFE, 0x1F, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xE7,
  0x00, 0x1E, 0x78, 0x03, 0xC7, 0xC0, 0x7C, 0x3E, 0x0F, 0x81, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x0F, 0xF7, 0x80, 0xFC, 0x78, 0x0E, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x07,
  0xE7, 0xC0, 0x3C, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0xFC, 0x78, 0x03, 0xC7, 0x80,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x3E, 0x7E, 0x07,
  0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xB8, 0x00, 0x39, 0xC0,
  0x03, 0xCE, 0x00, 0x1C, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xE0,
  0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x0E, 0x07,
  0x00, 0x70, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x71,
  0xFC, 0x07, 0x7F, 0xF0, 0x7F, 0xFF, 0x87, 0xE0, 0xFC, 0xF8, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x80, 0x3C, 0x7C, 0x0F,
  0xC3, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0x83, 0xC3, 0xE0, 0x3C, 0x78, 0x03, 0x9E, 0x00,
  0x73, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC3, 0xF0, 0x79, 0xFF,
  0x8F, 0x7F, 0xF9, 0xFC, 0x0F, 0xBF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xF0, 0x03,
  0xCE, 0x00, 0x79, 0xE0, 0x1E, 0x1F, 0x07, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x07, 0xE7, 0x80, 0x3C, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x70, 0x01, 0xEF, 0x00, 0x39, 0xE0, 0x0F,
  0x1F, 0x07, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xC1, 0xF0, 0x3E,
  0x78, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0x7E, 0x07, 0xC7, 0xFF, 0xF0,
  0x7F, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC,
  0x1F, 0x07, 0xC7, 0x80, 0x7D, 0xF0, 0x07, 0xBC, 0x00, 0x77, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3E,
  0xF0, 0x07, 0xDF, 0x83, 0xB9, 0xFF, 0xF7, 0x1F, 0xF9, 0xE0, 0xFE, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0xE0, 0x07, 0x9E, 0x00, 0xF3,
  0xC0, 0x3C, 0x3E, 0x1F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC7,
  0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0x03,
  0x03, 0x80, 0x00, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xF0, 0x7E, 0x7C, 0x01, 0xE7, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0x07, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x06, 0x00,
  0x07, 0x1C, 0x00, 0x06, 0x30, 0x3C, 0x6E, 0xE0, 0xFD, 0xDD, 0xC3, 0x8F,
  0xBB, 0x0E, 0x1E, 0x36, 0x38, 0x1C, 0x7C, 0x70, 0x38, 0xF8, 0xC0, 0x71,
  0xF3, 0x80, 0xE3, 0xE7, 0x01, 0xC7, 0xCE, 0x03, 0x0F, 0x1C, 0x0E, 0x1E,
  0x38, 0x1C, 0x3E, 0x60, 0x38, 0xFC, 0xC0, 0x71, 0xF9, 0xC1, 0xC3, 0x73,
  0x83, 0x86, 0xE7, 0x0F, 0x1C, 0xC7, 0x36, 0x31, 0xCF, 0xEF, 0xC3, 0x8F,
  0x0F, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x08, 0x07, 0x00,
  0x38, 0x07, 0x81, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xC7, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x78, 0x1C, 0x00,
  0x38, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xE0, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xE0, 0x1F,
  0x8F, 0x00, 0x3E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0,
  0x01, 0xE7, 0x80, 0x0E, 0x3C, 0x00, 0xF1, 0xE0, 0x1F, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x1E, 0x00, 0xFC, 0xF0, 0x01, 0xF7, 0x80,
  0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF0, 0x07, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x3F, 0x07, 0xC3, 0xE0, 0x1F, 0x1E, 0x00, 0x79, 0xF0, 0x01, 0xEF, 0x00,
  0x0C, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x47, 0x80, 0x07, 0x9E,
  0x00, 0x3C, 0xF0, 0x03, 0xC3, 0xC0, 0x3E, 0x1F, 0x83, 0xE0, 0x7F, 0xFE,
  0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x0F, 0x03, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF0, 0x3F, 0x07, 0xC3, 0xE0, 0x1F, 0x1E, 0x00, 0x79, 0xF0, 0x03, 0xCF,
  0x00, 0x0C, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07,
  0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x1F, 0x83, 0xF8, 0x7F,
  0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF0, 0x00,
  0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF0, 0x0F, 0x83,
  0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC3,
  0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0xF8, 0x00, 0xF7, 0xE0, 0x03, 0xDF, 0x80,
  0x0F, 0xFF, 0x00, 0x3F, 0xBE, 0x00, 0xFC, 0x7C, 0x03, 0xE0, 0xF0, 0x0F,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0x1E, 0x0F, 0x00,
  0x7C, 0x3C, 0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F,
  0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xEE, 0x06, 0xFE,
  0xE0, 0xEF, 0xEF, 0x0E, 0xFE, 0x71, 0xEF, 0xE7, 0x1C, 0xFE, 0x79, 0xCF,
  0xE3, 0xB8, 0xFE, 0x3B, 0x8F, 0xE1, 0xF8, 0xFE, 0x1F, 0x0F, 0xE1, 0xF0,
  0xFE, 0x0F, 0x0F, 0xE0, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xB8, 0x0F, 0xF7,
  0x81, 0xFE, 0x70, 0x3F, 0xCF, 0x07, 0xF8, 0xE0, 0xFF, 0x1E, 0x1F, 0xE1,
  0xC3, 0xFC, 0x3C, 0x7F, 0x87, 0x8F, 0xF0, 0x71, 0xFE, 0x0F, 0x3F, 0xC0,
  0xE7, 0xF8, 0x1E, 0xFF, 0x01, 0xDF, 0xE0, 0x3F, 0xFC, 0x03, 0xBF, 0x80,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x3E,
  0x1E, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x1E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x07, 0x87,
  0xC0, 0x7C, 0x1F, 0x07, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0x00, 0x7E, 0xF0,
  0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x7C,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x3E,
  0x1E, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x1E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x07, 0x87,
  0xC0, 0x7C, 0x1F, 0x07, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xE0, 0x0F, 0xCF, 0x00, 0x1E, 0x78,
  0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07,
  0xBC, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x7C, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x00, 0xF0, 0x7C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81,
  0xE0, 0x3E, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x1F, 0x1E, 0x00,
  0x78, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x7C, 0x07, 0xC7, 0xC0,
  0x1F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF7, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xEF, 0x00, 0x1E, 0x7E, 0x03, 0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x7B, 0xC0, 0x1E, 0x7C, 0x0F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x03,
  0xFC, 0x00, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF,
  0x80, 0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0E, 0x03,
  0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x07, 0xBC, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x39, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x0F,
  0x07, 0x8E, 0x0F, 0x83, 0xC7, 0x07, 0xC1, 0xC3, 0x83, 0xE0, 0xE1, 0xE1,
  0xB8, 0x70, 0xF1, 0xDC, 0x38, 0x78, 0xEE, 0x3C, 0x1C, 0x73, 0x1E, 0x0E,
  0x71, 0xCF, 0x07, 0x38, 0xE7, 0x03, 0x9C, 0x73, 0x81, 0xCE, 0x1D, 0xC0,
  0xFE, 0x0E, 0xE0, 0x7F, 0x07, 0x70, 0x1F, 0x83, 0xB8, 0x0F, 0xC0, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x3C, 0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80,
  0x03, 0xDE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xEF, 0x00, 0x03,
  0xDE, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0x78, 0xF8, 0x00,
  0x79, 0xE0, 0x00, 0xF7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x7D, 0xE0, 0x00, 0xF1, 0xE0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x1E,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x80,
  0x0F, 0x1E, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B,
  0x80, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC1,
  0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00,
  0xF3, 0x80, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x1F, 0x80, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x38,
  0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xF8, 0x1F, 0x07, 0x80,
  0x78, 0x3C, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xC0, 0x3C, 0x7C, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x7E, 0x3C,
  0x07, 0xF1, 0xF0, 0x77, 0x87, 0xFF, 0x3F, 0x9F, 0xF0, 0xFC, 0x7E, 0x03,
  0xE0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x87, 0xE0, 0xE7, 0xFE, 0x3B, 0xFF, 0xCE,
  0xE0, 0xFB, 0xE0, 0x1E, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xEE,
  0xE0, 0xFB, 0xBF, 0xFC, 0xE7, 0xFE, 0x38, 0x7E, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x07, 0xE7, 0xC0, 0x3C, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x01, 0xEF, 0x00, 0x3D, 0xF0, 0x0F, 0x1F, 0x03, 0xE1, 0xFF, 0xF8, 0x1F,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x3F, 0x0E, 0x1F,
  0xF9, 0xC7, 0xFF, 0xB9, 0xF8, 0x3F, 0x3C, 0x03, 0xE7, 0x80, 0x3D, 0xE0,
  0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0xC0,
  0x07, 0x78, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80,
  0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF9, 0xF0, 0x77, 0x1F, 0xFE, 0xE1, 0xFF,
  0x9C, 0x0F, 0xC3, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F,
  0x07, 0xC7, 0x80, 0x3C, 0xF0, 0x03, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x31, 0xF0,
  0x07, 0x9F, 0x03, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xE1, 0xE3, 0xFF, 0x3C, 0xFF, 0xF7, 0xBF, 0x0E, 0xF7,
  0x80, 0x7E, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xEF, 0x00, 0xFD, 0xE0, 0x1F, 0xBE,
  0x0E, 0xF3, 0xFF, 0xDE, 0x3F, 0xF3, 0xC1, 0xF8, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x79, 0xE0, 0x0F, 0x1E, 0x03, 0xE3, 0xE0, 0xF8, 0x3F,
  0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC7, 0xE0,
  0xE3, 0xFE, 0x3B, 0xFF, 0xCE, 0xE0, 0xFB, 0xF0, 0x1E, 0xF8, 0x07, 0xBC,
  0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF4, 0x03,
  0xEF, 0xFF, 0x9F, 0xFE, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x1E, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x03, 0xC3, 0xC1, 0xF0, 0xF0, 0xF8,
  0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xF9, 0xE0, 0x3C, 0x3C, 0x0F, 0x0F, 0x83, 0xC1,
  0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x01, 0xF3, 0xC0, 0x3C, 0xF0, 0x07,
  0xBC, 0x01, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xC3, 0xE7, 0x7F, 0x3F, 0xBB,
  0xFB, 0xFD, 0xF1, 0xF8, 0xFF, 0x8F, 0x87, 0xF8, 0x3C, 0x3F, 0xC1, 0xE0,
  0xFE, 0x0E, 0x07, 0xF0, 0x70, 0x3F, 0x83, 0x81, 0xFC, 0x1C, 0x0F, 0xE0,
  0xE0, 0x7F, 0x07, 0x03, 0xF8, 0x38, 0x1F, 0xC1, 0xC0, 0xFE, 0x0E, 0x07,
  0xF0, 0x70, 0x3F, 0x83, 0x81, 0xFC, 0x1C, 0x0F, 0xE0, 0xE0, 0x7F, 0x07,
  0x03, 0xF8, 0x38, 0x1F, 0xC1, 0xC0, 0xE0, 0xE1, 0xFC, 0x38, 0xFF, 0x8E,
  0x7F, 0xF3, 0xB8, 0x3E, 0xFC, 0x07, 0xBE, 0x01, 0xEF, 0x00, 0x3B, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3C, 0x03,
  0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0xFC, 0x7C, 0x03, 0xC7,
  0x80, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0E,
  0xF0, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x3C, 0x7C, 0x03, 0xC3, 0xE0,
  0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xE1, 0xF8, 0x39,
  0xFF, 0x8E, 0xFF, 0xF3, 0xB8, 0x3E, 0xF8, 0x07, 0xBE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x7B, 0xB8, 0x3E, 0xEF, 0xFF, 0x39, 0xFF, 0x8E, 0x1F,
  0x83, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE1, 0xE3,
  0xFF, 0x38, 0xFF, 0xF7, 0x3F, 0x0F, 0xE7, 0x80, 0x7C, 0xF0, 0x07, 0xBC,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0x78,
  0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x03, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0,
  0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1F, 0x3F, 0x0E, 0xE3, 0xFF, 0xDC, 0x3F,
  0xF3, 0x81, 0xF8, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF, 0x73, 0xC0, 0x77, 0x00, 0x76,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03,
  0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x03, 0xC3, 0x80, 0x3C, 0xF0,
  0x03, 0x9E, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xEE, 0x00, 0x3D, 0xC0, 0x07, 0x3E, 0x03, 0xE3, 0xFF,
  0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x43, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xE0, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0x7F, 0xFB, 0xCF, 0xFC, 0xF0, 0xFC, 0x3C,
  0x78, 0x00, 0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF1, 0xE0, 0x03, 0xC3,
  0xC0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x0F,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x70, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xC7,
  0x00, 0x03, 0xDE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xB8, 0x00,
  0x03, 0xDC, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0x78, 0xE0, 0xF8, 0x3C, 0x70, 0x7C, 0x1E, 0x38, 0x3E, 0x0E, 0x1C,
  0x1B, 0x87, 0x0F, 0x1D, 0xC7, 0x87, 0x8E, 0xE3, 0xC3, 0xC6, 0x31, 0xE0,
  0xE7, 0x1C, 0xF0, 0x73, 0x8E, 0x70, 0x39, 0xC3, 0x38, 0x1C, 0xC1, 0xDC,
  0x0F, 0xE0, 0xEE, 0x07, 0xF0, 0x7F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x78, 0x00, 0xF3, 0xC0, 0x07,
  0x8F, 0x00, 0x78, 0x3C, 0x07, 0x80, 0xE0, 0x38, 0x07, 0x83, 0xC0, 0x1E,
  0x3C, 0x00, 0x79, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0xF1,
  0xE0, 0x07, 0x07, 0x80, 0x78, 0x3C, 0x07, 0x80, 0xF0, 0x78, 0x03, 0xC3,
  0xC0, 0x1E, 0x3C, 0x00, 0x7B, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0xF0,
  0x00, 0x79, 0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x83, 0x80,
  0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03,
  0xC0, 0x1C, 0x07, 0x80, 0x3C, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x70,
  0x00, 0xF1, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xE7, 0x00, 0x01, 0xDE, 0x00,
  0x03, 0xB8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x1F,
  0xC0, 0x0F, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
};

const GFXglyph LiberationMono_Regular42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 4, 28, 25, 11, -28 },
  { 15, 13, 13, 25, 6, -30 },
  { 37, 23, 28, 25, 1, -28 },
  { 118, 23, 34, 25, 1, -31 },
  { 216, 25, 28, 25, 0, -28 },
  { 304, 23, 28, 25, 1, -28 },
  { 385, 5, 13, 25, 10, -30 },
  { 394, 11, 39, 25, 7, -30 },
  { 448, 11, 39, 25, 7, -30 },
  { 502, 15, 15, 25, 5, -30 },
  { 531, 21, 21, 25, 2, -24 },
  { 587, 9, 14, 25, 5, -6 },
  { 603, 11, 3, 25, 7, -13 },
  { 608, 5, 6, 25, 10, -6 },
  { 612, 21, 30, 25, 2, -30 },
  { 691, 20, 28, 25, 3, -28 },
  { 761, 20, 28, 25, 3, -28 },
  { 831, 19, 28, 25, 3, -28 },
  { 898, 20, 28, 25, 3, -28 },
  { 968, 21, 28, 25, 2, -28 },
  { 1042, 20, 28, 25, 3, -28 },
  { 1112, 19, 28, 25, 3, -28 },
  { 1179, 19, 28, 25, 3, -28 },
  { 1246, 19, 28, 25, 3, -28 },
  { 1313, 19, 28, 25, 3, -28 },
  { 1380, 5, 23, 25, 10, -23 },
  { 1395, 9, 31, 25, 7, -23 },
  { 1430, 21, 21, 25, 2, -24 },
  { 1486, 21, 14, 25, 2, -21 },
  { 1523, 21, 21, 25, 2, -24 },
  { 1579, 20, 28, 25, 2, -28 },
  { 1649, 23, 35, 25, 1, -30 },
  { 1750, 25, 28, 25, 0, -28 },
  { 1838, 21, 28, 25, 3, -28 },
  { 1912, 21, 28, 25, 2, -28 },
  { 1986, 20, 28, 25, 3, -28 },
  { 2056, 20, 28, 25, 3, -28 },
  { 2126, 18, 28, 25, 4, -28 },
  { 2189, 21, 28, 25, 2, -28 },
  { 2263, 19, 28, 25, 3, -28 },
  { 2330, 17, 28, 25, 4, -28 },
  { 2390, 16, 28, 25, 4, -28 },
  { 2446, 22, 28, 25, 3, -28 },
  { 2523, 18, 28, 25, 5, -28 },
  { 2586, 20, 28, 25, 3, -28 },
  { 2656, 19, 28, 25, 3, -28 },
  { 2723, 21, 28, 25, 2, -28 },
  { 2797, 20, 28, 25, 3, -28 },
  { 2867, 21, 36, 25, 2, -28 },
  { 2962, 21, 28, 25, 3, -28 },
  { 3036, 21, 28, 25, 2, -28 },
  { 3110, 22, 28, 25, 2, -28 },
  { 3187, 19, 28, 25, 3, -28 },
  { 3254, 25, 28, 25, 0, -28 },
  { 3342, 25, 28, 25, 0, -28 },
  { 3430, 23, 28, 25, 1, -28 },
  { 3511, 23, 28, 25, 1, -28 },
  { 3592, 23, 28, 25, 1, -28 },
  { 3673, 12, 39, 25, 8, -30 },
  { 3732, 21, 30, 25, 2, -30 },
  { 3811, 11, 39, 25, 6, -30 },
  { 3865, 19, 19, 25, 3, -28 },
  { 3911, 25, 2, 25, 0, 3 },
  { 3918, 9, 5, 25, 8, -30 },
  { 3924, 21, 23, 25, 3, -23 },
  { 3985, 18, 30, 25, 4, -30 },
  { 4053, 19, 23, 25, 3, -23 },
  { 4108, 19, 30, 25, 3, -30 },
  { 4180, 19, 23, 25, 3, -23 },
  { 4235, 20, 30, 25, 3, -30 },
  { 4310, 19, 32, 25, 3, -23 },
  { 4386, 18, 30, 25, 4, -30 },
  { 4454, 20, 30, 25, 3, -30 },
  { 4529, 15, 39, 25, 2, -30 },
  { 4603, 18, 30, 25, 5, -30 },
  { 4671, 20, 30, 25, 3, -30 },
  { 4746, 21, 23, 25, 2, -23 },
  { 4807, 18, 23, 25, 4, -23 },
  { 4859, 20, 23, 25, 3, -23 },
  { 4917, 18, 32, 25, 4, -23 },
  { 4989, 19, 32, 25, 3, -23 },
  { 5065, 16, 23, 25, 5, -23 },
  { 5111, 19, 23, 25, 3, -23 },
  { 5166, 17, 29, 25, 4, -29 },
  { 5228, 18, 23, 25, 4, -23 },
  { 5280, 23, 23, 25, 1, -23 },
  { 5347, 25, 23, 25, 0, -23 },
  { 5419, 21, 23, 25, 2, -23 },
  { 5480, 23, 32, 25, 1, -23 },
  { 5572, 19, 23, 25, 3, -23 },
  { 5627, 17, 39, 25, 5, -30 },
  { 5710, 3, 39, 25, 11, -30 },
  { 5725, 18, 39, 25, 3, -30 },
  { 5813, 21, 5, 25, 2, -16 },
};

const GFXfont LiberationMono_Regular42pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular42pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular42pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _LIBERATIONMONO_REGULAR42PT7B_H_
