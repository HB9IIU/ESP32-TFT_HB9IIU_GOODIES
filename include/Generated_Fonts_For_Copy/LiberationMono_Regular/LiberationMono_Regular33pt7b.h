#ifndef _LIBERATIONMONO_REGULAR33PT7B_H_
#define _LIBERATIONMONO_REGULAR33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0x6D, 0xB6, 0xDB, 0x00, 0x7F, 0xC0, 0x70, 0xEE,
  0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xEC, 0x1C,
  0x03, 0x03, 0x00, 0xC0, 0x80, 0x30, 0x60, 0x08, 0x18, 0x06, 0x06, 0x01,
  0x81, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0,
  0x80, 0x30, 0x60, 0x08, 0x18, 0x3F, 0xFF, 0xEF, 0xFF, 0xF8, 0x60, 0x40,
  0x18, 0x30, 0x04, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x20, 0x0C,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0xE0, 0x1F,
  0xFE, 0x0F, 0x33, 0xC7, 0x0C, 0x71, 0xC3, 0x0E, 0x70, 0xC3, 0x9C, 0x30,
  0x03, 0x8C, 0x00, 0xF3, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0D, 0xF0,
  0x03, 0x1E, 0x00, 0xC3, 0x80, 0x30, 0x60, 0x0C, 0x1F, 0x83, 0x07, 0xE0,
  0xC3, 0x9C, 0x30, 0xE7, 0xCC, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x3E, 0x00, 0xC7, 0xF0, 0x1C, 0xE3, 0x81,
  0x8E, 0x18, 0x30, 0xC1, 0x87, 0x0C, 0x18, 0xE0, 0xC1, 0x8C, 0x0E, 0x19,
  0x80, 0x63, 0xB8, 0x07, 0xF3, 0x00, 0x3E, 0x60, 0x00, 0x0E, 0x7C, 0x00,
  0xCF, 0xE0, 0x19, 0xC6, 0x03, 0x98, 0x70, 0x31, 0x87, 0x06, 0x18, 0x70,
  0xE1, 0x87, 0x0C, 0x18, 0x71, 0x81, 0xC6, 0x38, 0x0F, 0xE3, 0x00, 0x7C,
  0x03, 0xE0, 0x03, 0xFE, 0x00, 0xE1, 0xC0, 0x70, 0x70, 0x1C, 0x0C, 0x07,
  0x07, 0x01, 0xC3, 0x80, 0x31, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x31, 0xFC, 0x0C, 0x73, 0x87, 0x38, 0x71, 0xCE, 0x1C, 0x63, 0x03, 0xB8,
  0xC0, 0x7C, 0x38, 0x0F, 0x0E, 0x03, 0xC1, 0xC1, 0xFC, 0x3F, 0xE7, 0xC7,
  0xE0, 0xF0, 0xFF, 0xFE, 0xEE, 0x66, 0x66, 0x07, 0x0E, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C,
  0x0E, 0x07, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0x83, 0x81, 0xC1,
  0xC0, 0x06, 0x00, 0x60, 0x06, 0x04, 0x62, 0xF6, 0xF7, 0xFE, 0x0F, 0x00,
  0xF0, 0x1B, 0x83, 0x98, 0x31, 0xC1, 0x08, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x1E, 0x38, 0xF1, 0xE3, 0x87, 0x1C, 0x38, 0x60, 0xC3,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xF8,
  0x3C, 0x3C, 0x78, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x07,
  0xE0, 0x07, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x3C, 0x3C,
  0x1F, 0xF8, 0x07, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x1E, 0xE0,
  0xFC, 0xE0, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF,
  0x07, 0xE0, 0x3F, 0xF0, 0xF0, 0xF3, 0x80, 0xF7, 0x00, 0xEE, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x3C,
  0x70, 0x1E, 0x70, 0x0E, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x3F, 0xFC,
  0x0F, 0xF0, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xB8,
  0x03, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x0C, 0x38, 0x18, 0x38, 0x38, 0x38,
  0x70, 0x38, 0x60, 0x38, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x7F, 0xFC,
  0x7F, 0xFC, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x73, 0xE0, 0x7F, 0xF8, 0x7C, 0x3C, 0x70, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E,
  0x78, 0x3C, 0x3F, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x1E, 0x3C,
  0x38, 0x0E, 0x38, 0x0E, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x63, 0xF0,
  0xEF, 0xF8, 0xEC, 0x3C, 0xF8, 0x0E, 0xF0, 0x0E, 0x70, 0x07, 0x70, 0x07,
  0x70, 0x07, 0x70, 0x06, 0x70, 0x0E, 0x38, 0x0E, 0x1C, 0x3C, 0x0F, 0xF8,
  0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x3C, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x3C, 0x1F,
  0xF0, 0x1F, 0xF8, 0x38, 0x3C, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x78, 0x3C, 0x3F, 0xF8, 0x0F,
  0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x38, 0x70, 0x1C, 0x70, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0x70, 0x0F, 0x70,
  0x1F, 0x3C, 0x36, 0x1F, 0xE6, 0x0F, 0xCE, 0x00, 0x0E, 0x00, 0x0E, 0x70,
  0x1C, 0x70, 0x1C, 0x38, 0x78, 0x3F, 0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x3C, 0x78, 0xF1, 0xE3, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x1E, 0x38, 0xF1, 0xC3, 0x86,
  0x1C, 0x30, 0x60, 0x00, 0x01, 0x00, 0x07, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xE0,
  0xF3, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xE0, 0xE0, 0x70, 0x1C, 0x38, 0x03,
  0x8C, 0x00, 0x66, 0x1E, 0x79, 0x8F, 0xDB, 0x67, 0x1C, 0xF1, 0x87, 0x3C,
  0xE1, 0xCF, 0x30, 0x73, 0xCC, 0x1C, 0xF3, 0x06, 0x3C, 0xC1, 0x8F, 0x70,
  0x63, 0xDC, 0x18, 0xF3, 0x0E, 0x6C, 0xC3, 0x9B, 0x31, 0xEE, 0xCF, 0xDF,
  0x19, 0xE3, 0x86, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x02, 0x07, 0x03, 0xC0,
  0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0x98, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x70, 0xC0,
  0x07, 0x0E, 0x00, 0x60, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0C, 0x07,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0x80, 0x18, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0xE0, 0x78, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x78, 0xFF, 0xE0, 0xFF, 0xF0, 0xE0,
  0x3C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xF8, 0x3C,
  0x1C, 0x78, 0x0E, 0x70, 0x07, 0x70, 0x06, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x02, 0x70, 0x07, 0x70, 0x07, 0x38, 0x0E, 0x3C, 0x1C, 0x1F,
  0xF8, 0x07, 0xE0, 0xFF, 0x81, 0xFF, 0xC3, 0x83, 0xC7, 0x01, 0xCE, 0x01,
  0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1D, 0xC0,
  0x7B, 0x80, 0xE7, 0x07, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xFF, 0xF3, 0xFF, 0xE7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x3C,
  0x78, 0x0E, 0x70, 0x0F, 0x70, 0x06, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x38, 0x07, 0x3C, 0x1F, 0x1F, 0xFC,
  0x07, 0xF0, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xE0, 0x3F,
  0x01, 0xFC, 0x1C, 0xF1, 0xE3, 0xFE, 0x07, 0xC0, 0xE0, 0x1E, 0x70, 0x0E,
  0x38, 0x0E, 0x1C, 0x0F, 0x0E, 0x0F, 0x07, 0x0F, 0x03, 0x8F, 0x01, 0xC7,
  0x00, 0xE7, 0x00, 0x77, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0x3C, 0x07,
  0x0E, 0x03, 0x87, 0x81, 0xC1, 0xE0, 0xE0, 0x78, 0x70, 0x1C, 0x38, 0x07,
  0x1C, 0x03, 0xCE, 0x00, 0xF7, 0x00, 0x38, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x37, 0xEC, 0x37,
  0xEE, 0x77, 0xEE, 0x67, 0xE6, 0x67, 0xE7, 0xE7, 0xE3, 0xC7, 0xE3, 0xC7,
  0xE3, 0xC7, 0xE1, 0x87, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE,
  0x07, 0xD8, 0x1F, 0x70, 0x7D, 0xC1, 0xF3, 0x87, 0xCE, 0x1F, 0x1C, 0x7C,
  0x71, 0xF0, 0xC7, 0xC3, 0x9F, 0x06, 0x7C, 0x1D, 0xF0, 0x37, 0xC0, 0xFF,
  0x03, 0xBC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xF0, 0x07, 0xE0, 0x1F,
  0xF8, 0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x78, 0x1C, 0x3C,
  0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xE1, 0xFF, 0xF3, 0x80, 0xF7, 0x00,
  0xEE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3B,
  0x81, 0xF7, 0xFF, 0x8F, 0xFC, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x78,
  0x1C, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xF8, 0xE0,
  0x3C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x1C, 0xE0, 0x3C, 0xFF, 0xF8, 0xFF, 0xC0, 0xE1, 0xC0, 0xE1, 0xE0, 0xE0,
  0xE0, 0xE0, 0x70, 0xE0, 0x78, 0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0,
  0x0E, 0xE0, 0x0F, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0x07, 0x87, 0x00, 0xE7,
  0x00, 0x73, 0x80, 0x39, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x60, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xE7, 0x81, 0xE1, 0xFF, 0xE0,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0E,
  0xE0, 0x1D, 0xC0, 0x79, 0xC1, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0xF0, 0x00,
  0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x07, 0x00, 0xE0, 0x70, 0x0E,
  0x07, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x1C, 0x00,
  0x39, 0xC0, 0x03, 0x9C, 0x00, 0x1B, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xE6, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x0E,
  0x0E, 0x70, 0xF0, 0xC7, 0x0F, 0x0C, 0x30, 0xF1, 0xC3, 0x9F, 0x9C, 0x39,
  0x99, 0xC3, 0x99, 0x9C, 0x3B, 0x99, 0xC3, 0xB9, 0xD8, 0x1B, 0x0D, 0x81,
  0xB0, 0xD8, 0x1F, 0x0D, 0x81, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x70,
  0x70, 0x03, 0x9C, 0x01, 0xE3, 0x80, 0x70, 0x70, 0x38, 0x1C, 0x1E, 0x03,
  0x87, 0x00, 0x73, 0x80, 0x1D, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xDE, 0x00, 0x73, 0x80, 0x38, 0x70,
  0x1C, 0x1E, 0x07, 0x03, 0x83, 0x80, 0x71, 0xE0, 0x1E, 0x70, 0x03, 0xB8,
  0x00, 0x70, 0xE0, 0x01, 0xDC, 0x00, 0xE7, 0x00, 0x78, 0xE0, 0x1C, 0x3C,
  0x0E, 0x07, 0x07, 0x80, 0xE1, 0xC0, 0x3C, 0xE0, 0x07, 0x38, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFE,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x70,
  0x0C, 0x30, 0x1C, 0x38, 0x18, 0x18, 0x38, 0x18, 0x30, 0x1C, 0x30, 0x0C,
  0x70, 0x0E, 0x60, 0x06, 0xE0, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70,
  0x70, 0x70, 0x30, 0x0F, 0xE0, 0x1F, 0xF8, 0x0E, 0x0E, 0x0E, 0x03, 0x87,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x0E,
  0x3C, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xF0, 0xE1,
  0xBC, 0x7F, 0xCF, 0x8F, 0x87, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0xF8, 0x77, 0xF8, 0xF8, 0x79, 0xE0,
  0x7B, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0x77, 0x80, 0xEF, 0x03, 0xDF, 0x0F, 0x3B,
  0xFC, 0x73, 0xF0, 0x07, 0xE0, 0x3F, 0xF0, 0xF0, 0xF3, 0x80, 0x77, 0x00,
  0xFE, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x9E, 0x1E, 0x1F, 0xF8, 0x0F,
  0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC3, 0xE3, 0x9F, 0xF7, 0x38, 0x3E, 0xE0, 0x3D, 0xC0, 0x7F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x7B, 0x80, 0xF7, 0x01, 0xE7, 0x0F, 0xCF, 0xFB, 0x87, 0xC7, 0x07, 0xE0,
  0x1F, 0xF8, 0x3C, 0x3C, 0x70, 0x1E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x06,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x0C, 0x78, 0x0E, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0xFF,
  0x03, 0xFF, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x8E,
  0x7F, 0xDC, 0xE1, 0xFB, 0x81, 0xF7, 0x01, 0xEE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x77, 0x00, 0xEE, 0x03,
  0xDC, 0x07, 0x9C, 0x37, 0x3F, 0xEE, 0x1F, 0x1C, 0x00, 0x38, 0x00, 0x77,
  0x80, 0xE7, 0x03, 0x8F, 0x0F, 0x0F, 0xFC, 0x07, 0xE0, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x3E, 0x3B, 0xFC, 0xF8,
  0x7B, 0xC0, 0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x1D, 0xFF, 0x3F, 0xC0, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x03, 0xB8, 0x1C,
  0xE0, 0xF3, 0x87, 0x8E, 0x3C, 0x38, 0xE0, 0xE7, 0x03, 0xB8, 0x0F, 0xE0,
  0x3F, 0xC0, 0xF7, 0x83, 0x8E, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0xF3, 0x81,
  0xCE, 0x03, 0xB8, 0x0F, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x1C, 0xDF, 0x3E, 0xF3, 0xC7, 0xE3, 0xC7,
  0xE3, 0xC7, 0xE1, 0x87, 0xC1, 0x87, 0xC1, 0x87, 0xC1, 0x87, 0xC1, 0x87,
  0xC1, 0x87, 0xC1, 0x87, 0xC1, 0x87, 0xC1, 0x87, 0xC1, 0x87, 0xC1, 0x87,
  0xC1, 0x87, 0xC1, 0x87, 0xE3, 0xE3, 0xBF, 0xEF, 0x87, 0xBC, 0x0F, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x70,
  0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E,
  0xF0, 0x0E, 0x70, 0x0E, 0x78, 0x1C, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xE0,
  0xE3, 0xE1, 0xDF, 0xE3, 0xE1, 0xE7, 0x81, 0xEF, 0x01, 0xDC, 0x03, 0xB8,
  0x07, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xEE, 0x01,
  0xDE, 0x03, 0xBC, 0x0F, 0x7C, 0x3C, 0xEF, 0xF1, 0xCF, 0xC3, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0F,
  0x8E, 0x7F, 0xDC, 0xE0, 0xFB, 0x80, 0xF7, 0x01, 0xEE, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x01, 0xEE,
  0x03, 0xDC, 0x07, 0x9C, 0x37, 0x3F, 0xEE, 0x1F, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0xE1, 0xFF,
  0x3F, 0xFB, 0xFE, 0xDC, 0x07, 0xC0, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0x03, 0x98, 0x07, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0x80,
  0x07, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xFC, 0x0E, 0x7F, 0xF0, 0x7F, 0x00,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xE3,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0xFC,
  0x1F, 0xE0, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xDC, 0x1F, 0x7F, 0xDC, 0x7C, 0x70, 0xF0, 0x03,
  0x9C, 0x00, 0xE7, 0x00, 0x79, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x1C,
  0xE0, 0x07, 0x38, 0x01, 0xDC, 0x00, 0x37, 0x00, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00,
  0x77, 0x00, 0x0E, 0xE1, 0xE1, 0xDC, 0x3C, 0x31, 0x87, 0x8E, 0x31, 0xB1,
  0xC7, 0x33, 0x38, 0xE6, 0x67, 0x1D, 0xCC, 0xE3, 0xB1, 0xD8, 0x36, 0x1B,
  0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0xE0, 0x0F,
  0x70, 0x0E, 0x38, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x0E, 0x70, 0x07, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0xF0, 0x1E, 0x70,
  0x1C, 0x38, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x0E, 0xE0, 0x07, 0xE0, 0x03,
  0xDC, 0x00, 0xE7, 0x00, 0x38, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x1C,
  0xE0, 0x07, 0x38, 0x00, 0xCC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x3F, 0xC1, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xFC, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x7F, 0x83, 0xF0, 0x00, 0x7E, 0x00, 0xFF, 0xC3, 0x83,
  0xFF, 0x00, 0x7E,
};

const GFXglyph LiberationMono_Regular33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 3, 22, 20, 8, -22 },
  { 10, 11, 10, 20, 4, -24 },
  { 24, 18, 22, 20, 1, -22 },
  { 74, 18, 28, 20, 1, -25 },
  { 137, 20, 22, 20, 0, -22 },
  { 192, 18, 22, 20, 1, -22 },
  { 242, 4, 10, 20, 8, -24 },
  { 247, 8, 31, 20, 6, -24 },
  { 278, 9, 31, 20, 5, -24 },
  { 313, 12, 12, 20, 4, -24 },
  { 331, 16, 16, 20, 2, -19 },
  { 363, 7, 11, 20, 4, -5 },
  { 373, 9, 3, 20, 5, -10 },
  { 377, 4, 5, 20, 8, -5 },
  { 380, 16, 24, 20, 2, -24 },
  { 428, 16, 22, 20, 2, -22 },
  { 472, 16, 22, 20, 2, -22 },
  { 516, 15, 22, 20, 2, -22 },
  { 558, 16, 22, 20, 2, -22 },
  { 602, 16, 22, 20, 2, -22 },
  { 646, 16, 22, 20, 2, -22 },
  { 690, 16, 22, 20, 2, -22 },
  { 734, 14, 22, 20, 3, -22 },
  { 773, 16, 22, 20, 2, -22 },
  { 817, 16, 22, 20, 2, -22 },
  { 861, 4, 18, 20, 8, -18 },
  { 870, 7, 24, 20, 6, -18 },
  { 891, 16, 17, 20, 2, -19 },
  { 925, 16, 10, 20, 2, -16 },
  { 945, 16, 17, 20, 2, -19 },
  { 979, 15, 22, 20, 2, -22 },
  { 1021, 18, 28, 20, 1, -24 },
  { 1084, 20, 22, 20, 0, -22 },
  { 1139, 16, 22, 20, 3, -22 },
  { 1183, 16, 22, 20, 2, -22 },
  { 1227, 15, 22, 20, 3, -22 },
  { 1269, 15, 22, 20, 3, -22 },
  { 1311, 14, 22, 20, 3, -22 },
  { 1350, 16, 22, 20, 2, -22 },
  { 1394, 14, 22, 20, 3, -22 },
  { 1433, 14, 22, 20, 3, -22 },
  { 1472, 13, 22, 20, 3, -22 },
  { 1508, 17, 22, 20, 3, -22 },
  { 1555, 14, 22, 20, 4, -22 },
  { 1594, 16, 22, 20, 2, -22 },
  { 1638, 14, 22, 20, 3, -22 },
  { 1677, 16, 22, 20, 2, -22 },
  { 1721, 15, 22, 20, 3, -22 },
  { 1763, 16, 28, 20, 2, -22 },
  { 1819, 16, 22, 20, 3, -22 },
  { 1863, 17, 22, 20, 1, -22 },
  { 1910, 18, 22, 20, 1, -22 },
  { 1960, 15, 22, 20, 2, -22 },
  { 2002, 20, 22, 20, 0, -22 },
  { 2057, 20, 22, 20, 0, -22 },
  { 2112, 18, 22, 20, 1, -22 },
  { 2162, 18, 22, 20, 1, -22 },
  { 2212, 18, 22, 20, 1, -22 },
  { 2262, 8, 31, 20, 7, -24 },
  { 2293, 16, 24, 20, 2, -24 },
  { 2341, 9, 31, 20, 4, -24 },
  { 2376, 16, 15, 20, 2, -22 },
  { 2406, 20, 2, 20, 0, 2 },
  { 2411, 7, 4, 20, 6, -23 },
  { 2415, 17, 18, 20, 2, -18 },
  { 2454, 15, 24, 20, 3, -24 },
  { 2499, 15, 18, 20, 2, -18 },
  { 2533, 15, 24, 20, 2, -24 },
  { 2578, 16, 18, 20, 2, -18 },
  { 2614, 16, 24, 20, 2, -24 },
  { 2662, 15, 25, 20, 2, -18 },
  { 2709, 14, 24, 20, 3, -24 },
  { 2751, 16, 24, 20, 2, -24 },
  { 2799, 11, 31, 20, 2, -24 },
  { 2842, 14, 24, 20, 4, -24 },
  { 2884, 16, 24, 20, 2, -24 },
  { 2932, 16, 18, 20, 2, -18 },
  { 2968, 14, 18, 20, 3, -18 },
  { 3000, 16, 18, 20, 2, -18 },
  { 3036, 15, 25, 20, 3, -18 },
  { 3083, 15, 25, 20, 2, -18 },
  { 3130, 13, 18, 20, 4, -18 },
  { 3160, 14, 18, 20, 3, -18 },
  { 3192, 13, 23, 20, 3, -23 },
  { 3230, 14, 18, 20, 3, -18 },
  { 3262, 18, 18, 20, 1, -18 },
  { 3303, 19, 18, 20, 0, -18 },
  { 3346, 16, 18, 20, 2, -18 },
  { 3382, 18, 25, 20, 1, -18 },
  { 3439, 15, 18, 20, 2, -18 },
  { 3473, 13, 31, 20, 4, -24 },
  { 3524, 2, 31, 20, 9, -24 },
  { 3532, 13, 31, 20, 3, -24 },
  { 3583, 16, 4, 20, 2, -13 },
};

const GFXfont LiberationMono_Regular33pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular33pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular33pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _LIBERATIONMONO_REGULAR33PT7B_H_
