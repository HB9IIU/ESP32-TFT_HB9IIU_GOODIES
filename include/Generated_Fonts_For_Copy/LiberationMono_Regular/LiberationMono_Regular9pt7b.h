#ifndef _LIBERATIONMONO_REGULAR9PT7B_H_
#define _LIBERATIONMONO_REGULAR9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular9pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xB6, 0x80, 0x02, 0x7E, 0xAF, 0xA8, 0x00, 0x23, 0x9A, 0xC7,
  0x16, 0xAE, 0x20, 0xCD, 0xB4, 0x43, 0xAE, 0x60, 0x72, 0x98, 0xDA, 0xC9,
  0xA0, 0xE0, 0x29, 0x49, 0x12, 0x20, 0x48, 0x92, 0x4A, 0x40, 0x5D, 0x50,
  0x44, 0xF4, 0x40, 0x68, 0xE0, 0x80, 0x08, 0x84, 0x42, 0x21, 0x00, 0xE9,
  0x9D, 0x99, 0xE0, 0x4A, 0x22, 0x22, 0xF0, 0xE9, 0x12, 0x48, 0xF0, 0xE9,
  0x16, 0x19, 0xE0, 0x11, 0x94, 0xAF, 0x88, 0x40, 0xE8, 0xE1, 0x19, 0xE0,
  0x68, 0xE9, 0x99, 0x60, 0xF1, 0x24, 0x44, 0x40, 0xE9, 0x96, 0x99, 0xE0,
  0xE9, 0x9F, 0x12, 0xE0, 0x88, 0x8E, 0x1E, 0x8E, 0x10, 0xF0, 0xF0, 0x86,
  0x16, 0x80, 0x74, 0x42, 0x22, 0x00, 0x80, 0x32, 0x63, 0x7D, 0xFE, 0x09,
  0x70, 0x21, 0x94, 0xA7, 0xC6, 0x20, 0xE9, 0x9E, 0x99, 0xE0, 0x72, 0x61,
  0x04, 0x25, 0xC0, 0xE9, 0x99, 0x99, 0xE0, 0xF8, 0x8E, 0x88, 0xF0, 0xF8,
  0x8F, 0x88, 0x80, 0x72, 0x61, 0x34, 0xA5, 0xC0, 0x99, 0x9F, 0x99, 0x90,
  0xF4, 0x44, 0x44, 0xF0, 0x64, 0x93, 0x78, 0x9A, 0xCC, 0xAA, 0x90, 0x88,
  0x88, 0x88, 0xF0, 0x9B, 0xBD, 0xD9, 0x90, 0x99, 0xDD, 0xBB, 0xB0, 0x72,
  0x63, 0x18, 0xA5, 0xC0, 0xE9, 0x9E, 0x88, 0x80, 0x72, 0x63, 0x18, 0xA5,
  0xC2, 0x18, 0xE9, 0x9E, 0xAA, 0x90, 0x72, 0x50, 0x60, 0xC5, 0xC0, 0xF9,
  0x08, 0x42, 0x10, 0x80, 0x99, 0x99, 0x99, 0xE0, 0x8C, 0x52, 0xA5, 0x18,
  0x80, 0x8C, 0x6B, 0x5B, 0xAD, 0x60, 0x4A, 0x8C, 0x43, 0x2A, 0x20, 0x8A,
  0x54, 0x42, 0x10, 0x80, 0x78, 0x44, 0x44, 0x23, 0xE0, 0xEA, 0xAA, 0xC0,
  0x42, 0x08, 0x41, 0x08, 0x20, 0xE4, 0x92, 0x49, 0xE0, 0x46, 0xA9, 0xF8,
  0x90, 0xE2, 0xEA, 0xD0, 0x88, 0xE9, 0x99, 0xE0, 0xE8, 0x88, 0xE0, 0x11,
  0xF9, 0x99, 0xF0, 0xE9, 0xF8, 0xE0, 0x74, 0xF4, 0x44, 0x40, 0xF9, 0x99,
  0xF1, 0xE0, 0x88, 0xE9, 0x99, 0x90, 0x40, 0xC4, 0x44, 0xF0, 0x23, 0x92,
  0x49, 0xC0, 0x88, 0xAA, 0xCA, 0x90, 0xC4, 0x44, 0x44, 0xF0, 0xFD, 0x6B,
  0x5A, 0x80, 0xE9, 0x99, 0x90, 0xE9, 0x99, 0xE0, 0xE9, 0x99, 0xE8, 0x80,
  0xF9, 0x99, 0xF1, 0x10, 0xFC, 0x88, 0x80, 0xE8, 0x61, 0xE0, 0x5E, 0x48,
  0xC0, 0x99, 0x99, 0xF0, 0x8A, 0x54, 0x62, 0x00, 0x8D, 0x6F, 0xB5, 0x80,
  0x4A, 0x88, 0xA4, 0x80, 0x8A, 0x54, 0x62, 0x11, 0x00, 0xF2, 0x48, 0xF0,
  0x74, 0x44, 0x84, 0x44, 0x70, 0xFF, 0x80, 0xC9, 0x22, 0x92, 0xC0, 0x64,
  0xC0,
};

const GFXglyph LiberationMono_Regular9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 7, 5, 2, -7 },
  { 2, 3, 3, 5, 1, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 5, 7, 5, 0, -7 },
  { 20, 5, 7, 5, 0, -7 },
  { 25, 1, 3, 5, 2, -7 },
  { 26, 3, 9, 5, 1, -7 },
  { 30, 3, 9, 5, 1, -7 },
  { 34, 3, 4, 5, 1, -7 },
  { 36, 4, 5, 5, 1, -6 },
  { 39, 2, 3, 5, 1, -1 },
  { 40, 3, 1, 5, 1, -3 },
  { 41, 1, 1, 5, 2, -1 },
  { 42, 5, 7, 5, 0, -7 },
  { 47, 4, 7, 5, 1, -7 },
  { 51, 4, 7, 5, 1, -7 },
  { 55, 4, 7, 5, 1, -7 },
  { 59, 4, 7, 5, 1, -7 },
  { 63, 5, 7, 5, 0, -7 },
  { 68, 4, 7, 5, 1, -7 },
  { 72, 4, 7, 5, 1, -7 },
  { 76, 4, 7, 5, 1, -7 },
  { 80, 4, 7, 5, 1, -7 },
  { 84, 4, 7, 5, 1, -7 },
  { 88, 1, 5, 5, 2, -5 },
  { 89, 1, 7, 5, 2, -5 },
  { 90, 4, 5, 5, 1, -6 },
  { 93, 4, 3, 5, 1, -5 },
  { 95, 4, 5, 5, 1, -6 },
  { 98, 5, 7, 5, 0, -7 },
  { 103, 5, 9, 5, 0, -7 },
  { 109, 5, 7, 5, 0, -7 },
  { 114, 4, 7, 5, 1, -7 },
  { 118, 5, 7, 5, 0, -7 },
  { 123, 4, 7, 5, 1, -7 },
  { 127, 4, 7, 5, 1, -7 },
  { 131, 4, 7, 5, 1, -7 },
  { 135, 5, 7, 5, 0, -7 },
  { 140, 4, 7, 5, 1, -7 },
  { 144, 4, 7, 5, 1, -7 },
  { 148, 3, 7, 5, 1, -7 },
  { 151, 4, 7, 5, 1, -7 },
  { 155, 4, 7, 5, 1, -7 },
  { 159, 4, 7, 5, 1, -7 },
  { 163, 4, 7, 5, 1, -7 },
  { 167, 5, 7, 5, 0, -7 },
  { 172, 4, 7, 5, 1, -7 },
  { 176, 5, 9, 5, 0, -7 },
  { 182, 4, 7, 5, 1, -7 },
  { 186, 5, 7, 5, 0, -7 },
  { 191, 5, 7, 5, 0, -7 },
  { 196, 4, 7, 5, 1, -7 },
  { 200, 5, 7, 5, 0, -7 },
  { 205, 5, 7, 5, 0, -7 },
  { 210, 5, 7, 5, 0, -7 },
  { 215, 5, 7, 5, 0, -7 },
  { 220, 5, 7, 5, 0, -7 },
  { 225, 2, 9, 5, 2, -7 },
  { 228, 5, 7, 5, 0, -7 },
  { 233, 3, 9, 5, 1, -7 },
  { 237, 4, 4, 5, 1, -7 },
  { 239, 5, 1, 5, 0, 1 },
  { 240, 2, 2, 5, 2, -8 },
  { 241, 4, 5, 5, 1, -5 },
  { 244, 4, 7, 5, 1, -7 },
  { 248, 4, 5, 5, 1, -5 },
  { 251, 4, 7, 5, 1, -7 },
  { 255, 4, 5, 5, 1, -5 },
  { 258, 4, 7, 5, 1, -7 },
  { 262, 4, 7, 5, 1, -5 },
  { 266, 4, 7, 5, 1, -7 },
  { 270, 4, 7, 5, 1, -7 },
  { 274, 3, 9, 5, 1, -7 },
  { 278, 4, 7, 5, 1, -7 },
  { 282, 4, 7, 5, 1, -7 },
  { 286, 5, 5, 5, 0, -5 },
  { 290, 4, 5, 5, 1, -5 },
  { 293, 4, 5, 5, 1, -5 },
  { 296, 4, 7, 5, 1, -5 },
  { 300, 4, 7, 5, 1, -5 },
  { 304, 4, 5, 5, 1, -5 },
  { 307, 4, 5, 5, 1, -5 },
  { 310, 3, 6, 5, 1, -6 },
  { 313, 4, 5, 5, 1, -5 },
  { 316, 5, 5, 5, 0, -5 },
  { 320, 5, 5, 5, 0, -5 },
  { 324, 5, 5, 5, 0, -5 },
  { 328, 5, 7, 5, 0, -5 },
  { 333, 4, 5, 5, 1, -5 },
  { 336, 4, 9, 5, 1, -7 },
  { 341, 1, 9, 5, 2, -7 },
  { 343, 3, 9, 5, 1, -7 },
  { 347, 5, 2, 5, 0, -5 },
};

const GFXfont LiberationMono_Regular9pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular9pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular9pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _LIBERATIONMONO_REGULAR9PT7B_H_
