#ifndef _LIBERATIONMONO_REGULAR14PT7B_H_
#define _LIBERATIONMONO_REGULAR14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0x94, 0xA5, 0x20, 0x12, 0x12, 0x7F, 0x24, 0x24, 0xFF,
  0x24, 0x44, 0x48, 0x08, 0x3E, 0x4B, 0x48, 0x68, 0x3C, 0x0B, 0x09, 0x4B,
  0x3E, 0x08, 0xE1, 0x92, 0x94, 0xE8, 0x08, 0x17, 0x25, 0x25, 0x47, 0x3C,
  0x24, 0x24, 0x28, 0x72, 0xDA, 0x8A, 0xC4, 0x7B, 0xD5, 0x32, 0x44, 0x4C,
  0xCC, 0x44, 0x42, 0x30, 0x46, 0x23, 0x11, 0x11, 0x13, 0x26, 0x40, 0x25,
  0xD8, 0xC9, 0x00, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x5A, 0x40,
  0xF0, 0xF0, 0x04, 0x08, 0x20, 0xC1, 0x06, 0x08, 0x20, 0x41, 0x00, 0x79,
  0x8A, 0x14, 0x3B, 0x70, 0xA1, 0x62, 0x78, 0x10, 0x63, 0x40, 0x81, 0x02,
  0x04, 0x08, 0xFE, 0x7B, 0x18, 0x41, 0x08, 0xC6, 0x30, 0xFC, 0x79, 0x8A,
  0x10, 0x63, 0x80, 0xA1, 0xE2, 0x78, 0x08, 0x30, 0xA1, 0x44, 0x91, 0x3F,
  0x84, 0x08, 0xFD, 0x83, 0x05, 0xCC, 0x40, 0x81, 0x42, 0x78, 0x38, 0x8A,
  0x05, 0xCC, 0x50, 0xA1, 0x22, 0x38, 0xFC, 0x10, 0x86, 0x10, 0x42, 0x08,
  0x20, 0x7B, 0x18, 0x71, 0x3B, 0x18, 0x71, 0x78, 0x7B, 0x38, 0x61, 0xC5,
  0xF0, 0x73, 0x78, 0xF0, 0x3C, 0x6C, 0x00, 0xDA, 0x40, 0x06, 0x31, 0x84,
  0x06, 0x03, 0x01, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x80, 0xC0, 0x70, 0x11,
  0xCC, 0x20, 0x00, 0x7B, 0x18, 0x41, 0x08, 0x42, 0x00, 0x20, 0x1C, 0x22,
  0x41, 0x5B, 0xA5, 0xA5, 0xA5, 0xA5, 0xBE, 0x40, 0x62, 0x3C, 0x18, 0x14,
  0x14, 0x24, 0x22, 0x7E, 0x42, 0x41, 0xC1, 0xF9, 0x0A, 0x14, 0x2F, 0x90,
  0xE0, 0xC3, 0xFC, 0x38, 0x8A, 0x1C, 0x08, 0x10, 0x20, 0xA2, 0x38, 0xF9,
  0x1A, 0x14, 0x38, 0x70, 0xE1, 0x46, 0xF8, 0xFD, 0x02, 0x04, 0x0F, 0xD0,
  0x20, 0x40, 0xFE, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30, 0xC0, 0x38, 0x8A,
  0x1C, 0x09, 0xF0, 0xE1, 0xE3, 0x7C, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61,
  0x84, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0xFC, 0x3C, 0x30, 0xC3, 0x0C,
  0x3C, 0xD2, 0x78, 0x85, 0x1A, 0x65, 0x8D, 0x1B, 0x22, 0x42, 0x82, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0xC7, 0x9F, 0x3D, 0x7B, 0x72, 0xE1,
  0xC3, 0x86, 0xC7, 0x1A, 0x69, 0x96, 0x58, 0xE3, 0x8C, 0x79, 0x8A, 0x14,
  0x38, 0x70, 0xE1, 0x62, 0x78, 0xFD, 0x0A, 0x1C, 0x2F, 0x90, 0x20, 0x40,
  0x80, 0x79, 0x8A, 0x14, 0x38, 0x70, 0xE1, 0x62, 0x78, 0x30, 0x38, 0xFD,
  0x0A, 0x1C, 0x2F, 0x93, 0x22, 0x42, 0x86, 0x7D, 0x8A, 0x06, 0x03, 0xC0,
  0xC1, 0xC3, 0x7C, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x71, 0x78, 0xC1, 0x43, 0x42, 0x62, 0x26, 0x24,
  0x14, 0x18, 0x18, 0x81, 0x81, 0xD9, 0x59, 0x59, 0x57, 0x56, 0x66, 0x66,
  0x43, 0x26, 0x34, 0x18, 0x18, 0x1C, 0x24, 0x62, 0x43, 0x43, 0x42, 0x26,
  0x24, 0x1C, 0x18, 0x08, 0x08, 0x08, 0x7F, 0x02, 0x04, 0x0C, 0x18, 0x10,
  0x20, 0x40, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x80, 0x81,
  0x01, 0x03, 0x02, 0x06, 0x04, 0x04, 0x08, 0xF3, 0x33, 0x33, 0x33, 0x33,
  0x33, 0xF0, 0x30, 0xA4, 0x92, 0x46, 0x10, 0xFF, 0xC8, 0x79, 0x98, 0x13,
  0xE8, 0x51, 0xBD, 0x80, 0xC3, 0x0C, 0x2E, 0xC7, 0x1C, 0x71, 0xC6, 0xE0,
  0x7B, 0x18, 0x20, 0x83, 0x17, 0x80, 0x04, 0x10, 0x5D, 0xCE, 0x18, 0x61,
  0xCD, 0xD0, 0x7B, 0x18, 0x7F, 0x83, 0x17, 0x80, 0x1E, 0x40, 0x87, 0xE2,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x77, 0x38, 0x61, 0x87, 0x37, 0x41, 0x4D,
  0xE0, 0xC3, 0x0C, 0x2E, 0xC7, 0x1C, 0x71, 0xC7, 0x10, 0x10, 0x00, 0x03,
  0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x18, 0x00, 0xF1, 0x8C, 0x63, 0x18,
  0xC6, 0x3F, 0x00, 0x82, 0x08, 0x22, 0x92, 0x8E, 0x2C, 0x9A, 0x20, 0x70,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0xED, 0x2E, 0x4C, 0x99,
  0x32, 0x64, 0x80, 0xBB, 0x1C, 0x71, 0xC7, 0x1C, 0x40, 0x79, 0x8A, 0x14,
  0x38, 0x58, 0x9E, 0x00, 0xBB, 0x1C, 0x71, 0xC7, 0x1B, 0xB0, 0xC3, 0x00,
  0x77, 0x38, 0x61, 0x87, 0x37, 0x41, 0x04, 0x10, 0xBE, 0x21, 0x08, 0x42,
  0x00, 0x7B, 0x14, 0x0E, 0x06, 0x17, 0x80, 0x20, 0x8F, 0xD8, 0x61, 0x86,
  0x18, 0x3C, 0xC7, 0x1C, 0x71, 0xC7, 0x37, 0x40, 0x43, 0x42, 0x22, 0x24,
  0x34, 0x1C, 0x18, 0x81, 0xC1, 0x59, 0x5B, 0x56, 0x66, 0x66, 0xC4, 0x90,
  0xE1, 0x83, 0x89, 0xA1, 0x00, 0x43, 0x42, 0x22, 0x24, 0x14, 0x14, 0x18,
  0x18, 0x10, 0x60, 0xFC, 0x31, 0x8C, 0x63, 0x0F, 0xC0, 0x3B, 0x18, 0xC6,
  0x22, 0x08, 0x63, 0x18, 0xC3, 0x80, 0xFF, 0xF8, 0xE0, 0x41, 0x04, 0x10,
  0x40, 0xC4, 0x10, 0x41, 0x04, 0xE0, 0xE2, 0x38,
};

const GFXglyph LiberationMono_Regular14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 9, 8, 4, -9 },
  { 3, 5, 4, 8, 2, -10 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 8, 11, 8, 0, -10 },
  { 26, 8, 9, 8, 0, -9 },
  { 35, 8, 9, 8, 0, -9 },
  { 44, 2, 4, 8, 3, -10 },
  { 45, 4, 13, 8, 2, -10 },
  { 52, 4, 13, 8, 2, -10 },
  { 59, 5, 5, 8, 2, -10 },
  { 63, 7, 7, 8, 1, -8 },
  { 70, 3, 4, 8, 2, -2 },
  { 72, 4, 1, 8, 2, -4 },
  { 73, 2, 2, 8, 3, -2 },
  { 74, 7, 10, 8, 1, -10 },
  { 83, 7, 9, 8, 1, -9 },
  { 91, 7, 9, 8, 1, -9 },
  { 99, 6, 9, 8, 1, -9 },
  { 106, 7, 9, 8, 1, -9 },
  { 114, 7, 9, 8, 1, -9 },
  { 122, 7, 9, 8, 1, -9 },
  { 130, 7, 9, 8, 1, -9 },
  { 138, 6, 9, 8, 1, -9 },
  { 145, 6, 9, 8, 1, -9 },
  { 152, 6, 9, 8, 1, -9 },
  { 159, 2, 7, 8, 3, -7 },
  { 161, 3, 9, 8, 2, -7 },
  { 165, 7, 7, 8, 1, -8 },
  { 172, 7, 4, 8, 1, -6 },
  { 176, 7, 7, 8, 1, -8 },
  { 183, 6, 9, 8, 1, -9 },
  { 190, 8, 12, 8, 0, -10 },
  { 202, 8, 9, 8, 0, -9 },
  { 211, 7, 9, 8, 1, -9 },
  { 219, 7, 9, 8, 1, -9 },
  { 227, 7, 9, 8, 1, -9 },
  { 235, 7, 9, 8, 1, -9 },
  { 243, 6, 9, 8, 1, -9 },
  { 250, 7, 9, 8, 1, -9 },
  { 258, 6, 9, 8, 1, -9 },
  { 265, 6, 9, 8, 1, -9 },
  { 272, 6, 9, 8, 1, -9 },
  { 279, 7, 9, 8, 1, -9 },
  { 287, 6, 9, 8, 2, -9 },
  { 294, 7, 9, 8, 1, -9 },
  { 302, 6, 9, 8, 1, -9 },
  { 309, 7, 9, 8, 1, -9 },
  { 317, 7, 9, 8, 1, -9 },
  { 325, 7, 11, 8, 1, -9 },
  { 335, 7, 9, 8, 1, -9 },
  { 343, 7, 9, 8, 1, -9 },
  { 351, 7, 9, 8, 1, -9 },
  { 359, 6, 9, 8, 1, -9 },
  { 366, 8, 9, 8, 0, -9 },
  { 375, 8, 9, 8, 0, -9 },
  { 384, 8, 9, 8, 0, -9 },
  { 393, 8, 9, 8, 0, -9 },
  { 402, 8, 9, 8, 0, -9 },
  { 411, 4, 13, 8, 3, -10 },
  { 418, 7, 10, 8, 1, -10 },
  { 427, 4, 13, 8, 2, -10 },
  { 434, 6, 6, 8, 1, -9 },
  { 439, 8, 1, 8, 0, 1 },
  { 440, 3, 2, 8, 3, -10 },
  { 441, 7, 7, 8, 1, -7 },
  { 448, 6, 10, 8, 1, -10 },
  { 456, 6, 7, 8, 1, -7 },
  { 462, 6, 10, 8, 1, -10 },
  { 470, 6, 7, 8, 1, -7 },
  { 476, 7, 10, 8, 1, -10 },
  { 485, 6, 10, 8, 1, -7 },
  { 493, 6, 10, 8, 1, -10 },
  { 501, 7, 10, 8, 1, -10 },
  { 510, 5, 13, 8, 1, -10 },
  { 519, 6, 10, 8, 2, -10 },
  { 527, 7, 10, 8, 1, -10 },
  { 536, 7, 7, 8, 1, -7 },
  { 543, 6, 7, 8, 1, -7 },
  { 549, 7, 7, 8, 1, -7 },
  { 556, 6, 10, 8, 1, -7 },
  { 564, 6, 10, 8, 1, -7 },
  { 572, 5, 7, 8, 2, -7 },
  { 577, 6, 7, 8, 1, -7 },
  { 583, 6, 9, 8, 1, -9 },
  { 590, 6, 7, 8, 1, -7 },
  { 596, 8, 7, 8, 0, -7 },
  { 603, 8, 7, 8, 0, -7 },
  { 610, 7, 7, 8, 1, -7 },
  { 617, 8, 10, 8, 0, -7 },
  { 627, 6, 7, 8, 1, -7 },
  { 633, 5, 13, 8, 2, -10 },
  { 642, 1, 13, 8, 4, -10 },
  { 644, 6, 13, 8, 1, -10 },
  { 654, 7, 2, 8, 1, -6 },
};

const GFXfont LiberationMono_Regular14pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular14pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _LIBERATIONMONO_REGULAR14PT7B_H_
