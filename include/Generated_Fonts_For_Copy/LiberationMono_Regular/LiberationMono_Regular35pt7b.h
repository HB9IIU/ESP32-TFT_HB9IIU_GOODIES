#ifndef _LIBERATIONMONO_REGULAR35PT7B_H_
#define _LIBERATIONMONO_REGULAR35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0xF1, 0xFC,
  0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0x80, 0x01, 0x81, 0x80, 0x60, 0x20, 0x0C, 0x0C, 0x01, 0x81, 0x80,
  0x30, 0x30, 0x06, 0x06, 0x01, 0x81, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0,
  0xC0, 0xC0, 0x10, 0x18, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFE, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C,
  0x0C, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x78, 0xCF, 0x0E,
  0x18, 0xE3, 0x83, 0x0E, 0x70, 0x61, 0xCE, 0x0C, 0x01, 0xC1, 0x80, 0x1C,
  0x30, 0x01, 0xE6, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x63, 0xC0, 0x0C, 0x38, 0x01, 0x83, 0x30, 0x30, 0x7E, 0x06, 0x0E, 0xE0,
  0xC3, 0x9E, 0x18, 0x71, 0xE3, 0x3C, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x3E, 0x00, 0x63, 0xFC, 0x07, 0x18,
  0xE0, 0x71, 0xC3, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x83, 0x87, 0x18,
  0x1C, 0x39, 0xC0, 0xE1, 0xDC, 0x03, 0x1C, 0xC0, 0x1F, 0xEC, 0x00, 0x7C,
  0xE7, 0xC0, 0x06, 0xFF, 0x00, 0x67, 0x18, 0x07, 0x70, 0xE0, 0x73, 0x87,
  0x03, 0x1C, 0x38, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x38, 0x71, 0xC0,
  0xE3, 0x1C, 0x07, 0xF8, 0xC0, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80,
  0x38, 0x70, 0x06, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x03, 0x07, 0x00,
  0x61, 0xE0, 0x0E, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x06, 0x1F, 0x80, 0xC7,
  0xB8, 0x38, 0xE3, 0x87, 0x38, 0x78, 0xC7, 0x07, 0x38, 0xE0, 0x77, 0x1C,
  0x07, 0xC3, 0x80, 0x78, 0x70, 0x0F, 0x07, 0x87, 0xF8, 0x7F, 0xE7, 0xC3,
  0xF0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x83, 0x83, 0x83, 0xC1,
  0xC1, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x78, 0x1C,
  0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0F, 0x07,
  0x07, 0x83, 0x83, 0xC1, 0xC1, 0xC1, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x86, 0x2F, 0xBF, 0x3F, 0xF8, 0x1C, 0x01, 0xF0, 0x0D, 0x80, 0xC6, 0x0E,
  0x38, 0x20, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x38, 0x70, 0x70, 0x60, 0x60,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x87, 0x01, 0xC7, 0x00,
  0x73, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xC7, 0x01, 0xC1, 0xC1, 0xC0, 0x7F,
  0xC0, 0x1F, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0xFD,
  0xC0, 0xE1, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x87, 0x01, 0xE7, 0x80, 0x73,
  0x80, 0x39, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x8F, 0x01, 0xE7, 0x00,
  0x73, 0x80, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0xE0, 0x03, 0xF8, 0x03, 0xDC, 0x01, 0xCF, 0x00, 0xE3, 0xC1, 0xE0, 0xFF,
  0xE0, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1D, 0xC0, 0x0C, 0xE0, 0x0E, 0x70, 0x0E, 0x38, 0x0E, 0x1C, 0x06, 0x0E,
  0x07, 0x07, 0x07, 0x03, 0x83, 0x01, 0xC3, 0x80, 0xE3, 0x80, 0x71, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x3F, 0xFE, 0x1F, 0xFF, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x73, 0xF0, 0x3B,
  0xFE, 0x1F, 0x07, 0x8E, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0xF0, 0x03, 0xBC, 0x01, 0xCE, 0x01, 0xE3, 0xC1,
  0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x3C, 0x38,
  0x1E, 0x70, 0x0E, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xE0, 0xEF,
  0xF8, 0xFC, 0x3C, 0xF0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x1F,
  0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x8F, 0x01, 0xE7, 0x00, 0x73, 0x80, 0x39,
  0xC0, 0x1C, 0xE0, 0x0E, 0x38, 0x0E, 0x1E, 0x0F, 0x03, 0xFE, 0x01, 0xFF,
  0x03, 0xC1, 0xE3, 0x80, 0x39, 0xC0, 0x1D, 0xE0, 0x0F, 0xE0, 0x07, 0xF8,
  0x03, 0xDC, 0x01, 0xCE, 0x00, 0xE3, 0xC1, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0,
  0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0x0F, 0x0F, 0x01, 0xC7, 0x00, 0xE3, 0x80,
  0x3B, 0xC0, 0x1D, 0xE0, 0x0E, 0xF0, 0x07, 0x38, 0x03, 0xDC, 0x01, 0xEF,
  0x01, 0xF3, 0xC3, 0xF8, 0xFF, 0xB8, 0x1F, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x9C, 0x03, 0x8F, 0x03, 0xC3, 0xC3, 0xC0, 0xFF, 0xC0, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xCF, 0x9E, 0x3C, 0x71, 0xE3, 0x87, 0x0C, 0x38, 0x60, 0x00, 0x00,
  0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xFC,
  0x01, 0xF0, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x78,
  0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFE, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x7F,
  0xC0, 0x3C, 0x1C, 0x0E, 0x01, 0xC1, 0x80, 0x1C, 0x70, 0x01, 0x8C, 0x3C,
  0xF3, 0x0F, 0xF3, 0x63, 0x9E, 0x6C, 0xE1, 0xCF, 0x98, 0x39, 0xE7, 0x07,
  0x3C, 0xE0, 0xE7, 0x98, 0x18, 0xF3, 0x03, 0x1E, 0x60, 0x63, 0xCC, 0x1C,
  0x79, 0x83, 0x8F, 0x30, 0x63, 0xE6, 0x1C, 0x6C, 0xE6, 0xDD, 0x8F, 0xDF,
  0x18, 0xE3, 0xC3, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x20, 0xE0, 0x0E,
  0x0F, 0x07, 0x80, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xE6, 0x00,
  0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC1,
  0xC0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x3C, 0x01, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0xF0, 0x01,
  0xE7, 0x00, 0x07, 0x38, 0x00, 0x3B, 0xC0, 0x01, 0xE0, 0xFF, 0xE0, 0x7F,
  0xFC, 0x38, 0x0F, 0x1C, 0x03, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39,
  0xC0, 0x1C, 0xE0, 0x1E, 0x70, 0x1E, 0x3F, 0xFC, 0x1F, 0xFF, 0x0E, 0x01,
  0xE7, 0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xDC, 0x01, 0xEE, 0x01, 0xE7, 0xFF, 0xE3, 0xFF, 0xC0, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xE1, 0xE0, 0xE0, 0x3C, 0x78, 0x07, 0x1C, 0x00, 0xEF,
  0x00, 0x23, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x01,
  0x1C, 0x00, 0xE7, 0x80, 0x38, 0xF0, 0x1C, 0x1E, 0x1E, 0x03, 0xFF, 0x00,
  0x3F, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0xE0, 0xF8, 0xE0, 0x3C, 0xE0, 0x1E,
  0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0x78, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFE,
  0x0F, 0x87, 0x87, 0x01, 0xE7, 0x80, 0x73, 0x80, 0x3F, 0xC0, 0x09, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDE, 0x00,
  0xE7, 0x00, 0x71, 0xE0, 0xF8, 0x7F, 0xF0, 0x0F, 0xC0, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x03, 0x9C, 0x0E,
  0x78, 0x78, 0xFF, 0xC0, 0xFC, 0x00, 0xE0, 0x0F, 0x38, 0x03, 0x8E, 0x01,
  0xC3, 0x80, 0xF0, 0xE0, 0x78, 0x38, 0x3C, 0x0E, 0x1E, 0x03, 0x8F, 0x00,
  0xE3, 0x80, 0x39, 0xC0, 0x0E, 0xF8, 0x03, 0xFE, 0x00, 0xFB, 0xC0, 0x3E,
  0x78, 0x0F, 0x0F, 0x03, 0x83, 0xC0, 0xE0, 0x78, 0x38, 0x0F, 0x0E, 0x01,
  0xE3, 0x80, 0x78, 0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x3C, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0x60, 0xDF, 0xB8, 0xEF, 0xDC, 0x77, 0xE7,
  0x33, 0xF3, 0xB9, 0xF8, 0xD8, 0xFC, 0x7C, 0x7E, 0x3E, 0x3F, 0x0E, 0x1F,
  0x87, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0E, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7D, 0xC0, 0xFF, 0x81, 0xFB, 0x83, 0xF7, 0x07, 0xE7, 0x0F,
  0xCE, 0x1F, 0x8C, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x39, 0xF8, 0x73, 0xF0,
  0x77, 0xE0, 0xEF, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xF8, 0x07, 0x80, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x87, 0x01, 0xC7,
  0x00, 0x73, 0x80, 0x3B, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xF0, 0x07, 0xB8, 0x03, 0x9C, 0x01, 0xC7, 0x01, 0xC3, 0xC1, 0xE0,
  0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0xE0, 0xFF, 0xFC, 0xE0, 0x3E, 0xE0, 0x0E,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0E, 0xE0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x87, 0x01, 0xC7, 0x00,
  0x73, 0x80, 0x3B, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xF0, 0x07, 0xB8, 0x03, 0x9C, 0x01, 0xC7, 0x01, 0xC3, 0xC1, 0xE0, 0xFF,
  0xE0, 0x1F, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7C, 0xFF, 0xF0, 0x7F, 0xFE, 0x38, 0x07,
  0x9C, 0x01, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0,
  0x0F, 0x70, 0x07, 0x38, 0x0F, 0x9F, 0xFF, 0x0F, 0xFE, 0x07, 0x0F, 0x03,
  0x83, 0xC1, 0xC0, 0xE0, 0xE0, 0x78, 0x70, 0x1E, 0x38, 0x07, 0x1C, 0x03,
  0xCE, 0x00, 0xE7, 0x00, 0x7B, 0x80, 0x1E, 0x03, 0xF8, 0x03, 0xFF, 0x81,
  0xE0, 0xF0, 0xE0, 0x1E, 0x38, 0x03, 0x9E, 0x00, 0xE7, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77,
  0x00, 0x1D, 0xE0, 0x0F, 0x3E, 0x0F, 0x87, 0xFF, 0xC0, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCF, 0x01,
  0xE3, 0xC1, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0xF0, 0x00, 0x7B, 0x80, 0x03,
  0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0x80, 0x0E, 0x1E, 0x00, 0xF0, 0x70,
  0x07, 0x03, 0x80, 0x38, 0x1E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0,
  0x1E, 0x0F, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x0E, 0x38, 0x00, 0x71,
  0xC0, 0x03, 0x8E, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x1E, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39,
  0xC0, 0x01, 0xCE, 0x0E, 0x0E, 0x70, 0x70, 0x73, 0x87, 0xC3, 0x8E, 0x36,
  0x38, 0x71, 0xB1, 0xC3, 0x8D, 0xCE, 0x1C, 0xEE, 0x70, 0xE6, 0x33, 0x87,
  0x31, 0x9C, 0x1B, 0x8E, 0xC0, 0xDC, 0x76, 0x07, 0xC1, 0xB0, 0x3E, 0x0F,
  0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x38, 0x0E, 0x00, 0x70, 0x01, 0xCF,
  0x00, 0x78, 0xE0, 0x0E, 0x0E, 0x03, 0x81, 0xE0, 0xF0, 0x1C, 0x1C, 0x01,
  0xC7, 0x00, 0x3D, 0xE0, 0x03, 0xB8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0x70, 0x01, 0xEF, 0x00, 0x38, 0xE0, 0x0E,
  0x0E, 0x03, 0xC1, 0xE0, 0x70, 0x1C, 0x1C, 0x01, 0xC7, 0x80, 0x3C, 0xE0,
  0x03, 0xB8, 0x00, 0x38, 0xE0, 0x00, 0xEE, 0x00, 0x39, 0xE0, 0x0F, 0x1C,
  0x01, 0xC3, 0xC0, 0x78, 0x3C, 0x1E, 0x03, 0x83, 0x80, 0x78, 0xF0, 0x07,
  0x1C, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xFF,
  0x01, 0xC0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0xEE, 0x00, 0x63, 0x00, 0x71,
  0xC0, 0x30, 0xE0, 0x38, 0x30, 0x1C, 0x1C, 0x0C, 0x06, 0x0E, 0x03, 0x86,
  0x00, 0xC7, 0x00, 0x73, 0x80, 0x3B, 0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0xF0, 0x70, 0x70, 0x07, 0xF0, 0x07, 0xFE, 0x03, 0xC3,
  0xC1, 0xE0, 0x78, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x3F, 0xF8,
  0x3F, 0xFE, 0x1F, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x0E, 0x38,
  0x07, 0x8F, 0x03, 0xE1, 0xE1, 0xBC, 0x7F, 0xC7, 0xC7, 0xC1, 0xF0, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE3, 0xF0, 0xE7, 0xF8, 0xEC, 0x3C, 0xF8, 0x1E, 0xF0, 0x0E, 0xF0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF8, 0x1E, 0xEC, 0x3C, 0xEF, 0xF8, 0xE3,
  0xF0, 0x07, 0xF0, 0x1F, 0xFC, 0x3C, 0x1E, 0x38, 0x0F, 0x70, 0x07, 0x70,
  0x07, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x70, 0x07, 0x70, 0x07, 0x78, 0x0F, 0x3C, 0x1E, 0x1F, 0xFC, 0x07,
  0xF0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x0F, 0xC7, 0x1F, 0xF7, 0x3C, 0x37, 0x78, 0x0F, 0x70,
  0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0x78, 0x1F, 0x3C, 0x37, 0x1F,
  0xE7, 0x0F, 0xC7, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x8F, 0x01, 0xE7,
  0x00, 0x73, 0x80, 0x3B, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x30, 0xE0, 0x1C, 0x78,
  0x3C, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x01, 0xFF, 0xFE, 0xFF,
  0xFF, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xC7, 0x1F, 0xE7, 0x3C, 0x37, 0x78, 0x1F, 0x70, 0x0F, 0x70, 0x0F,
  0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07,
  0x70, 0x0F, 0x70, 0x0F, 0x78, 0x1F, 0x3C, 0x37, 0x1F, 0xE7, 0x0F, 0xC7,
  0x00, 0x07, 0x00, 0x07, 0x38, 0x0F, 0x38, 0x0E, 0x1E, 0x1E, 0x1F, 0xFC,
  0x07, 0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x71, 0xF8, 0xE7, 0xF9, 0xD8, 0x7B, 0xE0, 0x7F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0E, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x1E, 0xFF, 0xCF, 0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x0E, 0xE0, 0x39,
  0xC0, 0xE3, 0x83, 0x87, 0x0E, 0x0E, 0x38, 0x1C, 0xF0, 0x3B, 0xC0, 0x7F,
  0x80, 0xFF, 0x81, 0xE7, 0x03, 0x87, 0x07, 0x0F, 0x0E, 0x0F, 0x1C, 0x0F,
  0x38, 0x0E, 0x70, 0x1E, 0xE0, 0x1E, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xCF, 0x1E, 0x6F, 0xDF, 0xB4, 0xE8, 0xFC, 0x3C, 0x7E, 0x1C, 0x3F, 0x0E,
  0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC,
  0x38, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3,
  0xF0, 0xE1, 0xC0, 0xE3, 0xF1, 0xCF, 0xF3, 0xB0, 0xF7, 0xC0, 0xFF, 0x00,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1C, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x8F, 0x01, 0xE7, 0x00, 0x73,
  0x80, 0x3B, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xF7, 0x00, 0x73, 0x80, 0x39, 0xE0, 0x38, 0x78, 0x3C, 0x1F,
  0xFC, 0x03, 0xF8, 0x00, 0xE3, 0xF0, 0xE7, 0xF8, 0xEC, 0x3C, 0xF8, 0x1E,
  0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xEC, 0x3C,
  0xEF, 0xF8, 0xE3, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xC7, 0x1F, 0xF7, 0x3C, 0x37,
  0x78, 0x1F, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0x78, 0x1F,
  0x3C, 0x37, 0x1F, 0xE7, 0x0F, 0xC7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xE1, 0xFF, 0x8F, 0xF7,
  0x7F, 0xDF, 0xC0, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xE0, 0xF3, 0x80, 0xE6,
  0x00, 0xEE, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xB8, 0x0E, 0x3F, 0xF8,
  0x1F, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x03, 0xFF,
  0xFF, 0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xBC,
  0x37, 0x3F, 0xCE, 0x3F, 0x1C, 0xF0, 0x01, 0xEE, 0x00, 0x39, 0xE0, 0x0F,
  0x1C, 0x01, 0xC3, 0x80, 0x38, 0x78, 0x0E, 0x07, 0x01, 0xC0, 0xF0, 0x78,
  0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x3C, 0x70, 0x03, 0x8E, 0x00, 0x73, 0xC0,
  0x07, 0x70, 0x00, 0xEE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x3B, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00,
  0x07, 0x38, 0x38, 0x39, 0xC3, 0xE1, 0x87, 0x1B, 0x1C, 0x38, 0xD8, 0xE1,
  0xCE, 0xE7, 0x0E, 0x63, 0x38, 0x73, 0x19, 0xC1, 0xB8, 0xEC, 0x0D, 0x87,
  0xE0, 0x6C, 0x1F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1C, 0x00,
  0xF0, 0x07, 0xB8, 0x07, 0x8E, 0x03, 0x83, 0x83, 0x81, 0xE3, 0x80, 0x71,
  0xC0, 0x1D, 0xC0, 0x07, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x00,
  0xEE, 0x00, 0xE3, 0x80, 0xE0, 0xE0, 0xF0, 0x78, 0x70, 0x1C, 0x70, 0x07,
  0x70, 0x01, 0xC0, 0xF0, 0x01, 0xEE, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x01,
  0xC3, 0x80, 0x38, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x0E,
  0x01, 0xC1, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x39, 0x80, 0x07, 0x70,
  0x00, 0x6E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x01, 0xF8, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x03, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x7C, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x0F, 0xF0, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0xE0, 0xF0, 0x7F, 0xE0,
  0x07, 0xE0,
};

const GFXglyph LiberationMono_Regular35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 3, 23, 21, 9, -23 },
  { 10, 11, 11, 21, 5, -25 },
  { 26, 19, 23, 21, 1, -23 },
  { 81, 19, 29, 21, 1, -26 },
  { 150, 21, 23, 21, 0, -23 },
  { 211, 19, 23, 21, 1, -23 },
  { 266, 3, 11, 21, 9, -25 },
  { 271, 9, 32, 21, 6, -25 },
  { 307, 9, 32, 21, 6, -25 },
  { 343, 13, 12, 21, 4, -25 },
  { 363, 17, 16, 21, 2, -20 },
  { 397, 8, 11, 21, 4, -5 },
  { 408, 9, 3, 21, 6, -11 },
  { 412, 5, 5, 21, 8, -5 },
  { 416, 17, 25, 21, 2, -25 },
  { 470, 17, 23, 21, 2, -23 },
  { 519, 16, 23, 21, 3, -23 },
  { 565, 17, 23, 21, 2, -23 },
  { 614, 17, 23, 21, 2, -23 },
  { 663, 17, 23, 21, 2, -23 },
  { 712, 17, 23, 21, 2, -23 },
  { 761, 16, 23, 21, 3, -23 },
  { 807, 15, 23, 21, 3, -23 },
  { 851, 17, 23, 21, 2, -23 },
  { 900, 17, 23, 21, 2, -23 },
  { 949, 5, 18, 21, 8, -18 },
  { 961, 7, 24, 21, 6, -18 },
  { 982, 17, 17, 21, 2, -20 },
  { 1019, 17, 10, 21, 2, -17 },
  { 1041, 17, 17, 21, 2, -20 },
  { 1078, 16, 23, 21, 2, -23 },
  { 1124, 19, 30, 21, 1, -25 },
  { 1196, 21, 23, 21, 0, -23 },
  { 1257, 17, 23, 21, 3, -23 },
  { 1306, 18, 23, 21, 2, -23 },
  { 1358, 16, 23, 21, 3, -23 },
  { 1404, 16, 23, 21, 3, -23 },
  { 1450, 16, 23, 21, 3, -23 },
  { 1496, 17, 23, 21, 2, -23 },
  { 1545, 15, 23, 21, 3, -23 },
  { 1589, 15, 23, 21, 3, -23 },
  { 1633, 14, 23, 21, 3, -23 },
  { 1674, 18, 23, 21, 3, -23 },
  { 1726, 15, 23, 21, 4, -23 },
  { 1770, 17, 23, 21, 2, -23 },
  { 1819, 15, 23, 21, 3, -23 },
  { 1863, 17, 23, 21, 2, -23 },
  { 1912, 16, 23, 21, 3, -23 },
  { 1958, 17, 30, 21, 2, -23 },
  { 2022, 17, 23, 21, 3, -23 },
  { 2071, 18, 23, 21, 1, -23 },
  { 2123, 19, 23, 21, 1, -23 },
  { 2178, 17, 23, 21, 2, -23 },
  { 2227, 21, 23, 21, 0, -23 },
  { 2288, 21, 23, 21, 0, -23 },
  { 2349, 19, 23, 21, 1, -23 },
  { 2404, 19, 23, 21, 1, -23 },
  { 2459, 19, 23, 21, 1, -23 },
  { 2514, 9, 32, 21, 7, -25 },
  { 2550, 17, 25, 21, 2, -25 },
  { 2604, 9, 32, 21, 5, -25 },
  { 2640, 17, 15, 21, 2, -23 },
  { 2672, 21, 2, 21, 0, 2 },
  { 2678, 7, 4, 21, 7, -25 },
  { 2682, 18, 18, 21, 2, -18 },
  { 2723, 16, 25, 21, 3, -25 },
  { 2773, 16, 18, 21, 2, -18 },
  { 2809, 16, 25, 21, 2, -25 },
  { 2859, 17, 18, 21, 2, -18 },
  { 2898, 17, 25, 21, 2, -25 },
  { 2952, 16, 25, 21, 2, -18 },
  { 3002, 15, 25, 21, 3, -25 },
  { 3049, 17, 25, 21, 2, -25 },
  { 3103, 12, 32, 21, 2, -25 },
  { 3151, 15, 25, 21, 4, -25 },
  { 3198, 17, 25, 21, 2, -25 },
  { 3252, 17, 18, 21, 2, -18 },
  { 3291, 15, 18, 21, 3, -18 },
  { 3325, 17, 18, 21, 2, -18 },
  { 3364, 16, 25, 21, 3, -18 },
  { 3414, 16, 25, 21, 2, -18 },
  { 3464, 14, 18, 21, 4, -18 },
  { 3496, 15, 18, 21, 3, -18 },
  { 3530, 14, 23, 21, 3, -23 },
  { 3571, 15, 18, 21, 3, -18 },
  { 3605, 19, 18, 21, 1, -18 },
  { 3648, 21, 18, 21, 0, -18 },
  { 3696, 17, 18, 21, 2, -18 },
  { 3735, 19, 25, 21, 1, -18 },
  { 3795, 15, 18, 21, 3, -18 },
  { 3829, 14, 32, 21, 4, -25 },
  { 3885, 3, 32, 21, 9, -25 },
  { 3897, 14, 32, 21, 3, -25 },
  { 3953, 17, 4, 21, 2, -13 },
};

const GFXfont LiberationMono_Regular35pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular35pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular35pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _LIBERATIONMONO_REGULAR35PT7B_H_
