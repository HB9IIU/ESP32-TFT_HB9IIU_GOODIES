#ifndef _LIBERATIONMONO_REGULAR38PT7B_H_
#define _LIBERATIONMONO_REGULAR38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xF0,
  0xFF, 0x83, 0xFC, 0x1D, 0xE0, 0xEF, 0x07, 0x78, 0x39, 0xC1, 0xCE, 0x0E,
  0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE0, 0x01, 0x80, 0xC0, 0x0C, 0x06,
  0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x0C,
  0x06, 0x00, 0x60, 0x30, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC1, 0x80, 0xC0,
  0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x03, 0x00, 0x30, 0x18, 0x1F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF0, 0x60, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01,
  0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x60, 0x07, 0x03, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFC, 0x3E, 0x73, 0xE3, 0x87, 0x1E, 0x78, 0x70, 0xF7,
  0x87, 0x0E, 0x38, 0x70, 0x03, 0xC7, 0x00, 0x3E, 0x70, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0x1E, 0x00, 0x70,
  0xF0, 0x07, 0x07, 0x00, 0x70, 0x77, 0x07, 0x07, 0xF0, 0x70, 0x77, 0x87,
  0x0F, 0x7E, 0x73, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x38, 0xFF, 0x00,
  0x61, 0xC7, 0x01, 0xC7, 0x06, 0x07, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x38,
  0x38, 0x38, 0xE0, 0x70, 0x73, 0x80, 0xE0, 0xC7, 0x01, 0xC3, 0x9C, 0x01,
  0xC7, 0x70, 0x03, 0xFC, 0xC0, 0x01, 0xF3, 0x9F, 0x00, 0x0E, 0x7F, 0x00,
  0x19, 0xC7, 0x00, 0x73, 0x06, 0x01, 0xCE, 0x0E, 0x03, 0x1C, 0x1C, 0x0E,
  0x38, 0x38, 0x38, 0x70, 0x70, 0x60, 0xE0, 0xE1, 0xC0, 0xC1, 0x87, 0x01,
  0xC7, 0x1C, 0x01, 0xFC, 0x30, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0x1E, 0x1E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x38,
  0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x3C, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0x83, 0xF8, 0x0E, 0x3C, 0xE0, 0x71, 0xC3, 0x87, 0x1C, 0x1C,
  0x38, 0xE0, 0x71, 0xC7, 0x01, 0xDC, 0x38, 0x0F, 0xE1, 0xC0, 0x3E, 0x0F,
  0x00, 0xF0, 0x3C, 0x1F, 0xE1, 0xFF, 0xFF, 0xE7, 0xFF, 0x3F, 0x0F, 0xE0,
  0x78, 0xFF, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x01, 0xC0, 0x70, 0x1E, 0x07,
  0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x70, 0x1E, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x0F,
  0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0,
  0x78, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC1, 0x8E,
  0x3F, 0x77, 0xFF, 0xFC, 0x7F, 0x00, 0xE0, 0x0F, 0x80, 0xEE, 0x0E, 0x30,
  0xE1, 0xC1, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0x70, 0xE0,
  0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xF0, 0xF8, 0x3C, 0x3C, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x3D, 0xC0, 0x07,
  0x70, 0x01, 0xFC, 0x00, 0x7F, 0x1F, 0x1F, 0xC7, 0xC7, 0xF1, 0xF1, 0xFC,
  0x7C, 0x7F, 0x1F, 0x1F, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00,
  0x3D, 0xE0, 0x0E, 0x3C, 0x07, 0x8F, 0x83, 0xC1, 0xFF, 0xF0, 0x3F, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x7F, 0x80,
  0xFE, 0xE0, 0x3F, 0x38, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xE7, 0x00, 0xF7, 0x80,
  0x3F, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xF0, 0xF8, 0x3E, 0x78, 0x07, 0x9E, 0x00, 0xF7, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0xF8, 0x01, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x00,
  0x1D, 0xC0, 0x07, 0x78, 0x03, 0xDF, 0x83, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x73, 0x80, 0x1C, 0x70, 0x07, 0x0E,
  0x00, 0xE1, 0xC0, 0x38, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x1C, 0x03, 0x87, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x7E, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x0F, 0x9E, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x0F,
  0x78, 0x07, 0xCF, 0x83, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xE3, 0x80, 0x73, 0xC0,
  0x39, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0xFC, 0x39, 0xFF, 0x1D,
  0xFF, 0xEF, 0xC1, 0xF7, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0xF7, 0x80, 0x79, 0xF0, 0xF8, 0x7F,
  0xF8, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xF8, 0x3E, 0x78, 0x03, 0x9E,
  0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0E, 0x38, 0x03, 0x8F, 0x83, 0xC1, 0xFF,
  0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0x0F, 0x83, 0xE7, 0x80, 0x3D, 0xC0, 0x0F,
  0x70, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0F, 0x78, 0x03, 0xDF,
  0x83, 0xE3, 0xFF, 0xF8, 0x7F, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x8F, 0x83, 0xCF, 0x00, 0xF7, 0x80, 0x3B, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xF7, 0xC1,
  0xFB, 0xFF, 0xDC, 0x7F, 0xCE, 0x1F, 0x87, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xDE, 0x01, 0xEF, 0x01, 0xE3, 0xC1, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3E, 0x3C, 0x3C,
  0x78, 0x78, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF0, 0x3E, 0x78, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xF8, 0x01, 0xE0, 0xE0, 0x1C, 0x03, 0x81, 0xC0, 0x0E, 0x0C, 0x00, 0x30,
  0xE0, 0x01, 0xC6, 0x0F, 0x36, 0x70, 0xFD, 0xB3, 0x0E, 0x6D, 0xD8, 0xE1,
  0xE7, 0xC6, 0x0E, 0x3E, 0x70, 0x71, 0xE3, 0x03, 0x8F, 0x18, 0x1C, 0x79,
  0xC0, 0xE3, 0xCE, 0x06, 0x1E, 0x70, 0x30, 0xF3, 0x81, 0x8F, 0x9C, 0x1C,
  0x7C, 0xE0, 0xE3, 0x67, 0x07, 0x1B, 0x98, 0x79, 0xDC, 0xE6, 0xCC, 0x67,
  0xE7, 0xC3, 0x1E, 0x1C, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x08,
  0x0E, 0x00, 0xE0, 0x3C, 0x1E, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0E,
  0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0xC7,
  0x80, 0x07, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x1C,
  0x01, 0xE0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0xF0, 0x01, 0xC1, 0xE0, 0x03, 0xC3, 0x80, 0x03, 0x8F,
  0x00, 0x07, 0x1E, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xFF,
  0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xC0, 0x7C, 0xF0, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0x3C, 0x07, 0xCF, 0xFF, 0xC3,
  0xFF, 0xC0, 0xFF, 0xFE, 0x3C, 0x03, 0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x03,
  0xEF, 0xFF, 0xFB, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFE, 0x1F, 0x87, 0xC3, 0xC0, 0x3C, 0xF0, 0x03, 0xDE, 0x00,
  0x63, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x19, 0xE0, 0x07, 0xBC, 0x00, 0xF3, 0xC0, 0x3C, 0x3E, 0x1F,
  0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xC1, 0xF8, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x00, 0x7B,
  0xC0, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xBC, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x0F, 0x8F, 0xFF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8,
  0x3E, 0x3C, 0x03, 0xDE, 0x00, 0x77, 0x80, 0x19, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xDE, 0x00, 0x77, 0x80, 0x1D, 0xE0,
  0x07, 0x3C, 0x01, 0xC7, 0xC1, 0xF1, 0xFF, 0xFC, 0x1F, 0xFC, 0x03, 0xF8,
  0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1D, 0xC0, 0x3F, 0x80, 0xF7, 0x81, 0xEF, 0x87, 0x8F,
  0xFF, 0x0F, 0xFC, 0x07, 0xE0, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x0F,
  0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x0F,
  0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xDE, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x80, 0xF0, 0x78, 0x0F,
  0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x78,
  0xF0, 0x03, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xEC, 0x07, 0xFB, 0x83, 0xFE,
  0xE0, 0xFF, 0x9C, 0x77, 0xE7, 0x1D, 0xF9, 0xC6, 0x7E, 0x3B, 0x9F, 0x8E,
  0xE7, 0xE3, 0xB1, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x83, 0x87, 0xE0, 0xE1,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0x70, 0x1F, 0xB8, 0x0F, 0xDE, 0x07,
  0xE7, 0x03, 0xF3, 0xC1, 0xF8, 0xE0, 0xFC, 0x70, 0x7E, 0x1C, 0x3F, 0x0E,
  0x1F, 0x83, 0x8F, 0xC1, 0xC7, 0xE0, 0x73, 0xF0, 0x39, 0xF8, 0x0E, 0xFC,
  0x07, 0x7E, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F,
  0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0xC0,
  0x78, 0xF0, 0x07, 0x9C, 0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01,
  0xE7, 0xC0, 0x78, 0x7C, 0x1F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8,
  0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xC0, 0x7E, 0xF0, 0x07,
  0xBC, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3B, 0xC0, 0x1E, 0xF0, 0x1F, 0x3F, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF,
  0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0xC0, 0x78, 0xF0, 0x07,
  0x9C, 0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x78,
  0x7C, 0x1F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x78, 0x07, 0xCF,
  0x00, 0x79, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE,
  0x00, 0x73, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F,
  0xFC, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78,
  0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0xF0,
  0x03, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xE0, 0x7C,
  0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x38, 0x00, 0xE3, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x70,
  0x00, 0xF7, 0x80, 0x0F, 0x78, 0x01, 0xE3, 0xE0, 0x3E, 0x3F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0xF3, 0xC0, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0,
  0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x0F, 0x00,
  0x78, 0x1E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0E,
  0x00, 0x70, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0xC0,
  0x03, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x3C, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x73, 0x80,
  0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x38, 0x00,
  0x1E, 0x78, 0x38, 0x38, 0xF0, 0xF0, 0x70, 0xE1, 0xF0, 0xE1, 0xC3, 0xE1,
  0xC3, 0x86, 0xC3, 0x87, 0x1D, 0xC7, 0x0E, 0x3B, 0x9E, 0x1E, 0x67, 0x38,
  0x1D, 0xC6, 0x70, 0x3B, 0x8E, 0xE0, 0x77, 0x1D, 0xC0, 0xEC, 0x1B, 0x81,
  0xF8, 0x37, 0x03, 0xF0, 0x7C, 0x03, 0xC0, 0xF8, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x0F, 0x00, 0x78, 0x3C, 0x07,
  0x81, 0xE0, 0x38, 0x07, 0x83, 0xC0, 0x1C, 0x3C, 0x00, 0xF1, 0xC0, 0x03,
  0xDE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7B, 0xC0, 0x07, 0x8E, 0x00, 0x38,
  0x78, 0x03, 0xC1, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x3C, 0x1E, 0x00, 0xF1,
  0xE0, 0x03, 0x8E, 0x00, 0x1E, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x7B, 0x80,
  0x07, 0x9E, 0x00, 0x3C, 0x78, 0x03, 0xC1, 0xC0, 0x1C, 0x0F, 0x01, 0xE0,
  0x3C, 0x1E, 0x01, 0xE0, 0xE0, 0x07, 0x8F, 0x00, 0x1C, 0xF0, 0x00, 0xF7,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3B,
  0x00, 0x0E, 0xE0, 0x03, 0x38, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x38, 0x30,
  0x0E, 0x0E, 0x03, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x1C, 0x38, 0x03, 0x0E,
  0x00, 0xE7, 0x00, 0x39, 0xC0, 0x07, 0x70, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xFE, 0x03, 0xC0, 0xF0, 0x38, 0x07, 0x07, 0x80, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x87,
  0xC0, 0x78, 0x78, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF8,
  0xF0, 0x1F, 0x87, 0x83, 0xF8, 0x7F, 0xF3, 0xF3, 0xFE, 0x3F, 0x1F, 0x81,
  0xF0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE3, 0xF0, 0xF7, 0xFC, 0x7F, 0xFF, 0x3F, 0x87,
  0xDF, 0x01, 0xEF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1E, 0xFE, 0x1F, 0x7F, 0xFF, 0x3D, 0xFF, 0x1E, 0x3F,
  0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x3C, 0x03,
  0xDE, 0x00, 0xF7, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x3D, 0xE0,
  0x0F, 0x3C, 0x07, 0x8F, 0x83, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x0F, 0xC7, 0x3F, 0xF7, 0x7F, 0xF7, 0x7C, 0x3F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0x78, 0x3F, 0x7F, 0xF7, 0x3F, 0xE7, 0x0F, 0xC7, 0x03, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x38, 0x07, 0x9E, 0x00, 0xF7, 0x00,
  0x1D, 0xC0, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x06, 0x3C, 0x03, 0xCF,
  0x83, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0xC7, 0x9F,
  0xF3, 0x8F, 0xFD, 0xCF, 0x87, 0xEF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3D,
  0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00,
  0x77, 0x00, 0x3B, 0x80, 0x3D, 0xE0, 0x1E, 0xF0, 0x1F, 0x3C, 0x1F, 0x9F,
  0xFD, 0xC7, 0xFC, 0xE0, 0xFC, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x78, 0x0F, 0x3E, 0x0F, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF1, 0xF8, 0xF7, 0xFE, 0xFF, 0xFE, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x80, 0xFB, 0xFF, 0xCF, 0xFE, 0x1F,
  0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0xF0, 0x1E, 0x78, 0x1E, 0x3C, 0x1E,
  0x1E, 0x0E, 0x0F, 0x0F, 0x07, 0x8F, 0x03, 0xCF, 0x01, 0xEF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0x3C, 0x0F, 0x0E, 0x07, 0x87, 0x83,
  0xC1, 0xE1, 0xE0, 0x78, 0xF0, 0x1C, 0x78, 0x0F, 0x3C, 0x03, 0xDE, 0x00,
  0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x87, 0x9D, 0xF9,
  0xFB, 0xFF, 0x7F, 0x7C, 0xF8, 0xFF, 0x0F, 0x1F, 0xE1, 0xC1, 0xF8, 0x38,
  0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70,
  0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0,
  0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0E, 0xF1, 0xF8,
  0xF7, 0xFE, 0xFF, 0xFE, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8,
  0x3E, 0x3C, 0x07, 0x9E, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xDC, 0x00, 0x77,
  0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x07, 0x8F, 0x83, 0xE1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x03, 0xF8, 0x00, 0xF1, 0xF8, 0x7B, 0xFE, 0x3F, 0xFF, 0x9F, 0xC3,
  0xEF, 0x80, 0xF7, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0x7E, 0x0F, 0xBF, 0xFF, 0x9E, 0xFF, 0x8F, 0x1F,
  0x87, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC7, 0x3F, 0xF7, 0x7F, 0xF7,
  0x7C, 0x3F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0x7C, 0x3F, 0x7F, 0xF7, 0x3F, 0xE7, 0x0F, 0xC7,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x70, 0x7E, 0xE3, 0xFD, 0xCF, 0xFB, 0xBC, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x8F, 0x01, 0xE7, 0x00, 0x73, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0xC0, 0x0F, 0xF0, 0x07, 0x3C, 0x07, 0x9F, 0xFF,
  0x87, 0xFF, 0x80, 0x7F, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x8F, 0xFF, 0x0F, 0xFE, 0x07, 0xF0, 0xF0, 0x07, 0x78, 0x03, 0xBC, 0x01,
  0xDE, 0x00, 0xEF, 0x00, 0x77, 0x80, 0x3B, 0xC0, 0x1D, 0xE0, 0x0E, 0xF0,
  0x07, 0x78, 0x03, 0xBC, 0x01, 0xDE, 0x00, 0xEF, 0x00, 0x77, 0x80, 0x3B,
  0xC0, 0x1C, 0xE0, 0x1E, 0x70, 0x0F, 0x3C, 0x1F, 0x9F, 0xFD, 0xC7, 0xFC,
  0xF0, 0xFC, 0x78, 0xF0, 0x00, 0x73, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0x70,
  0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xE0, 0x70, 0x0F, 0x03, 0xC0, 0x78,
  0x0E, 0x03, 0x80, 0x70, 0x3C, 0x03, 0xC1, 0xC0, 0x0E, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x00, 0x0E, 0x78, 0x00, 0x7B, 0x80, 0x01, 0xDC, 0x00,
  0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00,
  0x3D, 0xC0, 0x00, 0xF7, 0x87, 0x83, 0x8E, 0x1F, 0x0E, 0x38, 0x7C, 0x38,
  0xE1, 0xB0, 0xE3, 0x8E, 0xE7, 0x8E, 0x33, 0x9E, 0x38, 0xC6, 0x70, 0x77,
  0x19, 0xC1, 0xDC, 0x77, 0x07, 0x61, 0xDC, 0x1F, 0x83, 0x70, 0x7E, 0x0D,
  0xC1, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0xF0, 0x01, 0xCF,
  0x00, 0x78, 0xE0, 0x1E, 0x0E, 0x07, 0x81, 0xE0, 0xE0, 0x1E, 0x3C, 0x01,
  0xCF, 0x00, 0x3D, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x0F, 0x78, 0x03, 0xC7, 0x00, 0x70, 0xF0, 0x1C,
  0x0F, 0x07, 0x80, 0xF0, 0xE0, 0x0E, 0x38, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x00, 0x73, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0x70, 0x01, 0xC3, 0xC0, 0x1E,
  0x0E, 0x00, 0xE0, 0x70, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0x78,
  0x3C, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00,
  0x07, 0x78, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF0, 0x01, 0xF8,
};

const GFXglyph LiberationMono_Regular38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 3, 25, 23, 10, -25 },
  { 11, 13, 12, 23, 5, -28 },
  { 31, 21, 25, 23, 1, -25 },
  { 97, 20, 31, 23, 1, -28 },
  { 175, 23, 25, 23, 0, -25 },
  { 247, 21, 25, 23, 1, -25 },
  { 313, 4, 12, 23, 9, -28 },
  { 319, 11, 36, 23, 6, -28 },
  { 369, 10, 36, 23, 6, -28 },
  { 414, 13, 13, 23, 5, -28 },
  { 436, 19, 19, 23, 2, -22 },
  { 482, 8, 12, 23, 5, -6 },
  { 494, 11, 3, 23, 6, -12 },
  { 499, 5, 6, 23, 9, -6 },
  { 503, 19, 28, 23, 2, -28 },
  { 570, 18, 25, 23, 2, -25 },
  { 627, 18, 25, 23, 3, -25 },
  { 684, 17, 25, 23, 3, -25 },
  { 738, 18, 25, 23, 2, -25 },
  { 795, 19, 25, 23, 2, -25 },
  { 855, 18, 25, 23, 2, -25 },
  { 912, 17, 25, 23, 3, -25 },
  { 966, 17, 25, 23, 3, -25 },
  { 1020, 18, 25, 23, 2, -25 },
  { 1077, 17, 25, 23, 3, -25 },
  { 1131, 5, 21, 23, 9, -21 },
  { 1145, 8, 27, 23, 7, -21 },
  { 1172, 19, 19, 23, 2, -22 },
  { 1218, 19, 13, 23, 2, -19 },
  { 1249, 19, 19, 23, 2, -22 },
  { 1295, 18, 25, 23, 2, -25 },
  { 1352, 21, 33, 23, 1, -28 },
  { 1439, 23, 25, 23, 0, -25 },
  { 1511, 18, 25, 23, 3, -25 },
  { 1568, 19, 25, 23, 2, -25 },
  { 1628, 18, 25, 23, 3, -25 },
  { 1685, 18, 25, 23, 3, -25 },
  { 1742, 16, 25, 23, 4, -25 },
  { 1792, 18, 25, 23, 2, -25 },
  { 1849, 17, 25, 23, 3, -25 },
  { 1903, 15, 25, 23, 4, -25 },
  { 1950, 15, 25, 23, 3, -25 },
  { 1997, 20, 25, 23, 3, -25 },
  { 2060, 16, 25, 23, 4, -25 },
  { 2110, 18, 25, 23, 2, -25 },
  { 2167, 17, 25, 23, 3, -25 },
  { 2221, 19, 25, 23, 2, -25 },
  { 2281, 18, 25, 23, 3, -25 },
  { 2338, 19, 32, 23, 2, -25 },
  { 2414, 19, 25, 23, 3, -25 },
  { 2474, 20, 25, 23, 1, -25 },
  { 2537, 20, 25, 23, 1, -25 },
  { 2600, 17, 25, 23, 3, -25 },
  { 2654, 23, 25, 23, 0, -25 },
  { 2726, 23, 25, 23, 0, -25 },
  { 2798, 21, 25, 23, 1, -25 },
  { 2864, 21, 25, 23, 1, -25 },
  { 2930, 20, 25, 23, 1, -25 },
  { 2993, 10, 36, 23, 8, -28 },
  { 3038, 19, 28, 23, 2, -28 },
  { 3105, 10, 36, 23, 5, -28 },
  { 3150, 18, 17, 23, 2, -25 },
  { 3189, 23, 2, 23, 0, 2 },
  { 3195, 8, 5, 23, 7, -27 },
  { 3200, 20, 21, 23, 2, -21 },
  { 3253, 17, 28, 23, 3, -28 },
  { 3313, 18, 21, 23, 2, -21 },
  { 3361, 16, 28, 23, 3, -28 },
  { 3417, 18, 21, 23, 2, -21 },
  { 3465, 17, 28, 23, 3, -28 },
  { 3525, 17, 29, 23, 3, -21 },
  { 3587, 16, 28, 23, 3, -28 },
  { 3643, 18, 28, 23, 3, -28 },
  { 3706, 14, 36, 23, 2, -28 },
  { 3769, 17, 28, 23, 4, -28 },
  { 3829, 19, 28, 23, 2, -28 },
  { 3896, 19, 21, 23, 2, -21 },
  { 3946, 16, 21, 23, 3, -21 },
  { 3988, 18, 21, 23, 2, -21 },
  { 4036, 17, 29, 23, 3, -21 },
  { 4098, 16, 29, 23, 3, -21 },
  { 4156, 15, 21, 23, 4, -21 },
  { 4196, 17, 21, 23, 3, -21 },
  { 4241, 15, 26, 23, 4, -26 },
  { 4290, 17, 21, 23, 3, -21 },
  { 4335, 21, 21, 23, 1, -21 },
  { 4391, 22, 21, 23, 0, -21 },
  { 4449, 19, 21, 23, 2, -21 },
  { 4499, 21, 29, 23, 1, -21 },
  { 4576, 17, 21, 23, 3, -21 },
  { 4621, 16, 36, 23, 4, -28 },
  { 4693, 3, 36, 23, 10, -28 },
  { 4707, 16, 36, 23, 3, -28 },
  { 4779, 19, 5, 23, 2, -15 },
};

const GFXfont LiberationMono_Regular38pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular38pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular38pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _LIBERATIONMONO_REGULAR38PT7B_H_
