#ifndef _LIBERATIONMONO_REGULAR17PT7B_H_
#define _LIBERATIONMONO_REGULAR17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x3C, 0xCF, 0x3C, 0xD3, 0x4C, 0x08, 0x84, 0x41, 0x11,
  0xFF, 0x11, 0x04, 0x82, 0x23, 0xFE, 0x22, 0x08, 0x84, 0x40, 0x08, 0x3F,
  0x32, 0xD9, 0x2C, 0x82, 0x40, 0xF0, 0x16, 0x09, 0x44, 0xF2, 0xCF, 0xC0,
  0x80, 0x70, 0xA6, 0x68, 0x92, 0x68, 0x74, 0x03, 0x00, 0xB8, 0x49, 0x36,
  0x48, 0x94, 0x38, 0x1E, 0x0C, 0xC2, 0x30, 0xC8, 0x1C, 0x1E, 0x24, 0x9B,
  0x14, 0xC5, 0x11, 0xC3, 0xDC, 0xFF, 0xC0, 0x32, 0x64, 0xCC, 0x88, 0x88,
  0xCC, 0x46, 0x23, 0xC4, 0x63, 0x31, 0x11, 0x11, 0x13, 0x36, 0x4C, 0x12,
  0x55, 0xCC, 0x31, 0xA4, 0x80, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x76, 0x64, 0x48, 0xF0, 0xF0, 0x03, 0x02, 0x06, 0x04, 0x0C,
  0x08, 0x18, 0x10, 0x20, 0x60, 0x40, 0xC0, 0x3C, 0x62, 0xC3, 0xC1, 0xC1,
  0xD9, 0xD9, 0xC3, 0xC3, 0x62, 0x3C, 0x08, 0x38, 0xE8, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0xFF, 0x3C, 0x62, 0xC3, 0x03, 0x02, 0x06, 0x0C,
  0x30, 0x60, 0x40, 0xFF, 0x3C, 0x42, 0xC3, 0x03, 0x06, 0x1C, 0x03, 0x01,
  0xC1, 0x43, 0x3E, 0x06, 0x0E, 0x1E, 0x36, 0x26, 0x46, 0xC6, 0xFF, 0x06,
  0x06, 0x06, 0x7E, 0x40, 0x40, 0x40, 0x5C, 0xE3, 0x03, 0x01, 0xC3, 0x42,
  0x3C, 0x3E, 0x63, 0x40, 0xC0, 0xDE, 0xE3, 0xC3, 0xC1, 0x43, 0x63, 0x3C,
  0xFF, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x30, 0x3C,
  0x42, 0xC3, 0xC3, 0x62, 0x3C, 0x43, 0xC3, 0xC3, 0x43, 0x3C, 0x3C, 0x66,
  0xC3, 0xC3, 0xC3, 0x63, 0x3F, 0x03, 0x02, 0x46, 0x7C, 0xF0, 0x03, 0xC0,
  0x66, 0x00, 0x00, 0x06, 0x64, 0x4C, 0x80, 0x01, 0x06, 0x18, 0x60, 0x80,
  0x60, 0x18, 0x06, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x06, 0x18, 0x60, 0x80, 0x3C, 0xC3, 0x83, 0x03, 0x06, 0x18, 0x10,
  0x00, 0x00, 0x10, 0x10, 0x1F, 0x0C, 0x62, 0x09, 0x35, 0x53, 0x54, 0xDB,
  0x26, 0x89, 0xA2, 0x5D, 0xA5, 0xB9, 0x00, 0x21, 0x87, 0x80, 0x0C, 0x03,
  0x81, 0xA0, 0x48, 0x13, 0x0C, 0x42, 0x11, 0xFE, 0x60, 0x90, 0x3C, 0x0C,
  0xFC, 0x61, 0xB0, 0xD8, 0x6C, 0x27, 0xE3, 0x0D, 0x83, 0xC1, 0xE1, 0xBF,
  0x80, 0x3E, 0x63, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC1, 0x63, 0x3E,
  0xFC, 0xC6, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0xC6, 0xFC, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0x02,
  0x04, 0x08, 0x1F, 0xE0, 0x40, 0x81, 0x02, 0x00, 0x1C, 0x62, 0xC1, 0xC0,
  0xC0, 0xCF, 0xC1, 0xC1, 0xC1, 0x63, 0x3E, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFE, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x63, 0xF8, 0x1E, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x42,
  0xCC, 0xF0, 0xC3, 0x63, 0x31, 0x19, 0x0D, 0x07, 0xC3, 0xB1, 0x8C, 0xC2,
  0x61, 0xB0, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0xF8, 0xC3, 0xE3, 0xA5, 0xA5, 0x95, 0x99, 0x99, 0x81, 0x81, 0x81, 0x81,
  0xC3, 0xE3, 0xE3, 0xD3, 0xD3, 0xCB, 0xCB, 0xCF, 0xC7, 0xC5, 0xC3, 0x3C,
  0x62, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0xC3, 0x62, 0x3C, 0xFE, 0xC3,
  0xC1, 0xC1, 0xC3, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3C, 0x62, 0xC3,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0xC3, 0x62, 0x3C, 0x08, 0x0C, 0x07, 0xFE,
  0x61, 0xB0, 0x58, 0x2C, 0x37, 0xF3, 0x31, 0x8C, 0xC6, 0x61, 0xB0, 0x40,
  0x3E, 0x43, 0xC3, 0xC0, 0x70, 0x3E, 0x03, 0x01, 0x81, 0xC3, 0x7E, 0xFF,
  0x8C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x42, 0x3C, 0xC0,
  0xD0, 0x36, 0x09, 0x86, 0x21, 0x0C, 0xC1, 0x30, 0x48, 0x1E, 0x03, 0x00,
  0xC0, 0xC0, 0x70, 0x3C, 0x0D, 0x33, 0x4C, 0x93, 0x25, 0xA9, 0xCA, 0x72,
  0x8C, 0xE3, 0x18, 0x60, 0x88, 0x63, 0x30, 0x68, 0x0C, 0x03, 0x01, 0xE0,
  0x4C, 0x31, 0x18, 0x64, 0x0C, 0x40, 0xD8, 0x63, 0x10, 0x4C, 0x1E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xFF, 0x01, 0x81, 0x80, 0x80,
  0x80, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x3F, 0xE0, 0xFE, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x18,
  0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x7F, 0x18, 0x1C, 0x24, 0x24, 0x66, 0x42, 0x42, 0xC1,
  0xFF, 0xC0, 0x46, 0x30, 0x7C, 0x23, 0x00, 0x80, 0x47, 0xE6, 0x13, 0x09,
  0x8C, 0x7B, 0x80, 0x40, 0x40, 0x40, 0x5E, 0x62, 0x43, 0x43, 0x43, 0x43,
  0x43, 0x62, 0x5E, 0x3E, 0x63, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x63, 0x3E,
  0x03, 0x03, 0x03, 0x3B, 0x47, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x47, 0x3B,
  0x3C, 0x62, 0xC3, 0xC3, 0xFF, 0xC0, 0xC0, 0x63, 0x3E, 0x1F, 0x10, 0x30,
  0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3B, 0x47, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x47, 0x3B, 0x03, 0x03, 0x62, 0x3C, 0x81, 0x02,
  0x05, 0xEC, 0x50, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x08, 0x08, 0x00,
  0x78, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x0C, 0x30, 0x1F,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xBC, 0x81, 0x02, 0x04,
  0x38, 0xD3, 0x2C, 0x78, 0xD9, 0x12, 0x34, 0x30, 0x78, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0xB7, 0xD9, 0x99, 0x99,
  0x99, 0x99, 0x99, 0x99, 0x99, 0x5E, 0x62, 0x43, 0x43, 0x43, 0x43, 0x43,
  0x43, 0x43, 0x3C, 0x62, 0xC3, 0xC3, 0xC1, 0xC3, 0xC3, 0x62, 0x3C, 0x5E,
  0x62, 0x43, 0x43, 0x43, 0x43, 0x43, 0x62, 0x5E, 0x40, 0x40, 0x40, 0x40,
  0x3B, 0x47, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x47, 0x3B, 0x03, 0x03, 0x03,
  0x03, 0xDF, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x3E, 0x42, 0x40,
  0x60, 0x3E, 0x03, 0x03, 0xC3, 0x7E, 0x41, 0x0F, 0xD0, 0x41, 0x04, 0x10,
  0x41, 0x83, 0xC0, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0xF6, 0x81,
  0x61, 0x90, 0xCC, 0x46, 0x61, 0x20, 0xF0, 0x38, 0x18, 0x00, 0xC0, 0xF0,
  0x34, 0x0D, 0x32, 0x4C, 0x96, 0xA7, 0x29, 0xCE, 0x31, 0x80, 0xC3, 0x66,
  0x24, 0x1C, 0x18, 0x3C, 0x26, 0x42, 0xC3, 0x81, 0x60, 0x90, 0xC8, 0x46,
  0x61, 0x20, 0xD0, 0x38, 0x18, 0x0C, 0x04, 0x06, 0x0E, 0x00, 0x7F, 0x06,
  0x04, 0x0C, 0x18, 0x30, 0x60, 0x40, 0xFF, 0x1E, 0x60, 0xC1, 0x83, 0x06,
  0x08, 0x60, 0x60, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x30, 0x20, 0x40, 0x81, 0x03, 0x03, 0x0C, 0x10, 0x20, 0x40,
  0x81, 0x06, 0x78, 0xF0, 0x0F,
};

const GFXglyph LiberationMono_Regular17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 11, 10, 4, -11 },
  { 4, 6, 5, 10, 2, -12 },
  { 8, 10, 11, 10, 0, -11 },
  { 22, 9, 13, 10, 1, -12 },
  { 37, 10, 11, 10, 0, -11 },
  { 51, 10, 11, 10, 0, -11 },
  { 65, 2, 5, 10, 4, -12 },
  { 67, 4, 16, 10, 3, -12 },
  { 75, 4, 16, 10, 3, -12 },
  { 83, 6, 7, 10, 2, -12 },
  { 89, 8, 9, 10, 1, -10 },
  { 98, 4, 6, 10, 2, -2 },
  { 101, 4, 1, 10, 3, -5 },
  { 102, 2, 2, 10, 4, -2 },
  { 103, 8, 12, 10, 1, -12 },
  { 115, 8, 11, 10, 1, -11 },
  { 126, 8, 11, 10, 1, -11 },
  { 137, 8, 11, 10, 1, -11 },
  { 148, 8, 11, 10, 1, -11 },
  { 159, 8, 11, 10, 1, -11 },
  { 170, 8, 11, 10, 1, -11 },
  { 181, 8, 11, 10, 1, -11 },
  { 192, 8, 11, 10, 1, -11 },
  { 203, 8, 11, 10, 1, -11 },
  { 214, 8, 11, 10, 1, -11 },
  { 225, 2, 9, 10, 4, -9 },
  { 228, 4, 13, 10, 3, -9 },
  { 235, 8, 9, 10, 1, -10 },
  { 244, 8, 4, 10, 1, -7 },
  { 248, 8, 9, 10, 1, -10 },
  { 257, 8, 11, 10, 1, -11 },
  { 268, 10, 14, 10, 0, -12 },
  { 286, 10, 11, 10, 0, -11 },
  { 300, 9, 11, 10, 1, -11 },
  { 313, 8, 11, 10, 1, -11 },
  { 324, 8, 11, 10, 1, -11 },
  { 335, 8, 11, 10, 1, -11 },
  { 346, 7, 11, 10, 2, -11 },
  { 356, 8, 11, 10, 1, -11 },
  { 367, 8, 11, 10, 1, -11 },
  { 378, 7, 11, 10, 2, -11 },
  { 388, 7, 11, 10, 1, -11 },
  { 398, 9, 11, 10, 1, -11 },
  { 411, 7, 11, 10, 2, -11 },
  { 421, 8, 11, 10, 1, -11 },
  { 432, 8, 11, 10, 1, -11 },
  { 443, 8, 11, 10, 1, -11 },
  { 454, 8, 11, 10, 1, -11 },
  { 465, 8, 14, 10, 1, -11 },
  { 479, 9, 11, 10, 1, -11 },
  { 492, 8, 11, 10, 1, -11 },
  { 503, 9, 11, 10, 1, -11 },
  { 516, 8, 11, 10, 1, -11 },
  { 527, 10, 11, 10, 0, -11 },
  { 541, 10, 11, 10, 0, -11 },
  { 555, 10, 11, 10, 0, -11 },
  { 569, 10, 11, 10, 0, -11 },
  { 583, 9, 11, 10, 1, -11 },
  { 596, 5, 16, 10, 3, -12 },
  { 606, 8, 12, 10, 1, -12 },
  { 618, 5, 16, 10, 2, -12 },
  { 628, 8, 8, 10, 1, -11 },
  { 636, 10, 1, 10, 0, 1 },
  { 638, 4, 3, 10, 3, -13 },
  { 640, 9, 9, 10, 1, -9 },
  { 651, 8, 12, 10, 1, -12 },
  { 663, 8, 9, 10, 1, -9 },
  { 672, 8, 12, 10, 1, -12 },
  { 684, 8, 9, 10, 1, -9 },
  { 693, 8, 12, 10, 1, -12 },
  { 705, 8, 13, 10, 1, -9 },
  { 718, 7, 12, 10, 2, -12 },
  { 729, 8, 12, 10, 1, -12 },
  { 741, 6, 16, 10, 1, -12 },
  { 753, 7, 12, 10, 2, -12 },
  { 764, 8, 12, 10, 1, -12 },
  { 776, 8, 9, 10, 1, -9 },
  { 785, 8, 9, 10, 1, -9 },
  { 794, 8, 9, 10, 1, -9 },
  { 803, 8, 13, 10, 1, -9 },
  { 816, 8, 13, 10, 1, -9 },
  { 829, 7, 9, 10, 2, -9 },
  { 837, 8, 9, 10, 1, -9 },
  { 846, 6, 11, 10, 2, -11 },
  { 855, 7, 9, 10, 2, -9 },
  { 863, 9, 9, 10, 1, -9 },
  { 874, 10, 9, 10, 0, -9 },
  { 886, 8, 9, 10, 1, -9 },
  { 895, 9, 13, 10, 1, -9 },
  { 910, 8, 9, 10, 1, -9 },
  { 919, 7, 16, 10, 2, -12 },
  { 933, 2, 16, 10, 4, -12 },
  { 937, 7, 16, 10, 1, -12 },
  { 951, 8, 2, 10, 1, -7 },
};

const GFXfont LiberationMono_Regular17pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular17pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular17pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _LIBERATIONMONO_REGULAR17PT7B_H_
