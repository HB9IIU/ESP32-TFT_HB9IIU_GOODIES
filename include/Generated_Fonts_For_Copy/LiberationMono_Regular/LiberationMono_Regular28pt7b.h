#ifndef _LIBERATIONMONO_REGULAR28PT7B_H_
#define _LIBERATIONMONO_REGULAR28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x07, 0xFC, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0x00, 0x06, 0x08, 0x08, 0x30, 0x10,
  0x60, 0x60, 0x80, 0xC1, 0x1F, 0xFF, 0xFF, 0xFF, 0x84, 0x18, 0x18, 0x20,
  0x30, 0x40, 0x41, 0x87, 0xFF, 0xEF, 0xFF, 0xC6, 0x08, 0x0C, 0x10, 0x10,
  0x60, 0x20, 0xC0, 0xC1, 0x00, 0x01, 0x00, 0x02, 0x00, 0x3F, 0x81, 0xFF,
  0xC7, 0x13, 0x8C, 0x23, 0x98, 0x43, 0x30, 0x80, 0x79, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0B, 0xE0, 0x11, 0xC0, 0x21, 0xC0, 0x43, 0xE0, 0x87, 0xE1,
  0x0C, 0xE2, 0x38, 0xFF, 0xE0, 0x7F, 0x00, 0x10, 0x00, 0x20, 0x00, 0x3C,
  0x06, 0x3F, 0x03, 0x39, 0xC3, 0x18, 0x63, 0x0C, 0x31, 0x86, 0x19, 0x83,
  0x9D, 0x80, 0xFD, 0x80, 0x3C, 0xC0, 0x00, 0xCF, 0x00, 0xCF, 0xC0, 0x6E,
  0x70, 0x66, 0x18, 0x63, 0x0C, 0x31, 0x86, 0x30, 0xE7, 0x30, 0x3F, 0x30,
  0x0F, 0x00, 0x07, 0xC0, 0x3F, 0xC0, 0x61, 0xC0, 0xC1, 0x81, 0x87, 0x03,
  0x1C, 0x06, 0xF0, 0x0F, 0x80, 0x3C, 0x08, 0xEC, 0x33, 0x9C, 0x66, 0x18,
  0xCC, 0x1B, 0x18, 0x3E, 0x30, 0x3C, 0x70, 0x7C, 0x7F, 0xFE, 0x7E, 0x1C,
  0xFF, 0xFF, 0xFE, 0xC0, 0x0E, 0x38, 0x61, 0xC3, 0x0E, 0x18, 0x70, 0xE1,
  0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE1, 0xC3, 0x83, 0x07, 0x06, 0x0E,
  0x0C, 0x1C, 0x1C, 0xE0, 0xC1, 0xC1, 0xC1, 0x83, 0x87, 0x06, 0x0E, 0x1C,
  0x38, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x0E, 0x38,
  0x61, 0xC0, 0x04, 0x01, 0x00, 0x41, 0x93, 0xFF, 0xC3, 0x81, 0xE0, 0x6C,
  0x31, 0x8C, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x03, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x3B, 0xDC, 0xE6, 0x73, 0x18, 0x80, 0xFF, 0xFC, 0xFF, 0xF0,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x00, 0x0F, 0x81, 0xFF,
  0x1C, 0x3C, 0xC0, 0x6E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0xE3, 0xC7, 0x1E,
  0x38, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x19, 0x81, 0xCE, 0x1E, 0x3F,
  0xE0, 0x7C, 0x00, 0x03, 0x80, 0x3C, 0x07, 0xE1, 0xF7, 0x0E, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x81, 0xFF,
  0x1C, 0x1D, 0xC0, 0x6E, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0x1C, 0x1D, 0xC0, 0x6E, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x1C, 0x0F, 0xC0, 0x7F, 0x00, 0x3C, 0x00, 0x70, 0x03,
  0xE0, 0x1F, 0x80, 0xEE, 0x0E, 0x7F, 0xF0, 0xFE, 0x00, 0x00, 0x70, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0x70, 0x19, 0xC0, 0xE7, 0x03, 0x1C, 0x18,
  0x70, 0xC1, 0xC7, 0x07, 0x18, 0x1C, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x7F, 0xF3, 0xFF, 0x98, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0xBF, 0x1F, 0xFC, 0xF0, 0xF0, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xE0, 0x1F, 0x80, 0xCE, 0x1E, 0x7F, 0xE0, 0xFC, 0x00, 0x0F,
  0xC0, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x00, 0x70, 0x03, 0x9F, 0x1F, 0xFC,
  0xF8, 0x77, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xB0, 0x1D, 0xC0, 0xC7,
  0x0E, 0x3F, 0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x1F,
  0x81, 0xFF, 0x1C, 0x1D, 0xC0, 0x6E, 0x03, 0x70, 0x19, 0x80, 0xCE, 0x0E,
  0x3F, 0xC1, 0xFF, 0x1C, 0x1D, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFE,
  0x0E, 0x7F, 0xE0, 0xFE, 0x00, 0x1F, 0x81, 0xFF, 0x1C, 0x39, 0xC0, 0xEE,
  0x03, 0x60, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3B, 0x87, 0xCF, 0xFE, 0x3E,
  0x70, 0x03, 0x00, 0x1B, 0x81, 0xCE, 0x1C, 0x7F, 0xC0, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x38, 0xE3, 0x8E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x39, 0xE7, 0x1C, 0x63, 0x8C, 0x30, 0x00, 0x08, 0x01, 0xC0,
  0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x03, 0x80, 0x1C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0x00, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x0E, 0x00, 0x40, 0x00, 0x0F, 0xC0, 0xFF, 0xC3, 0x83,
  0x9C, 0x07, 0x60, 0x1F, 0x80, 0x70, 0x01, 0x80, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0x70, 0xE1, 0xC0, 0x67, 0x00,
  0xCC, 0x72, 0xD1, 0x95, 0xE6, 0x3B, 0xC8, 0x33, 0xB0, 0x66, 0x61, 0x8C,
  0xC3, 0x19, 0x86, 0x73, 0x0C, 0xE6, 0x19, 0xCC, 0x72, 0xD9, 0x6D, 0x9C,
  0x73, 0x00, 0x03, 0x00, 0x07, 0x00, 0x87, 0x07, 0x07, 0xFC, 0x03, 0xE0,
  0x01, 0xC0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x77, 0x00, 0x31,
  0x80, 0x38, 0xC0, 0x1C, 0x70, 0x0C, 0x18, 0x0E, 0x0E, 0x06, 0x07, 0x07,
  0xFF, 0x83, 0xFF, 0xE1, 0x80, 0x71, 0xC0, 0x18, 0xE0, 0x0E, 0x60, 0x03,
  0x70, 0x01, 0xC0, 0xFF, 0xC3, 0xFF, 0x8E, 0x07, 0x38, 0x0E, 0xE0, 0x3B,
  0x80, 0xEE, 0x03, 0x38, 0x3C, 0xFF, 0xC3, 0xFF, 0x8E, 0x07, 0xB8, 0x06,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x1E, 0xFF, 0xF3, 0xFF, 0x00, 0x0F,
  0xC0, 0xFF, 0x87, 0x87, 0x1C, 0x0E, 0xE0, 0x13, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x67,
  0x03, 0x9E, 0x1E, 0x3F, 0xF0, 0x3F, 0x00, 0xFF, 0x07, 0xFE, 0x38, 0x39,
  0xC0, 0xEE, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xDC, 0x1C, 0xFF, 0xC7, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xFF, 0xF7, 0xFF, 0xB8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0xC1,
  0xFF, 0x1E, 0x1C, 0xE0, 0x7E, 0x01, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x1F, 0xF0, 0xFF, 0x80, 0x3E, 0x01, 0xF0, 0x0D, 0xC0, 0x6F, 0x07,
  0x3F, 0xF0, 0x7E, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xC0, 0xFF, 0xFF,
  0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFC, 0x07,
  0xE0, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0xC0, 0xD8, 0x3B, 0x87, 0x3F, 0xC3, 0xF0,
  0xE0, 0x39, 0xC0, 0xE3, 0x83, 0x87, 0x07, 0x0E, 0x1C, 0x1C, 0x70, 0x39,
  0xC0, 0x77, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xCE, 0x07, 0x0E, 0x0E, 0x1E,
  0x1C, 0x1C, 0x38, 0x1C, 0x70, 0x1C, 0xE0, 0x1D, 0xC0, 0x38, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFD, 0x8D, 0xEC, 0x6F, 0x77,
  0x79, 0xB3, 0xCD, 0x9E, 0x78, 0xF1, 0xC7, 0x8E, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xC0, 0xE0, 0x3F, 0x81, 0xFC, 0x0F,
  0xB0, 0x7D, 0x83, 0xF6, 0x1F, 0xB0, 0xFD, 0xC7, 0xE6, 0x3F, 0x39, 0xF8,
  0xCF, 0xC7, 0x7E, 0x1B, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x03,
  0xC0, 0x07, 0xC0, 0x7F, 0xC3, 0x87, 0x9C, 0x0E, 0x70, 0x1D, 0x80, 0x76,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xD8, 0x07, 0x70, 0x1D,
  0xC0, 0x77, 0x03, 0x8E, 0x1E, 0x1F, 0xF0, 0x1F, 0x00, 0xFF, 0xC7, 0xFF,
  0xB8, 0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x77,
  0xFF, 0x3F, 0xF1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xE1, 0xE3, 0x81, 0xC7, 0x01,
  0xCC, 0x03, 0x98, 0x07, 0x70, 0x06, 0xE0, 0x0D, 0xC0, 0x1B, 0x80, 0x33,
  0x00, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x1C, 0x3C, 0x1F, 0xF0, 0x1F,
  0x80, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0xFF,
  0xC3, 0xFF, 0xCE, 0x07, 0xB8, 0x0E, 0xE0, 0x1B, 0x80, 0x6E, 0x03, 0xB8,
  0x1E, 0xFF, 0xF3, 0xFF, 0x0E, 0x38, 0x38, 0x70, 0xE0, 0xC3, 0x83, 0x8E,
  0x07, 0x38, 0x0C, 0xE0, 0x3B, 0x80, 0x70, 0x0F, 0xE0, 0xFF, 0xC7, 0x83,
  0x9C, 0x07, 0x70, 0x1D, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0xE0, 0x0F,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x80, 0x3E, 0x01, 0xDE, 0x0F, 0x3F,
  0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xCE, 0x0E, 0x7F, 0xE0, 0xFC, 0x00, 0xE0, 0x03, 0x30, 0x03, 0x9C,
  0x01, 0xCE, 0x00, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0x60, 0x30, 0x38, 0x38,
  0x1C, 0x18, 0x06, 0x1C, 0x03, 0x8E, 0x00, 0xC6, 0x00, 0x67, 0x00, 0x3B,
  0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x39, 0x87,
  0x1C, 0xE3, 0x8E, 0x73, 0xC6, 0x19, 0xB3, 0x0C, 0xD9, 0x86, 0x6C, 0xC3,
  0x66, 0x61, 0xB1, 0xB0, 0xD8, 0xF0, 0x78, 0x78, 0x1C, 0x1C, 0x0E, 0x0E,
  0x00, 0x70, 0x06, 0x38, 0x0E, 0x1C, 0x1C, 0x1C, 0x18, 0x0E, 0x38, 0x06,
  0x70, 0x03, 0x60, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07,
  0x70, 0x0E, 0x30, 0x0C, 0x18, 0x1C, 0x1C, 0x38, 0x0E, 0x30, 0x0E, 0x70,
  0x07, 0x70, 0x07, 0x70, 0x06, 0x38, 0x0E, 0x1C, 0x1C, 0x1C, 0x18, 0x0E,
  0x38, 0x07, 0x70, 0x07, 0x60, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFC, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0xFF, 0xFC, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0xFF, 0xFC, 0x07, 0x00, 0x78, 0x03, 0x60, 0x33,
  0x01, 0x8C, 0x0C, 0x60, 0xC1, 0x86, 0x0C, 0x60, 0x63, 0x01, 0xB8, 0x0D,
  0x80, 0x30, 0xFF, 0xFF, 0x80, 0x70, 0xE0, 0xC0, 0x1F, 0x81, 0xFF, 0x87,
  0x0E, 0x38, 0x1C, 0x00, 0x70, 0x01, 0xC1, 0xFF, 0x1F, 0xFC, 0xF0, 0x73,
  0x81, 0xCC, 0x07, 0x30, 0x3C, 0xE1, 0xF1, 0xFC, 0xF3, 0xE3, 0xC0, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x33, 0xE1, 0xBF, 0x8F, 0x0E,
  0x70, 0x33, 0x01, 0xD8, 0x0E, 0xC0, 0x76, 0x03, 0xB0, 0x1D, 0x80, 0xEC,
  0x07, 0x70, 0x33, 0xC3, 0xBB, 0xF9, 0xCF, 0x80, 0x0F, 0xC1, 0xFF, 0x1C,
  0x1C, 0xC0, 0x7E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x77, 0x07, 0x1F, 0xF0, 0x3F, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x31, 0xF3, 0x3F, 0xB7, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x77, 0x0F,
  0x7F, 0xB1, 0xF3, 0x0F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x6E, 0x03, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x67, 0x87,
  0x1F, 0xF0, 0x3E, 0x00, 0x03, 0xF8, 0x7F, 0xC3, 0x80, 0x18, 0x01, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE3, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0x1F, 0x33, 0xFB, 0x70, 0xFE, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0x70, 0xF7, 0xFB, 0x1F, 0x30,
  0x03, 0x00, 0x37, 0x07, 0x78, 0xF3, 0xFE, 0x1F, 0x80, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x9F, 0x37, 0xF7, 0x87, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x30, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0x80,
  0xC0, 0x60, 0x00, 0x03, 0xFD, 0xFE, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E,
  0x0F, 0xFF, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x07, 0xE0, 0xEE, 0x1C, 0xE3, 0x8E, 0x70, 0xEE, 0x0F, 0xC0, 0xFE, 0x0F,
  0x70, 0xE3, 0x0E, 0x38, 0xE1, 0xCE, 0x0E, 0xE0, 0xEE, 0x07, 0x3F, 0x01,
  0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x3F, 0xFF, 0xFF, 0xF0, 0xCE, 0x3B, 0x7D, 0xFD, 0x38,
  0xF8, 0xE3, 0xE3, 0x8F, 0x8E, 0x3E, 0x38, 0xF8, 0xE3, 0xE3, 0x8F, 0x8E,
  0x3E, 0x38, 0xF8, 0xE3, 0xE3, 0x8F, 0x8E, 0x3E, 0x38, 0xC0, 0xE7, 0xCE,
  0xFE, 0x78, 0x77, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36,
  0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x30, 0x0F, 0x81, 0xFF,
  0x1C, 0x1D, 0xC0, 0x6E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xE7, 0x0F, 0x1F, 0xF0, 0x7E, 0x00, 0xE7, 0xC7,
  0x7F, 0x1E, 0x1C, 0xE0, 0x66, 0x03, 0xB0, 0x1D, 0x80, 0xEC, 0x07, 0x60,
  0x3B, 0x01, 0xD8, 0x0E, 0xE0, 0x67, 0x87, 0x37, 0xF1, 0x9F, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x1F, 0x33, 0xFB,
  0x70, 0xFE, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x7E, 0x07, 0x70, 0xF7, 0xFB, 0x1F, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0xE3, 0xEC, 0xFD, 0xB0, 0x3C, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x00, 0x1F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x66, 0x00, 0x38, 0x00,
  0xFC, 0x03, 0xFC, 0x01, 0xF0, 0x03, 0x80, 0x0D, 0xC0, 0x67, 0x07, 0x3F,
  0xF0, 0x7F, 0x00, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x0F, 0xFD, 0xFF, 0x8C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x38, 0x07, 0xFC, 0x3F, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7E, 0x1F,
  0xFE, 0xCF, 0x98, 0xE0, 0x0E, 0xC0, 0x19, 0xC0, 0x73, 0x80, 0xC3, 0x03,
  0x87, 0x07, 0x0E, 0x0C, 0x0E, 0x38, 0x1C, 0x60, 0x19, 0xC0, 0x3B, 0x80,
  0x76, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x30, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0x66, 0x1C, 0x73, 0x8E, 0x39, 0xCD, 0x18, 0x66,
  0xCC, 0x33, 0x66, 0x1B, 0x13, 0x0D, 0x8F, 0x86, 0xC7, 0xC3, 0x43, 0xC0,
  0xE0, 0xE0, 0x70, 0x70, 0x70, 0x1C, 0xC0, 0xE3, 0x83, 0x07, 0x1C, 0x0C,
  0xE0, 0x1B, 0x00, 0x78, 0x00, 0xE0, 0x07, 0xC0, 0x3B, 0x00, 0xC6, 0x06,
  0x1C, 0x38, 0x39, 0xC0, 0x66, 0x01, 0xC0, 0xE0, 0x0E, 0xC0, 0x19, 0xC0,
  0x73, 0x80, 0xC3, 0x01, 0x87, 0x07, 0x06, 0x0C, 0x0E, 0x38, 0x0C, 0x60,
  0x18, 0xC0, 0x3B, 0x80, 0x36, 0x00, 0x6C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xF0, 0x7F, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x0F, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0x03, 0xC0,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0xFE, 0x0F, 0xC0, 0x3E, 0x03, 0xFE, 0x1C, 0x3F, 0xE0, 0x3E,
};

const GFXglyph LiberationMono_Regular28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 3, 18, 17, 7, -18 },
  { 8, 9, 9, 17, 4, -20 },
  { 19, 15, 18, 17, 1, -18 },
  { 53, 15, 22, 17, 1, -20 },
  { 95, 17, 18, 17, 0, -18 },
  { 134, 15, 18, 17, 1, -18 },
  { 168, 3, 9, 17, 7, -20 },
  { 172, 7, 26, 17, 5, -20 },
  { 195, 7, 26, 17, 5, -20 },
  { 218, 10, 10, 17, 3, -20 },
  { 231, 13, 14, 17, 2, -16 },
  { 254, 5, 9, 17, 4, -4 },
  { 260, 7, 2, 17, 5, -9 },
  { 262, 3, 4, 17, 7, -4 },
  { 264, 13, 20, 17, 2, -20 },
  { 297, 13, 18, 17, 2, -18 },
  { 327, 13, 18, 17, 2, -18 },
  { 357, 13, 18, 17, 2, -18 },
  { 387, 13, 18, 17, 2, -18 },
  { 417, 14, 18, 17, 1, -18 },
  { 449, 13, 18, 17, 2, -18 },
  { 479, 13, 18, 17, 2, -18 },
  { 509, 13, 18, 17, 2, -18 },
  { 539, 13, 18, 17, 2, -18 },
  { 569, 13, 18, 17, 2, -18 },
  { 599, 3, 15, 17, 7, -15 },
  { 605, 6, 20, 17, 5, -15 },
  { 620, 13, 14, 17, 2, -16 },
  { 643, 13, 8, 17, 2, -13 },
  { 656, 13, 14, 17, 2, -16 },
  { 679, 14, 18, 17, 1, -18 },
  { 711, 15, 24, 17, 1, -20 },
  { 756, 17, 18, 17, 0, -18 },
  { 795, 14, 18, 17, 2, -18 },
  { 827, 14, 18, 17, 2, -18 },
  { 859, 13, 18, 17, 2, -18 },
  { 889, 13, 18, 17, 2, -18 },
  { 919, 12, 18, 17, 3, -18 },
  { 946, 13, 18, 17, 2, -18 },
  { 976, 13, 18, 17, 2, -18 },
  { 1006, 11, 18, 17, 3, -18 },
  { 1031, 11, 18, 17, 2, -18 },
  { 1056, 15, 18, 17, 2, -18 },
  { 1090, 12, 18, 17, 3, -18 },
  { 1117, 13, 18, 17, 2, -18 },
  { 1147, 13, 18, 17, 2, -18 },
  { 1177, 14, 18, 17, 1, -18 },
  { 1209, 13, 18, 17, 2, -18 },
  { 1239, 15, 23, 17, 1, -18 },
  { 1283, 14, 18, 17, 2, -18 },
  { 1315, 14, 18, 17, 1, -18 },
  { 1347, 15, 18, 17, 1, -18 },
  { 1381, 13, 18, 17, 2, -18 },
  { 1411, 17, 18, 17, 0, -18 },
  { 1450, 17, 18, 17, 0, -18 },
  { 1489, 16, 18, 17, 0, -18 },
  { 1525, 16, 18, 17, 0, -18 },
  { 1561, 15, 18, 17, 1, -18 },
  { 1595, 7, 26, 17, 6, -20 },
  { 1618, 13, 20, 17, 2, -20 },
  { 1651, 7, 26, 17, 4, -20 },
  { 1674, 13, 12, 17, 2, -18 },
  { 1694, 17, 1, 17, 0, 2 },
  { 1697, 6, 3, 17, 5, -19 },
  { 1700, 14, 15, 17, 2, -15 },
  { 1727, 13, 20, 17, 2, -20 },
  { 1760, 13, 15, 17, 2, -15 },
  { 1785, 12, 20, 17, 2, -20 },
  { 1815, 13, 15, 17, 2, -15 },
  { 1840, 13, 20, 17, 2, -20 },
  { 1873, 12, 21, 17, 2, -15 },
  { 1905, 11, 20, 17, 3, -20 },
  { 1933, 13, 20, 17, 2, -20 },
  { 1966, 9, 26, 17, 2, -20 },
  { 1996, 12, 20, 17, 3, -20 },
  { 2026, 13, 20, 17, 2, -20 },
  { 2059, 14, 15, 17, 1, -15 },
  { 2086, 12, 15, 17, 2, -15 },
  { 2109, 13, 15, 17, 2, -15 },
  { 2134, 13, 21, 17, 2, -15 },
  { 2169, 12, 21, 17, 2, -15 },
  { 2201, 11, 15, 17, 3, -15 },
  { 2222, 13, 15, 17, 2, -15 },
  { 2247, 11, 19, 17, 3, -19 },
  { 2274, 11, 15, 17, 3, -15 },
  { 2295, 15, 15, 17, 1, -15 },
  { 2324, 17, 15, 17, 0, -15 },
  { 2356, 14, 15, 17, 1, -15 },
  { 2383, 15, 21, 17, 1, -15 },
  { 2423, 13, 15, 17, 2, -15 },
  { 2448, 12, 26, 17, 3, -20 },
  { 2487, 3, 26, 17, 7, -20 },
  { 2497, 12, 26, 17, 2, -20 },
  { 2536, 14, 4, 17, 1, -12 },
};

const GFXfont LiberationMono_Regular28pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular28pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular28pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _LIBERATIONMONO_REGULAR28PT7B_H_
