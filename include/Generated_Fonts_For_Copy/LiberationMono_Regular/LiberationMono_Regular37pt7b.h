#ifndef _LIBERATIONMONO_REGULAR37PT7B_H_
#define _LIBERATIONMONO_REGULAR37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Regular.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Regular37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x76, 0x60, 0x00, 0xFF,
  0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x07, 0x70, 0x76, 0x07, 0x60, 0x76, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x18,
  0x01, 0x81, 0x80, 0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x18, 0x03, 0x03,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x60, 0x30, 0x06, 0x07, 0x00, 0x60,
  0x60, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE1, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x18, 0x01,
  0x81, 0x80, 0x30, 0x18, 0x03, 0x01, 0x80, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x83, 0xFF, 0xFC, 0x3C, 0x63,
  0xC7, 0x86, 0x1E, 0x78, 0x60, 0xE7, 0x06, 0x00, 0x78, 0x60, 0x03, 0x86,
  0x00, 0x3E, 0x60, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x6F, 0xC0, 0x06, 0x1E, 0x00, 0x60, 0xF0, 0x06, 0x07, 0x60, 0x60, 0x7F,
  0x06, 0x0F, 0x78, 0x60, 0xE7, 0xC6, 0x3E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x1F, 0x00,
  0x39, 0xFE, 0x01, 0xC7, 0x1C, 0x0E, 0x38, 0x70, 0x30, 0xE0, 0xC1, 0xC3,
  0x83, 0x0E, 0x0E, 0x0C, 0x30, 0x38, 0x31, 0xC0, 0xE1, 0xCE, 0x01, 0xC7,
  0x30, 0x07, 0xF9, 0xC0, 0x07, 0xCE, 0x00, 0x00, 0x73, 0xF0, 0x01, 0x9F,
  0xE0, 0x0E, 0xE1, 0xC0, 0x73, 0x87, 0x01, 0x8E, 0x1C, 0x0E, 0x38, 0x30,
  0x70, 0xE0, 0xC1, 0x83, 0x87, 0x0C, 0x0E, 0x1C, 0x70, 0x1C, 0x73, 0x80,
  0x7F, 0x8C, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0xF0, 0xF0, 0x0E, 0x07, 0x00, 0xC0, 0x70, 0x0C, 0x06, 0x00, 0xE1, 0xC0,
  0x0E, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x83, 0xF8, 0x1C, 0x7B, 0xC1,
  0xC7, 0x1C, 0x1C, 0xE0, 0xE1, 0x8E, 0x0F, 0x38, 0xE0, 0x7B, 0x8E, 0x03,
  0xF0, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0xF8, 0x3F, 0xC7, 0xFF, 0xFF, 0x3F,
  0xF1, 0xF0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x66, 0x03, 0xC0,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E,
  0x03, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1E,
  0x0F, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x10, 0xC2, 0x73, 0x39, 0xFF,
  0xF0, 0xFE, 0x01, 0xE0, 0x07, 0xC0, 0x33, 0x01, 0xCE, 0x0E, 0x1C, 0x18,
  0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1E, 0x3E, 0x3C, 0x3C,
  0x38, 0x78, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8,
  0x3C, 0x38, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x1E, 0x1F, 0xC7, 0x87, 0xF1, 0xE1, 0xFC, 0x78, 0x7F,
  0x1E, 0x3F, 0xC0, 0x0F, 0x70, 0x03, 0xDC, 0x00, 0xE7, 0x80, 0x78, 0xE0,
  0x1E, 0x3E, 0x1F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0xEE, 0x07, 0xC7, 0x03, 0x83,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xEF, 0x00, 0xF7,
  0x80, 0x3B, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8,
  0x3E, 0x78, 0x07, 0x9C, 0x00, 0xE7, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x3D, 0xE0,
  0x0E, 0x7C, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x73, 0x80,
  0x1C, 0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0x83, 0x80, 0xE0, 0xE0, 0x70,
  0x38, 0x38, 0x0E, 0x0C, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x38, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x73, 0xF8,
  0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x39, 0xC0,
  0x1E, 0x7C, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0x83, 0xC7, 0x80, 0xF3, 0x80, 0x39, 0xC0,
  0x01, 0xC0, 0x00, 0xE3, 0xF0, 0x77, 0xFE, 0x3B, 0xFF, 0x9F, 0x83, 0xEF,
  0x00, 0xF7, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03,
  0xDC, 0x01, 0xCF, 0x01, 0xE3, 0xC1, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xF0, 0x3C, 0x78, 0x07,
  0x9E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x07, 0x8F, 0x03, 0xC1,
  0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFE, 0x0F, 0x03, 0xC7, 0x80, 0x39, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x3D, 0xE0, 0x0E, 0x7C, 0x0F,
  0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x1F, 0xFC, 0x1F,
  0xFF, 0x0F, 0x07, 0xCF, 0x00, 0xE7, 0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0E,
  0xE0, 0x07, 0x70, 0x03, 0xFC, 0x03, 0xEF, 0x07, 0xF7, 0xFF, 0xF9, 0xFF,
  0xBC, 0x3F, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0xB8, 0x03, 0x9E,
  0x03, 0xC7, 0x83, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0x60, 0xE0, 0x00,
  0x00, 0x40, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C,
  0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x3C,
  0x00, 0x08, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0x81,
  0xF7, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xF0,
  0x07, 0x87, 0x80, 0xE0, 0x1C, 0x1C, 0x00, 0xE3, 0x80, 0x06, 0x30, 0x00,
  0x67, 0x07, 0x1F, 0x71, 0xFB, 0x36, 0x38, 0xF3, 0x63, 0x07, 0x3E, 0x70,
  0x73, 0xC6, 0x07, 0x3C, 0x60, 0x63, 0xCE, 0x06, 0x3C, 0xE0, 0x63, 0xCE,
  0x06, 0x3C, 0xC0, 0xE3, 0xCC, 0x0E, 0x3C, 0xC0, 0xC3, 0xCE, 0x1C, 0x6C,
  0xE1, 0xC6, 0xE6, 0x3C, 0xEE, 0x7E, 0x7C, 0x63, 0xC7, 0x87, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x08, 0x1C, 0x01, 0xC0, 0xE0, 0x78, 0x07, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xF0, 0x00, 0xF1,
  0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1E, 0x00, 0x78, 0x38, 0x01, 0xC0, 0xE0,
  0x0F, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x1C, 0x78, 0x00,
  0x79, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0x80, 0x7C, 0xE0, 0x0F, 0x38, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x07, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0,
  0xFF, 0xFE, 0x38, 0x03, 0xCE, 0x00, 0x7B, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1E, 0xE0, 0x0F, 0xBF, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07,
  0xC7, 0xC0, 0x7C, 0xF0, 0x07, 0x9C, 0x00, 0x47, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x8F, 0x00, 0x39, 0xE0, 0x0F,
  0x1E, 0x01, 0xC3, 0xE0, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0,
  0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1C, 0x0F, 0xCE, 0x01, 0xF7, 0x00,
  0x7B, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xB8, 0x03, 0xDC, 0x03, 0xCE, 0x07, 0xE7, 0xFF, 0xE3, 0xFF,
  0xE1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x7C, 0x07, 0x9E, 0x00, 0xF7, 0x00,
  0x13, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0x70, 0x01, 0xDE,
  0x00, 0x77, 0x80, 0x1C, 0xF0, 0x07, 0x3E, 0x07, 0xC7, 0xFF, 0xE0, 0xFF,
  0xF0, 0x0F, 0xE0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B,
  0xC0, 0xE7, 0xC3, 0xC7, 0xFF, 0x07, 0xFC, 0x03, 0xF0, 0xE0, 0x07, 0x9C,
  0x01, 0xE3, 0x80, 0x3C, 0x70, 0x0F, 0x0E, 0x03, 0xC1, 0xC0, 0xF0, 0x38,
  0x3C, 0x07, 0x0F, 0x00, 0xE3, 0xC0, 0x1C, 0xF0, 0x03, 0x9E, 0x00, 0x77,
  0xE0, 0x0F, 0xFC, 0x01, 0xFB, 0xC0, 0x3E, 0x3C, 0x07, 0x83, 0xC0, 0xE0,
  0x78, 0x1C, 0x07, 0x83, 0x80, 0x78, 0x70, 0x07, 0x8E, 0x00, 0xF9, 0xC0,
  0x0F, 0x38, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xEC, 0x0F, 0xFB, 0x83, 0x7E, 0xE1, 0xDF, 0x9C, 0x77,
  0xE7, 0x39, 0xF9, 0xCE, 0x7E, 0x3B, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0x78, 0x7E, 0x1E, 0x1F, 0x83, 0x87, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07,
  0xEE, 0x07, 0xEE, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE3, 0x87, 0xE3, 0x87,
  0xE1, 0xC7, 0xE1, 0xC7, 0xE0, 0xE7, 0xE0, 0xE7, 0xE0, 0x77, 0xE0, 0x77,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xF8, 0x7C, 0x78, 0x07, 0x9E,
  0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x80, 0x79, 0xF0, 0x1E, 0x3E, 0x1F, 0x07,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9C, 0x03, 0xEE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3,
  0xFF, 0xC1, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0x0F, 0x87, 0x80, 0x78, 0xF0, 0x0F, 0x1C,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0x70,
  0x00, 0xEE, 0x00, 0x1D, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x80, 0x1E, 0xF0,
  0x03, 0xCE, 0x00, 0x79, 0xE0, 0x1E, 0x3E, 0x03, 0xC3, 0xE1, 0xF0, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0xFF,
  0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0x80, 0x7E, 0xE0, 0x07, 0xB8, 0x00,
  0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0xB8, 0x01, 0xEE, 0x01, 0xF3,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xF8, 0x0E, 0x0F, 0x03, 0x81, 0xC0, 0xE0,
  0x78, 0x38, 0x0F, 0x0E, 0x01, 0xC3, 0x80, 0x78, 0xE0, 0x0F, 0x38, 0x01,
  0xEE, 0x00, 0x7B, 0x80, 0x0F, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0x03, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0xCE, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xEE, 0x00, 0x1D,
  0xC0, 0x03, 0xBC, 0x00, 0xF3, 0xE0, 0x3E, 0x7F, 0xFF, 0x83, 0xFF, 0xE0,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x01, 0xDE, 0x01, 0xE7, 0x81, 0xF3, 0xFF,
  0xF0, 0xFF, 0xF0, 0x1F, 0xE0, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x80,
  0x07, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xF0, 0x03, 0xC1, 0xC0, 0x0F,
  0x07, 0x80, 0x38, 0x1E, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xF0, 0x1C, 0x01,
  0xC0, 0xF0, 0x07, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x38, 0x78, 0x00, 0xE1,
  0xC0, 0x03, 0xCF, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x70, 0x00,
  0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x1E, 0x0E, 0x78, 0x78, 0x38,
  0xE1, 0xE0, 0xE3, 0x87, 0xC7, 0x8E, 0x3F, 0x1C, 0x38, 0xEC, 0x70, 0xE3,
  0x31, 0xC3, 0x8C, 0xE7, 0x0E, 0x73, 0x9C, 0x1D, 0xC6, 0x70, 0x76, 0x19,
  0x81, 0xD8, 0x76, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x80,
  0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x70, 0x00, 0xE3, 0xC0, 0x0F, 0x0F, 0x00,
  0xF0, 0x38, 0x07, 0x01, 0xE0, 0x78, 0x07, 0x87, 0x80, 0x1C, 0x38, 0x00,
  0x73, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0xF3, 0xC0, 0x07,
  0x0E, 0x00, 0x78, 0x38, 0x07, 0x81, 0xE0, 0x38, 0x07, 0x03, 0xC0, 0x1C,
  0x3C, 0x00, 0xF1, 0xC0, 0x03, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x73, 0x80,
  0x07, 0x9E, 0x00, 0x78, 0x70, 0x03, 0x83, 0xC0, 0x3C, 0x0F, 0x01, 0xC0,
  0x38, 0x1C, 0x01, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x1C, 0xF0, 0x00, 0xF7,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0C,
  0xC0, 0x07, 0x38, 0x01, 0xC6, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0C, 0x0E,
  0x07, 0x03, 0x81, 0x80, 0x60, 0xE0, 0x1C, 0x38, 0x03, 0x1C, 0x00, 0xE7,
  0x00, 0x39, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x78,
  0x1C, 0x0E, 0x07, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x1E, 0x0F,
  0x87, 0x80, 0xF0, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x07, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E, 0x03, 0x8F, 0x00, 0x71, 0xE0, 0x0E,
  0x3C, 0x03, 0xC7, 0x80, 0xF8, 0x78, 0x37, 0x8F, 0xFE, 0xFC, 0xFF, 0x9F,
  0x8F, 0xC1, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE3, 0xE0, 0xF7, 0xFC, 0x7F, 0xFF,
  0x3F, 0x07, 0xDF, 0x01, 0xEF, 0x00, 0x77, 0x80, 0x3B, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x77,
  0x80, 0x3B, 0xE0, 0x3D, 0xF8, 0x3C, 0xFF, 0xFE, 0x73, 0xFE, 0x38, 0x7C,
  0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x78, 0x07,
  0x9E, 0x00, 0xE7, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x39, 0xE0,
  0x1E, 0x3E, 0x0F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x0F, 0xC7, 0x1F, 0xF3, 0x9F, 0xFD, 0xCF, 0x07, 0xEF, 0x01, 0xF7,
  0x80, 0x7B, 0x80, 0x3D, 0xC0, 0x1E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xDC, 0x01, 0xEE, 0x00, 0xF7, 0x00, 0x7B, 0xC0, 0x3D, 0xE0, 0x3E, 0x78,
  0x3F, 0x3F, 0xFB, 0x8F, 0xF9, 0xC1, 0xF8, 0xE0, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0xF8, 0x3C, 0x78, 0x07, 0x9C, 0x00, 0xE7, 0x00, 0x39,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x0C, 0x3E, 0x0F, 0x87, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE0, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0x87, 0x3F, 0xE7, 0x7F, 0xF7,
  0x78, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0x78, 0x3F, 0x7F, 0xF7, 0x3F, 0xE7, 0x0F, 0x87, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x70, 0x0E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xEE, 0x1E,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xF9, 0xFF, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xF0, 0x1E, 0xFF, 0xF7,
  0xFF, 0x1F, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0,
  0x78, 0xF0, 0xF0, 0xF1, 0xE0, 0xF3, 0xC0, 0xF7, 0x80, 0xF7, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0xFB, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0x70, 0xF0,
  0x78, 0xF0, 0x3C, 0xF0, 0x1C, 0xF0, 0x1E, 0xF0, 0x0F, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE7, 0x0F,
  0x3B, 0xE7, 0xEF, 0xFD, 0xFF, 0xC7, 0xCF, 0xF1, 0xE1, 0xF8, 0x78, 0x7E,
  0x0E, 0x1F, 0x83, 0x87, 0xE0, 0xE1, 0xF8, 0x38, 0x7E, 0x0E, 0x1F, 0x83,
  0x87, 0xE0, 0xE1, 0xF8, 0x38, 0x7E, 0x0E, 0x1F, 0x83, 0x87, 0xE0, 0xE1,
  0xF8, 0x38, 0x7E, 0x0E, 0x1F, 0x83, 0x87, 0xE1, 0xF8, 0xE7, 0xFC, 0xEF,
  0xFE, 0xEE, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3C, 0x78, 0x07, 0x9E, 0x00,
  0xE7, 0x00, 0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xDC, 0x00, 0xE7, 0x80, 0x39, 0xE0, 0x1E, 0x3E,
  0x0F, 0x07, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xC0, 0xE1, 0xF0, 0x7B, 0xFE,
  0x3F, 0xFF, 0x9F, 0x83, 0xEF, 0x80, 0xF7, 0x80, 0x3B, 0xC0, 0x1D, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3B, 0xC0, 0x1D, 0xF0, 0x1E, 0xFC, 0x1F, 0x7F, 0xFF, 0x3D, 0xFF,
  0x1E, 0x3E, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE3, 0x8F, 0xF9,
  0xCF, 0xFE, 0xE7, 0x83, 0xF7, 0x80, 0xFB, 0xC0, 0x3D, 0xC0, 0x1E, 0xE0,
  0x0F, 0x70, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0xF7, 0x00, 0x7B,
  0x80, 0x3D, 0xE0, 0x1E, 0xF0, 0x1F, 0x3C, 0x1B, 0x9F, 0xFD, 0xC7, 0xFC,
  0xE0, 0xF8, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0xF0, 0xFE, 0xE3, 0xFD,
  0xCF, 0xFB, 0xBC, 0x07, 0x60, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x1F, 0xFC, 0x3F, 0xFE, 0x78, 0x1E, 0x70, 0x07, 0x70, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x7F, 0xFE, 0x3F, 0xFC,
  0x0F, 0xF0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x03,
  0xFC, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x1F, 0x78, 0x3F, 0x7F,
  0xF7, 0x3F, 0xE7, 0x1F, 0x87, 0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x78, 0x01,
  0xE3, 0x80, 0x1E, 0x3C, 0x01, 0xC3, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xE0,
  0x78, 0x0E, 0x07, 0x80, 0xE0, 0x70, 0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07,
  0x8E, 0x00, 0x39, 0xE0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1D, 0xC0, 0x00,
  0xF7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC1, 0xE0, 0xE7,
  0x87, 0x83, 0x8E, 0x1F, 0x1E, 0x38, 0xFC, 0x70, 0xE3, 0x31, 0xC3, 0x8C,
  0xC7, 0x0E, 0x73, 0x9C, 0x39, 0xC6, 0x70, 0x76, 0x19, 0xC1, 0xD8, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03,
  0xC0, 0x70, 0xF0, 0x03, 0xDE, 0x01, 0xE3, 0x80, 0x70, 0x70, 0x38, 0x1E,
  0x1E, 0x03, 0x87, 0x00, 0x73, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0xB8, 0x03, 0xCF, 0x00, 0xE1, 0xC0,
  0x70, 0x38, 0x3C, 0x0F, 0x0E, 0x01, 0xE7, 0x00, 0x3B, 0xC0, 0x0F, 0xF0,
  0x00, 0xF7, 0x00, 0x0E, 0x78, 0x00, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC1,
  0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xE0, 0x38, 0x0E, 0x07, 0x80, 0xE0, 0x70,
  0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x8E, 0x00, 0x39, 0xC0, 0x03, 0x9C,
  0x00, 0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0xFC, 0x01, 0xE0, 0x03, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xC0, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0xFF, 0x81, 0xFF,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0x00, 0x1F, 0x00,
};

const GFXglyph LiberationMono_Regular37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 4, 24, 22, 9, -24 },
  { 13, 12, 12, 22, 5, -27 },
  { 31, 20, 24, 22, 1, -24 },
  { 91, 20, 30, 22, 1, -27 },
  { 166, 22, 24, 22, 0, -24 },
  { 232, 20, 24, 22, 1, -24 },
  { 292, 4, 12, 22, 9, -27 },
  { 298, 10, 35, 22, 6, -27 },
  { 342, 10, 35, 22, 6, -27 },
  { 386, 14, 13, 22, 4, -27 },
  { 409, 18, 19, 22, 2, -22 },
  { 452, 8, 12, 22, 5, -5 },
  { 464, 10, 3, 22, 6, -11 },
  { 468, 4, 5, 22, 9, -5 },
  { 471, 18, 27, 22, 2, -27 },
  { 532, 18, 24, 22, 2, -24 },
  { 586, 17, 24, 22, 3, -24 },
  { 637, 17, 24, 22, 3, -24 },
  { 688, 18, 24, 22, 2, -24 },
  { 742, 18, 24, 22, 2, -24 },
  { 796, 18, 24, 22, 2, -24 },
  { 850, 17, 24, 22, 3, -24 },
  { 901, 16, 24, 22, 3, -24 },
  { 949, 18, 24, 22, 2, -24 },
  { 1003, 17, 24, 22, 3, -24 },
  { 1054, 4, 20, 22, 9, -20 },
  { 1064, 8, 27, 22, 6, -20 },
  { 1091, 18, 19, 22, 2, -22 },
  { 1134, 18, 12, 22, 2, -18 },
  { 1161, 18, 19, 22, 2, -22 },
  { 1204, 17, 24, 22, 2, -24 },
  { 1255, 20, 32, 22, 1, -27 },
  { 1335, 22, 24, 22, 0, -24 },
  { 1401, 18, 24, 22, 3, -24 },
  { 1455, 19, 24, 22, 2, -24 },
  { 1512, 17, 24, 22, 3, -24 },
  { 1563, 17, 24, 22, 3, -24 },
  { 1614, 17, 24, 22, 3, -24 },
  { 1665, 18, 24, 22, 2, -24 },
  { 1719, 16, 24, 22, 3, -24 },
  { 1767, 15, 24, 22, 4, -24 },
  { 1812, 15, 24, 22, 3, -24 },
  { 1857, 19, 24, 22, 3, -24 },
  { 1914, 16, 24, 22, 4, -24 },
  { 1962, 18, 24, 22, 2, -24 },
  { 2016, 16, 24, 22, 3, -24 },
  { 2064, 18, 24, 22, 2, -24 },
  { 2118, 17, 24, 22, 3, -24 },
  { 2169, 19, 31, 22, 2, -24 },
  { 2243, 18, 24, 22, 3, -24 },
  { 2297, 19, 24, 22, 1, -24 },
  { 2354, 20, 24, 22, 1, -24 },
  { 2414, 17, 24, 22, 3, -24 },
  { 2465, 22, 24, 22, 0, -24 },
  { 2531, 22, 24, 22, 0, -24 },
  { 2597, 21, 24, 22, 1, -24 },
  { 2660, 21, 24, 22, 1, -24 },
  { 2723, 20, 24, 22, 1, -24 },
  { 2783, 10, 35, 22, 7, -27 },
  { 2827, 18, 27, 22, 2, -27 },
  { 2888, 10, 35, 22, 5, -27 },
  { 2932, 18, 16, 22, 2, -24 },
  { 2968, 22, 2, 22, 0, 2 },
  { 2974, 8, 5, 22, 7, -27 },
  { 2979, 19, 20, 22, 2, -20 },
  { 3027, 17, 27, 22, 3, -27 },
  { 3085, 18, 20, 22, 2, -20 },
  { 3130, 17, 27, 22, 2, -27 },
  { 3188, 18, 20, 22, 2, -20 },
  { 3233, 18, 27, 22, 2, -27 },
  { 3294, 16, 28, 22, 3, -20 },
  { 3350, 16, 27, 22, 3, -27 },
  { 3404, 17, 27, 22, 3, -27 },
  { 3462, 13, 35, 22, 2, -27 },
  { 3519, 16, 27, 22, 4, -27 },
  { 3573, 18, 27, 22, 2, -27 },
  { 3634, 18, 20, 22, 2, -20 },
  { 3679, 16, 20, 22, 3, -20 },
  { 3719, 18, 20, 22, 2, -20 },
  { 3764, 17, 28, 22, 3, -20 },
  { 3824, 17, 28, 22, 2, -20 },
  { 3884, 15, 20, 22, 4, -20 },
  { 3922, 16, 20, 22, 3, -20 },
  { 3962, 15, 25, 22, 3, -25 },
  { 4009, 16, 20, 22, 3, -20 },
  { 4049, 20, 20, 22, 1, -20 },
  { 4099, 22, 20, 22, 0, -20 },
  { 4154, 18, 20, 22, 2, -20 },
  { 4199, 20, 28, 22, 1, -20 },
  { 4269, 16, 20, 22, 3, -20 },
  { 4309, 15, 35, 22, 4, -27 },
  { 4375, 3, 35, 22, 10, -27 },
  { 4389, 15, 35, 22, 3, -27 },
  { 4455, 18, 5, 22, 2, -15 },
};

const GFXfont LiberationMono_Regular37pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Regular37pt7bBitmaps,
  (GFXglyph *)LiberationMono_Regular37pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _LIBERATIONMONO_REGULAR37PT7B_H_
