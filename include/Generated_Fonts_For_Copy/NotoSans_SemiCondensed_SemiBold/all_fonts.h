#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_SemiCondensed_SemiBold
// Headers: 67

#include "NotoSans_SemiCondensed_SemiBold6pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold7pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold8pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold9pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold10pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold11pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold12pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold13pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold14pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold15pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold16pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold17pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold18pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold19pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold20pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold21pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold22pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold23pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold24pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold25pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold26pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold27pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold28pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold29pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold30pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold31pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold32pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold33pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold34pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold35pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold36pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold37pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold38pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold39pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold40pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold41pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold42pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold43pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold44pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold45pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold46pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold47pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold48pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold49pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold50pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold51pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold52pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold53pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold54pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold55pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold56pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold57pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold58pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold59pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold60pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold61pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold62pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold63pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold64pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold65pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold66pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold67pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold68pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold69pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold70pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold71pt7b.h"
#include "NotoSans_SemiCondensed_SemiBold72pt7b.h"
