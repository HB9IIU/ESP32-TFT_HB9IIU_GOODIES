#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x37, 0xD5, 0xF5, 0x28, 0x27, 0xA6, 0x3B, 0x62, 0x45,
  0x52, 0xA5, 0xB5, 0xA5, 0x49, 0x80, 0x21, 0x45, 0x18, 0xFF, 0x67, 0xC0,
  0xC0, 0x6A, 0x48, 0x98, 0xD5, 0x5C, 0x2F, 0x25, 0x2F, 0x22, 0x60, 0xE0,
  0x80, 0x25, 0x25, 0x00, 0x25, 0xD9, 0x95, 0x70, 0xF5, 0x50, 0x2D, 0x11,
  0x24, 0xF0, 0x2D, 0x16, 0x11, 0xF0, 0x31, 0x95, 0x2F, 0x88, 0x74, 0x71,
  0x1F, 0x16, 0x4B, 0xD5, 0x70, 0xF1, 0x32, 0x24, 0x25, 0x56, 0x59, 0x70,
  0x25, 0x9D, 0x71, 0x60, 0x88, 0x40, 0x60, 0x3C, 0x61, 0xFF, 0xC3, 0x3C,
  0x4B, 0x32, 0x40, 0x40, 0x7C, 0xB6, 0xAD, 0x5B, 0x48, 0x0E, 0x00, 0x32,
  0x94, 0xFC, 0xC4, 0xF9, 0xE9, 0x9E, 0x13, 0x51, 0x84, 0x21, 0xE0, 0xF9,
  0x99, 0x9E, 0xF3, 0xC9, 0xC0, 0xF3, 0xC9, 0x00, 0x13, 0x51, 0xB4, 0xA5,
  0xE0, 0x99, 0xF9, 0x99, 0xE9, 0x25, 0xC0, 0x24, 0x92, 0x4E, 0xBA, 0xCA,
  0xA9, 0x92, 0x49, 0xC0, 0xCF, 0x3D, 0x6D, 0xB6, 0x90, 0xCE, 0x6B, 0x59,
  0xCC, 0x11, 0xA4, 0x71, 0x45, 0x37, 0x80, 0xE9, 0xBC, 0x88, 0x11, 0xA4,
  0x71, 0x45, 0x37, 0x82, 0x0C, 0xF9, 0xEA, 0xA9, 0x25, 0xC6, 0x11, 0xF0,
  0xF2, 0x22, 0x22, 0x99, 0x99, 0x9F, 0x8A, 0x54, 0xA3, 0x10, 0x99, 0xDA,
  0x5A, 0x6A, 0x66, 0x64, 0xDA, 0x88, 0xE5, 0x64, 0xDA, 0x98, 0x42, 0x10,
  0xF3, 0x24, 0x4F, 0xEA, 0xAC, 0x89, 0x12, 0x40, 0xD5, 0x5C, 0x22, 0x95,
  0x10, 0xF0, 0xC4, 0x71, 0x79, 0x70, 0x88, 0xEB, 0x99, 0xE0, 0x74, 0xCC,
  0x70, 0x18, 0xDE, 0xBD, 0xED, 0xA0, 0x75, 0xF4, 0x70, 0x6B, 0xA4, 0x90,
  0x6A, 0xF7, 0xB7, 0x89, 0xC0, 0x88, 0xEB, 0x99, 0x90, 0xBE, 0x45, 0x55,
  0xC0, 0x88, 0xBE, 0xCA, 0xB0, 0xFE, 0xEE, 0xDA, 0x69, 0xA4, 0xEB, 0x99,
  0x90, 0x72, 0xF2, 0xB7, 0x00, 0xEB, 0x99, 0xE8, 0x80, 0x6A, 0xF7, 0xB7,
  0x8C, 0x60, 0xEA, 0x80, 0x78, 0x61, 0xE0, 0x5D, 0x24, 0xC0, 0xBB, 0xBB,
  0xD0, 0x9D, 0x56, 0x60, 0x93, 0xE9, 0xB3, 0x66, 0xC0, 0xD7, 0x27, 0xD0,
  0x95, 0x56, 0x22, 0xC0, 0xF2, 0x64, 0xF0, 0x69, 0x44, 0x98, 0xFF, 0x80,
  0xC9, 0x14, 0xB0, 0xF9,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 2, 2, 4, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 0, -7 },
  { 11, 7, 7, 7, 0, -7 },
  { 18, 6, 7, 6, 0, -7 },
  { 24, 1, 2, 2, 1, -6 },
  { 25, 3, 7, 3, 0, -6 },
  { 28, 2, 7, 3, 0, -6 },
  { 30, 4, 4, 5, 0, -7 },
  { 32, 4, 4, 5, 0, -5 },
  { 34, 2, 2, 2, 0, -1 },
  { 35, 3, 1, 3, 0, -3 },
  { 36, 1, 1, 2, 1, -1 },
  { 37, 3, 6, 4, 0, -6 },
  { 40, 4, 7, 5, 0, -7 },
  { 44, 2, 6, 5, 1, -6 },
  { 46, 4, 7, 5, 0, -7 },
  { 50, 4, 7, 5, 0, -7 },
  { 54, 5, 6, 5, 0, -6 },
  { 58, 4, 6, 5, 0, -6 },
  { 61, 4, 7, 5, 0, -7 },
  { 65, 4, 6, 5, 0, -6 },
  { 68, 4, 7, 5, 0, -7 },
  { 72, 4, 7, 5, 0, -7 },
  { 76, 1, 5, 2, 1, -5 },
  { 77, 2, 6, 2, 0, -5 },
  { 79, 4, 4, 5, 0, -5 },
  { 81, 4, 2, 5, 0, -4 },
  { 82, 4, 4, 5, 0, -5 },
  { 84, 4, 7, 4, 0, -7 },
  { 88, 7, 7, 7, 0, -6 },
  { 95, 5, 6, 5, 0, -6 },
  { 99, 4, 6, 5, 1, -6 },
  { 102, 5, 7, 5, 0, -7 },
  { 107, 4, 6, 6, 1, -6 },
  { 110, 3, 6, 5, 1, -6 },
  { 113, 3, 6, 4, 1, -6 },
  { 116, 5, 7, 6, 0, -7 },
  { 121, 4, 6, 6, 1, -6 },
  { 124, 3, 6, 3, 0, -6 },
  { 127, 3, 8, 3, -1, -6 },
  { 130, 4, 6, 5, 1, -6 },
  { 133, 3, 6, 4, 1, -6 },
  { 136, 6, 6, 8, 1, -6 },
  { 141, 5, 6, 7, 1, -6 },
  { 145, 6, 7, 6, 0, -7 },
  { 151, 4, 6, 5, 1, -6 },
  { 154, 6, 9, 6, 0, -7 },
  { 161, 4, 6, 5, 1, -6 },
  { 164, 4, 7, 5, 0, -7 },
  { 168, 4, 6, 5, 0, -6 },
  { 171, 4, 6, 6, 1, -6 },
  { 174, 5, 6, 5, 0, -6 },
  { 178, 8, 6, 8, 0, -6 },
  { 184, 5, 6, 5, 0, -6 },
  { 188, 5, 6, 5, 0, -6 },
  { 192, 4, 6, 5, 0, -6 },
  { 195, 2, 7, 3, 1, -6 },
  { 197, 3, 6, 4, 0, -6 },
  { 200, 2, 7, 3, 0, -6 },
  { 202, 5, 4, 5, 0, -6 },
  { 205, 4, 1, 4, 0, 1 },
  { 206, 3, 2, 3, 0, -7 },
  { 207, 4, 5, 5, 0, -5 },
  { 210, 4, 7, 5, 1, -7 },
  { 214, 4, 5, 4, 0, -5 },
  { 217, 5, 7, 5, 0, -7 },
  { 222, 4, 5, 5, 0, -5 },
  { 225, 3, 7, 3, 0, -7 },
  { 228, 5, 7, 5, 0, -5 },
  { 233, 4, 7, 5, 1, -7 },
  { 237, 1, 7, 2, 1, -7 },
  { 238, 2, 9, 2, 0, -7 },
  { 241, 4, 7, 5, 1, -7 },
  { 245, 1, 7, 2, 1, -7 },
  { 246, 6, 5, 8, 1, -5 },
  { 250, 4, 5, 5, 1, -5 },
  { 253, 5, 5, 5, 0, -5 },
  { 257, 4, 7, 5, 1, -5 },
  { 261, 5, 7, 5, 0, -5 },
  { 266, 2, 5, 4, 1, -5 },
  { 268, 4, 5, 4, 0, -5 },
  { 271, 3, 6, 3, 0, -6 },
  { 274, 4, 5, 5, 1, -5 },
  { 277, 4, 5, 4, 0, -5 },
  { 280, 7, 5, 7, 0, -5 },
  { 285, 4, 5, 5, 0, -5 },
  { 288, 4, 7, 5, 0, -5 },
  { 292, 4, 5, 4, 0, -5 },
  { 295, 3, 7, 3, 0, -6 },
  { 298, 1, 9, 5, 2, -7 },
  { 300, 3, 7, 3, 0, -6 },
  { 303, 4, 2, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD9PT7B_H_
