#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0x77, 0x66, 0x66, 0x66, 0x60, 0x07, 0xF7, 0xE7, 0xE7, 0x67,
  0x66, 0x66, 0x66, 0x06, 0x60, 0x33, 0x03, 0x18, 0x18, 0xC7, 0xFF, 0xBF,
  0xFC, 0x33, 0x01, 0x98, 0x18, 0xC7, 0xFF, 0xBF, 0xFC, 0x33, 0x01, 0x98,
  0x0C, 0xC0, 0xC6, 0x06, 0x30, 0x0C, 0x07, 0x87, 0xFD, 0xFE, 0xEC, 0x3B,
  0x0E, 0xC1, 0xF0, 0x3F, 0x03, 0xE0, 0xFC, 0x37, 0x0D, 0xFB, 0xFF, 0xF9,
  0xF8, 0x0C, 0x03, 0x00, 0x30, 0x04, 0x3E, 0x0C, 0x3B, 0x0E, 0x19, 0xC6,
  0x0C, 0x67, 0x06, 0x33, 0x03, 0x1B, 0x81, 0x9D, 0x9C, 0xED, 0xDF, 0x3E,
  0xDD, 0xCC, 0xEC, 0x60, 0x66, 0x30, 0x33, 0x18, 0x31, 0x8C, 0x18, 0xE6,
  0x18, 0x3E, 0x1C, 0x0F, 0x00, 0x0E, 0x00, 0xFE, 0x03, 0xF8, 0x1C, 0x60,
  0x71, 0x81, 0xCE, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x05, 0xF8, 0xEE, 0x73,
  0xB8, 0xEE, 0xE1, 0xF3, 0x83, 0x8F, 0x1F, 0x1F, 0xFE, 0x3F, 0x3C, 0xFD,
  0xB6, 0xC0, 0x1C, 0xE3, 0x1C, 0x63, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x86, 0x1C, 0x70, 0xC3, 0x87, 0xE3, 0x1C, 0x63, 0x9C, 0xE3, 0x18, 0xC6,
  0x31, 0x9C, 0xE6, 0x73, 0x39, 0x80, 0x1C, 0x03, 0x00, 0xC2, 0x32, 0xFF,
  0xFF, 0xF1, 0xE0, 0xF8, 0x77, 0x0C, 0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x76, 0x6E, 0xCC,
  0xFF, 0xC0, 0x7F, 0x70, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x30, 0x38,
  0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0xE0, 0x00,
  0x0C, 0x0F, 0xC7, 0xF9, 0xCE, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x77, 0x39, 0xFE, 0x3F, 0x00, 0x0E, 0x3C,
  0xFF, 0xB6, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x1C, 0x1F, 0xCF, 0xF9, 0x0F, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0x1C, 0x1F,
  0xCF, 0xF9, 0x07, 0x01, 0xC0, 0x70, 0x38, 0xFC, 0x3E, 0x0F, 0xE0, 0x1C,
  0x07, 0x01, 0xC0, 0x78, 0x3F, 0xFE, 0xFF, 0x00, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x0D, 0xC1, 0xDC, 0x19, 0xC3, 0x1C, 0x31, 0xC6, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x7F, 0x9F, 0xE6, 0x01,
  0x80, 0x60, 0x18, 0x07, 0xF3, 0xFE, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xF0, 0xEF, 0xFB, 0xF8, 0x03, 0x87, 0xE3, 0xF9, 0xC0, 0x60, 0x38, 0x0E,
  0x63, 0xFE, 0xFF, 0xF8, 0x7E, 0x1F, 0x83, 0xE1, 0xF8, 0x77, 0x3D, 0xFE,
  0x1F, 0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x06, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x06, 0x03, 0x81, 0xE0, 0x0C, 0x0F,
  0xE7, 0xFB, 0x87, 0xE1, 0xF8, 0x77, 0x38, 0xFC, 0x1E, 0x1F, 0xEF, 0x3F,
  0x87, 0xE0, 0xF8, 0x7E, 0x1D, 0xFE, 0x3F, 0x00, 0x0C, 0x0F, 0xC7, 0xFB,
  0x8E, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xDF, 0xB3, 0xDC, 0x07, 0x01,
  0xC0, 0xE0, 0x79, 0xFC, 0x7C, 0x00, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x7F,
  0x70, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x76, 0xEE, 0xCC, 0x00, 0x40, 0x70,
  0x7C, 0x7C, 0x7C, 0x3C, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x0C, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80, 0x38, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x70, 0x3C, 0x3C, 0x7C, 0x3C, 0x0C, 0x00, 0x1C, 0x7F, 0x9F,
  0xE8, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x78, 0x1C, 0x00, 0x00, 0xC0, 0x03, 0xFC, 0x07, 0x87, 0x07,
  0x00, 0xC3, 0x00, 0x33, 0x1F, 0x99, 0x9F, 0xC7, 0xCC, 0x63, 0xC6, 0x31,
  0xE7, 0x18, 0xF3, 0x8C, 0x79, 0xC6, 0x6C, 0x67, 0xB3, 0x3E, 0xF1, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x08, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x0C, 0xC0, 0x73, 0x81, 0xCE, 0x07, 0x38,
  0x38, 0x70, 0xFF, 0xC3, 0xFF, 0x1F, 0xFE, 0x70, 0x39, 0xC0, 0xEF, 0x03,
  0xF8, 0x07, 0xFF, 0x9F, 0xFB, 0x87, 0x70, 0xEE, 0x1D, 0xC3, 0xBF, 0xE7,
  0xF8, 0xFF, 0xDC, 0x3B, 0x83, 0xF0, 0x7E, 0x0F, 0xC7, 0xBF, 0xF7, 0xF8,
  0x03, 0x81, 0xFF, 0x3F, 0xE3, 0x82, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x63, 0xFE,
  0x0F, 0xE0, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xE1, 0xEE, 0x7C, 0xFF,
  0x8F, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x03, 0xC0,
  0x7F, 0xCF, 0xFC, 0x78, 0x27, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE1,
  0xFF, 0x0F, 0xF8, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1C, 0xF0, 0xE3, 0xFF,
  0x0F, 0xF0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xFD, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xCF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x3F, 0xF7, 0xC7, 0x00, 0xE0, 0xEE, 0x1C,
  0xE3, 0x8E, 0x78, 0xE7, 0x0E, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0E, 0x70,
  0xE7, 0x0E, 0x38, 0xE3, 0xCE, 0x1C, 0xE1, 0xEE, 0x0F, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xD8, 0x1F, 0xD8,
  0x3F, 0xFC, 0x37, 0xEC, 0x37, 0xEC, 0x77, 0xEE, 0x67, 0xE6, 0x67, 0xE6,
  0xE7, 0xE7, 0xC7, 0xE7, 0xC7, 0xE3, 0xC7, 0xE3, 0x87, 0xE3, 0x87, 0xF0,
  0x3F, 0x81, 0xFE, 0x0F, 0xB8, 0x7D, 0xC3, 0xE7, 0x1F, 0xB8, 0xFC, 0xE7,
  0xE7, 0x3F, 0x1D, 0xF8, 0xEF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC,
  0x0F, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x39, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0x70, 0x1D,
  0xC0, 0xE3, 0xC7, 0x8F, 0xFC, 0x0F, 0xE0, 0xFF, 0x3F, 0xEE, 0x3F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x9E, 0xFF, 0xBF, 0x8E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x39,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07,
  0x70, 0x1D, 0xC0, 0xE3, 0xC7, 0x8F, 0xFC, 0x0F, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0xEE, 0x1D, 0xC3,
  0xB8, 0xF7, 0xFC, 0xFF, 0x1C, 0xE3, 0x9C, 0x71, 0xCE, 0x39, 0xC3, 0xB8,
  0x7F, 0x07, 0x0E, 0x0F, 0xF7, 0xFB, 0x82, 0xE0, 0x38, 0x0F, 0x01, 0xF0,
  0x3E, 0x07, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x7C, 0x3B, 0xFE, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEF, 0x1E, 0x7F, 0xC3, 0xF8, 0xE0, 0x3B,
  0x01, 0xDC, 0x0C, 0xE0, 0xE3, 0x07, 0x1C, 0x30, 0xE3, 0x87, 0x1C, 0x18,
  0xC0, 0xEE, 0x07, 0x70, 0x1B, 0x80, 0xD8, 0x07, 0xC0, 0x1E, 0x00, 0xE0,
  0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0x70, 0xF0, 0x67, 0x0F, 0x0E, 0x70, 0xF8,
  0xE7, 0x1F, 0x8E, 0x31, 0x98, 0xC3, 0x99, 0x9C, 0x39, 0x9D, 0xC3, 0xB9,
  0xDC, 0x1B, 0x0D, 0x81, 0xB0, 0xD8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0E,
  0x07, 0x80, 0xE0, 0x70, 0xF0, 0x7B, 0xC3, 0x8E, 0x38, 0x3B, 0x81, 0xDC,
  0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0x70, 0x3B, 0x83,
  0x8E, 0x3C, 0x79, 0xC1, 0xDC, 0x0F, 0xE0, 0x7B, 0x83, 0x9C, 0x38, 0x71,
  0xC3, 0x9C, 0x0E, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xFF, 0xFF, 0xF0, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0,
  0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x3F, 0xF0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0,
  0xE0, 0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03,
  0x80, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xFF, 0xF0, 0x0C, 0x03, 0xC0, 0x78, 0x1D, 0x83, 0x30, 0x63, 0x18, 0x63,
  0x0E, 0xC0, 0xD8, 0x1C, 0xFF, 0xFF, 0xF0, 0xE3, 0x8C, 0x30, 0x1E, 0x1F,
  0xE3, 0x38, 0x07, 0x01, 0xC3, 0xF7, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F,
  0xFF, 0x7C, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCE, 0x37, 0xEF, 0xFB,
  0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x3F, 0xFE, 0xDF,
  0x00, 0x0E, 0x1F, 0xDF, 0xCE, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x1C, 0x2F, 0xF3, 0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x71, 0xCE, 0x7D,
  0xDF, 0xFB, 0x8F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xDC,
  0x7B, 0xFF, 0x3E, 0xE0, 0x0E, 0x0F, 0xE7, 0xB9, 0x87, 0xE1, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x38, 0x07, 0x05, 0xFF, 0x1F, 0x80, 0x06, 0x0F, 0xCF,
  0xC7, 0x03, 0x81, 0xC3, 0xFD, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x1C, 0x07, 0xDD, 0xFF, 0xB8, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1D, 0xC7, 0xBF, 0xF3, 0xEE,
  0x01, 0xC0, 0x32, 0x0E, 0x7F, 0xCF, 0xF0, 0x20, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xCE, 0x37, 0xEF, 0xFB, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xC0, 0x6F, 0x60, 0x06, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x18, 0xF1, 0x80, 0x00, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x8E, 0xFB, 0xE4, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x70, 0xEC, 0x73, 0x1C, 0xCE, 0x37, 0x0F, 0xC3,
  0xF8, 0xEE, 0x31, 0xCC, 0x3B, 0x0E, 0xC1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0E, 0x1C, 0xDF, 0xBF, 0xFF, 0xFF, 0xE3, 0xC7, 0xE1, 0xC3, 0xE1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0x0E, 0x37, 0xEF, 0xFB, 0x87, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xC0, 0x0E, 0x07, 0xF1, 0xFF,
  0x38, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1D, 0xC7, 0x1F,
  0xC1, 0xF0, 0x0E, 0x37, 0xEF, 0xFB, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07,
  0xE1, 0xF8, 0x7F, 0x3F, 0xFE, 0xDF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0x1C, 0x07, 0xDD, 0xFF, 0xB8, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1D, 0xC7, 0xBF, 0xF3, 0xEE, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x0F, 0xBF, 0xFF, 0x8E, 0x1C, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x00, 0x1C, 0x7F, 0xF7, 0xE0, 0xE0, 0xF8, 0x7E,
  0x1F, 0x07, 0x03, 0x87, 0xFF, 0xFE, 0x18, 0x38, 0x38, 0xFF, 0xFF, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x1F, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0xFF, 0xFD, 0xF7,
  0xE0, 0xEE, 0x1D, 0xC3, 0x38, 0xE3, 0x1C, 0x73, 0x0E, 0xE0, 0xDC, 0x1F,
  0x03, 0xE0, 0x3C, 0x07, 0x00, 0xE1, 0xE3, 0xB0, 0xF1, 0xDC, 0x78, 0xEE,
  0x6C, 0x67, 0x37, 0x71, 0x99, 0xB8, 0xEC, 0xDC, 0x7E, 0x6C, 0x1E, 0x36,
  0x0F, 0x1F, 0x07, 0x87, 0x03, 0xC3, 0x80, 0xF0, 0xE7, 0x38, 0xEE, 0x0F,
  0xC1, 0xF0, 0x1E, 0x07, 0xC0, 0xFC, 0x3B, 0x87, 0x39, 0xC7, 0x78, 0x70,
  0xE0, 0xEE, 0x1D, 0xC3, 0x38, 0xE3, 0x9C, 0x73, 0x06, 0xE0, 0xDC, 0x1F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x03, 0xE0, 0x78, 0x04,
  0x00, 0xFF, 0xFF, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0xFF,
  0xFF, 0x0F, 0x1F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x78, 0xE0, 0xF8,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x0F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF1, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x3E, 0x1C,
  0x79, 0xC3, 0x06, 0x0C, 0x18, 0x31, 0xE3, 0xC6, 0x00, 0x78, 0x7F, 0xF8,
  0xFE, 0x0E,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 8, 6, 10, 1, -16 },
  { 15, 13, 16, 14, 0, -16 },
  { 41, 10, 18, 12, 1, -17 },
  { 64, 17, 17, 19, 1, -17 },
  { 101, 14, 17, 15, 1, -17 },
  { 131, 3, 6, 6, 1, -16 },
  { 134, 6, 20, 7, 1, -16 },
  { 149, 5, 20, 7, 1, -16 },
  { 162, 10, 10, 12, 1, -18 },
  { 175, 10, 11, 12, 1, -14 },
  { 189, 4, 6, 6, 1, -3 },
  { 192, 5, 2, 7, 1, -7 },
  { 194, 4, 3, 6, 1, -3 },
  { 196, 9, 17, 9, 0, -17 },
  { 216, 10, 17, 12, 1, -17 },
  { 238, 7, 16, 12, 1, -16 },
  { 252, 10, 17, 12, 1, -17 },
  { 274, 10, 17, 12, 1, -17 },
  { 296, 12, 16, 12, 0, -16 },
  { 320, 10, 16, 12, 1, -16 },
  { 340, 10, 17, 12, 1, -17 },
  { 362, 10, 16, 12, 1, -16 },
  { 382, 10, 17, 12, 1, -17 },
  { 404, 10, 17, 12, 1, -17 },
  { 426, 4, 13, 6, 1, -13 },
  { 433, 4, 16, 6, 1, -13 },
  { 441, 10, 11, 12, 1, -14 },
  { 455, 10, 6, 12, 1, -11 },
  { 463, 10, 11, 12, 1, -14 },
  { 477, 9, 17, 10, 0, -17 },
  { 497, 17, 19, 19, 1, -17 },
  { 538, 14, 16, 14, 0, -16 },
  { 566, 11, 16, 14, 2, -16 },
  { 588, 12, 17, 13, 1, -17 },
  { 614, 12, 16, 15, 2, -16 },
  { 638, 8, 16, 12, 2, -16 },
  { 654, 8, 16, 11, 2, -16 },
  { 670, 13, 17, 15, 1, -17 },
  { 698, 12, 16, 16, 2, -16 },
  { 722, 6, 16, 8, 1, -16 },
  { 734, 7, 21, 7, -2, -16 },
  { 753, 12, 16, 14, 2, -16 },
  { 777, 9, 16, 11, 2, -16 },
  { 795, 16, 16, 20, 2, -16 },
  { 827, 13, 16, 17, 2, -16 },
  { 853, 14, 17, 16, 1, -17 },
  { 883, 10, 16, 13, 2, -16 },
  { 903, 14, 21, 16, 1, -17 },
  { 940, 11, 16, 14, 2, -16 },
  { 962, 10, 17, 12, 1, -17 },
  { 984, 11, 16, 12, 0, -16 },
  { 1006, 12, 16, 16, 2, -16 },
  { 1030, 13, 16, 13, 0, -16 },
  { 1056, 20, 16, 20, 0, -16 },
  { 1096, 13, 16, 13, 0, -16 },
  { 1122, 13, 16, 13, 0, -16 },
  { 1148, 10, 16, 12, 1, -16 },
  { 1168, 5, 20, 7, 2, -16 },
  { 1181, 9, 17, 9, 0, -17 },
  { 1201, 5, 20, 7, 1, -16 },
  { 1214, 11, 10, 13, 1, -16 },
  { 1228, 10, 2, 10, 0, 2 },
  { 1231, 5, 4, 7, 1, -18 },
  { 1234, 10, 13, 12, 1, -13 },
  { 1251, 10, 17, 13, 2, -17 },
  { 1273, 9, 13, 11, 1, -13 },
  { 1288, 11, 17, 13, 1, -17 },
  { 1312, 10, 13, 12, 1, -13 },
  { 1329, 9, 18, 8, 0, -18 },
  { 1350, 11, 19, 13, 1, -13 },
  { 1377, 10, 17, 13, 2, -17 },
  { 1399, 4, 17, 6, 1, -17 },
  { 1408, 6, 23, 6, -1, -17 },
  { 1426, 10, 17, 12, 2, -17 },
  { 1448, 2, 17, 6, 2, -17 },
  { 1453, 16, 13, 20, 2, -13 },
  { 1479, 10, 13, 13, 2, -13 },
  { 1496, 11, 13, 13, 1, -13 },
  { 1514, 10, 19, 13, 2, -13 },
  { 1538, 11, 19, 13, 1, -13 },
  { 1565, 7, 13, 9, 2, -13 },
  { 1577, 8, 13, 10, 1, -13 },
  { 1590, 8, 15, 8, 0, -15 },
  { 1605, 10, 12, 13, 2, -12 },
  { 1620, 11, 12, 11, 0, -12 },
  { 1637, 17, 12, 18, 0, -12 },
  { 1663, 11, 12, 12, 0, -12 },
  { 1680, 11, 18, 12, 0, -12 },
  { 1705, 8, 12, 10, 1, -12 },
  { 1717, 8, 20, 9, 0, -16 },
  { 1737, 2, 22, 12, 5, -17 },
  { 1743, 7, 20, 9, 1, -16 },
  { 1761, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD23PT7B_H_
