#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xB4, 0x28, 0xA7, 0xD4, 0xF9, 0x45, 0x00, 0x23, 0xBA, 0xC3,
  0x17, 0xE4, 0x20, 0x64, 0xA4, 0xA8, 0x6F, 0x15, 0x15, 0x26, 0x70, 0xB1,
  0xC3, 0x2D, 0x59, 0x1D, 0x80, 0xC0, 0x69, 0x6C, 0x92, 0x20, 0xC9, 0x92,
  0x52, 0x80, 0x21, 0x3E, 0xA5, 0x00, 0x21, 0x3E, 0x42, 0x00, 0x70, 0xE0,
  0x80, 0x12, 0x26, 0x44, 0x80, 0x72, 0xF3, 0x9C, 0xAD, 0xC0, 0x7D, 0xB6,
  0xD8, 0xF0, 0xC6, 0x22, 0x23, 0xE0, 0xF0, 0xC4, 0xE1, 0x8F, 0xC0, 0x11,
  0x94, 0xAF, 0x88, 0x40, 0xE8, 0x8F, 0x13, 0xE0, 0x72, 0x1D, 0xBC, 0xA5,
  0xC0, 0xF8, 0xC4, 0x22, 0x11, 0x80, 0x72, 0x54, 0xED, 0xE5, 0xC0, 0x76,
  0xF2, 0xF0, 0x89, 0xC0, 0xC4, 0x50, 0x1C, 0x09, 0xB0, 0x60, 0x80, 0xF8,
  0x3E, 0xC1, 0x86, 0xC8, 0x00, 0xF1, 0x36, 0x40, 0x60, 0x3E, 0x42, 0x5D,
  0xA5, 0xA5, 0x5E, 0x40, 0x3C, 0x30, 0xC7, 0x92, 0x7B, 0x38, 0x40, 0xF4,
  0xA5, 0xE9, 0xCF, 0xC0, 0x78, 0x88, 0x88, 0x70, 0xF4, 0xE3, 0x18, 0xCF,
  0xC0, 0xF8, 0x8E, 0x88, 0xF0, 0xF8, 0x8E, 0x88, 0x80, 0x7C, 0x21, 0x78,
  0xC5, 0xE0, 0x8C, 0x63, 0xF8, 0xC6, 0x20, 0xE9, 0x24, 0xB8, 0x24, 0x92,
  0x49, 0xE0, 0x9D, 0xA9, 0xCA, 0x4A, 0x60, 0x88, 0x88, 0x88, 0xF0, 0xC7,
  0x8F, 0x2D, 0x5A, 0xB6, 0x64, 0x80, 0xCE, 0x7B, 0x59, 0xCE, 0x20, 0xFA,
  0x28, 0xE3, 0x8A, 0x27, 0x00, 0xF9, 0x9F, 0x88, 0x80, 0xFA, 0x28, 0xE3,
  0x8A, 0x27, 0x04, 0x08, 0xF4, 0xA5, 0xEA, 0x4A, 0x60, 0x7E, 0x10, 0x61,
  0x8F, 0xC0, 0xF9, 0x08, 0x42, 0x10, 0x80, 0x8C, 0x63, 0x18, 0xC5, 0xC0,
  0x8D, 0x24, 0x96, 0x70, 0xC3, 0x00, 0x89, 0xEC, 0x95, 0x4A, 0xA5, 0x73,
  0x30, 0x88, 0xC9, 0x63, 0x0C, 0x71, 0x6C, 0xC0, 0xCA, 0xDC, 0x62, 0x10,
  0x80, 0xF8, 0x8C, 0x46, 0x23, 0xE0, 0xEA, 0xAA, 0xC0, 0x84, 0x46, 0x22,
  0x10, 0xED, 0xB6, 0xDB, 0xE0, 0x21, 0x95, 0x90, 0xF0, 0xCC, 0x22, 0xC6,
  0xFD, 0xB4, 0x88, 0xAF, 0x99, 0x9F, 0x27, 0x4C, 0x47, 0x08, 0x4A, 0xF4,
  0xE5, 0x2F, 0x22, 0xD3, 0xF4, 0x3C, 0x34, 0x4E, 0x44, 0x44, 0x23, 0xD3,
  0x94, 0xBC, 0x2F, 0x88, 0xAF, 0x99, 0x99, 0xDF, 0x51, 0x55, 0x70, 0x88,
  0x8B, 0xEE, 0xA9, 0xFF, 0x25, 0xFE, 0x4C, 0x99, 0x32, 0x40, 0x2F, 0x99,
  0x99, 0x22, 0xD3, 0x94, 0xB8, 0x2F, 0x99, 0x9F, 0x88, 0x22, 0xD3, 0x94,
  0xBC, 0x21, 0x3E, 0x49, 0x00, 0x2D, 0xC3, 0x1F, 0x4B, 0xA4, 0x98, 0x99,
  0x99, 0xF0, 0xDA, 0x94, 0xA2, 0x00, 0xDB, 0x5A, 0x6A, 0x6E, 0x64, 0xDB,
  0x88, 0xAD, 0x80, 0xDA, 0x94, 0xA2, 0x13, 0x80, 0xF2, 0x64, 0xF0, 0x29,
  0x2C, 0x93, 0x20, 0xFF, 0xC0, 0xC4, 0x46, 0x34, 0x44, 0x80, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 3, 1, -7 },
  { 2, 3, 2, 4, 1, -7 },
  { 3, 6, 7, 6, 0, -7 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 8, 7, 8, 0, -7 },
  { 22, 7, 7, 7, 0, -7 },
  { 29, 1, 2, 2, 1, -7 },
  { 30, 3, 9, 3, 0, -7 },
  { 34, 3, 9, 3, 0, -7 },
  { 38, 5, 5, 5, 0, -8 },
  { 42, 5, 5, 5, 0, -6 },
  { 46, 2, 2, 3, 0, -1 },
  { 47, 3, 1, 3, 0, -3 },
  { 48, 1, 1, 3, 1, -1 },
  { 49, 4, 7, 4, 0, -7 },
  { 53, 5, 7, 5, 0, -7 },
  { 58, 3, 7, 5, 1, -7 },
  { 61, 5, 7, 5, 0, -7 },
  { 66, 5, 7, 5, 0, -7 },
  { 71, 5, 7, 5, 0, -7 },
  { 76, 4, 7, 5, 1, -7 },
  { 80, 5, 7, 5, 0, -7 },
  { 85, 5, 7, 5, 0, -7 },
  { 90, 5, 7, 5, 0, -7 },
  { 95, 5, 7, 5, 0, -7 },
  { 100, 1, 6, 3, 1, -6 },
  { 101, 2, 7, 3, 0, -6 },
  { 103, 5, 5, 5, 0, -6 },
  { 107, 5, 3, 5, 0, -5 },
  { 109, 5, 5, 5, 0, -6 },
  { 113, 4, 7, 4, 0, -7 },
  { 117, 8, 8, 8, 0, -7 },
  { 125, 6, 7, 6, 0, -7 },
  { 131, 5, 7, 6, 1, -7 },
  { 136, 4, 7, 6, 1, -7 },
  { 140, 5, 7, 7, 1, -7 },
  { 145, 4, 7, 5, 1, -7 },
  { 149, 4, 7, 5, 1, -7 },
  { 153, 5, 7, 7, 1, -7 },
  { 158, 5, 7, 7, 1, -7 },
  { 163, 3, 7, 3, 0, -7 },
  { 166, 3, 9, 3, -1, -7 },
  { 170, 5, 7, 6, 1, -7 },
  { 175, 4, 7, 5, 1, -7 },
  { 179, 7, 7, 9, 1, -7 },
  { 186, 5, 7, 7, 1, -7 },
  { 191, 6, 7, 7, 1, -7 },
  { 197, 4, 7, 6, 1, -7 },
  { 201, 6, 9, 7, 1, -7 },
  { 208, 5, 7, 6, 1, -7 },
  { 213, 5, 7, 5, 0, -7 },
  { 218, 5, 7, 5, 0, -7 },
  { 223, 5, 7, 7, 1, -7 },
  { 228, 6, 7, 6, 0, -7 },
  { 234, 9, 7, 9, 0, -7 },
  { 242, 6, 7, 6, 0, -7 },
  { 248, 5, 7, 5, 0, -7 },
  { 253, 5, 7, 5, 0, -7 },
  { 258, 2, 9, 3, 1, -7 },
  { 261, 4, 7, 4, 0, -7 },
  { 265, 3, 9, 3, 0, -7 },
  { 269, 5, 4, 5, 0, -7 },
  { 272, 4, 1, 4, 0, 1 },
  { 273, 3, 2, 3, 0, -8 },
  { 274, 5, 6, 5, 0, -6 },
  { 278, 4, 8, 6, 1, -8 },
  { 282, 4, 6, 5, 0, -6 },
  { 285, 5, 8, 6, 0, -8 },
  { 290, 5, 6, 5, 0, -6 },
  { 294, 4, 8, 3, 0, -8 },
  { 298, 5, 8, 6, 0, -6 },
  { 303, 4, 8, 6, 1, -8 },
  { 307, 1, 8, 3, 1, -8 },
  { 308, 2, 10, 3, 0, -8 },
  { 311, 4, 8, 5, 1, -8 },
  { 315, 1, 8, 3, 1, -8 },
  { 316, 7, 6, 9, 1, -6 },
  { 322, 4, 6, 6, 1, -6 },
  { 325, 5, 6, 6, 0, -6 },
  { 329, 4, 8, 6, 1, -6 },
  { 333, 5, 8, 6, 0, -6 },
  { 338, 3, 6, 4, 1, -6 },
  { 341, 4, 6, 4, 0, -6 },
  { 344, 3, 7, 4, 0, -7 },
  { 347, 4, 5, 6, 1, -5 },
  { 350, 5, 5, 5, 0, -5 },
  { 354, 8, 5, 8, 0, -5 },
  { 359, 5, 5, 5, 0, -5 },
  { 363, 5, 7, 5, 0, -5 },
  { 368, 4, 5, 4, 0, -5 },
  { 371, 3, 9, 4, 0, -7 },
  { 375, 1, 10, 5, 2, -8 },
  { 377, 4, 9, 4, 0, -7 },
  { 382, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD10PT7B_H_
