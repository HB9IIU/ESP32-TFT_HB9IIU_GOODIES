#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD52PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x18, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F,
  0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFE, 0x70, 0xF1, 0xF8, 0xE0,
  0x23, 0xF1, 0xC0, 0x0F, 0xE3, 0x80, 0x0F, 0xC7, 0x00, 0x1F, 0x8E, 0x00,
  0x3F, 0x9C, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x39, 0xFE, 0x00, 0x71, 0xFC, 0x00, 0xE1, 0xF8, 0x01,
  0xC3, 0xF0, 0x03, 0x87, 0xF8, 0x07, 0x0F, 0xFC, 0x0E, 0x3F, 0xFF, 0xDF,
  0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x1F, 0x00, 0x3F,
  0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x3E, 0x03,
  0xE0, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x1F, 0x00, 0x07,
  0xC0, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xE1,
  0xF0, 0x00, 0x3E, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x0F, 0x83, 0xC0,
  0xF8, 0x3E, 0x3E, 0x1F, 0xE0, 0xF8, 0x7C, 0x7C, 0x7F, 0xE1, 0xF1, 0xF9,
  0xF1, 0xFF, 0xE3, 0xFF, 0xE3, 0xE7, 0xFF, 0xE3, 0xFF, 0xCF, 0x8F, 0x87,
  0xC3, 0xFF, 0x1F, 0x1F, 0x0F, 0x83, 0xFC, 0x7C, 0x3E, 0x1F, 0x01, 0xC0,
  0xF8, 0xF8, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x3E, 0x00, 0x07, 0xC3, 0xE0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x01, 0xF1, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xC1, 0xFF,
  0xF8, 0x0F, 0xE1, 0xFF, 0xFE, 0x07, 0xE1, 0xFE, 0x7F, 0x07, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0xFE, 0x07, 0xF1, 0xF8, 0x7F, 0x01, 0xFD, 0xFC, 0x3F,
  0x80, 0x7F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFE, 0x0F, 0xE0, 0x0F, 0xFE, 0x07,
  0xF0, 0x03, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x7F, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x3F, 0x80, 0xFF, 0xFE, 0x1F, 0xE0, 0x1F, 0xFC, 0x07,
  0xFC, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x3C, 0x1E, 0x07, 0xFE, 0x79, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x07, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xCF, 0x80, 0x3F, 0x3F, 0x01, 0xF8,
  0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0x03, 0xE0, 0x1C, 0x0E, 0x00, 0x10, 0x10,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E,
  0x3E, 0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0x80,
  0xFE, 0x7F, 0x01, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xE0,
  0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0xC3,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xBF, 0xFE, 0x3F, 0x3C, 0x3F, 0x38, 0x3F, 0x10, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x78, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x1F, 0xC0, 0xFF, 0x1E, 0x00, 0xFE, 0x10, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0x00, 0xFF, 0x18, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0xF0, 0x07, 0xFD, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7E,
  0x00, 0x0F, 0xDF, 0x80, 0x03, 0xE7, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C,
  0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xC1, 0xF8, 0x03,
  0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0C, 0x03, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE8, 0x00, 0x7F, 0xBC, 0x03, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x3E, 0x3F, 0xF0,
  0xFC, 0xFF, 0xF1, 0xFB, 0xFF, 0xF3, 0xFF, 0xFF, 0xF7, 0xFE, 0x3F, 0xEF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0xC0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0xC1,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x9F,
  0xC0, 0x7F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xF0, 0x0F, 0xC7, 0xF0, 0x3F, 0x0F, 0xF0,
  0xFE, 0x0F, 0xF7, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xE1, 0xFE,
  0x3F, 0x80, 0xFE, 0x7E, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0x7F, 0x00, 0xFE, 0xFF, 0xDF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xE0, 0xFE, 0x3F, 0x80, 0xFE, 0xFE, 0x00,
  0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFD, 0xFC, 0x07, 0xFB, 0xFE, 0x3F, 0xF3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xEF, 0xC7, 0xFF, 0xDF, 0x87, 0xFE, 0x3F, 0x01, 0xF0, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0x7E, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0x0C, 0x1F,
  0x9F, 0xCF, 0xF7, 0xFB, 0xFC, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x3F, 0x1F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF0, 0xF8, 0xFC, 0x7C,
  0x3E, 0x1F, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xF0, 0x1F, 0xC6,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x60, 0x03, 0xE1,
  0xF0, 0x0F, 0xFF, 0x0F, 0x8F, 0xC0, 0xFF, 0xFC, 0x1E, 0x3E, 0x07, 0xFF,
  0xF0, 0x7C, 0xF8, 0x3F, 0xCF, 0xC1, 0xF7, 0xC0, 0xF8, 0x1F, 0x07, 0xDF,
  0x07, 0xE0, 0x7C, 0x0F, 0x7C, 0x1F, 0x01, 0xF0, 0x3D, 0xF0, 0x7C, 0x07,
  0xC0, 0xF7, 0x83, 0xE0, 0x1F, 0x03, 0xDE, 0x0F, 0x80, 0x7C, 0x0F, 0x78,
  0x3E, 0x01, 0xF0, 0x3F, 0xE0, 0xF8, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0x3F,
  0x07, 0xDE, 0x0F, 0x80, 0xFC, 0x1F, 0x78, 0x3E, 0x03, 0xF0, 0x79, 0xE0,
  0x7C, 0x0F, 0xC3, 0xE7, 0xC1, 0xF8, 0x7F, 0x0F, 0x9F, 0x07, 0xFF, 0xDF,
  0xFC, 0x7C, 0x0F, 0xFE, 0x7F, 0xE1, 0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xE0,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0x00, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07,
  0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xF0,
  0x1F, 0xF3, 0xF8, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xE7,
  0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xE0, 0x3F,
  0xE7, 0xF0, 0x07, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFD, 0xFC, 0x0F, 0xFE, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0x80, 0xF0, 0x7F, 0x80, 0x0C, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x04, 0x1F,
  0xF8, 0x0F, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0x8F, 0xE0,
  0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF8, 0xFE, 0x01, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFC, 0x03, 0xC1, 0xFF, 0x00, 0x04, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F,
  0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x03, 0xFA, 0x1F, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3,
  0xFF, 0x0F, 0xF8, 0x04, 0x00, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF3,
  0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8,
  0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xC7, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0x87, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xF3,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xBF, 0xFD, 0xF0, 0x00, 0x7D,
  0xFF, 0xEF, 0x80, 0x07, 0xEF, 0xFF, 0x7E, 0x00, 0x3F, 0x7F, 0xFB, 0xF0,
  0x01, 0xF3, 0xFF, 0xCF, 0x80, 0x0F, 0x9F, 0xFE, 0x7E, 0x00, 0xFD, 0xFF,
  0xF3, 0xF0, 0x07, 0xCF, 0xFF, 0x8F, 0x80, 0x3E, 0x7F, 0xFC, 0x7E, 0x03,
  0xF3, 0xFF, 0xE3, 0xF0, 0x1F, 0x1F, 0xFF, 0x0F, 0x80, 0xF8, 0xFF, 0xF8,
  0x7C, 0x0F, 0xC7, 0xFF, 0xC3, 0xF0, 0x7C, 0x3F, 0xFE, 0x0F, 0x83, 0xE1,
  0xFF, 0xF0, 0x7C, 0x3F, 0x0F, 0xFF, 0x83, 0xF1, 0xF0, 0x7F, 0xFC, 0x1F,
  0x8F, 0x83, 0xFF, 0xE0, 0x7C, 0xFC, 0x1F, 0xFF, 0x03, 0xF7, 0xC0, 0xFF,
  0xF8, 0x1F, 0xBE, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFC,
  0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0x00,
  0xFF, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xEF, 0xC0, 0x0F, 0xFF,
  0x7F, 0x00, 0x7F, 0xF9, 0xFC, 0x03, 0xFF, 0xCF, 0xE0, 0x1F, 0xFE, 0x3F,
  0x80, 0xFF, 0xF1, 0xFC, 0x07, 0xFF, 0x87, 0xF0, 0x3F, 0xFC, 0x3F, 0x81,
  0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0x07, 0xF0, 0x7F, 0xF8, 0x1F, 0xC3, 0xFF,
  0xC0, 0x7E, 0x1F, 0xFE, 0x03, 0xF8, 0xFF, 0xF0, 0x0F, 0xE3, 0xFF, 0x80,
  0x7F, 0x1F, 0xFC, 0x01, 0xFC, 0xFF, 0xE0, 0x0F, 0xE7, 0xFF, 0x00, 0x3F,
  0xBF, 0xF8, 0x01, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x0F, 0xF0,
  0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x9F, 0xC3, 0xFF, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFD, 0xFC,
  0x0F, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF9,
  0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x07,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0x83, 0xFF, 0x0F, 0xE0, 0x1F, 0xE3, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE3,
  0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xF8, 0x0F, 0x1F, 0xC0, 0x0C, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0xFE, 0xFC, 0x07, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x3F, 0x9F, 0xE0, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x03,
  0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xC0,
  0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7F,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF7,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xFE, 0x00, 0xFE, 0x3F, 0x00,
  0x3F, 0xF0, 0x07, 0xE1, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0x07, 0xE0, 0x1F,
  0x7C, 0x01, 0xF8, 0x3F, 0x00, 0xFB, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xDF,
  0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xE3, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0x1F, 0x83, 0xF8, 0x0F, 0xC0, 0xF8, 0xFC, 0x1F,
  0x80, 0x7E, 0x0F, 0xC3, 0xE0, 0xFC, 0x03, 0xF8, 0x7E, 0x1F, 0x07, 0xE0,
  0x0F, 0xC3, 0xE0, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x07, 0xE3, 0xF0, 0x03,
  0xF1, 0xF8, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0xF8, 0xFC, 0x00, 0x7E,
  0x7C, 0x07, 0xC7, 0xE0, 0x03, 0xF3, 0xE0, 0x3F, 0x7F, 0x00, 0x1F, 0xBF,
  0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0x80,
  0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x0F,
  0xBE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x03,
  0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFB,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFC, 0xFC,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00,
  0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F,
  0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00,
  0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3E, 0x0F, 0xE0, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0x7F, 0x9F, 0xFD, 0xFF, 0xFD, 0xF3,
  0xFF, 0xE7, 0xCF, 0xFF, 0x1F, 0x0F, 0xF8, 0x3C, 0x06, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0xFC,
  0x7F, 0xC0, 0xFC, 0xFF, 0xE0, 0xFD, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFF, 0x01, 0xFC, 0xFF, 0x83, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xF9, 0xFF, 0xF0, 0xF8, 0xFF, 0xE0, 0xF8, 0x7F, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xC0, 0x63, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x13,
  0xFC, 0x07, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x01, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0xF8, 0x3F, 0x03, 0xFE, 0x3F, 0x0F, 0xFF, 0x3F, 0x1F,
  0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0x80, 0xFF, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0x3F,
  0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0x07,
  0xFF, 0x1F, 0x03, 0xFE, 0x1F, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xF8,
  0x7F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7F, 0x7F, 0x00, 0x7E, 0xFC, 0x00,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x9F, 0xE0, 0x06, 0x1F, 0xFB, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F,
  0xF7, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x03, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFE, 0x1F, 0x0F, 0xFF, 0x1F, 0x0F, 0xFF, 0xBF, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0x3F, 0x81, 0xFF, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0x07, 0xFF, 0x3F, 0x03, 0xFE,
  0x3F, 0x00, 0x60, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x20, 0x00, 0xFE, 0x3C, 0x01, 0xFE, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x78, 0x0F,
  0xC7, 0xFE, 0x1F, 0xBF, 0xFE, 0x3F, 0x7F, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0x03, 0xFB, 0xFC, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x3C, 0xFF, 0xFF, 0xFF,
  0xEF, 0xCF, 0x00, 0x00, 0x00, 0x03, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x80, 0x01, 0xE0, 0x3F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x07, 0xF0, 0x7F, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0,
  0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x80,
  0xFC, 0x7F, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0,
  0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8,
  0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x03, 0xE1,
  0xFF, 0x03, 0xFF, 0x0F, 0x9F, 0xFF, 0x1F, 0xFE, 0x3E, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF0,
  0x3F, 0xF0, 0x3F, 0xBF, 0x80, 0x7F, 0x80, 0x7F, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0x00,
  0x3F, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x3F,
  0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x1F, 0x01, 0xF0, 0xFF, 0xC3, 0xE7, 0xFF, 0xC7, 0xDF, 0xFF, 0xCF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xE0, 0x7F, 0x7F, 0x80, 0xFE, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0x1F, 0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x00,
  0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xEF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF,
  0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFC,
  0x7F, 0x81, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x7F, 0xC0, 0xF8, 0xFF, 0xE0, 0xF9, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xEF, 0xFC, 0xFF, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0x01, 0xFC, 0xFF, 0x83, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFD, 0xFF, 0xF0, 0xFC, 0xFF, 0xE0, 0xFC, 0x7F,
  0xC0, 0xFC, 0x04, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xFE, 0x1F, 0x0F, 0xFF, 0x1F, 0x0F, 0xFF,
  0xBF, 0x1F, 0xFF, 0xFF, 0x3F, 0xF7, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0x3F, 0xC1,
  0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0x07, 0xFF,
  0x3F, 0x03, 0xFE, 0x3F, 0x00, 0x20, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x1E, 0xF8, 0x7F, 0xF8, 0xFF, 0xF9, 0xFF,
  0xFB, 0xFF, 0xFB, 0xFE, 0xFF, 0xE2, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7,
  0xFF, 0xFD, 0xFE, 0x0F, 0xBF, 0x80, 0x27, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0xC0, 0x01,
  0x80, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x04, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0x7E, 0xFF, 0xFE, 0xFC, 0xFF, 0xF9, 0xF8, 0x7F,
  0xC3, 0xF0, 0x08, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7,
  0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF0,
  0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF3, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFE, 0x00, 0xFD, 0xF8, 0x03,
  0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3F, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F, 0xE0, 0x7F, 0x1F, 0xC1,
  0xF7, 0xC0, 0xFC, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3F, 0x07, 0xCF, 0x83,
  0xF0, 0x7E, 0x0F, 0x9F, 0x0F, 0xC0, 0xFE, 0x3E, 0x3E, 0x1F, 0x80, 0xFC,
  0x7C, 0x7C, 0x3F, 0x01, 0xF8, 0xF8, 0x7C, 0x7E, 0x03, 0xF1, 0xF0, 0xF8,
  0xF8, 0x03, 0xE3, 0xE1, 0xF3, 0xF0, 0x07, 0xEF, 0x83, 0xE7, 0xE0, 0x0F,
  0xDF, 0x03, 0xCF, 0xC0, 0x1F, 0xBE, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x0F,
  0xBE, 0x00, 0x3E, 0xF0, 0x1F, 0xFC, 0x00, 0x7D, 0xE0, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xCF, 0xE0, 0x07, 0xF3,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xFC, 0x00,
  0xFE, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0x7E,
  0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0x3F, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x0F,
  0xFE, 0x07, 0xFC, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F,
  0x00, 0xFF, 0x03, 0xFF, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x02, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x03, 0xFE, 0x40, 0x00, 0x20,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 38, 14, 3, -37 },
  { 39, 17, 13, 23, 3, -37 },
  { 67, 28, 37, 31, 1, -37 },
  { 197, 23, 42, 27, 2, -39 },
  { 318, 39, 38, 43, 2, -38 },
  { 504, 33, 39, 35, 2, -38 },
  { 665, 7, 13, 13, 3, -37 },
  { 677, 13, 45, 17, 2, -37 },
  { 751, 13, 45, 17, 1, -37 },
  { 825, 22, 23, 26, 2, -40 },
  { 889, 23, 25, 27, 2, -31 },
  { 961, 9, 13, 14, 2, -6 },
  { 976, 13, 6, 16, 2, -17 },
  { 986, 8, 8, 14, 3, -7 },
  { 994, 19, 37, 21, 1, -37 },
  { 1082, 23, 39, 27, 2, -38 },
  { 1195, 16, 37, 27, 3, -37 },
  { 1269, 23, 38, 27, 2, -38 },
  { 1379, 23, 39, 27, 2, -38 },
  { 1492, 26, 37, 27, 1, -37 },
  { 1613, 22, 38, 27, 3, -37 },
  { 1718, 23, 39, 27, 2, -38 },
  { 1831, 23, 37, 27, 2, -37 },
  { 1938, 23, 39, 27, 2, -38 },
  { 2051, 23, 39, 27, 2, -38 },
  { 2164, 8, 30, 14, 3, -29 },
  { 2194, 9, 36, 14, 2, -29 },
  { 2235, 23, 26, 27, 2, -32 },
  { 2310, 23, 15, 27, 2, -26 },
  { 2354, 23, 26, 27, 2, -32 },
  { 2429, 21, 39, 22, 0, -38 },
  { 2532, 38, 41, 43, 2, -37 },
  { 2727, 32, 37, 32, 0, -37 },
  { 2875, 25, 37, 31, 4, -37 },
  { 2991, 26, 39, 30, 3, -38 },
  { 3118, 28, 37, 34, 4, -37 },
  { 3248, 20, 37, 26, 4, -37 },
  { 3341, 20, 37, 26, 4, -37 },
  { 3434, 28, 39, 34, 3, -38 },
  { 3571, 27, 37, 36, 4, -37 },
  { 3696, 14, 37, 18, 2, -37 },
  { 3761, 14, 48, 15, -3, -37 },
  { 3845, 27, 37, 31, 4, -37 },
  { 3970, 20, 37, 25, 4, -37 },
  { 4063, 37, 37, 45, 4, -37 },
  { 4235, 29, 37, 38, 4, -37 },
  { 4370, 31, 39, 37, 3, -38 },
  { 4522, 23, 37, 29, 4, -37 },
  { 4629, 31, 47, 37, 3, -38 },
  { 4812, 26, 37, 31, 4, -37 },
  { 4933, 22, 39, 26, 2, -38 },
  { 5041, 25, 37, 27, 1, -37 },
  { 5157, 27, 38, 35, 4, -37 },
  { 5286, 30, 37, 30, 0, -37 },
  { 5425, 45, 37, 45, 0, -37 },
  { 5634, 29, 37, 29, 0, -37 },
  { 5769, 28, 37, 28, 0, -37 },
  { 5899, 24, 37, 26, 1, -37 },
  { 6010, 12, 45, 17, 4, -37 },
  { 6078, 20, 37, 21, 0, -37 },
  { 6171, 12, 45, 17, 1, -37 },
  { 6239, 26, 23, 28, 1, -37 },
  { 6314, 22, 3, 22, 0, 5 },
  { 6323, 13, 8, 17, 2, -40 },
  { 6336, 22, 30, 28, 2, -29 },
  { 6419, 24, 41, 30, 4, -40 },
  { 6542, 20, 30, 24, 2, -29 },
  { 6617, 24, 41, 30, 2, -40 },
  { 6740, 23, 30, 28, 2, -29 },
  { 6827, 19, 40, 18, 1, -40 },
  { 6922, 24, 41, 30, 2, -29 },
  { 7045, 23, 40, 30, 4, -40 },
  { 7160, 7, 39, 14, 3, -39 },
  { 7195, 12, 51, 14, -2, -39 },
  { 7272, 24, 40, 28, 4, -40 },
  { 7392, 6, 40, 14, 4, -40 },
  { 7422, 38, 29, 45, 4, -29 },
  { 7560, 23, 29, 30, 4, -29 },
  { 7644, 25, 30, 29, 2, -29 },
  { 7738, 24, 41, 30, 4, -29 },
  { 7861, 24, 41, 30, 2, -29 },
  { 7984, 16, 29, 21, 4, -29 },
  { 8042, 19, 30, 23, 2, -29 },
  { 8114, 17, 35, 19, 1, -34 },
  { 8189, 23, 29, 30, 4, -28 },
  { 8273, 26, 28, 26, 0, -28 },
  { 8364, 39, 28, 40, 0, -28 },
  { 8501, 26, 28, 26, 0, -28 },
  { 8592, 26, 40, 26, 0, -28 },
  { 8722, 19, 28, 22, 2, -28 },
  { 8789, 17, 45, 20, 1, -37 },
  { 8885, 5, 52, 26, 11, -40 },
  { 8918, 16, 45, 20, 2, -37 },
  { 9008, 23, 8, 27, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD52PT7B_H_
