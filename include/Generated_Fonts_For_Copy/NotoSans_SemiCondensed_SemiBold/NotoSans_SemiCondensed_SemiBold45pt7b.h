#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD45PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF,
  0xFF, 0x20, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xEF, 0x07, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xE0, 0xF0, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF8, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x1F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x0F, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7E, 0x61,
  0xCF, 0xC6, 0x00, 0xF8, 0x60, 0x0F, 0x86, 0x00, 0xFC, 0x60, 0x07, 0xE6,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x06, 0x7E, 0x00, 0x63, 0xF0,
  0x06, 0x3F, 0x00, 0x61, 0xF8, 0x06, 0x3F, 0xE0, 0x67, 0xEF, 0xE7, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xE0, 0x0F, 0xF8, 0x01, 0xF0, 0x0F,
  0xFE, 0x00, 0xF0, 0x07, 0x9F, 0x00, 0xF8, 0x07, 0xC7, 0xC0, 0x78, 0x03,
  0xC3, 0xE0, 0x7C, 0x01, 0xE0, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x3E, 0x00,
  0x78, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x1F, 0x00, 0x1E, 0x0F, 0x0F, 0x00,
  0x0F, 0x07, 0x8F, 0x80, 0x07, 0x83, 0xC7, 0x83, 0x83, 0xC3, 0xE7, 0xC7,
  0xF1, 0xF1, 0xF3, 0xC7, 0xFC, 0x79, 0xF3, 0xE7, 0xFF, 0x3F, 0xF9, 0xE3,
  0xC7, 0x8F, 0xF8, 0xF3, 0xE3, 0xE3, 0xF8, 0xF1, 0xE0, 0xF0, 0x30, 0x78,
  0xF0, 0x78, 0x00, 0x78, 0x78, 0x3C, 0x00, 0x3C, 0x3C, 0x1E, 0x00, 0x3C,
  0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x83, 0xC0, 0x0F,
  0x03, 0xC1, 0xE0, 0x0F, 0x01, 0xF0, 0xF0, 0x07, 0x80, 0xF8, 0xF8, 0x07,
  0xC0, 0x3E, 0xF8, 0x03, 0xC0, 0x1F, 0xFC, 0x03, 0xE0, 0x07, 0xFC, 0x03,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xF0, 0xFC,
  0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xBF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x07, 0xE1, 0xFF, 0xC0, 0x7C, 0x3F, 0xFE, 0x0F, 0xC7, 0xF7,
  0xF0, 0xFC, 0xFE, 0x3F, 0x8F, 0x8F, 0xC1, 0xF9, 0xF8, 0xFC, 0x0F, 0xDF,
  0x8F, 0x80, 0x7F, 0xF0, 0xF8, 0x03, 0xFF, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xDF, 0xC1, 0xFF, 0xF8, 0xFE, 0x07, 0xFE, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0xF8, 0x1E, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80,
  0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x06, 0x0F, 0x02, 0x7C, 0xF1,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFE, 0x00, 0x7D, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x1F,
  0x0F, 0xC0, 0xF0, 0x70, 0x02, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x3E, 0xFD, 0xFB, 0xE7, 0xCF, 0xBE, 0x7C, 0xF9, 0xE3, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFF, 0xF2, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xF1, 0xFC, 0x7E,
  0x07, 0xC7, 0xC0, 0x7E, 0x7C, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x03, 0xE7, 0xC0,
  0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x3F, 0x9F, 0xC3, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F,
  0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFC, 0xFD, 0xE3,
  0xF2, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC7, 0xE1, 0xFC, 0x78, 0x07, 0xE3, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xC1, 0xFC, 0x30, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE8, 0x00, 0xFE,
  0xF0, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3D, 0xF0, 0x01,
  0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1E, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3E, 0x7F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0xC0, 0x0F,
  0xEF, 0x83, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFE, 0x03, 0xFF,
  0xC0, 0x00, 0x02, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC1, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x18, 0x0F, 0x9F, 0xF0,
  0xFB, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF0, 0x7E, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0x3F,
  0x8F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xE0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x07, 0xE7, 0xE0, 0x7C, 0x3F, 0x0F, 0xC3, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x87,
  0xF1, 0xFC, 0x7E, 0x0F, 0xEF, 0xC0, 0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07,
  0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00,
  0x40, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x87,
  0xF1, 0xFC, 0xFC, 0x07, 0xCF, 0xC0, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFD, 0xF3, 0xFF,
  0x9F, 0x0F, 0xF3, 0xE0, 0x10, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x40, 0x7F, 0x83,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7B, 0xFF,
  0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78,
  0xF8, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F,
  0x07, 0xF2, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x3C, 0x1E, 0x01, 0xF8, 0x1F, 0x1E, 0x03, 0xFF, 0x87, 0x8F, 0x07,
  0xFF, 0xC3, 0xCF, 0x87, 0xFF, 0xE1, 0xF7, 0x83, 0xE0, 0xF0, 0x7B, 0xC3,
  0xE0, 0x78, 0x3D, 0xE1, 0xE0, 0x3C, 0x1F, 0xE0, 0xF0, 0x1E, 0x0F, 0xF0,
  0x78, 0x0F, 0x07, 0xF8, 0x7C, 0x0F, 0x83, 0xFC, 0x3E, 0x07, 0xC1, 0xFE,
  0x0F, 0x03, 0xE0, 0xFF, 0x07, 0x81, 0xF0, 0xF7, 0x83, 0xC0, 0xF8, 0x7B,
  0xE1, 0xF0, 0xFC, 0x7C, 0xF0, 0xFF, 0xFF, 0xFC, 0x78, 0x3F, 0xF7, 0xFC,
  0x3C, 0x0F, 0xF1, 0xFC, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01,
  0x00, 0x0F, 0xE0, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3F,
  0x00, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x83, 0xFF, 0x7C,
  0x03, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F,
  0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3E, 0x01, 0xFD,
  0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFE, 0x0F, 0x07, 0xF0, 0x02, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x41, 0xFF, 0xCF, 0x81, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0x00, 0xFF, 0x3E, 0x00, 0x7F, 0x7C, 0x00, 0xFE, 0xF8, 0x00, 0xFD, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8, 0x01, 0xFD, 0xF0, 0x07, 0xF3,
  0xE0, 0x3F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xC0, 0xF0, 0x7F, 0x80, 0x08, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xDF, 0x00, 0xFF,
  0xEF, 0x80, 0x7F, 0xF7, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xE0,
  0x07, 0xE3, 0xF8, 0x03, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x87, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F,
  0x03, 0xF0, 0x7F, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xF8,
  0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80,
  0x7E, 0x1F, 0x01, 0xF8, 0x3E, 0x07, 0xF0, 0x7C, 0x0F, 0xC0, 0xF8, 0x3F,
  0x01, 0xF0, 0xFC, 0x03, 0xE3, 0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x9F, 0x80,
  0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xFB, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0x83, 0xF0, 0x1F,
  0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0,
  0x1F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x9F, 0x00,
  0x3F, 0x3E, 0x00, 0x7F, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xBF, 0xF7, 0xC0, 0x1F, 0x7F, 0xEF, 0x80, 0x3E, 0xFF, 0xDF, 0x00,
  0x79, 0xFF, 0x9E, 0x01, 0xF3, 0xFF, 0x3E, 0x03, 0xE7, 0xFE, 0x7C, 0x07,
  0x8F, 0xFC, 0x78, 0x1F, 0x1F, 0xF8, 0xF8, 0x3E, 0x3F, 0xF1, 0xF0, 0x78,
  0x7F, 0xE1, 0xE1, 0xF0, 0xFF, 0xC3, 0xE3, 0xE1, 0xFF, 0x87, 0xC7, 0x83,
  0xFF, 0x0F, 0x9F, 0x07, 0xFE, 0x0F, 0xBE, 0x0F, 0xFC, 0x1F, 0x78, 0x1F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0x80, 0xFF,
  0xC0, 0xFF, 0x01, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0x01, 0xF8, 0x07, 0xFE,
  0x03, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFD,
  0xF8, 0x07, 0xFE, 0xFC, 0x03, 0xFF, 0x3F, 0x01, 0xFF, 0x8F, 0x80, 0xFF,
  0xC7, 0xE0, 0x7F, 0xE1, 0xF8, 0x3F, 0xF0, 0xFC, 0x1F, 0xF8, 0x3F, 0x0F,
  0xFC, 0x1F, 0x87, 0xFE, 0x07, 0xE3, 0xFF, 0x03, 0xF1, 0xFF, 0x80, 0xFC,
  0xFF, 0xC0, 0x7E, 0x7F, 0xE0, 0x1F, 0xBF, 0xF0, 0x0F, 0xDF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x7E, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x03,
  0xF8, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0x80, 0xFE, 0xF8, 0x07,
  0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x0F, 0xF8,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFE, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x80,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xE0, 0x3F, 0x8F, 0x80, 0x7E, 0x3E, 0x00,
  0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xF8,
  0xF8, 0x07, 0xE3, 0xE0, 0x3F, 0x8F, 0x83, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x3F,
  0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0x0F, 0xC3,
  0xE0, 0x3F, 0x8F, 0x80, 0x7E, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0,
  0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x3F, 0x00, 0x70, 0x00, 0xFF, 0xE0,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0x1F, 0x1F, 0x80, 0x67,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xEF, 0xE3, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x3F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7D, 0xF8, 0x01, 0xF9, 0xF8, 0x07, 0xF3, 0xFE, 0x3F, 0xC3, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0x7E,
  0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0xF8,
  0x00, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xF0,
  0x03, 0xE7, 0xE0, 0x0F, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0xE0, 0x1F, 0x8F,
  0x80, 0x7F, 0xC0, 0x3F, 0x1F, 0x00, 0xFF, 0x80, 0x7C, 0x3E, 0x01, 0xEF,
  0x00, 0xF8, 0x7E, 0x03, 0xDF, 0x01, 0xF0, 0x7C, 0x0F, 0xBE, 0x07, 0xE0,
  0xF8, 0x1F, 0x7C, 0x0F, 0xC1, 0xF0, 0x3E, 0x78, 0x1F, 0x03, 0xF0, 0x78,
  0xF8, 0x3E, 0x03, 0xE1, 0xF1, 0xF0, 0xFC, 0x07, 0xC3, 0xE3, 0xE1, 0xF8,
  0x0F, 0x87, 0xC3, 0xC3, 0xE0, 0x1F, 0x0F, 0x07, 0xC7, 0xC0, 0x3F, 0x3E,
  0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x1E, 0x7C,
  0x00, 0xF9, 0xE0, 0x3C, 0xF8, 0x01, 0xF3, 0xC0, 0x7D, 0xF0, 0x01, 0xFF,
  0x80, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x1F,
  0x8F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xE3, 0xF0, 0x01, 0xF9,
  0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7E, 0x00,
  0x1F, 0x9F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE1, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1,
  0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF7,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xCF, 0x80, 0x1E, 0x1E, 0x00,
  0xF8, 0x7C, 0x03, 0xC0, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x81, 0xE0,
  0x1F, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF9, 0xF0, 0x01, 0xE7, 0x80, 0x07,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x78, 0x01, 0xFC, 0x01,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xF1, 0xFC, 0x30, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0x8F,
  0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFE, 0xF9, 0xFF, 0x8F, 0x1F, 0xE1, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x3F,
  0x3F, 0xE1, 0xFB, 0xFF, 0x8F, 0xBF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFC, 0x1F,
  0xDF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7D, 0xFC, 0x07, 0xEF, 0xE0,
  0x3F, 0x7F, 0x87, 0xF3, 0xFF, 0xFF, 0x9F, 0x7F, 0xF8, 0xF9, 0xFF, 0x87,
  0xC7, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF3,
  0xFF, 0xF1, 0xF8, 0x09, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x13, 0xF8, 0x79,
  0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x0F, 0xC3,
  0xFE, 0x7E, 0x3F, 0xFB, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFC, 0x1F,
  0xEF, 0xC0, 0x7F, 0x7E, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x03, 0xF7, 0xE0,
  0x3F, 0xBF, 0x83, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xDF, 0x0F, 0xFC, 0xF8,
  0x3F, 0xC7, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF,
  0xFC, 0x3F, 0x8F, 0xC7, 0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x02, 0x3F, 0x80, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFE, 0x1F, 0xC2, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0xC7, 0xC7, 0xFF, 0x3E, 0x7F, 0xFD,
  0xF3, 0xFF, 0xFF, 0xBF, 0x83, 0xFD, 0xF8, 0x0F, 0xEF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x07, 0xF7, 0xF0, 0x7F, 0x9F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xBF, 0x07, 0xF9, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x20, 0x01, 0xF9, 0xC0, 0x1F, 0xCF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC3, 0xE0, 0xFC, 0xFF, 0x8F, 0x9F, 0xFC, 0xFB, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0xFF,
  0xDF, 0xFB, 0xFE, 0x7F, 0x87, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0xFD, 0xF8,
  0x0F, 0xCF, 0xC0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x87, 0xE0,
  0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x01, 0xFB, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x7E, 0x07,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x07,
  0xE3, 0xF0, 0x1F, 0x9F, 0x80, 0xFE, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x7C, 0xFF, 0xC3, 0xFF, 0x3E, 0xFF,
  0xF3, 0xFF, 0xDF, 0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xC1, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xF8, 0x07, 0xE0, 0x3F, 0xFC,
  0x03, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0xF8, 0x03, 0xFF,
  0x80, 0x7C, 0x01, 0xFF, 0xC0, 0x3E, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x7F,
  0xF0, 0x0F, 0x80, 0x3F, 0xF8, 0x07, 0xC0, 0x1F, 0xFC, 0x03, 0xE0, 0x0F,
  0xFE, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7C, 0x01,
  0xFF, 0xC0, 0x3E, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x7F, 0xF0, 0x0F, 0x80,
  0x3F, 0xF8, 0x07, 0xC0, 0x1F, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E,
  0x0F, 0x8F, 0xF8, 0xFB, 0xFF, 0xCF, 0xBF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x3F, 0x81, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFB, 0xE0, 0x0F,
  0xDF, 0x80, 0x7C, 0xFC, 0x07, 0xE3, 0xF0, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0x07, 0xC7, 0xFC,
  0x3E, 0x7F, 0xF1, 0xF7, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x83, 0xFB, 0xF8,
  0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x80, 0xFD, 0xFC, 0x07, 0xEF,
  0xF8, 0xFE, 0x7F, 0xFF, 0xF3, 0xEF, 0xFF, 0x1F, 0xBF, 0xF0, 0xFC, 0xFF,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC7, 0xC7,
  0xFF, 0x3E, 0x7F, 0xFD, 0xF3, 0xFF, 0xFF, 0xBF, 0x83, 0xFD, 0xF8, 0x0F,
  0xEF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x07, 0xF7, 0xF0,
  0x7F, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xBF, 0x07, 0xF1, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE3, 0xFF, 0x9F, 0xFE, 0xFF,
  0xFB, 0xFF, 0xFF, 0xBF, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFE, 0xFE, 0x3E, 0xF8,
  0x06, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFC, 0x7F, 0xF0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E,
  0x11, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xF7, 0xF1, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xDF, 0x3F, 0xF9, 0xF0, 0xFF, 0x0F, 0xFC, 0x00, 0xFD, 0xF0,
  0x03, 0xF7, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xFC, 0x07,
  0xC3, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0x80,
  0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xDF, 0x00, 0xFE, 0x03, 0xE7, 0xE0,
  0x7F, 0x80, 0xF9, 0xF8, 0x1F, 0xE0, 0x3E, 0x3E, 0x07, 0xF8, 0x1F, 0x8F,
  0x81, 0xFF, 0x07, 0xC3, 0xF0, 0xFB, 0xC1, 0xF0, 0xFC, 0x3C, 0xF0, 0x7C,
  0x1F, 0x0F, 0x3C, 0x3F, 0x07, 0xC3, 0xCF, 0x8F, 0x81, 0xF1, 0xF1, 0xE3,
  0xE0, 0x7E, 0x7C, 0x78, 0xF8, 0x0F, 0x9E, 0x1E, 0x7E, 0x03, 0xE7, 0x87,
  0xDF, 0x00, 0xF9, 0xE1, 0xF7, 0xC0, 0x1E, 0xF8, 0x3D, 0xF0, 0x07, 0xFC,
  0x0F, 0x7C, 0x01, 0xFF, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0xFC,
  0x07, 0xE3, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F,
  0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7E,
  0x07, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0xBF,
  0x80, 0x3F, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0x9F, 0x80,
  0x3E, 0x3E, 0x01, 0xF8, 0xFC, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xFC,
  0x1F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7E, 0x03, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC3,
  0xFE, 0x0F, 0xF0, 0x3E, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x03, 0xFC, 0x07,
  0xF0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x03, 0xFC, 0x1F, 0xF0, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFC, 0x80, 0x03, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 33, 12, 3, -32 },
  { 26, 14, 11, 20, 3, -32 },
  { 46, 25, 32, 26, 1, -32 },
  { 146, 20, 37, 24, 2, -34 },
  { 239, 33, 33, 37, 2, -33 },
  { 376, 28, 33, 30, 2, -33 },
  { 492, 5, 11, 11, 3, -32 },
  { 499, 11, 39, 14, 2, -32 },
  { 553, 11, 39, 14, 1, -32 },
  { 607, 20, 19, 23, 1, -34 },
  { 655, 20, 22, 24, 2, -27 },
  { 710, 7, 11, 12, 2, -5 },
  { 720, 12, 4, 14, 1, -14 },
  { 726, 6, 7, 12, 3, -6 },
  { 732, 17, 32, 18, 0, -32 },
  { 800, 20, 33, 24, 2, -33 },
  { 883, 14, 32, 24, 3, -32 },
  { 939, 20, 33, 24, 2, -33 },
  { 1022, 20, 33, 24, 2, -33 },
  { 1105, 22, 32, 24, 1, -32 },
  { 1193, 20, 32, 24, 2, -32 },
  { 1273, 20, 33, 24, 2, -33 },
  { 1356, 21, 32, 24, 1, -32 },
  { 1440, 20, 33, 24, 2, -33 },
  { 1523, 20, 33, 24, 2, -33 },
  { 1606, 6, 26, 12, 3, -25 },
  { 1626, 8, 31, 12, 1, -25 },
  { 1657, 20, 22, 24, 2, -27 },
  { 1712, 20, 13, 24, 2, -22 },
  { 1745, 20, 22, 24, 2, -27 },
  { 1800, 18, 34, 19, 0, -33 },
  { 1877, 33, 36, 37, 2, -32 },
  { 2026, 27, 32, 27, 0, -32 },
  { 2134, 21, 32, 27, 4, -32 },
  { 2218, 23, 33, 26, 2, -33 },
  { 2313, 23, 32, 30, 4, -32 },
  { 2405, 16, 32, 23, 4, -32 },
  { 2469, 16, 32, 22, 4, -32 },
  { 2533, 25, 33, 30, 2, -33 },
  { 2637, 23, 32, 31, 4, -32 },
  { 2729, 13, 32, 16, 1, -32 },
  { 2781, 12, 41, 13, -3, -32 },
  { 2843, 23, 32, 27, 4, -32 },
  { 2935, 17, 32, 22, 4, -32 },
  { 3003, 31, 32, 39, 4, -32 },
  { 3127, 25, 32, 33, 4, -32 },
  { 3227, 28, 33, 32, 2, -33 },
  { 3343, 20, 32, 25, 4, -32 },
  { 3423, 28, 41, 32, 2, -33 },
  { 3567, 22, 32, 26, 4, -32 },
  { 3655, 19, 33, 23, 2, -33 },
  { 3734, 21, 32, 23, 1, -32 },
  { 3818, 23, 32, 30, 4, -32 },
  { 3910, 26, 32, 26, 0, -32 },
  { 4014, 39, 32, 39, 0, -32 },
  { 4170, 25, 32, 26, 0, -32 },
  { 4270, 24, 32, 24, 0, -32 },
  { 4366, 21, 32, 23, 1, -32 },
  { 4450, 10, 39, 15, 3, -32 },
  { 4499, 17, 32, 18, 0, -32 },
  { 4567, 10, 39, 15, 1, -32 },
  { 4616, 22, 20, 25, 1, -32 },
  { 4671, 19, 3, 19, 0, 4 },
  { 4679, 11, 7, 14, 2, -34 },
  { 4689, 19, 25, 24, 2, -25 },
  { 4749, 21, 34, 26, 3, -34 },
  { 4839, 17, 25, 21, 2, -25 },
  { 4893, 21, 34, 26, 2, -34 },
  { 4983, 20, 25, 24, 2, -25 },
  { 5046, 16, 34, 15, 1, -34 },
  { 5114, 21, 36, 26, 2, -25 },
  { 5209, 20, 34, 26, 3, -34 },
  { 5294, 6, 34, 12, 3, -34 },
  { 5320, 11, 45, 12, -2, -34 },
  { 5382, 21, 34, 24, 3, -34 },
  { 5472, 6, 34, 12, 3, -34 },
  { 5498, 33, 25, 39, 3, -25 },
  { 5602, 20, 25, 26, 3, -25 },
  { 5665, 21, 25, 25, 2, -25 },
  { 5731, 21, 36, 26, 3, -25 },
  { 5826, 21, 36, 26, 2, -25 },
  { 5921, 14, 25, 18, 3, -25 },
  { 5965, 16, 25, 20, 2, -25 },
  { 6015, 14, 30, 17, 1, -30 },
  { 6068, 20, 24, 26, 3, -24 },
  { 6128, 22, 24, 22, 0, -24 },
  { 6194, 34, 24, 34, 0, -24 },
  { 6296, 22, 24, 23, 0, -24 },
  { 6362, 22, 35, 23, 0, -24 },
  { 6459, 17, 24, 19, 1, -24 },
  { 6510, 14, 39, 17, 1, -32 },
  { 6579, 5, 44, 23, 9, -34 },
  { 6607, 14, 39, 17, 2, -32 },
  { 6676, 20, 7, 24, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD45PT7B_H_
