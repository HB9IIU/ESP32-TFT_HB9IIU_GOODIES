#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0xDC, 0xE7, 0x39, 0xCE, 0x70,
  0x00, 0xEF, 0xFF, 0xFF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x73, 0x8E, 0x71, 0xC0, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x38, 0xE0,
  0x0E, 0x38, 0x07, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0xE1, 0xFF, 0xFF, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF0, 0xF1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x8E,
  0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0x0E, 0x01, 0xC3, 0x80,
  0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x07, 0xFC, 0x3F, 0xFD, 0xFF, 0xFF, 0xB3, 0xBC,
  0xC0, 0xF3, 0x03, 0xCC, 0x0F, 0xB0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x03, 0x7C, 0x0C, 0xF0, 0x31, 0xE0, 0xCF, 0xC3, 0x3F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0x08, 0x0F, 0xC0, 0x1C, 0x07, 0xF8, 0x0F, 0x01, 0xEF, 0x03,
  0x80, 0x71, 0xC1, 0xE0, 0x3C, 0x70, 0x70, 0x0F, 0x1C, 0x3C, 0x03, 0xC7,
  0x0E, 0x00, 0xF1, 0xC7, 0x80, 0x3C, 0x71, 0xC0, 0x0F, 0x1C, 0xF1, 0xC1,
  0xC7, 0x39, 0xFC, 0x73, 0xDE, 0xFF, 0x9F, 0xE7, 0x3C, 0xE3, 0xF3, 0xCE,
  0x38, 0x30, 0xE3, 0x8F, 0x00, 0x39, 0xE3, 0xC0, 0x1C, 0x78, 0xF0, 0x07,
  0x1E, 0x3C, 0x03, 0x83, 0x8F, 0x00, 0xE0, 0xE3, 0x80, 0x70, 0x38, 0xE0,
  0x1C, 0x0F, 0xF8, 0x0E, 0x01, 0xFC, 0x07, 0x80, 0x3E, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3E, 0x3C, 0x00,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x7C, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0xF8, 0xFF, 0x83,
  0xC7, 0xFF, 0x0F, 0x1F, 0x3E, 0x7C, 0x78, 0x7D, 0xE3, 0xE0, 0xFF, 0x8F,
  0x81, 0xFC, 0x3E, 0x03, 0xF0, 0x78, 0x0F, 0x81, 0xF8, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0x7C, 0x0F, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0x70,
  0x07, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0xF0, 0x78, 0x38,
  0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x07, 0x07,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1C, 0x3C, 0x38,
  0x78, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x04, 0x38, 0x5F,
  0x77, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7,
  0x83, 0xC7, 0x83, 0x8E, 0x02, 0x08, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x3C, 0xF7, 0x9E, 0x79, 0xC7, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x77, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xC0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x7C, 0x3E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x03,
  0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xDF, 0xF7, 0xDC, 0xF9, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0x80, 0x1F, 0xF0,
  0x3F, 0xF8, 0xFF, 0xFC, 0x78, 0x7C, 0x20, 0x3E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00,
  0x7F, 0xE3, 0xFF, 0xE3, 0xFF, 0xE7, 0x03, 0xE4, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xFF,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8,
  0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x7F, 0xFC, 0x7F, 0xE0, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xB8, 0x07, 0xF8, 0x07,
  0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x38, 0x78, 0x70,
  0x78, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x7F, 0xF9, 0xFF,
  0xE7, 0xFF, 0x9E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0x60, 0xFC, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0xE1, 0xFB, 0xFF, 0xEF,
  0xFF, 0x1F, 0xF0, 0x00, 0x38, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x40, 0x73,
  0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8,
  0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x7C, 0x1E, 0x3E, 0x3E, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3E,
  0x7C, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF8, 0x3E, 0xFC, 0x7C,
  0x3E, 0x78, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1E, 0x7C,
  0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x00, 0x0F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x7C, 0x7C, 0x78, 0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0x78, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F,
  0xEE, 0x1F, 0xDE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7C, 0x01, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0x77, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xDF, 0xFF, 0xFE, 0x39, 0xF7, 0xDF,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x7D, 0xE7, 0x9E,
  0x71, 0xCF, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xFF, 0x8F, 0xFF,
  0x1F, 0xFE, 0x70, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xC1, 0xF8,
  0x1F, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x78, 0x3F, 0x8E,
  0x70, 0xFF, 0xC7, 0xF1, 0xFF, 0xC7, 0xE1, 0xE3, 0xC7, 0xE3, 0xC3, 0xC7,
  0xE3, 0x83, 0xC7, 0xE3, 0x83, 0xC7, 0xE3, 0x83, 0x87, 0xE3, 0x83, 0x87,
  0xE3, 0x83, 0x87, 0xE3, 0xC7, 0x8F, 0xE1, 0xEF, 0xFE, 0xE1, 0xFE, 0xFC,
  0xF0, 0xFC, 0x78, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3D,
  0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00,
  0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x83,
  0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0x00, 0xF8, 0xF8, 0x03, 0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0xFB, 0xE0, 0x03,
  0xDF, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x7E, 0xF0,
  0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x7C, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xE0, 0x00, 0x60, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE3,
  0xF0, 0x73, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x78, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE3, 0xC3, 0xF8, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x00,
  0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC,
  0x03, 0xEF, 0x01, 0xF3, 0xC0, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFE,
  0x3F, 0x81, 0x8F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF7, 0x80, 0x3D, 0xF0, 0x0F,
  0x7E, 0x03, 0xCF, 0xE1, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x80,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF7, 0xF8, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x3F, 0xEF, 0xFF, 0xFF, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x87, 0xC3, 0xFF, 0xEF, 0xF7, 0xF3, 0xE0, 0xF0, 0x0F, 0xF8, 0x0F,
  0xBC, 0x0F, 0x9E, 0x07, 0x8F, 0x07, 0x87, 0x87, 0xC3, 0xC7, 0xC1, 0xE3,
  0xC0, 0xF3, 0xE0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFF, 0x03, 0xE7, 0x81, 0xE3, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1F,
  0x1E, 0x07, 0x8F, 0x03, 0xE7, 0x80, 0xFB, 0xC0, 0x7D, 0xE0, 0x1F, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xEE, 0x00, 0xFF, 0xFF, 0x00, 0xEF, 0xFF, 0x01, 0xEF, 0xF7,
  0x01, 0xEF, 0xF7, 0x01, 0xCF, 0xF7, 0x83, 0xCF, 0xF7, 0x83, 0xCF, 0xF3,
  0x83, 0x8F, 0xF3, 0xC3, 0x8F, 0xF3, 0xC7, 0x8F, 0xF1, 0xC7, 0x0F, 0xF1,
  0xE7, 0x0F, 0xF1, 0xEF, 0x0F, 0xF0, 0xEE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0,
  0x78, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xDE, 0x03, 0xFF, 0xE0, 0x7F, 0xBC, 0x0F, 0xF7, 0xC1, 0xFE,
  0x78, 0x3F, 0xCF, 0x87, 0xF8, 0xF0, 0xFF, 0x1F, 0x1F, 0xE1, 0xE3, 0xFC,
  0x1E, 0x7F, 0x83, 0xEF, 0xF0, 0x3D, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00,
  0x60, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x07, 0xC7,
  0xC0, 0x3E, 0x7C, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0,
  0x3E, 0x7E, 0x03, 0xE3, 0xF9, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0x87, 0xEF, 0x03, 0xDE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xF7, 0x9F,
  0xEF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0x60, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x07, 0xC7,
  0xC0, 0x3E, 0x7C, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0,
  0x3E, 0x7E, 0x03, 0xE3, 0xF9, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1E,
  0x1F, 0x8F, 0x03, 0xE7, 0x81, 0xF3, 0xC0, 0x79, 0xE0, 0x7C, 0xF0, 0x3E,
  0x78, 0x1E, 0x3C, 0x1F, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xC7,
  0x81, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1F, 0x1E, 0x07, 0x8F,
  0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x7D, 0xE0, 0x1F, 0x01, 0x80, 0x1F, 0xFC,
  0xFF, 0xF1, 0xFF, 0xE7, 0xC1, 0xCF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xFC, 0x03, 0xDF,
  0x1F, 0xBF, 0xFE, 0x7F, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0x01, 0xF7, 0xE3, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xF0, 0xF0, 0x01,
  0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3C, 0x7C, 0x03, 0xC3, 0xC0,
  0x3C, 0x3C, 0x07, 0xC3, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x1E,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x07, 0x9E, 0x00,
  0x79, 0xE0, 0x07, 0x9C, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x7F, 0xE0, 0x3E, 0x01, 0xE7, 0x80, 0xF8, 0x07, 0x9E, 0x03, 0xF0,
  0x1E, 0x78, 0x0F, 0xC0, 0xF9, 0xF0, 0x7F, 0x03, 0xC3, 0xC1, 0xFC, 0x0F,
  0x0F, 0x07, 0x78, 0x3C, 0x3C, 0x1D, 0xE1, 0xF0, 0xF0, 0xF3, 0x87, 0x81,
  0xE3, 0xCE, 0x1E, 0x07, 0x8F, 0x3C, 0x78, 0x1E, 0x38, 0xF1, 0xE0, 0x79,
  0xE1, 0xCF, 0x00, 0xE7, 0x87, 0x3C, 0x03, 0xDE, 0x1E, 0xF0, 0x0F, 0x70,
  0x7B, 0xC0, 0x3D, 0xC0, 0xEE, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x0F,
  0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE7, 0x80, 0xF8, 0xF8, 0x1E, 0x0F,
  0x07, 0xC1, 0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0xE7, 0x80, 0x3D, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0xBE, 0x01, 0xE3, 0xC0, 0x7C,
  0x3C, 0x0F, 0x07, 0xC3, 0xE0, 0x78, 0x78, 0x0F, 0x9F, 0x00, 0xF7, 0xC0,
  0x1F, 0xF8, 0x03, 0xEF, 0x00, 0xF9, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xE0,
  0xF0, 0x3C, 0x3E, 0x07, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x00, 0xF7,
  0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x73, 0x80, 0x39, 0xE0, 0x3C,
  0x70, 0x1C, 0x3C, 0x1E, 0x0E, 0x0E, 0x07, 0x8F, 0x01, 0xC7, 0x00, 0xF7,
  0x80, 0x3B, 0x80, 0x1E, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E,
  0x07, 0x03, 0xC0, 0x3F, 0xF0, 0xFF, 0xF0, 0xF3, 0xE1, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x0F, 0xFE, 0x7F, 0xFD, 0xFC, 0x7B, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x3F, 0x7F, 0xFE, 0xFF, 0xBC, 0xFE,
  0x38, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0xE0, 0xF3, 0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC,
  0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xFC, 0x3E, 0xFF,
  0xFC, 0xF7, 0xFC, 0xF3, 0xF8, 0x07, 0xC0, 0xFF, 0xCF, 0xFC, 0xFF, 0xE7,
  0x81, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x86, 0x7F, 0xF1, 0xFF, 0x83, 0xFC,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x87, 0x8F, 0x3F, 0xDE, 0xFF, 0xFD, 0xFF, 0xFF, 0xC1, 0xFF, 0x83,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFF, 0x07, 0xDF, 0x1F, 0xBF, 0xFF, 0x3F, 0xDE, 0x3F,
  0x1C, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xC7, 0x83, 0xDE, 0x07,
  0xBC, 0x07, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x06, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F,
  0xE0, 0x07, 0xE0, 0xFF, 0x1F, 0xE3, 0xF6, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0xFF, 0xCF, 0xFC, 0xFF, 0xC3, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x7F, 0xBD, 0xFF, 0xFB, 0xFF, 0xFF,
  0x83, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xBE, 0x3F, 0x7F, 0xFE,
  0x7F, 0xBC, 0x7E, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xB8,
  0x7E, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x78, 0xF3, 0xFD,
  0xEF, 0xFB, 0xFF, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3C, 0x27, 0xFF, 0xF7, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x04, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0xBE, 0xFE, 0xFC, 0xF8, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x7D, 0xE0, 0xF3, 0xC3, 0xC7, 0x8F, 0x8F, 0x3E, 0x1E,
  0xF8, 0x3D, 0xE0, 0x77, 0x80, 0xFF, 0x81, 0xFF, 0x83, 0xEF, 0x07, 0x8F,
  0x0F, 0x1F, 0x1E, 0x1E, 0x3C, 0x3E, 0x78, 0x3E, 0xF0, 0x3D, 0xE0, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x3C, 0x79, 0xFC, 0x7F, 0xBD,
  0xFF, 0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFF, 0xC0, 0xF8, 0x3F,
  0xE0, 0x78, 0x1F, 0xF0, 0x3C, 0x0F, 0xF8, 0x1E, 0x07, 0xFC, 0x0F, 0x03,
  0xFE, 0x07, 0x81, 0xFF, 0x03, 0xC0, 0xFF, 0x81, 0xE0, 0x7F, 0xC0, 0xF0,
  0x3F, 0xE0, 0x78, 0x1F, 0xF0, 0x3C, 0x0F, 0xF8, 0x1E, 0x07, 0xFC, 0x0F,
  0x03, 0xFE, 0x07, 0x81, 0xE0, 0x00, 0xE1, 0xE7, 0xFB, 0xDF, 0xF7, 0xFF,
  0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x78, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xFC, 0x78, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3E, 0x7C,
  0x7C, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0x01, 0xE0, 0xF3, 0xF8, 0xF7,
  0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1E, 0xFC, 0x3E, 0xFF, 0xFC, 0xF7, 0xFC, 0xF3, 0xF8, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x7F, 0xBD, 0xFF, 0xFB, 0xFF, 0xFF, 0x83, 0xFF, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xBE, 0x3F, 0x7F, 0xFE, 0x7F, 0xBC, 0x7E,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xFE, 0x7F, 0xDF, 0xFF, 0xFF, 0xE1, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xFF, 0xDF, 0xFC,
  0xF9, 0xEF, 0x01, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x80, 0xFF, 0x03,
  0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xFC, 0x1F, 0xFF, 0xF7, 0xFF,
  0x9F, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x0F, 0xFD, 0xFF, 0xBF, 0xF1,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF8, 0x9F, 0xF1, 0xFE, 0x1F, 0xC0, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x07, 0xDF,
  0x1F, 0xBF, 0xFF, 0x3F, 0xEE, 0x3F, 0x9C, 0xF8, 0x0F, 0xBC, 0x07, 0x9E,
  0x03, 0xCF, 0x83, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x78,
  0x1E, 0x3C, 0x0F, 0x1E, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x3B,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x3F,
  0x07, 0xDE, 0x0F, 0xC1, 0xE7, 0x83, 0xF0, 0x79, 0xE0, 0xFC, 0x1E, 0x3C,
  0x7F, 0x0F, 0x0F, 0x1C, 0xE3, 0xC3, 0xC7, 0x38, 0xF0, 0xF1, 0xCE, 0x3C,
  0x1E, 0x73, 0x9E, 0x07, 0xBC, 0xF7, 0x81, 0xEE, 0x1D, 0xE0, 0x7B, 0x87,
  0x78, 0x0E, 0xE1, 0xDC, 0x03, 0xB8, 0x77, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x9E,
  0x0F, 0x0F, 0x8F, 0x83, 0xC7, 0x80, 0xF7, 0xC0, 0x7B, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xEF, 0x00, 0xF7,
  0x80, 0xF1, 0xE0, 0xF8, 0xF8, 0x78, 0x3C, 0x7C, 0x1F, 0x7C, 0x07, 0xC0,
  0xF8, 0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x83, 0xE3, 0xC1, 0xE1, 0xE0,
  0xF0, 0x78, 0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x07, 0x1E, 0x03, 0xDE, 0x01,
  0xEF, 0x00, 0x77, 0x80, 0x3B, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x02, 0x7E,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFC, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xC1, 0xF0, 0xFC, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x78, 0x3E, 0x3F, 0x0F, 0x03, 0xF0, 0x3E, 0x07,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xFC,
  0x3F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x1F, 0x83, 0xF8, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0xC0,
  0x78, 0x3F, 0x0F, 0x83, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC3, 0xF8, 0x7E, 0x0F, 0x80, 0x08, 0x01, 0x7F, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFE, 0x80, 0x10,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 11, 9, 15, 2, -24 },
  { 29, 18, 24, 20, 1, -24 },
  { 83, 14, 28, 18, 2, -26 },
  { 132, 26, 25, 28, 1, -25 },
  { 214, 22, 25, 23, 1, -25 },
  { 283, 4, 9, 8, 2, -24 },
  { 288, 9, 29, 11, 1, -24 },
  { 321, 8, 29, 11, 1, -24 },
  { 350, 15, 15, 17, 1, -26 },
  { 379, 16, 16, 18, 1, -20 },
  { 411, 6, 8, 9, 1, -4 },
  { 417, 9, 4, 11, 1, -11 },
  { 422, 5, 5, 9, 2, -5 },
  { 426, 13, 24, 13, 0, -24 },
  { 465, 16, 25, 18, 1, -25 },
  { 515, 11, 24, 18, 2, -24 },
  { 548, 16, 25, 18, 1, -25 },
  { 598, 15, 25, 18, 1, -25 },
  { 645, 16, 24, 18, 1, -24 },
  { 693, 14, 24, 18, 2, -24 },
  { 735, 16, 25, 18, 1, -25 },
  { 785, 16, 24, 18, 1, -24 },
  { 833, 16, 25, 18, 1, -25 },
  { 883, 16, 25, 18, 1, -25 },
  { 933, 5, 19, 9, 2, -19 },
  { 945, 6, 23, 9, 1, -19 },
  { 963, 16, 17, 18, 1, -21 },
  { 997, 16, 10, 18, 1, -17 },
  { 1017, 16, 17, 18, 1, -21 },
  { 1051, 14, 25, 14, 0, -25 },
  { 1095, 24, 27, 28, 2, -24 },
  { 1176, 21, 24, 21, 0, -24 },
  { 1239, 16, 24, 21, 3, -24 },
  { 1287, 17, 25, 20, 2, -25 },
  { 1341, 18, 24, 23, 3, -24 },
  { 1395, 12, 24, 17, 3, -24 },
  { 1431, 12, 24, 17, 3, -24 },
  { 1467, 18, 25, 23, 2, -25 },
  { 1524, 17, 24, 23, 3, -24 },
  { 1575, 10, 24, 12, 1, -24 },
  { 1605, 9, 31, 10, -2, -24 },
  { 1640, 17, 24, 20, 3, -24 },
  { 1691, 13, 24, 17, 3, -24 },
  { 1730, 24, 24, 29, 3, -24 },
  { 1802, 19, 24, 25, 3, -24 },
  { 1859, 20, 25, 24, 2, -25 },
  { 1922, 15, 24, 19, 3, -24 },
  { 1967, 20, 31, 24, 2, -25 },
  { 2045, 17, 24, 20, 3, -24 },
  { 2096, 15, 25, 17, 1, -25 },
  { 2143, 16, 24, 17, 1, -24 },
  { 2191, 17, 24, 23, 3, -24 },
  { 2242, 20, 24, 20, 0, -24 },
  { 2302, 30, 24, 30, 0, -24 },
  { 2392, 19, 24, 19, 0, -24 },
  { 2449, 19, 24, 19, 0, -24 },
  { 2506, 15, 24, 17, 1, -24 },
  { 2551, 8, 29, 11, 2, -24 },
  { 2580, 13, 24, 13, 0, -24 },
  { 2619, 8, 29, 11, 1, -24 },
  { 2648, 17, 15, 19, 1, -24 },
  { 2680, 14, 2, 14, 0, 3 },
  { 2684, 8, 5, 11, 1, -26 },
  { 2689, 15, 19, 18, 1, -19 },
  { 2725, 16, 26, 20, 2, -26 },
  { 2777, 13, 19, 16, 2, -19 },
  { 2808, 15, 26, 20, 2, -26 },
  { 2857, 15, 19, 18, 2, -19 },
  { 2893, 12, 26, 11, 1, -26 },
  { 2932, 15, 27, 20, 2, -19 },
  { 2983, 15, 26, 20, 2, -26 },
  { 3032, 5, 26, 9, 2, -26 },
  { 3049, 8, 34, 9, -1, -26 },
  { 3083, 15, 26, 18, 3, -26 },
  { 3132, 5, 26, 9, 2, -26 },
  { 3149, 25, 19, 30, 2, -19 },
  { 3209, 15, 19, 20, 2, -19 },
  { 3245, 16, 19, 19, 2, -19 },
  { 3283, 16, 27, 20, 2, -19 },
  { 3337, 15, 27, 20, 2, -19 },
  { 3388, 11, 19, 13, 2, -19 },
  { 3415, 13, 19, 15, 1, -19 },
  { 3446, 11, 22, 13, 1, -22 },
  { 3477, 15, 18, 20, 2, -18 },
  { 3511, 17, 18, 17, 0, -18 },
  { 3550, 26, 18, 26, 0, -18 },
  { 3609, 17, 18, 17, 0, -18 },
  { 3648, 17, 26, 17, 0, -18 },
  { 3704, 13, 18, 15, 1, -18 },
  { 3734, 10, 29, 13, 1, -24 },
  { 3771, 3, 34, 17, 7, -26 },
  { 3784, 11, 29, 13, 1, -24 },
  { 3824, 16, 6, 18, 1, -15 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD34PT7B_H_
