#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLD38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLD38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x80, 0x00, 0x07, 0xBF, 0xFF, 0xF7, 0x80, 0xF8, 0xFF,
  0xC7, 0xBE, 0x3D, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xC3, 0xCE, 0x1E, 0x70,
  0xF3, 0x87, 0x80, 0x01, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xE0, 0x03,
  0x87, 0x00, 0x3C, 0x38, 0x01, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xF0,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0x1E, 0x00, 0x70,
  0xF0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x07,
  0x0E, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0xF8, 0x1F, 0xFE,
  0x7F, 0xFF, 0x7F, 0xFE, 0xF9, 0x8E, 0xF1, 0x80, 0xF1, 0x80, 0xF1, 0x80,
  0xF9, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x01, 0xBF, 0x01, 0x8F, 0x01, 0x8F, 0x01, 0x8F, 0xC1, 0x9F,
  0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xF0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x02, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xF0, 0x0F,
  0xF0, 0x07, 0x00, 0xFF, 0xC0, 0x78, 0x07, 0x9E, 0x03, 0x80, 0x38, 0x70,
  0x3C, 0x01, 0xC3, 0xC1, 0xC0, 0x1E, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0xE0,
  0x07, 0x87, 0x8F, 0x00, 0x3C, 0x3C, 0x70, 0x00, 0xE1, 0xE7, 0x87, 0x07,
  0x0E, 0x38, 0xFC, 0x3C, 0xF3, 0xCF, 0xF1, 0xFF, 0x9C, 0xFF, 0xC7, 0xF9,
  0xE7, 0x8E, 0x1F, 0x8E, 0x38, 0x78, 0x30, 0xF3, 0xC3, 0xC0, 0x07, 0x1E,
  0x1E, 0x00, 0x78, 0xF0, 0xF0, 0x03, 0x87, 0x87, 0x80, 0x3C, 0x3C, 0x3C,
  0x01, 0xC0, 0xE1, 0xE0, 0x1E, 0x07, 0x0E, 0x00, 0xF0, 0x3C, 0xF0, 0x0F,
  0x00, 0xFF, 0x80, 0x78, 0x07, 0xF8, 0x07, 0x80, 0x1F, 0x80, 0x00, 0x40,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x1F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1F,
  0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x3E, 0x3F, 0xF8, 0x3E, 0x3E, 0xFC,
  0x3C, 0x7C, 0x7E, 0x7C, 0x7C, 0x3F, 0x7C, 0xF8, 0x1F, 0xF8, 0xF8, 0x0F,
  0xF8, 0xF8, 0x07, 0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFE, 0x7E, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF7, 0xBD, 0xCE, 0x73, 0x80, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xE1,
  0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1F, 0x07,
  0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x07,
  0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x8E, 0x39, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x01, 0xFC, 0x01, 0xEF, 0x01, 0xF7,
  0xC0, 0xF1, 0xE0, 0xF8, 0xF8, 0x18, 0x30, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3E, 0x78, 0xF3, 0xE7, 0x8F, 0x1E, 0x38, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x80, 0x01, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0x87, 0xC7, 0xC0, 0xF1,
  0xF0, 0x3E, 0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0xBE, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF8,
  0xF8, 0x7C, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x01,
  0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF, 0xFD, 0xF7, 0x9F, 0x31,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x00, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xF7, 0xF1, 0xC0, 0xF8, 0x40, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x0F, 0xFC, 0x1F, 0xFF, 0x9F, 0xFF,
  0xE7, 0xE7, 0xF1, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xF0,
  0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1D, 0xE0, 0x0F, 0x78, 0x07, 0x9E,
  0x01, 0xE7, 0x80, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0xC0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x03,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xF8, 0x43, 0xE0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0xFE, 0x1E, 0xFF,
  0x8F, 0xFF, 0xE7, 0xF3, 0xFB, 0xE0, 0x7D, 0xF0, 0x1E, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xF7, 0xC0, 0xF9, 0xF0, 0x7C,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0xF8,
  0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xF8, 0x7C, 0x7C, 0x0F, 0x9F, 0x03, 0xE7,
  0xC0, 0xF9, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x87, 0xC1, 0xFF, 0xE0, 0x3F,
  0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFC, 0xFC, 0x7C, 0x1F,
  0x9E, 0x03, 0xE7, 0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xE7,
  0xC0, 0xF9, 0xF8, 0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x07,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xEF, 0xE7, 0xC1, 0xF3, 0xE0, 0x7D,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xEF, 0x01,
  0xF7, 0xC1, 0xFB, 0xF9, 0xFC, 0xFF, 0xFE, 0x3F, 0xEF, 0x0F, 0xE7, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x67, 0xF8, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x7B, 0xFF, 0xFF,
  0x7D, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF,
  0x78, 0x3C, 0x7D, 0xFB, 0xF3, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0xF1, 0xE7, 0xCF, 0x1E, 0x3C, 0x71, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE,
  0x01, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x3F, 0xE3, 0xFF, 0xE3, 0xFF, 0xE7, 0xEF, 0xE4, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3E,
  0x00, 0x3C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xF1, 0xC0, 0xFF, 0x0F, 0x78, 0x3F, 0xF1, 0xEE, 0x0F, 0xFE,
  0x1F, 0xC3, 0xC3, 0xC3, 0xF8, 0x70, 0x78, 0x7F, 0x1E, 0x0F, 0x0F, 0xC3,
  0xC1, 0xE1, 0xF8, 0x78, 0x3C, 0x3F, 0x0E, 0x07, 0x87, 0xE1, 0xC0, 0xF0,
  0xFC, 0x3C, 0x1E, 0x1F, 0x87, 0x87, 0xC7, 0xF8, 0x79, 0xF9, 0xEF, 0x0F,
  0xFB, 0xF8, 0xE0, 0xFE, 0x7F, 0x1E, 0x07, 0x03, 0x83, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x80, 0x7E, 0x00, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xC7, 0x80, 0x07,
  0x8F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F,
  0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE,
  0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x0F, 0xBE,
  0x03, 0xEF, 0x81, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x01, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xFC,
  0x02, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF8, 0x1F, 0xCF,
  0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x07, 0xEF, 0x80, 0xFC, 0xF8, 0x3F, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xC0, 0x10, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF8, 0x01, 0xF7,
  0xC0, 0x0F, 0xBF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xF0, 0x1F, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xC1, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F,
  0xB3, 0xF7, 0xFE, 0xFF, 0x9F, 0xE1, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0x00,
  0xFB, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x7C, 0x3E, 0x1F,
  0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0xC0, 0x7D, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFC, 0xF8,
  0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0xE7, 0xC0, 0x7C, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x0F,
  0x80, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFD, 0xE0, 0x0F, 0xFF, 0xBC, 0x01, 0xFF, 0xF7, 0x80, 0x7B, 0xFE, 0x78,
  0x0F, 0x7F, 0xCF, 0x01, 0xEF, 0xFD, 0xE0, 0x79, 0xFF, 0x9E, 0x0F, 0x3F,
  0xF3, 0xC1, 0xE7, 0xFE, 0x78, 0x78, 0xFF, 0xC7, 0x8F, 0x1F, 0xF8, 0xF1,
  0xE3, 0xFF, 0x1E, 0x78, 0x7F, 0xE3, 0xEF, 0x0F, 0xFC, 0x3D, 0xE1, 0xFF,
  0x87, 0xF8, 0x3F, 0xF0, 0xFF, 0x07, 0xFE, 0x0F, 0xE0, 0xFF, 0xC1, 0xF8,
  0x1F, 0xF8, 0x3F, 0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x78, 0x0F, 0x80,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0xDF, 0x01, 0xFE, 0xF8, 0x0F, 0xF3, 0xE0, 0x7F,
  0x9F, 0x03, 0xFC, 0x7C, 0x1F, 0xE3, 0xE0, 0xFF, 0x0F, 0x87, 0xFC, 0x7C,
  0x3F, 0xE1, 0xF1, 0xFF, 0x0F, 0x8F, 0xF8, 0x3E, 0x7F, 0xC1, 0xFB, 0xFE,
  0x07, 0xDF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7E, 0x00,
  0x30, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0x8F, 0x80, 0x3E, 0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x83, 0xF7, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xEF, 0x83, 0xF7,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF0, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xE0, 0x3F, 0x1F,
  0x80, 0x3F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x8F, 0x80, 0x3E,
  0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x81, 0xF1, 0xF0, 0x1F, 0x3E, 0x03,
  0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F,
  0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xF8, 0xF8,
  0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x3E,
  0x3E, 0x07, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x0F,
  0x80, 0x00, 0x80, 0x0F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xF8,
  0x0C, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1E, 0xE0,
  0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xEF, 0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF,
  0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xE7,
  0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x1E, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x03, 0xC0, 0xF0, 0x0F, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x78, 0x78, 0x01,
  0xE1, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xDE, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0xFE,
  0x01, 0xE7, 0xC0, 0x7F, 0x01, 0xF3, 0xE0, 0x3F, 0x80, 0xF8, 0xF0, 0x1D,
  0xC0, 0x7C, 0x78, 0x1E, 0xF0, 0x3C, 0x3E, 0x0F, 0x78, 0x1E, 0x1F, 0x07,
  0xBC, 0x1F, 0x07, 0x83, 0xDE, 0x0F, 0x83, 0xC1, 0xE7, 0x87, 0x81, 0xF1,
  0xE3, 0xC3, 0xC0, 0xF8, 0xF1, 0xE3, 0xE0, 0x7C, 0x78, 0xF1, 0xF0, 0x1E,
  0x3C, 0x3C, 0xF0, 0x0F, 0x3C, 0x1E, 0x78, 0x07, 0xDE, 0x0F, 0x3C, 0x03,
  0xEF, 0x07, 0xBE, 0x00, 0xF7, 0x81, 0xDF, 0x00, 0x7B, 0x80, 0xFF, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0,
  0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x7C, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x3E, 0x07, 0xC1,
  0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xDF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3E, 0xF8,
  0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0x7C,
  0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x01, 0xF3, 0xE0, 0x0F, 0xFF, 0x00, 0x3E,
  0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0x7C, 0x07, 0xC3, 0xE0,
  0x3C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x01, 0xE1, 0xF0, 0x0F, 0x8F, 0x80,
  0x3C, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x1E, 0x03, 0xC3, 0xC0, 0x78,
  0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x00, 0xF7, 0x80,
  0x1E, 0xF0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x03, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xE0, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0xFF,
  0x87, 0xFF, 0xCF, 0xFF, 0xEF, 0xF1, 0xF7, 0xC0, 0xFB, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0x78, 0x1F, 0xBE, 0x1F, 0xDF, 0xFD, 0xE7, 0xFC, 0xF1,
  0xFC, 0x78, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF1, 0xF0, 0x79, 0xFE, 0x3D,
  0xFF, 0x9F, 0xFF, 0xEF, 0xC1, 0xF7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0x7F, 0xBF, 0xBF, 0xFF, 0x9E,
  0xFF, 0x8E, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xF3, 0xFF, 0xCF, 0xFF, 0x7E,
  0x09, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x05, 0xFF, 0xF3,
  0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x0F, 0xC7,
  0x8F, 0xF3, 0xCF, 0xFD, 0xEF, 0xFF, 0xF7, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0x7C, 0x1F, 0xBF, 0xBF,
  0xCF, 0xFD, 0xE7, 0xFE, 0xF0, 0xFC, 0x78, 0x07, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D, 0xF0, 0x1E,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0x3F, 0x87, 0x8F, 0xFF, 0xC3,
  0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0xF8, 0x7F, 0xC7, 0xFE, 0x3F, 0xE1, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE1,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x00, 0x0F, 0xC7, 0x8F, 0xF3, 0xCF, 0xFD, 0xEF, 0xFF,
  0xF7, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0x7C, 0x1F, 0xBF, 0xBF, 0xCF, 0xFD, 0xE7, 0xFE, 0xF0, 0xFC,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xB0, 0x0F, 0x9F,
  0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0x80, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF1, 0xF8, 0x79, 0xFE, 0x3D, 0xFF, 0x9F, 0xFF, 0xEF, 0xC1, 0xF7,
  0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF8, 0x11, 0xEF,
  0xFF, 0x78, 0x40, 0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x01, 0x01, 0xE0, 0xFC,
  0x3F, 0x07, 0x80, 0x40, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x83, 0xEF, 0xFB, 0xFC, 0xFF, 0x3F, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x0F, 0xF8, 0x0F, 0xBC, 0x0F, 0x9E, 0x0F, 0x8F, 0x0F, 0xC7,
  0x87, 0xC3, 0xC7, 0xC1, 0xE7, 0xC0, 0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xDF, 0x07, 0xC7, 0xC3, 0xC3, 0xE1, 0xE0, 0xF8, 0xF0,
  0x7C, 0x78, 0x1F, 0x3C, 0x07, 0xDE, 0x03, 0xEF, 0x00, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE1, 0xF8, 0x3F, 0x0F, 0x7F, 0xC7, 0xFC, 0xFF, 0xFE, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0xFC, 0x3F, 0xC3, 0xEF, 0x81, 0xF8, 0x3E, 0xF8, 0x1F,
  0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x1F,
  0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xFF, 0x01,
  0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x1F, 0x01,
  0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x1F, 0xF0,
  0x1F, 0x01, 0xF0, 0xE1, 0xF8, 0x7B, 0xFE, 0x3D, 0xFF, 0x9F, 0xFF, 0xEF,
  0xC1, 0xF7, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF8,
  0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x1F, 0x1E,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0x79, 0xE0, 0x3E,
  0x7C, 0x1F, 0x9F, 0xCF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x00,
  0xE1, 0xF0, 0x79, 0xFE, 0x3D, 0xFF, 0x9F, 0xFF, 0xEF, 0xC1, 0xF7, 0xC0,
  0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F,
  0x7F, 0xBF, 0xBF, 0xFF, 0x9E, 0xFF, 0x8F, 0x3F, 0x87, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xC7, 0x8F, 0xF3, 0xCF, 0xFD, 0xEF, 0xFF,
  0xF7, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0x7C, 0x1F, 0xBF, 0xBF, 0xCF, 0xFD, 0xE7, 0xFE, 0xF0, 0xFC,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0xE1, 0xFE, 0x3F, 0xF7,
  0xEF, 0xFE, 0xFF, 0xEF, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0x01,
  0x78, 0x03, 0xC0, 0x1F, 0x80, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7F, 0x8F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFC, 0x00, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xFB,
  0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xEF, 0x3F, 0xC7, 0xF8,
  0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x78,
  0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xE3, 0xE0, 0x7C,
  0x7C, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1F, 0x78, 0x01, 0xEF, 0x00, 0x3D,
  0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0xFB, 0xC0, 0x7C, 0x07, 0x9E, 0x07, 0xF0, 0x3C,
  0xF8, 0x3F, 0x83, 0xE7, 0xC1, 0xDC, 0x1F, 0x1E, 0x0E, 0xE0, 0xF0, 0xF0,
  0xF7, 0x87, 0x87, 0xC7, 0xBC, 0x7C, 0x3E, 0x3D, 0xE3, 0xE0, 0xF1, 0xC7,
  0x1E, 0x07, 0x9E, 0x3C, 0xF0, 0x3E, 0xF1, 0xEF, 0x81, 0xF7, 0x8F, 0x7C,
  0x07, 0xB8, 0x3B, 0xC0, 0x3D, 0xC1, 0xDE, 0x01, 0xEE, 0x0E, 0xF0, 0x07,
  0xF0, 0x77, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0xF8,
  0x3E, 0x1F, 0x07, 0xC1, 0xF1, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x80, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF0, 0x1F, 0x1F, 0x07, 0xC1,
  0xF0, 0xF8, 0x3E, 0x3E, 0x03, 0xEF, 0xC0, 0x7E, 0xF8, 0x03, 0xFF, 0x00,
  0x7D, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xC0, 0x7C, 0x7C, 0x0F, 0x0F, 0x83,
  0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xE3, 0xE0, 0x3C, 0x7C, 0x07, 0x8F,
  0x00, 0xFB, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x3F,
  0x07, 0xF0, 0xFE, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x7F, 0x0F, 0xE0, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xFF, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0xE0, 0x7F, 0x00, 0xF0, 0x7F, 0x0F, 0xE0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0xF8, 0x00, 0x3F, 0x80, 0x5F, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xC0, 0x7F, 0x20, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 27, 10, 2, -27 },
  { 22, 13, 10, 17, 2, -27 },
  { 39, 21, 27, 22, 1, -27 },
  { 110, 16, 31, 20, 2, -29 },
  { 172, 29, 28, 31, 1, -28 },
  { 274, 24, 28, 25, 1, -28 },
  { 358, 5, 10, 9, 2, -27 },
  { 365, 9, 33, 12, 2, -27 },
  { 403, 9, 33, 12, 1, -27 },
  { 441, 17, 16, 19, 1, -29 },
  { 475, 17, 19, 20, 2, -23 },
  { 516, 7, 9, 10, 1, -4 },
  { 524, 10, 4, 12, 1, -12 },
  { 529, 6, 5, 10, 2, -5 },
  { 533, 15, 27, 15, 0, -27 },
  { 584, 18, 28, 20, 1, -28 },
  { 647, 12, 27, 20, 2, -27 },
  { 688, 17, 28, 20, 1, -28 },
  { 748, 17, 28, 20, 1, -28 },
  { 808, 18, 27, 20, 1, -27 },
  { 869, 16, 27, 20, 2, -27 },
  { 923, 17, 27, 20, 2, -27 },
  { 981, 18, 27, 20, 1, -27 },
  { 1042, 18, 27, 20, 1, -27 },
  { 1103, 17, 27, 20, 1, -27 },
  { 1161, 6, 21, 10, 2, -21 },
  { 1177, 7, 26, 10, 1, -21 },
  { 1200, 18, 19, 20, 1, -23 },
  { 1243, 16, 11, 20, 2, -19 },
  { 1265, 17, 19, 20, 2, -23 },
  { 1306, 15, 28, 16, 0, -28 },
  { 1359, 27, 30, 31, 2, -27 },
  { 1461, 23, 27, 23, 0, -27 },
  { 1539, 18, 27, 23, 3, -27 },
  { 1600, 19, 28, 22, 2, -28 },
  { 1667, 20, 27, 25, 3, -27 },
  { 1735, 14, 27, 19, 3, -27 },
  { 1783, 14, 27, 19, 3, -27 },
  { 1831, 21, 28, 25, 2, -28 },
  { 1905, 20, 27, 26, 3, -27 },
  { 1973, 11, 27, 13, 1, -27 },
  { 2011, 11, 35, 11, -3, -27 },
  { 2060, 19, 27, 22, 3, -27 },
  { 2125, 15, 27, 19, 3, -27 },
  { 2176, 27, 27, 33, 3, -27 },
  { 2268, 21, 27, 28, 3, -27 },
  { 2339, 23, 28, 27, 2, -28 },
  { 2420, 17, 27, 21, 3, -27 },
  { 2478, 23, 34, 27, 2, -28 },
  { 2576, 19, 27, 22, 3, -27 },
  { 2641, 16, 28, 19, 2, -28 },
  { 2697, 18, 27, 19, 1, -27 },
  { 2758, 20, 27, 26, 3, -27 },
  { 2826, 22, 27, 22, 0, -27 },
  { 2901, 33, 27, 33, 0, -27 },
  { 3013, 21, 27, 22, 0, -27 },
  { 3084, 21, 27, 21, 0, -27 },
  { 3155, 17, 27, 19, 1, -27 },
  { 3213, 8, 33, 12, 3, -27 },
  { 3246, 15, 27, 15, 0, -27 },
  { 3297, 9, 33, 12, 1, -27 },
  { 3335, 19, 17, 21, 1, -27 },
  { 3376, 16, 3, 16, 0, 3 },
  { 3382, 9, 6, 12, 2, -29 },
  { 3389, 17, 21, 20, 1, -21 },
  { 3434, 17, 29, 22, 3, -29 },
  { 3496, 14, 21, 17, 2, -21 },
  { 3533, 17, 29, 22, 2, -29 },
  { 3595, 17, 21, 20, 2, -21 },
  { 3640, 13, 29, 13, 1, -29 },
  { 3688, 17, 30, 22, 2, -21 },
  { 3752, 17, 29, 22, 3, -29 },
  { 3814, 6, 29, 10, 2, -29 },
  { 3836, 10, 38, 10, -2, -29 },
  { 3884, 17, 29, 20, 3, -29 },
  { 3946, 4, 29, 10, 3, -29 },
  { 3961, 28, 21, 33, 3, -21 },
  { 4035, 17, 21, 22, 3, -21 },
  { 4080, 18, 21, 21, 2, -21 },
  { 4128, 17, 30, 22, 3, -21 },
  { 4192, 17, 30, 22, 2, -21 },
  { 4256, 12, 21, 15, 3, -21 },
  { 4288, 13, 21, 17, 2, -21 },
  { 4323, 12, 25, 14, 1, -25 },
  { 4361, 16, 21, 22, 3, -21 },
  { 4403, 19, 21, 19, 0, -21 },
  { 4453, 29, 21, 29, 0, -21 },
  { 4530, 19, 21, 19, 0, -21 },
  { 4580, 19, 30, 19, 0, -21 },
  { 4652, 14, 21, 16, 1, -21 },
  { 4689, 12, 33, 14, 1, -27 },
  { 4739, 3, 38, 19, 8, -29 },
  { 4754, 12, 33, 14, 1, -27 },
  { 4804, 18, 6, 20, 1, -16 },
};

const GFXfont NotoSans_SemiCondensed_SemiBold38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBold38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBold38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLD38PT7B_H_
